#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC31PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0x82, 0x08, 0x61, 0x04, 0x10, 0x43, 0x08, 0x20, 0x82,
  0x10, 0x40, 0x00, 0x00, 0xC3, 0x00, 0x22, 0xC5, 0x1A, 0x24, 0x48, 0xA1,
  0x44, 0x01, 0x84, 0x01, 0x04, 0x01, 0x04, 0x01, 0x08, 0x02, 0x08, 0x02,
  0x08, 0x02, 0x10, 0x3F, 0xFF, 0x04, 0x10, 0x04, 0x30, 0x0C, 0x20, 0x08,
  0x20, 0x08, 0x20, 0x08, 0x40, 0xFF, 0xFC, 0x10, 0x40, 0x10, 0xC0, 0x20,
  0x80, 0x20, 0x80, 0x20, 0x80, 0x21, 0x00, 0x41, 0x00, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x07, 0xE0, 0xC9, 0x8C, 0x40, 0x42, 0x02, 0x20, 0x11, 0x00,
  0x88, 0x06, 0x40, 0x1A, 0x00, 0x60, 0x01, 0xC0, 0x0B, 0x00, 0x44, 0x02,
  0x20, 0x21, 0x01, 0x08, 0x08, 0xC8, 0x4C, 0x7B, 0xC0, 0x30, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x00, 0x1F, 0x01, 0x8C, 0x40, 0x42, 0x10, 0x21, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x42, 0x0C, 0x11, 0x02, 0x04, 0x40, 0x83, 0x22,
  0x20, 0x99, 0xE8, 0x24, 0x8F, 0x12, 0x41, 0x79, 0x90, 0x40, 0x48, 0x10,
  0x22, 0x0C, 0x18, 0x82, 0x04, 0x20, 0x82, 0x08, 0x21, 0x82, 0x18, 0x40,
  0x84, 0x20, 0x22, 0x18, 0x0F, 0x80, 0x03, 0xF0, 0x0C, 0x20, 0x10, 0x60,
  0x60, 0xC0, 0x81, 0x81, 0x02, 0x03, 0x0C, 0x02, 0x30, 0x04, 0xC0, 0x0E,
  0x00, 0x18, 0x00, 0xC8, 0x03, 0x10, 0x2C, 0x10, 0xF0, 0x31, 0x40, 0x26,
  0x80, 0x69, 0x00, 0x62, 0x00, 0xC4, 0x02, 0x8C, 0x18, 0x87, 0xE1, 0x80,
  0x2D, 0x24, 0xA4, 0x01, 0x81, 0x01, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x40,
  0x20, 0x30, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x03, 0x00, 0x80, 0x40, 0x20, 0x08, 0x00, 0x02, 0x01,
  0x00, 0x40, 0x20, 0x10, 0x0C, 0x06, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30,
  0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x60,
  0x20, 0x20, 0x20, 0x30, 0x00, 0x04, 0x00, 0xC0, 0x10, 0x42, 0x0C, 0x40,
  0x68, 0xC3, 0xE0, 0xA0, 0x22, 0x08, 0x43, 0x0C, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x1F, 0xFF, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x32, 0x26, 0x48,
  0x80, 0xFE, 0xF0, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x00, 0x03, 0xF0, 0x30, 0xC2, 0x02, 0x30, 0x11, 0x00, 0x88,
  0x04, 0x80, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x34, 0x01,
  0xA0, 0x09, 0x00, 0x58, 0x06, 0xC0, 0x22, 0x03, 0x10, 0x10, 0x81, 0x86,
  0x18, 0x1F, 0x80, 0x07, 0x0E, 0x12, 0x62, 0xC6, 0x04, 0x04, 0x04, 0x0C,
  0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20,
  0x20, 0x03, 0xF0, 0x30, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x30, 0x30, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x18, 0x01, 0xC0, 0x78, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x80, 0xC1, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x50, 0x03,
  0xC0, 0x0A, 0x00, 0x48, 0x02, 0x20, 0x19, 0x80, 0x44, 0x02, 0x10, 0x10,
  0x40, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x80, 0x84, 0x02, 0x3F, 0xFF, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x03, 0xFE,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x3F, 0x80, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x08,
  0x0C, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x30, 0x03, 0x00, 0x30, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x47, 0x02, 0xEE, 0x28, 0x19, 0x80, 0x4C,
  0x02, 0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x03, 0x20, 0x11, 0x01,
  0x04, 0x18, 0x1F, 0x00, 0xFF, 0xF0, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08,
  0x00, 0x07, 0xF0, 0x30, 0x60, 0x80, 0x84, 0x03, 0x10, 0x0C, 0x40, 0x21,
  0x00, 0x82, 0x04, 0x0C, 0x20, 0x1B, 0x00, 0x70, 0x07, 0x20, 0x30, 0x41,
  0x00, 0x8C, 0x02, 0x20, 0x0C, 0x80, 0x12, 0x00, 0xC8, 0x02, 0x30, 0x18,
  0x60, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x60, 0x86, 0x06, 0x20, 0x13, 0x00,
  0x90, 0x04, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0xC8, 0x0E, 0x60, 0xE1,
  0xFD, 0x01, 0x08, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03,
  0x00, 0x30, 0x7E, 0x00, 0x10, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x80, 0x04, 0x0C, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x10, 0x20, 0x81, 0x04, 0x08, 0x00, 0x00, 0x08,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x04, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x40, 0x00, 0x3F, 0x10, 0x20,
  0x0C, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x08, 0x04, 0x01, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x3F, 0x00, 0x0E, 0x06, 0x00, 0xC0, 0x08, 0x08, 0x00, 0x60,
  0x80, 0x01, 0x0C, 0x00, 0x08, 0x40, 0x7C, 0x64, 0x0C, 0x41, 0x20, 0x82,
  0x0B, 0x08, 0x10, 0x50, 0x41, 0x86, 0x84, 0x08, 0x24, 0x20, 0x41, 0x61,
  0x02, 0x0B, 0x08, 0x30, 0x98, 0x41, 0x04, 0x82, 0x14, 0x46, 0x1B, 0x2C,
  0x10, 0x70, 0x80, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0xC3, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xA0, 0x01, 0x40, 0x04, 0x80, 0x09, 0x00, 0x23, 0x00, 0x42, 0x01, 0x04,
  0x02, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0xFF, 0x82, 0x01, 0x04,
  0x02, 0x10, 0x04, 0x20, 0x0C, 0x80, 0x1B, 0x00, 0x14, 0x00, 0x38, 0x00,
  0x40, 0x0F, 0xF8, 0x18, 0x18, 0x20, 0x18, 0x40, 0x10, 0x80, 0x23, 0x00,
  0x44, 0x01, 0x08, 0x02, 0x10, 0x08, 0x20, 0x60, 0xFF, 0x01, 0x01, 0x82,
  0x01, 0x84, 0x01, 0x08, 0x02, 0x30, 0x04, 0x40, 0x08, 0x80, 0x31, 0x00,
  0x46, 0x01, 0x88, 0x0E, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x0E, 0x04, 0x30,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x02, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x0C, 0x1C, 0x08, 0x06, 0x08, 0x02, 0x08, 0x03, 0x18,
  0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x30, 0x01, 0x20,
  0x03, 0x20, 0x02, 0x20, 0x02, 0x20, 0x06, 0x60, 0x04, 0x40, 0x0C, 0x40,
  0x08, 0x40, 0x10, 0xC0, 0x60, 0xC1, 0xC0, 0xFF, 0x00, 0x0F, 0xFC, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x03, 0xFF, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0F, 0xFC, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x00, 0x01, 0xFF, 0x83, 0x80, 0x83, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x0F, 0xC8, 0x00, 0x64, 0x00, 0x22, 0x00, 0x11, 0x00,
  0x08, 0x80, 0x04, 0x60, 0x06, 0x10, 0x02, 0x0C, 0x01, 0x03, 0x01, 0x80,
  0xFF, 0x80, 0x04, 0x00, 0xC3, 0x00, 0x20, 0x80, 0x08, 0x20, 0x02, 0x08,
  0x01, 0x86, 0x00, 0x41, 0x00, 0x10, 0x40, 0x04, 0x10, 0x01, 0x04, 0x00,
  0xC3, 0xFF, 0xE0, 0x80, 0x08, 0x20, 0x02, 0x08, 0x01, 0x82, 0x00, 0x41,
  0x80, 0x10, 0x40, 0x04, 0x10, 0x01, 0x04, 0x00, 0xC3, 0x00, 0x20, 0xC0,
  0x08, 0x20, 0x02, 0x00, 0x07, 0xC0, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x3F, 0x00, 0x00, 0x10, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0xF8,
  0x00, 0x0C, 0x03, 0x0C, 0x06, 0x08, 0x0C, 0x08, 0x18, 0x08, 0x30, 0x18,
  0x60, 0x10, 0xC0, 0x11, 0x80, 0x13, 0x00, 0x16, 0x00, 0x3E, 0x00, 0x29,
  0x00, 0x31, 0x00, 0x21, 0x80, 0x20, 0x80, 0x60, 0x80, 0x40, 0xC0, 0x40,
  0x40, 0x40, 0x60, 0xC0, 0x20, 0x80, 0x20, 0x80, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x3F,
  0xF0, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0x70, 0xA0, 0x01, 0x82, 0x80, 0x0A,
  0x0A, 0x00, 0x68, 0x68, 0x01, 0x61, 0x20, 0x0D, 0x04, 0x80, 0x24, 0x12,
  0x01, 0x90, 0x4C, 0x04, 0x43, 0x10, 0x23, 0x08, 0x40, 0x88, 0x21, 0x04,
  0x20, 0x84, 0x10, 0x82, 0x10, 0x82, 0x18, 0x46, 0x18, 0x41, 0x10, 0x41,
  0x06, 0xC1, 0x04, 0x0A, 0x04, 0x30, 0x38, 0x10, 0x80, 0xC0, 0xC2, 0x02,
  0x02, 0x00, 0x0C, 0x00, 0x43, 0x00, 0x30, 0xA0, 0x08, 0x28, 0x02, 0x0A,
  0x00, 0x86, 0x40, 0x61, 0x10, 0x10, 0x44, 0x04, 0x10, 0x81, 0x04, 0x20,
  0x43, 0x08, 0x30, 0x83, 0x08, 0x20, 0x42, 0x08, 0x10, 0x82, 0x06, 0x21,
  0x80, 0x98, 0x40, 0x24, 0x10, 0x0D, 0x04, 0x01, 0x43, 0x00, 0x50, 0x80,
  0x18, 0x20, 0x02, 0x00, 0x03, 0xFC, 0x06, 0x06, 0x08, 0x02, 0x18, 0x03,
  0x30, 0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06,
  0x80, 0x04, 0xC0, 0x0C, 0x40, 0x08, 0x60, 0x10, 0x30, 0x60, 0x1F, 0xC0,
  0x0F, 0xF0, 0x30, 0x60, 0x80, 0xC2, 0x01, 0x08, 0x04, 0x60, 0x11, 0x00,
  0x44, 0x01, 0x10, 0x0C, 0x40, 0x23, 0x01, 0x08, 0x78, 0x3F, 0x80, 0x80,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x00, 0x03, 0xFC, 0x06, 0x06, 0x08, 0x02, 0x18, 0x03, 0x30,
  0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80,
  0x04, 0xC0, 0x0C, 0x40, 0x08, 0x60, 0x10, 0x30, 0x60, 0x1F, 0xC0, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x0F, 0xF0, 0x30,
  0x60, 0x80, 0xC2, 0x01, 0x08, 0x04, 0x60, 0x11, 0x00, 0x44, 0x01, 0x10,
  0x08, 0x40, 0x63, 0x03, 0x0F, 0xF0, 0x20, 0x80, 0x82, 0x02, 0x08, 0x18,
  0x30, 0x40, 0x41, 0x01, 0x04, 0x06, 0x30, 0x08, 0xC0, 0x22, 0x00, 0xC0,
  0x03, 0xFC, 0x10, 0x10, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x80,
  0xC3, 0xFE, 0x00, 0xFF, 0xF8, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x00, 0x18, 0x01, 0x88, 0x00, 0x84, 0x00, 0x42, 0x00, 0x23,
  0x00, 0x11, 0x00, 0x18, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02, 0x30, 0x03,
  0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0x42, 0x00, 0x23, 0x00, 0x31, 0x00,
  0x10, 0x80, 0x08, 0x40, 0x0C, 0x20, 0x04, 0x08, 0x06, 0x06, 0x06, 0x01,
  0xFC, 0x00, 0x80, 0x0E, 0x00, 0x28, 0x01, 0xA0, 0x04, 0xC0, 0x33, 0x00,
  0x8C, 0x06, 0x10, 0x10, 0x40, 0xC1, 0x02, 0x04, 0x18, 0x10, 0x40, 0x43,
  0x01, 0x08, 0x04, 0x60, 0x11, 0x00, 0x44, 0x01, 0x20, 0x06, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x00, 0xC0, 0x10, 0x07, 0x00, 0xC0, 0x3C, 0x03,
  0x00, 0xB0, 0x14, 0x02, 0xC0, 0x50, 0x13, 0x03, 0x40, 0x4C, 0x09, 0x03,
  0x10, 0x64, 0x08, 0x41, 0x10, 0x61, 0x04, 0x41, 0x04, 0x21, 0x04, 0x10,
  0x84, 0x20, 0x44, 0x10, 0x81, 0x10, 0x46, 0x04, 0xC1, 0x10, 0x12, 0x04,
  0xC0, 0x58, 0x12, 0x01, 0x40, 0x48, 0x05, 0x01, 0x40, 0x18, 0x05, 0x00,
  0x60, 0x18, 0x01, 0x00, 0x20, 0x00, 0x02, 0x00, 0xC0, 0x80, 0x60, 0x30,
  0x30, 0x04, 0x08, 0x01, 0x04, 0x00, 0x43, 0x00, 0x08, 0x80, 0x02, 0x40,
  0x00, 0xB0, 0x00, 0x38, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x60, 0x00,
  0xC8, 0x00, 0x22, 0x00, 0x10, 0x80, 0x0C, 0x10, 0x06, 0x04, 0x01, 0x01,
  0x00, 0x80, 0x60, 0x60, 0x08, 0x30, 0x02, 0x00, 0x80, 0x1C, 0x01, 0xB0,
  0x08, 0x80, 0xC4, 0x04, 0x20, 0x41, 0x06, 0x04, 0x20, 0x22, 0x01, 0x30,
  0x09, 0x00, 0x70, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x40, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x10, 0x03, 0xF0, 0x00, 0x84, 0x10, 0x84, 0x21, 0x08, 0x21,
  0x08, 0x42, 0x10, 0x42, 0x10, 0x84, 0x21, 0x84, 0x07, 0xE0, 0x04, 0x00,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x83, 0xF0, 0x00, 0x00, 0x80,
  0x0E, 0x00, 0xD0, 0x04, 0x80, 0x46, 0x06, 0x10, 0x20, 0x83, 0x02, 0x10,
  0x11, 0x00, 0x98, 0x03, 0x80, 0x10, 0xFF, 0xE0, 0x91, 0x22, 0x03, 0x84,
  0x39, 0xA1, 0x82, 0x84, 0x06, 0x20, 0x18, 0x80, 0x44, 0x01, 0x10, 0x04,
  0x40, 0x13, 0x00, 0xCC, 0x02, 0x30, 0x08, 0xC0, 0x63, 0x01, 0x84, 0x0A,
  0x18, 0x50, 0x3E, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x02, 0x18, 0x13, 0x30, 0xA0, 0xC6, 0x02, 0x60, 0x13,
  0x00, 0x90, 0x04, 0x80, 0x2C, 0x01, 0x40, 0x1A, 0x00, 0x90, 0x04, 0x80,
  0x6C, 0x02, 0x50, 0x32, 0x83, 0x13, 0xE0, 0x01, 0xD0, 0x62, 0x18, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x08, 0x3F, 0x80, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x01, 0xC2,
  0x06, 0x6C, 0x30, 0x30, 0x40, 0x61, 0x00, 0xC2, 0x01, 0x88, 0x03, 0x10,
  0x04, 0x20, 0x08, 0xC0, 0x11, 0x80, 0x63, 0x00, 0xC6, 0x03, 0x0C, 0x06,
  0x08, 0x14, 0x18, 0x48, 0x1F, 0x20, 0x01, 0xC0, 0x66, 0x08, 0x31, 0x03,
  0x20, 0x32, 0x02, 0x40, 0x64, 0x1C, 0x7F, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x04, 0x00, 0x40, 0x02, 0x04, 0x1F, 0x80, 0x00, 0x0E, 0x00, 0x19,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x03, 0xF8, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x06, 0x64, 0x30, 0x30, 0x40, 0x61, 0x00, 0xC2, 0x01, 0x88, 0x03, 0x10,
  0x04, 0x20, 0x08, 0xC0, 0x11, 0x80, 0x63, 0x00, 0xC6, 0x03, 0x0C, 0x06,
  0x08, 0x14, 0x18, 0x58, 0x1F, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x18, 0x20, 0x20, 0x7F, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x18, 0x13, 0x30, 0xA0, 0x86,
  0x06, 0x60, 0x33, 0x01, 0x10, 0x08, 0x80, 0x4C, 0x02, 0x40, 0x32, 0x01,
  0x10, 0x08, 0x80, 0x4C, 0x02, 0x40, 0x32, 0x01, 0x10, 0x08, 0x0C, 0x20,
  0x00, 0x00, 0x01, 0x04, 0x10, 0xC2, 0x08, 0x21, 0x84, 0x10, 0x41, 0x0C,
  0x20, 0x82, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x20, 0x08, 0x0F, 0x00, 0x04, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x31, 0x06, 0x10, 0xC2,
  0x18, 0x23, 0x02, 0x20, 0x24, 0x06, 0xC0, 0x52, 0x06, 0x20, 0x43, 0x04,
  0x10, 0xC1, 0x08, 0x18, 0x80, 0x88, 0x0C, 0x04, 0x30, 0x82, 0x08, 0x21,
  0x84, 0x10, 0x41, 0x08, 0x20, 0x82, 0x18, 0x41, 0x04, 0x10, 0xC2, 0x08,
  0x20, 0x01, 0xC0, 0xC0, 0xB3, 0x19, 0x85, 0x0D, 0x04, 0x30, 0x30, 0x33,
  0x01, 0x81, 0x18, 0x08, 0x08, 0x80, 0xC0, 0x44, 0x04, 0x02, 0x60, 0x20,
  0x12, 0x01, 0x01, 0x90, 0x08, 0x08, 0x80, 0xC0, 0x44, 0x04, 0x02, 0x60,
  0x20, 0x32, 0x01, 0x01, 0x10, 0x08, 0x08, 0x80, 0x80, 0x40, 0x00, 0xC0,
  0x99, 0x85, 0x04, 0x70, 0x33, 0x01, 0x98, 0x08, 0x80, 0x44, 0x02, 0x60,
  0x12, 0x01, 0x90, 0x08, 0x80, 0x44, 0x02, 0x60, 0x12, 0x01, 0x90, 0x08,
  0x80, 0x40, 0x01, 0xC0, 0x33, 0x06, 0x04, 0x20, 0x32, 0x00, 0x90, 0x05,
  0x00, 0x28, 0x01, 0x40, 0x1E, 0x00, 0xF0, 0x05, 0x80, 0x2C, 0x03, 0x20,
  0x11, 0x01, 0x0C, 0x18, 0x3F, 0x00, 0x00, 0x30, 0x09, 0x98, 0x14, 0x18,
  0x30, 0x10, 0xC0, 0x21, 0x80, 0x42, 0x00, 0x84, 0x01, 0x18, 0x02, 0x20,
  0x0C, 0x40, 0x10, 0x80, 0x21, 0x00, 0xC6, 0x01, 0x0A, 0x06, 0x14, 0x18,
  0x27, 0xC0, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x19, 0x91, 0x81, 0x84, 0x06, 0x20, 0x18,
  0x80, 0x66, 0x01, 0x90, 0x04, 0x40, 0x13, 0x00, 0x4C, 0x03, 0x30, 0x0C,
  0xC0, 0x63, 0x01, 0x84, 0x0A, 0x18, 0x48, 0x3E, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0xC4, 0xD1,
  0x40, 0x60, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x00, 0x03, 0x83, 0x9C, 0x40, 0x18,
  0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x24, 0x08, 0xFE, 0x00, 0x08, 0x08, 0x10, 0x10, 0x7F,
  0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0,
  0x80, 0xC0, 0x78, 0x10, 0x08, 0x80, 0x4C, 0x02, 0x40, 0x32, 0x01, 0x10,
  0x09, 0x80, 0x48, 0x06, 0x40, 0x22, 0x01, 0x10, 0x09, 0x80, 0xCC, 0x06,
  0x60, 0x61, 0x05, 0x0F, 0xC8, 0x80, 0x70, 0x0A, 0x03, 0x40, 0x48, 0x11,
  0x02, 0x20, 0x86, 0x10, 0xC4, 0x08, 0x81, 0x20, 0x24, 0x05, 0x00, 0xA0,
  0x18, 0x03, 0x00, 0x80, 0x80, 0xE0, 0x60, 0x28, 0x18, 0x12, 0x0B, 0x04,
  0x82, 0x42, 0x21, 0x90, 0x88, 0x44, 0x62, 0x31, 0x10, 0x88, 0x4C, 0x26,
  0x12, 0x09, 0x04, 0x82, 0x41, 0x40, 0xA0, 0x50, 0x28, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0x08, 0x0C, 0x20, 0x60, 0x43, 0x01, 0x08, 0x06, 0x40,
  0x0B, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x16, 0x00, 0x88, 0x06, 0x20,
  0x10, 0xC0, 0x81, 0x04, 0x04, 0x30, 0x08, 0x04, 0x01, 0x04, 0x02, 0x04,
  0x02, 0x04, 0x04, 0x06, 0x0C, 0x06, 0x08, 0x02, 0x18, 0x02, 0x10, 0x02,
  0x30, 0x02, 0x20, 0x02, 0x60, 0x02, 0x40, 0x02, 0xC0, 0x02, 0x80, 0x03,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x18, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x0F, 0xF8, 0x01, 0x80, 0x08,
  0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02,
  0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x1F, 0xF8, 0x01, 0xE0, 0x60,
  0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20,
  0x0C, 0x03, 0x01, 0x80, 0x08, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10,
  0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x0E, 0x00, 0x60, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x18, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x60,
  0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x03, 0x03, 0x80, 0x00, 0xFE, 0x0C, 0x1F, 0x80, 0x10,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 22, 7, 1, -22 },
  { 18, 7, 8, 10, 3, -22 },
  { 25, 16, 22, 16, 1, -22 },
  { 69, 13, 26, 15, 1, -24 },
  { 112, 18, 22, 21, 2, -22 },
  { 162, 15, 22, 17, 1, -22 },
  { 204, 3, 8, 5, 3, -22 },
  { 207, 9, 27, 8, 1, -22 },
  { 238, 9, 27, 8, -2, -22 },
  { 269, 11, 12, 14, 4, -24 },
  { 286, 13, 14, 16, 2, -18 },
  { 309, 4, 7, 6, -1, -3 },
  { 313, 7, 1, 9, 1, -9 },
  { 314, 2, 2, 6, 1, -2 },
  { 315, 13, 22, 10, -1, -22 },
  { 351, 13, 22, 15, 1, -22 },
  { 387, 8, 22, 15, 4, -22 },
  { 409, 14, 22, 15, 0, -22 },
  { 448, 14, 22, 15, 0, -22 },
  { 487, 14, 22, 15, 0, -22 },
  { 526, 15, 22, 15, 0, -22 },
  { 568, 13, 22, 15, 2, -22 },
  { 604, 12, 22, 15, 3, -22 },
  { 637, 14, 22, 15, 1, -22 },
  { 676, 13, 22, 15, 1, -22 },
  { 712, 5, 17, 6, 1, -17 },
  { 723, 7, 21, 6, -1, -17 },
  { 742, 13, 14, 16, 2, -18 },
  { 765, 13, 8, 16, 2, -15 },
  { 778, 13, 14, 16, 2, -18 },
  { 801, 10, 22, 11, 2, -22 },
  { 829, 21, 25, 22, 1, -22 },
  { 895, 15, 22, 15, -2, -22 },
  { 937, 15, 22, 16, 1, -22 },
  { 979, 15, 22, 16, 2, -22 },
  { 1021, 16, 22, 18, 1, -22 },
  { 1065, 14, 22, 14, 1, -22 },
  { 1104, 14, 22, 13, 1, -22 },
  { 1143, 17, 22, 19, 2, -22 },
  { 1190, 18, 22, 18, 1, -22 },
  { 1240, 10, 22, 8, -1, -22 },
  { 1268, 12, 27, 7, -5, -22 },
  { 1309, 16, 22, 15, 1, -22 },
  { 1353, 10, 22, 13, 1, -22 },
  { 1381, 22, 22, 23, 1, -22 },
  { 1442, 18, 22, 19, 1, -22 },
  { 1492, 16, 22, 19, 2, -22 },
  { 1536, 14, 22, 15, 1, -22 },
  { 1575, 16, 27, 19, 2, -22 },
  { 1629, 14, 22, 15, 1, -22 },
  { 1668, 14, 22, 14, 0, -22 },
  { 1707, 13, 22, 13, 3, -22 },
  { 1743, 17, 22, 18, 2, -22 },
  { 1790, 14, 22, 15, 3, -22 },
  { 1829, 22, 22, 23, 3, -22 },
  { 1890, 18, 22, 13, -2, -22 },
  { 1940, 13, 22, 13, 3, -22 },
  { 1976, 16, 22, 14, -1, -22 },
  { 2020, 11, 27, 9, 0, -22 },
  { 2058, 5, 22, 10, 3, -22 },
  { 2072, 11, 27, 9, -2, -22 },
  { 2110, 13, 12, 15, 1, -22 },
  { 2130, 11, 1, 10, -3, 3 },
  { 2132, 3, 5, 7, 5, -24 },
  { 2134, 14, 17, 15, 1, -17 },
  { 2164, 13, 24, 16, 1, -24 },
  { 2203, 12, 17, 12, 1, -17 },
  { 2229, 15, 24, 16, 1, -24 },
  { 2274, 12, 17, 14, 1, -17 },
  { 2300, 16, 31, 8, -4, -24 },
  { 2362, 15, 24, 16, 0, -17 },
  { 2407, 13, 24, 15, 1, -24 },
  { 2446, 6, 22, 6, 1, -22 },
  { 2463, 11, 29, 6, -4, -22 },
  { 2503, 12, 24, 12, 1, -24 },
  { 2539, 6, 24, 6, 1, -24 },
  { 2557, 21, 17, 23, 1, -17 },
  { 2602, 13, 17, 15, 1, -17 },
  { 2630, 13, 17, 15, 1, -17 },
  { 2658, 15, 24, 16, -1, -17 },
  { 2703, 14, 24, 16, 1, -17 },
  { 2745, 10, 17, 10, 1, -17 },
  { 2767, 11, 17, 12, 0, -17 },
  { 2791, 8, 20, 8, 1, -20 },
  { 2811, 13, 16, 15, 1, -16 },
  { 2837, 11, 16, 12, 2, -16 },
  { 2859, 18, 16, 18, 2, -16 },
  { 2895, 14, 16, 12, -1, -16 },
  { 2923, 16, 24, 12, -3, -16 },
  { 2971, 13, 16, 11, -1, -16 },
  { 2997, 11, 27, 10, 1, -22 },
  { 3035, 1, 32, 15, 7, -24 },
  { 3039, 11, 27, 10, -2, -22 },
  { 3077, 13, 3, 16, 2, -12 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC31PT7B_H_
