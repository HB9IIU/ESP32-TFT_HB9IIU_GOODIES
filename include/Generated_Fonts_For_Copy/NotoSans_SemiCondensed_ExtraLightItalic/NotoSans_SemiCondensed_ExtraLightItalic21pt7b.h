#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC21PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0x10, 0x00, 0x03, 0x00, 0x4A,
  0x55, 0x29, 0x00, 0x02, 0x40, 0x88, 0x11, 0x02, 0x23, 0xFE, 0x11, 0x02,
  0x20, 0x88, 0x11, 0x0F, 0xBA, 0x48, 0x11, 0x02, 0x20, 0x44, 0x11, 0x00,
  0x04, 0x02, 0x07, 0xE4, 0x84, 0x42, 0x40, 0xA0, 0x70, 0x08, 0x07, 0x04,
  0x82, 0x41, 0x20, 0xB3, 0xE0, 0x40, 0x20, 0x00, 0x3C, 0x12, 0x42, 0x44,
  0x44, 0x44, 0x44, 0x88, 0x50, 0x89, 0x78, 0xA9, 0x74, 0x90, 0x51, 0x09,
  0x11, 0x11, 0x11, 0x12, 0x12, 0x41, 0xC0, 0x07, 0x81, 0x10, 0x22, 0x08,
  0x40, 0x88, 0x16, 0x03, 0x00, 0xE0, 0x24, 0x28, 0x45, 0x05, 0x40, 0xC8,
  0x08, 0x87, 0x1F, 0x10, 0x56, 0x80, 0x0C, 0x41, 0x08, 0x41, 0x04, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0x00, 0x18, 0x20, 0x82, 0x04,
  0x10, 0x41, 0x08, 0x20, 0x82, 0x10, 0x42, 0x08, 0x42, 0x00, 0x10, 0x22,
  0x43, 0xF3, 0x0A, 0x22, 0x04, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40,
  0x20, 0x10, 0x08, 0x00, 0x29, 0x28, 0xF0, 0xC0, 0x00, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02,
  0x00, 0x0F, 0x08, 0x88, 0x28, 0x14, 0x0A, 0x06, 0x03, 0x02, 0x81, 0x40,
  0xA0, 0x50, 0x48, 0x24, 0x21, 0xE0, 0x19, 0x74, 0x21, 0x08, 0x44, 0x21,
  0x08, 0x84, 0x21, 0x00, 0x0F, 0x84, 0x20, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0F, 0xF0, 0x0F,
  0x84, 0x20, 0x04, 0x01, 0x00, 0x80, 0x20, 0x30, 0x78, 0x01, 0x00, 0x40,
  0x08, 0x04, 0x01, 0x00, 0x8F, 0xC0, 0x00, 0xC0, 0x60, 0x28, 0x0A, 0x04,
  0x82, 0x41, 0x10, 0x44, 0x21, 0x10, 0x4F, 0xF8, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x0F, 0xC4, 0x01, 0x00, 0x40, 0x10, 0x08, 0x03, 0xE0, 0x04, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x8F, 0xC0, 0x07, 0x8C, 0x04, 0x04,
  0x04, 0x02, 0x01, 0xF9, 0x82, 0x81, 0x40, 0xA0, 0x50, 0x28, 0x24, 0x11,
  0xF0, 0xFF, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20,
  0x20, 0x40, 0x80, 0x80, 0x1F, 0x10, 0x48, 0x24, 0x12, 0x09, 0x08, 0x58,
  0x38, 0x62, 0x41, 0x20, 0x50, 0x28, 0x24, 0x11, 0xF0, 0x1E, 0x10, 0x90,
  0x28, 0x14, 0x0A, 0x05, 0x04, 0x86, 0x3D, 0x00, 0x80, 0x80, 0x40, 0x40,
  0x43, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x10, 0x88, 0x40, 0x01, 0x83, 0x06, 0x04, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x08, 0x18, 0x30, 0x60, 0xC0, 0x00, 0x7C, 0x04, 0x08,
  0x10, 0x20, 0x82, 0x08, 0x20, 0x81, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xE0, 0x30, 0x41, 0x00, 0x88, 0x01, 0x41, 0xC5, 0x19, 0x18, 0x84, 0x62,
  0x11, 0x88, 0x8A, 0x42, 0x29, 0x08, 0xA2, 0x64, 0x8E, 0x62, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x1F, 0x80, 0x01, 0x00, 0x60, 0x28, 0x0A, 0x04, 0x81,
  0x20, 0x88, 0x22, 0x10, 0x87, 0xE2, 0x08, 0x81, 0x40, 0x50, 0x18, 0x04,
  0x1F, 0x08, 0x22, 0x04, 0x81, 0x20, 0x48, 0x24, 0x11, 0xF8, 0x41, 0x10,
  0x24, 0x0A, 0x02, 0x81, 0x20, 0x8F, 0xC0, 0x07, 0xE1, 0x00, 0x40, 0x10,
  0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x0F, 0xC0, 0x1F, 0x04, 0x10, 0x81, 0x10, 0x22, 0x02, 0x40,
  0x50, 0x0A, 0x02, 0x40, 0x48, 0x09, 0x02, 0x40, 0x48, 0x11, 0x0C, 0x3E,
  0x00, 0x1F, 0x90, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0xFE, 0x40, 0x20,
  0x10, 0x10, 0x08, 0x04, 0x03, 0xF0, 0x1F, 0x90, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x00, 0xFE, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x00, 0x07,
  0xF0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x38, 0x80,
  0x48, 0x04, 0x80, 0x48, 0x04, 0x40, 0x44, 0x08, 0x3F, 0x80, 0x10, 0x12,
  0x02, 0x20, 0x22, 0x02, 0x20, 0x22, 0x02, 0x40, 0x47, 0xFC, 0x40, 0x44,
  0x04, 0x40, 0x88, 0x08, 0x80, 0x88, 0x08, 0x80, 0x80, 0x1C, 0x20, 0x84,
  0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x41, 0x0E, 0x00, 0x01, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x10, 0xE0, 0x10, 0x64, 0x10, 0x84, 0x11, 0x02, 0x40, 0x50,
  0x14, 0x03, 0x40, 0x48, 0x08, 0x81, 0x10, 0x42, 0x08, 0x21, 0x04, 0x20,
  0x40, 0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82, 0x0F,
  0xC0, 0x10, 0x06, 0x20, 0x18, 0xC0, 0x31, 0x40, 0xA2, 0x81, 0x45, 0x05,
  0x12, 0x0A, 0x24, 0x24, 0x48, 0x48, 0x91, 0x12, 0x24, 0x44, 0x28, 0x88,
  0x61, 0x10, 0xC2, 0x21, 0x04, 0x00, 0x10, 0x11, 0x01, 0x28, 0x22, 0x82,
  0x28, 0x22, 0x42, 0x44, 0x44, 0x44, 0x42, 0x44, 0x24, 0x42, 0x48, 0x18,
  0x81, 0x88, 0x18, 0x80, 0x80, 0x0F, 0xC2, 0x04, 0x80, 0x90, 0x14, 0x02,
  0x80, 0x50, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x40, 0x24, 0x08, 0x83,
  0x0F, 0x80, 0x1F, 0x10, 0x48, 0x24, 0x12, 0x09, 0x05, 0x02, 0x86, 0x7C,
  0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x00, 0x0F, 0xC2, 0x04, 0x80, 0x90,
  0x14, 0x02, 0x80, 0x50, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x40, 0x24,
  0x08, 0x83, 0x0F, 0x80, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x1F, 0x10,
  0x48, 0x24, 0x12, 0x09, 0x05, 0x04, 0x84, 0x7C, 0x22, 0x11, 0x10, 0x48,
  0x24, 0x12, 0x0C, 0x0F, 0xC4, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x8F, 0xC0, 0xFF, 0x84,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x30, 0x12, 0x02, 0x20, 0x22, 0x02, 0x20, 0x24, 0x02,
  0x40, 0x44, 0x04, 0x40, 0x44, 0x04, 0x80, 0x48, 0x08, 0x80, 0x84, 0x10,
  0x3E, 0x00, 0x80, 0xE0, 0x28, 0x12, 0x04, 0x82, 0x20, 0x88, 0x42, 0x10,
  0x48, 0x12, 0x05, 0x01, 0x40, 0x60, 0x18, 0x04, 0x00, 0x81, 0x03, 0x02,
  0x06, 0x0C, 0x14, 0x18, 0x28, 0x50, 0x90, 0xA1, 0x22, 0x44, 0x44, 0x48,
  0x90, 0x91, 0x21, 0x42, 0x42, 0x85, 0x06, 0x0A, 0x0C, 0x08, 0x10, 0x10,
  0x20, 0x00, 0x10, 0x30, 0x82, 0x08, 0x40, 0x88, 0x05, 0x00, 0x50, 0x06,
  0x00, 0x60, 0x0A, 0x00, 0xA0, 0x12, 0x02, 0x10, 0x21, 0x04, 0x10, 0x80,
  0x80, 0x81, 0xC0, 0xA0, 0x88, 0x44, 0x42, 0x41, 0x20, 0xA0, 0x20, 0x10,
  0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x1F, 0xC0, 0x10, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x0F,
  0xF0, 0x0F, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0xF0, 0x92, 0x24, 0x92, 0x44, 0x92,
  0x48, 0x1E, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40,
  0x81, 0x04, 0x08, 0x11, 0xE0, 0x04, 0x06, 0x04, 0x82, 0x42, 0x21, 0x09,
  0x05, 0x01, 0x80, 0x80, 0xFE, 0x94, 0x1E, 0x90, 0x90, 0x48, 0x28, 0x14,
  0x0A, 0x09, 0x04, 0x82, 0x43, 0x1E, 0x80, 0x08, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x07, 0xE3, 0x08, 0xC1, 0x20, 0x48, 0x14, 0x09, 0x02, 0x40, 0x90,
  0x46, 0x12, 0x78, 0x1E, 0x41, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x01,
  0xF0, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x87, 0xA2, 0x19, 0x04, 0x41,
  0x20, 0x48, 0x12, 0x04, 0x82, 0x20, 0x88, 0x61, 0xE8, 0x1E, 0x21, 0x41,
  0x42, 0x84, 0xF8, 0x80, 0x80, 0x80, 0x80, 0x7C, 0x00, 0xE0, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x1F, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x0E,
  0x00, 0x0F, 0x44, 0x32, 0x08, 0x82, 0x40, 0x90, 0x24, 0x09, 0x04, 0x41,
  0x10, 0xC3, 0xD0, 0x04, 0x02, 0x00, 0x80, 0x43, 0xE0, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x00, 0xFC, 0xC2, 0x61, 0x20, 0x90, 0x48, 0x28, 0x14, 0x12,
  0x09, 0x05, 0x02, 0x18, 0x00, 0x01, 0x10, 0x84, 0x21, 0x10, 0x84, 0x22,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0xE0, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x84, 0x84, 0x44, 0x24, 0x14, 0x16, 0x0C, 0x84, 0x42,
  0x21, 0x09, 0x04, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0x10, 0x84, 0x21,
  0x10, 0x1F, 0x3C, 0x61, 0x84, 0x82, 0x09, 0x04, 0x22, 0x08, 0x44, 0x20,
  0x90, 0x41, 0x20, 0x82, 0x41, 0x08, 0x84, 0x12, 0x08, 0x20, 0x1F, 0x98,
  0x4C, 0x24, 0x12, 0x09, 0x05, 0x02, 0x82, 0x41, 0x20, 0xA0, 0x40, 0x1E,
  0x21, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x7C, 0x0B, 0xC2,
  0x88, 0x60, 0x88, 0x11, 0x02, 0x20, 0x88, 0x11, 0x02, 0x20, 0x84, 0x11,
  0x7C, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x1E, 0x90, 0xD0, 0x48,
  0x28, 0x14, 0x0A, 0x05, 0x04, 0x82, 0x43, 0x1E, 0x80, 0x40, 0x40, 0x20,
  0x10, 0x08, 0x1F, 0x30, 0x30, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x80, 0x3F, 0x20, 0x40, 0x20, 0x30, 0x18, 0x04, 0x04, 0x04, 0x04, 0xF8,
  0x21, 0x09, 0xF4, 0x21, 0x08, 0x84, 0x21, 0x08, 0x70, 0x40, 0xA0, 0x90,
  0x48, 0x24, 0x14, 0x0A, 0x09, 0x04, 0x82, 0x43, 0x3E, 0x80, 0x81, 0x82,
  0x82, 0x84, 0x88, 0x48, 0x50, 0x50, 0x60, 0x60, 0x40, 0x82, 0x18, 0x61,
  0x86, 0x28, 0xA2, 0x8A, 0x49, 0x24, 0x92, 0x8A, 0x28, 0xA2, 0x84, 0x30,
  0x41, 0x00, 0x10, 0xC4, 0x20, 0x90, 0x28, 0x0C, 0x01, 0x00, 0xC0, 0x48,
  0x22, 0x10, 0x8C, 0x10, 0x10, 0x22, 0x08, 0x41, 0x04, 0x40, 0x88, 0x12,
  0x02, 0x40, 0x50, 0x0A, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x08,
  0x06, 0x00, 0x3F, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80,
  0xFC, 0x06, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x41, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x40, 0x80, 0xC0, 0xFF, 0xFF, 0xF8, 0x1C, 0x08, 0x08, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x0C, 0x20, 0x41, 0x02, 0x04, 0x08, 0x21, 0xC0,
  0xFC, 0x81, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 15, 5, 0, -15 },
  { 11, 5, 5, 6, 2, -15 },
  { 15, 11, 15, 11, 0, -15 },
  { 36, 9, 17, 10, 1, -16 },
  { 56, 12, 15, 14, 1, -15 },
  { 79, 11, 15, 12, 0, -15 },
  { 100, 2, 5, 4, 2, -15 },
  { 102, 6, 18, 5, 1, -15 },
  { 116, 6, 18, 5, -1, -15 },
  { 130, 7, 8, 10, 3, -16 },
  { 137, 9, 9, 11, 1, -12 },
  { 148, 3, 5, 4, -1, -2 },
  { 150, 4, 1, 6, 1, -6 },
  { 151, 2, 1, 4, 0, -1 },
  { 152, 9, 15, 7, -1, -15 },
  { 169, 9, 15, 10, 1, -15 },
  { 186, 5, 15, 10, 3, -15 },
  { 196, 10, 15, 10, 0, -15 },
  { 215, 10, 15, 10, 0, -15 },
  { 234, 10, 15, 10, 0, -15 },
  { 253, 10, 15, 10, 0, -15 },
  { 272, 9, 15, 10, 1, -15 },
  { 289, 8, 15, 10, 2, -15 },
  { 304, 9, 15, 10, 1, -15 },
  { 321, 9, 15, 10, 1, -15 },
  { 338, 4, 11, 4, 0, -11 },
  { 344, 5, 14, 4, -1, -11 },
  { 353, 9, 9, 11, 1, -12 },
  { 364, 9, 5, 11, 1, -10 },
  { 370, 9, 9, 11, 1, -12 },
  { 381, 7, 15, 7, 1, -15 },
  { 395, 14, 17, 15, 1, -15 },
  { 425, 10, 15, 10, -1, -15 },
  { 444, 10, 15, 11, 1, -15 },
  { 463, 11, 15, 11, 1, -15 },
  { 484, 11, 15, 12, 1, -15 },
  { 505, 9, 15, 10, 1, -15 },
  { 522, 9, 15, 9, 1, -15 },
  { 539, 12, 15, 13, 1, -15 },
  { 562, 12, 15, 13, 1, -15 },
  { 585, 6, 15, 5, 0, -15 },
  { 597, 8, 19, 4, -3, -15 },
  { 616, 11, 15, 10, 1, -15 },
  { 637, 6, 15, 9, 1, -15 },
  { 649, 15, 15, 15, 1, -15 },
  { 678, 12, 15, 13, 1, -15 },
  { 701, 11, 15, 13, 1, -15 },
  { 722, 9, 15, 10, 1, -15 },
  { 739, 11, 19, 13, 1, -15 },
  { 766, 9, 15, 10, 1, -15 },
  { 783, 10, 15, 9, 0, -15 },
  { 802, 9, 15, 9, 2, -15 },
  { 819, 12, 15, 13, 1, -15 },
  { 842, 10, 15, 10, 2, -15 },
  { 861, 15, 15, 16, 2, -15 },
  { 890, 12, 15, 9, -1, -15 },
  { 913, 9, 15, 9, 2, -15 },
  { 930, 10, 15, 10, 0, -15 },
  { 949, 8, 18, 6, 0, -15 },
  { 967, 3, 15, 7, 2, -15 },
  { 973, 7, 18, 6, -1, -15 },
  { 989, 9, 9, 10, 1, -15 },
  { 1000, 7, 1, 7, -2, 2 },
  { 1001, 2, 3, 5, 3, -16 },
  { 1002, 9, 11, 10, 1, -11 },
  { 1015, 10, 16, 11, 0, -16 },
  { 1035, 7, 11, 8, 1, -11 },
  { 1045, 10, 16, 11, 1, -16 },
  { 1065, 8, 11, 9, 1, -11 },
  { 1076, 11, 21, 5, -3, -16 },
  { 1105, 10, 16, 11, 0, -11 },
  { 1125, 9, 16, 10, 0, -16 },
  { 1143, 5, 15, 4, 0, -15 },
  { 1153, 8, 20, 4, -3, -15 },
  { 1173, 9, 16, 8, 0, -16 },
  { 1191, 5, 16, 4, 0, -16 },
  { 1201, 15, 11, 16, 0, -11 },
  { 1222, 9, 11, 10, 0, -11 },
  { 1235, 8, 11, 10, 1, -11 },
  { 1246, 11, 16, 11, -1, -11 },
  { 1268, 9, 16, 11, 1, -11 },
  { 1286, 8, 11, 7, 0, -11 },
  { 1297, 8, 11, 8, 0, -11 },
  { 1308, 5, 14, 6, 1, -14 },
  { 1317, 9, 11, 10, 1, -11 },
  { 1330, 8, 11, 8, 1, -11 },
  { 1341, 12, 11, 13, 1, -11 },
  { 1358, 10, 11, 8, -1, -11 },
  { 1372, 11, 16, 8, -2, -11 },
  { 1394, 8, 11, 8, 0, -11 },
  { 1405, 7, 18, 7, 1, -15 },
  { 1421, 1, 21, 10, 5, -16 },
  { 1424, 7, 18, 7, -1, -15 },
  { 1440, 9, 2, 11, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC21PT7B_H_
