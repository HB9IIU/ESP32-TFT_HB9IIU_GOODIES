#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC36PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x60, 0xC1,
  0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x00, 0x00, 0x00, 0x20, 0xC1, 0x80,
  0x63, 0x63, 0x42, 0x42, 0x42, 0x46, 0xC4, 0x84, 0x84, 0x84, 0x00, 0x40,
  0x80, 0x08, 0x30, 0x03, 0x04, 0x00, 0x40, 0x80, 0x08, 0x30, 0x03, 0x04,
  0x00, 0x40, 0x80, 0x08, 0x10, 0x3F, 0xFF, 0xE0, 0x60, 0x80, 0x08, 0x10,
  0x01, 0x06, 0x00, 0x60, 0x80, 0x08, 0x10, 0x01, 0x06, 0x00, 0x60, 0x80,
  0x08, 0x10, 0x1F, 0xFF, 0xE0, 0x20, 0xC0, 0x0C, 0x10, 0x01, 0x02, 0x00,
  0x20, 0xC0, 0x0C, 0x10, 0x01, 0x02, 0x00, 0x20, 0xC0, 0x0C, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x03, 0xFE, 0x06, 0x23, 0x0C, 0x40,
  0x18, 0x40, 0x18, 0x40, 0x10, 0x40, 0x18, 0x40, 0x18, 0x80, 0x0C, 0x80,
  0x06, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0x70, 0x01, 0x18, 0x01, 0x18,
  0x01, 0x08, 0x03, 0x08, 0x02, 0x08, 0x02, 0x18, 0x02, 0x30, 0xC2, 0x60,
  0x7F, 0xC0, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0F, 0x00,
  0x61, 0x18, 0x04, 0x20, 0x80, 0x86, 0x08, 0x18, 0x40, 0x81, 0x04, 0x08,
  0x20, 0xC0, 0x86, 0x08, 0x18, 0x40, 0x81, 0x8C, 0x08, 0x11, 0x80, 0x81,
  0x11, 0xC8, 0x33, 0x36, 0x82, 0x26, 0x38, 0x64, 0xC1, 0xCC, 0xC8, 0x17,
  0x88, 0x81, 0x01, 0x18, 0x10, 0x31, 0x03, 0x02, 0x10, 0x30, 0x41, 0x02,
  0x0C, 0x10, 0x20, 0x83, 0x06, 0x10, 0x30, 0x43, 0x01, 0x0C, 0x20, 0x10,
  0x84, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x63, 0x00, 0x30, 0x60, 0x08, 0x18,
  0x06, 0x06, 0x01, 0x01, 0x80, 0x40, 0x40, 0x10, 0x30, 0x06, 0x08, 0x00,
  0x8C, 0x00, 0x36, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x20, 0x01, 0x8C,
  0x04, 0xC1, 0x03, 0x60, 0x60, 0x90, 0x08, 0x6C, 0x03, 0x12, 0x00, 0x68,
  0x80, 0x0E, 0x20, 0x03, 0x08, 0x01, 0xC3, 0x00, 0xD8, 0x60, 0xE2, 0x0F,
  0xE0, 0xC0, 0x6D, 0x24, 0xB4, 0x90, 0x00, 0x40, 0x20, 0x10, 0x0C, 0x06,
  0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x18, 0x04,
  0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00,
  0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x03, 0x00,
  0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01,
  0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x40, 0x30, 0x18, 0x04,
  0x02, 0x00, 0x01, 0x80, 0x08, 0x00, 0x41, 0x82, 0x07, 0x20, 0x0D, 0x0C,
  0x1F, 0xE0, 0xC0, 0x09, 0x00, 0x88, 0x18, 0x20, 0x81, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x0C, 0x21, 0x84, 0x30,
  0x86, 0x10, 0xC0, 0xFF, 0x7C, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x06,
  0x30, 0x10, 0x30, 0x40, 0x21, 0x80, 0x62, 0x00, 0xCC, 0x01, 0x90, 0x03,
  0x60, 0x06, 0xC0, 0x0D, 0x00, 0x12, 0x00, 0x2C, 0x00, 0x58, 0x00, 0xA0,
  0x03, 0x40, 0x06, 0x80, 0x09, 0x00, 0x12, 0x00, 0x64, 0x00, 0x88, 0x03,
  0x10, 0x04, 0x30, 0x18, 0x60, 0x60, 0x61, 0x80, 0x7E, 0x00, 0x01, 0x07,
  0x0D, 0x3B, 0x62, 0xC2, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C,
  0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20,
  0x00, 0xFC, 0x03, 0x86, 0x06, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFC, 0x01, 0xC3, 0x01, 0x80, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x03, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0xC0, 0x70, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x05, 0x00, 0x0B, 0x00, 0x1A, 0x00, 0x32,
  0x00, 0x22, 0x00, 0x46, 0x00, 0xC6, 0x01, 0x84, 0x01, 0x04, 0x02, 0x04,
  0x04, 0x0C, 0x0C, 0x0C, 0x18, 0x08, 0x10, 0x08, 0x20, 0x08, 0x60, 0x18,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x03, 0xFF, 0x03, 0xFF, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x1F, 0xE0, 0x10, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x80, 0xC0, 0xFF, 0x80, 0x00, 0x7E, 0x03, 0x84,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x8F, 0x02, 0x73, 0x85, 0x01, 0x9C, 0x01, 0x30, 0x02,
  0x60, 0x04, 0xC0, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0xC8, 0x01, 0x90,
  0x02, 0x30, 0x0C, 0x20, 0x30, 0x60, 0xC0, 0x7F, 0x00, 0x7F, 0xFE, 0xFF,
  0xFC, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x00, 0x01, 0xF8,
  0x03, 0x0E, 0x06, 0x02, 0x0C, 0x03, 0x08, 0x03, 0x08, 0x01, 0x08, 0x03,
  0x08, 0x02, 0x08, 0x06, 0x04, 0x04, 0x06, 0x18, 0x03, 0x70, 0x01, 0xC0,
  0x06, 0x60, 0x18, 0x30, 0x30, 0x18, 0x60, 0x08, 0xC0, 0x0C, 0xC0, 0x0C,
  0x80, 0x0C, 0x80, 0x0C, 0x80, 0x08, 0xC0, 0x08, 0x40, 0x10, 0x70, 0x70,
  0x1F, 0xC0, 0x01, 0xF0, 0x06, 0x38, 0x10, 0x10, 0x40, 0x31, 0x80, 0x22,
  0x00, 0x4C, 0x00, 0x98, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00,
  0x33, 0x00, 0xE2, 0x03, 0xC7, 0x0D, 0x03, 0xE2, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x83,
  0x81, 0xFC, 0x00, 0x1C, 0x60, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x43, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x18, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x00, 0x1F, 0x83, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xC0, 0x07,
  0x00, 0xC0, 0x18, 0x00, 0x40, 0x60, 0x00, 0x41, 0x80, 0x00, 0x86, 0x00,
  0x01, 0x88, 0x00, 0x01, 0x20, 0x3F, 0x82, 0x40, 0xC1, 0x05, 0x03, 0x06,
  0x0A, 0x0C, 0x08, 0x1C, 0x10, 0x10, 0x30, 0x60, 0x20, 0x60, 0x80, 0xC1,
  0xC1, 0x01, 0x02, 0x82, 0x02, 0x05, 0x04, 0x0C, 0x1A, 0x08, 0x18, 0x24,
  0x10, 0x50, 0x88, 0x31, 0x23, 0x10, 0x3C, 0x38, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x03, 0x00, 0x02, 0x80,
  0x01, 0x40, 0x01, 0x20, 0x01, 0x90, 0x00, 0x88, 0x00, 0xC4, 0x00, 0x42,
  0x00, 0x61, 0x80, 0x20, 0xC0, 0x30, 0x60, 0x10, 0x30, 0x18, 0x08, 0x08,
  0x04, 0x0F, 0xFE, 0x04, 0x01, 0x06, 0x00, 0x82, 0x00, 0x43, 0x00, 0x21,
  0x00, 0x19, 0x80, 0x0C, 0x80, 0x06, 0xC0, 0x03, 0x40, 0x00, 0xE0, 0x00,
  0x40, 0x07, 0xF8, 0x03, 0xFF, 0x81, 0x80, 0x60, 0x80, 0x30, 0x40, 0x08,
  0x60, 0x04, 0x30, 0x02, 0x10, 0x01, 0x08, 0x01, 0x84, 0x00, 0x86, 0x00,
  0xC3, 0x01, 0x81, 0xFF, 0x00, 0x80, 0xE0, 0x40, 0x18, 0x60, 0x04, 0x30,
  0x02, 0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0x46, 0x00, 0x22, 0x00, 0x31,
  0x00, 0x30, 0x80, 0x30, 0xC0, 0x70, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x38, 0x70, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x08, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0xC0, 0x18, 0x0C, 0x02, 0x00, 0xC0, 0x40, 0x0C, 0x18, 0x00, 0x83, 0x00,
  0x18, 0x40, 0x03, 0x08, 0x00, 0x61, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00,
  0x31, 0x00, 0x06, 0x20, 0x00, 0x84, 0x00, 0x11, 0x80, 0x06, 0x30, 0x00,
  0xC4, 0x00, 0x10, 0x80, 0x06, 0x30, 0x00, 0x86, 0x00, 0x30, 0x80, 0x0C,
  0x10, 0x03, 0x02, 0x01, 0xC0, 0xC1, 0xE0, 0x1F, 0xF0, 0x00, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0xFF, 0xC0, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xE0,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x1C, 0x3C, 0x0E, 0x00, 0x83, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x3F, 0xB0,
  0x08, 0x26, 0x00, 0x04, 0xC0, 0x00, 0x98, 0x00, 0x33, 0x00, 0x06, 0x20,
  0x00, 0x84, 0x00, 0x10, 0xC0, 0x02, 0x18, 0x00, 0xC1, 0x80, 0x18, 0x1C,
  0x06, 0x01, 0xFF, 0x80, 0x02, 0x00, 0x18, 0x30, 0x00, 0x81, 0x80, 0x04,
  0x08, 0x00, 0x20, 0x40, 0x03, 0x06, 0x00, 0x10, 0x30, 0x00, 0x81, 0x00,
  0x04, 0x08, 0x00, 0x60, 0x40, 0x03, 0x06, 0x00, 0x10, 0x30, 0x00, 0x81,
  0xFF, 0xFC, 0x08, 0x00, 0x60, 0x40, 0x03, 0x06, 0x00, 0x10, 0x30, 0x00,
  0x81, 0x00, 0x04, 0x08, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x10, 0x20,
  0x00, 0x81, 0x00, 0x0C, 0x08, 0x00, 0x60, 0xC0, 0x02, 0x06, 0x00, 0x10,
  0x00, 0x03, 0xF0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x0F, 0xE0, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x3F, 0x00,
  0x06, 0x00, 0x60, 0xC0, 0x18, 0x10, 0x06, 0x02, 0x01, 0x80, 0x40, 0x60,
  0x18, 0x18, 0x03, 0x06, 0x00, 0x41, 0x80, 0x08, 0x60, 0x01, 0x18, 0x00,
  0x66, 0x00, 0x0D, 0x80, 0x01, 0x78, 0x00, 0x29, 0x00, 0x06, 0x30, 0x01,
  0x86, 0x00, 0x30, 0x40, 0x04, 0x0C, 0x00, 0x80, 0x80, 0x30, 0x18, 0x06,
  0x03, 0x00, 0x80, 0x20, 0x10, 0x06, 0x02, 0x00, 0x40, 0xC0, 0x08, 0x18,
  0x01, 0x80, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x1F, 0xFC, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x60, 0x50, 0x00, 0x38,
  0x14, 0x00, 0x0A, 0x05, 0x00, 0x07, 0x83, 0x40, 0x01, 0x40, 0xD0, 0x00,
  0x90, 0x24, 0x00, 0x64, 0x09, 0x80, 0x13, 0x02, 0x60, 0x0C, 0xC1, 0x88,
  0x02, 0x20, 0x62, 0x01, 0x88, 0x10, 0x80, 0x42, 0x04, 0x20, 0x31, 0x81,
  0x08, 0x08, 0x60, 0xC2, 0x06, 0x10, 0x30, 0xC1, 0x04, 0x08, 0x30, 0x81,
  0x02, 0x04, 0x60, 0xC1, 0x81, 0x10, 0x30, 0x60, 0x4C, 0x08, 0x10, 0x12,
  0x02, 0x04, 0x05, 0x81, 0x81, 0x01, 0x40, 0x60, 0xC0, 0x70, 0x10, 0x30,
  0x18, 0x04, 0x00, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0xC0, 0x04, 0x0A,
  0x00, 0x20, 0x50, 0x01, 0x06, 0xC0, 0x18, 0x32, 0x00, 0xC1, 0x10, 0x04,
  0x08, 0xC0, 0x20, 0x42, 0x01, 0x06, 0x10, 0x18, 0x30, 0xC0, 0xC1, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0xC3, 0x06, 0x02, 0x18, 0x30, 0x10, 0x81,
  0x00, 0xC4, 0x08, 0x02, 0x20, 0xC0, 0x13, 0x06, 0x00, 0xD8, 0x20, 0x02,
  0x81, 0x00, 0x14, 0x08, 0x00, 0xE0, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x00,
  0x00, 0x7E, 0x00, 0x38, 0x70, 0x0C, 0x03, 0x02, 0x00, 0x20, 0xC0, 0x06,
  0x30, 0x00, 0xC4, 0x00, 0x09, 0x80, 0x01, 0x20, 0x00, 0x24, 0x00, 0x05,
  0x80, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x06, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x02, 0xC0, 0x00, 0x58, 0x00, 0x1B, 0x00, 0x02, 0x60, 0x00, 0xC4,
  0x00, 0x10, 0x80, 0x06, 0x18, 0x01, 0x81, 0x80, 0x60, 0x18, 0x18, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x01, 0x80, 0xC0, 0x80, 0x20, 0x40,
  0x18, 0x60, 0x0C, 0x30, 0x06, 0x10, 0x03, 0x08, 0x01, 0x84, 0x00, 0x86,
  0x00, 0xC3, 0x00, 0x41, 0x00, 0x60, 0x80, 0xC0, 0x7F, 0xC0, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x38, 0x70, 0x0C, 0x03, 0x02, 0x00, 0x20, 0xC0, 0x06, 0x30, 0x00,
  0xC4, 0x00, 0x09, 0x80, 0x01, 0x20, 0x00, 0x24, 0x00, 0x05, 0x80, 0x00,
  0xA0, 0x00, 0x14, 0x00, 0x06, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x02,
  0xC0, 0x00, 0x58, 0x00, 0x1B, 0x00, 0x02, 0x60, 0x00, 0xC4, 0x00, 0x10,
  0x80, 0x06, 0x18, 0x01, 0x81, 0x80, 0x60, 0x18, 0x18, 0x01, 0xFE, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x07, 0xF0, 0x03, 0xFF, 0x01, 0x80, 0xC0, 0x80, 0x20, 0x40,
  0x18, 0x60, 0x0C, 0x30, 0x06, 0x10, 0x03, 0x08, 0x01, 0x04, 0x00, 0x86,
  0x00, 0xC3, 0x00, 0xC1, 0x00, 0xC0, 0xFF, 0xC0, 0x7F, 0x00, 0x60, 0xC0,
  0x30, 0x60, 0x10, 0x10, 0x08, 0x08, 0x0C, 0x06, 0x06, 0x01, 0x02, 0x00,
  0x81, 0x00, 0x60, 0x80, 0x30, 0xC0, 0x08, 0x60, 0x06, 0x00, 0x00, 0xFE,
  0x01, 0xC3, 0xC1, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x60, 0xC0, 0x60, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x30, 0x80, 0x03,
  0x08, 0x00, 0x20, 0x80, 0x02, 0x18, 0x00, 0x61, 0x80, 0x06, 0x10, 0x00,
  0x41, 0x00, 0x04, 0x10, 0x00, 0x43, 0x00, 0x0C, 0x30, 0x00, 0xC2, 0x00,
  0x08, 0x20, 0x00, 0x82, 0x00, 0x08, 0x60, 0x01, 0x86, 0x00, 0x18, 0x40,
  0x01, 0x04, 0x00, 0x10, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x02, 0x0C,
  0x00, 0x60, 0x40, 0x04, 0x06, 0x00, 0x80, 0x30, 0x38, 0x01, 0xFE, 0x00,
  0xC0, 0x01, 0xA0, 0x00, 0x90, 0x00, 0xC8, 0x00, 0x44, 0x00, 0x62, 0x00,
  0x21, 0x00, 0x30, 0x80, 0x10, 0x40, 0x18, 0x30, 0x08, 0x18, 0x0C, 0x0C,
  0x04, 0x06, 0x06, 0x03, 0x02, 0x00, 0x83, 0x00, 0x41, 0x00, 0x21, 0x80,
  0x10, 0x80, 0x08, 0xC0, 0x04, 0x40, 0x02, 0x60, 0x01, 0x20, 0x00, 0xB0,
  0x00, 0x50, 0x00, 0x38, 0x00, 0x18, 0x00, 0x00, 0x80, 0x08, 0x00, 0xE0,
  0x02, 0x00, 0x28, 0x01, 0xC0, 0x1A, 0x00, 0x70, 0x04, 0x80, 0x3C, 0x03,
  0x20, 0x0B, 0x00, 0x88, 0x06, 0xC0, 0x62, 0x01, 0x30, 0x10, 0x80, 0xCC,
  0x04, 0x20, 0x23, 0x03, 0x08, 0x08, 0xC0, 0x82, 0x04, 0x30, 0x60, 0x81,
  0x04, 0x10, 0x30, 0xC1, 0x0C, 0x0C, 0x20, 0x42, 0x03, 0x18, 0x10, 0x80,
  0xC4, 0x04, 0x60, 0x33, 0x01, 0x10, 0x0C, 0x80, 0x4C, 0x03, 0x60, 0x12,
  0x00, 0xD0, 0x05, 0x80, 0x34, 0x01, 0x40, 0x0F, 0x00, 0x50, 0x03, 0x80,
  0x18, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0x00, 0x30,
  0x30, 0x02, 0x01, 0x00, 0x60, 0x10, 0x0C, 0x01, 0x80, 0x80, 0x08, 0x10,
  0x00, 0x83, 0x00, 0x0C, 0x60, 0x00, 0x44, 0x00, 0x04, 0xC0, 0x00, 0x58,
  0x00, 0x07, 0x00, 0x00, 0x20, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x09,
  0x00, 0x01, 0x10, 0x00, 0x31, 0x80, 0x06, 0x08, 0x00, 0x40, 0x80, 0x08,
  0x0C, 0x01, 0x80, 0xC0, 0x30, 0x04, 0x02, 0x00, 0x40, 0x60, 0x06, 0x0C,
  0x00, 0x20, 0xC0, 0x02, 0x80, 0x0D, 0x00, 0x32, 0x00, 0x46, 0x01, 0x8C,
  0x06, 0x08, 0x08, 0x10, 0x30, 0x20, 0x40, 0x61, 0x00, 0x46, 0x00, 0x88,
  0x01, 0x30, 0x03, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x80, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x03, 0xF0, 0x1F, 0x80, 0x84, 0x21, 0x0C,
  0x61, 0x08, 0x42, 0x18, 0xC2, 0x10, 0x84, 0x31, 0x84, 0x21, 0x08, 0x63,
  0x08, 0x40, 0x03, 0xF8, 0x1F, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x03, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x60, 0x00, 0x60, 0x00, 0xA0,
  0x01, 0xB0, 0x01, 0x10, 0x03, 0x10, 0x02, 0x18, 0x04, 0x08, 0x0C, 0x08,
  0x08, 0x04, 0x18, 0x04, 0x30, 0x06, 0x20, 0x02, 0x60, 0x02, 0xC0, 0x03,
  0xFF, 0xF0, 0xC4, 0x62, 0x31, 0x07, 0xE2, 0x18, 0x6C, 0x60, 0x51, 0x80,
  0x62, 0x00, 0xCC, 0x01, 0x90, 0x02, 0x60, 0x04, 0xC0, 0x09, 0x00, 0x32,
  0x00, 0x64, 0x00, 0x88, 0x01, 0x10, 0x06, 0x20, 0x0C, 0x40, 0x38, 0xC0,
  0xA0, 0x82, 0x41, 0xF8, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0xF8, 0x36, 0x18,
  0x78, 0x18, 0xA0, 0x11, 0x80, 0x23, 0x00, 0x4C, 0x00, 0x98, 0x01, 0x20,
  0x02, 0x40, 0x04, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x4C, 0x01, 0x98, 0x02,
  0x70, 0x0C, 0xA0, 0x31, 0x20, 0xC2, 0x3F, 0x00, 0x07, 0xF8, 0x60, 0x46,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x02, 0x0F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x07, 0xE2, 0x06, 0x09,
  0x06, 0x03, 0x86, 0x01, 0x82, 0x00, 0xC3, 0x00, 0x61, 0x00, 0x31, 0x80,
  0x18, 0xC0, 0x08, 0x40, 0x04, 0x20, 0x06, 0x10, 0x03, 0x08, 0x01, 0x84,
  0x01, 0x82, 0x00, 0xC1, 0x00, 0xA0, 0xC0, 0xF0, 0x20, 0xD0, 0x0F, 0x88,
  0x00, 0x07, 0xE0, 0x60, 0x86, 0x06, 0x60, 0x32, 0x01, 0xB0, 0x09, 0x00,
  0xD8, 0x0C, 0xC3, 0x87, 0xF0, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x02, 0x0F, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0xFC, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x3F, 0xC0, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xF8, 0x81, 0x82, 0x41, 0x80, 0xE1, 0x80, 0x60, 0x80, 0x30, 0xC0,
  0x18, 0x40, 0x0C, 0x60, 0x06, 0x30, 0x02, 0x10, 0x01, 0x08, 0x01, 0x84,
  0x00, 0xC2, 0x00, 0x61, 0x00, 0x60, 0x80, 0x30, 0x40, 0x28, 0x30, 0x3C,
  0x08, 0x36, 0x07, 0xE2, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x40, 0x20, 0x3F, 0xE0, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x09, 0xFC, 0x36, 0x08, 0x78, 0x18, 0xA0, 0x31, 0x80,
  0x62, 0x00, 0xCC, 0x01, 0x18, 0x02, 0x20, 0x04, 0x40, 0x18, 0x80, 0x33,
  0x00, 0x46, 0x00, 0x88, 0x01, 0x10, 0x06, 0x20, 0x0C, 0xC0, 0x11, 0x00,
  0x22, 0x00, 0xC0, 0x06, 0x0C, 0x10, 0x00, 0x00, 0x00, 0x04, 0x18, 0x30,
  0x40, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x30, 0x60,
  0x81, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x07, 0xC0, 0x18, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x06, 0x30, 0x10, 0x60, 0x40, 0x81, 0x01, 0x04, 0x02,
  0x10, 0x0C, 0x40, 0x19, 0x80, 0x26, 0x00, 0x56, 0x00, 0xC4, 0x03, 0x08,
  0x04, 0x18, 0x08, 0x10, 0x10, 0x30, 0x60, 0x60, 0xC0, 0x41, 0x00, 0xC2,
  0x00, 0x80, 0x06, 0x0C, 0x10, 0x20, 0x41, 0x82, 0x04, 0x08, 0x30, 0x60,
  0x81, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x60, 0xC1,
  0x02, 0x00, 0x09, 0xF8, 0x7E, 0x1B, 0x08, 0x83, 0x14, 0x0D, 0x03, 0x1C,
  0x06, 0x01, 0x18, 0x06, 0x01, 0x10, 0x04, 0x03, 0x30, 0x0C, 0x03, 0x30,
  0x0C, 0x02, 0x20, 0x08, 0x02, 0x20, 0x08, 0x02, 0x20, 0x18, 0x06, 0x60,
  0x18, 0x06, 0x60, 0x10, 0x04, 0x40, 0x10, 0x04, 0x40, 0x10, 0x04, 0xC0,
  0x30, 0x0C, 0xC0, 0x30, 0x08, 0x80, 0x20, 0x08, 0x80, 0x20, 0x08, 0x09,
  0xFC, 0x36, 0x18, 0x58, 0x18, 0xA0, 0x31, 0x80, 0x62, 0x00, 0xCC, 0x01,
  0x18, 0x02, 0x20, 0x04, 0x40, 0x18, 0x80, 0x33, 0x00, 0x46, 0x00, 0x88,
  0x01, 0x10, 0x06, 0x60, 0x0C, 0xC0, 0x11, 0x00, 0x22, 0x00, 0xC0, 0x07,
  0xF0, 0x30, 0x61, 0x80, 0x8C, 0x03, 0x20, 0x05, 0x80, 0x14, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x02, 0x80, 0x0A, 0x00, 0x68,
  0x01, 0x20, 0x0C, 0xC0, 0x61, 0x83, 0x03, 0xF8, 0x00, 0x02, 0x3E, 0x03,
  0x61, 0x81, 0x60, 0x60, 0xA0, 0x10, 0x60, 0x08, 0x30, 0x04, 0x30, 0x02,
  0x18, 0x01, 0x08, 0x00, 0x84, 0x00, 0x42, 0x00, 0x63, 0x00, 0x31, 0x80,
  0x10, 0xC0, 0x18, 0x60, 0x08, 0x30, 0x0C, 0x38, 0x0C, 0x12, 0x0C, 0x08,
  0xFC, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x07, 0xE2, 0x18, 0x24, 0x60,
  0x39, 0x80, 0x62, 0x00, 0xCC, 0x01, 0x90, 0x03, 0x60, 0x06, 0xC0, 0x09,
  0x00, 0x12, 0x00, 0x64, 0x00, 0xC8, 0x01, 0x90, 0x06, 0x20, 0x0C, 0x40,
  0x28, 0xC0, 0xF0, 0x83, 0x61, 0xF8, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x09, 0xF1,
  0xB0, 0x16, 0x01, 0x40, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x00, 0x07, 0xF8, 0x60, 0x44, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x46, 0x06, 0x1F, 0xC0, 0x04, 0x01,
  0x00, 0xC0, 0x20, 0x08, 0x5F, 0xE1, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0,
  0x30, 0x04, 0x01, 0xF0, 0x30, 0x06, 0x60, 0x08, 0x80, 0x11, 0x00, 0x22,
  0x00, 0xCC, 0x01, 0x98, 0x02, 0x20, 0x04, 0x40, 0x18, 0x80, 0x33, 0x00,
  0x46, 0x00, 0x88, 0x03, 0x10, 0x06, 0x20, 0x1C, 0x40, 0x30, 0x80, 0xA1,
  0x86, 0x41, 0xF8, 0x80, 0x80, 0x1C, 0x00, 0xA0, 0x0D, 0x80, 0x4C, 0x06,
  0x60, 0x21, 0x03, 0x08, 0x10, 0x41, 0x82, 0x08, 0x10, 0xC0, 0x84, 0x04,
  0x60, 0x22, 0x01, 0xB0, 0x0D, 0x00, 0x70, 0x01, 0x80, 0x08, 0x00, 0x80,
  0x20, 0x1C, 0x03, 0x00, 0xA0, 0x18, 0x0D, 0x01, 0x40, 0x4C, 0x0A, 0x06,
  0x60, 0xD0, 0x23, 0x04, 0x83, 0x18, 0x66, 0x10, 0xC2, 0x30, 0x86, 0x31,
  0x8C, 0x31, 0x0C, 0x41, 0x98, 0x26, 0x0C, 0x81, 0x20, 0x2C, 0x0B, 0x01,
  0x40, 0x50, 0x0E, 0x02, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x0C, 0x03, 0x04, 0x06, 0x04, 0x04, 0x06, 0x08, 0x02, 0x18, 0x02,
  0x30, 0x03, 0x20, 0x01, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x06,
  0xC0, 0x04, 0x40, 0x08, 0x40, 0x18, 0x60, 0x30, 0x20, 0x20, 0x30, 0x40,
  0x10, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x60, 0x0C, 0x0C, 0x01, 0x00, 0x80,
  0x60, 0x10, 0x08, 0x02, 0x03, 0x00, 0x40, 0x40, 0x08, 0x18, 0x01, 0x02,
  0x00, 0x20, 0x80, 0x06, 0x10, 0x00, 0xC4, 0x00, 0x08, 0x80, 0x01, 0x20,
  0x00, 0x2C, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x38,
  0x07, 0x80, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x60, 0x1E, 0x00,
  0xE0, 0x00, 0x80, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xF0,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0x80, 0x1F, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00,
  0x0F, 0x00, 0x78, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x03,
  0xE0, 0x1C, 0x00, 0x7F, 0x03, 0x83, 0x8E, 0x01, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 26, 8, 1, -26 },
  { 24, 8, 10, 11, 4, -26 },
  { 34, 19, 26, 19, 1, -26 },
  { 96, 16, 29, 17, 1, -27 },
  { 154, 20, 26, 25, 3, -26 },
  { 219, 18, 26, 20, 1, -26 },
  { 278, 3, 10, 6, 4, -26 },
  { 282, 10, 32, 9, 1, -26 },
  { 322, 10, 32, 9, -2, -26 },
  { 362, 13, 13, 16, 4, -27 },
  { 384, 15, 17, 18, 2, -21 },
  { 416, 6, 9, 7, -2, -4 },
  { 423, 8, 1, 11, 1, -10 },
  { 424, 2, 3, 7, 1, -3 },
  { 425, 16, 26, 11, -2, -26 },
  { 477, 15, 26, 17, 2, -26 },
  { 526, 8, 26, 17, 5, -26 },
  { 552, 16, 26, 17, 0, -26 },
  { 604, 17, 26, 17, 0, -26 },
  { 660, 16, 26, 17, 0, -26 },
  { 712, 16, 26, 17, 1, -26 },
  { 764, 15, 26, 17, 2, -26 },
  { 813, 15, 26, 17, 3, -26 },
  { 862, 16, 26, 17, 1, -26 },
  { 914, 15, 26, 17, 1, -26 },
  { 963, 6, 19, 7, 1, -19 },
  { 978, 9, 24, 7, -2, -19 },
  { 1005, 15, 16, 18, 2, -21 },
  { 1035, 15, 9, 18, 2, -17 },
  { 1052, 15, 16, 18, 2, -21 },
  { 1082, 12, 26, 13, 2, -26 },
  { 1121, 23, 29, 26, 2, -26 },
  { 1205, 17, 26, 17, -2, -26 },
  { 1261, 17, 26, 19, 1, -26 },
  { 1317, 18, 26, 18, 2, -26 },
  { 1376, 19, 26, 21, 1, -26 },
  { 1438, 17, 26, 17, 1, -26 },
  { 1494, 17, 26, 15, 1, -26 },
  { 1550, 19, 26, 22, 2, -26 },
  { 1612, 21, 26, 21, 1, -26 },
  { 1681, 12, 26, 9, -1, -26 },
  { 1720, 14, 32, 8, -6, -26 },
  { 1776, 19, 26, 17, 1, -26 },
  { 1838, 11, 26, 15, 1, -26 },
  { 1874, 26, 26, 26, 1, -26 },
  { 1959, 21, 26, 22, 1, -26 },
  { 2028, 19, 26, 22, 2, -26 },
  { 2090, 17, 26, 18, 1, -26 },
  { 2146, 19, 32, 22, 2, -26 },
  { 2222, 17, 26, 18, 1, -26 },
  { 2278, 17, 26, 16, 0, -26 },
  { 2334, 15, 26, 15, 3, -26 },
  { 2383, 20, 26, 21, 2, -26 },
  { 2448, 17, 26, 17, 3, -26 },
  { 2504, 26, 26, 27, 4, -26 },
  { 2589, 20, 26, 16, -2, -26 },
  { 2654, 15, 26, 15, 3, -26 },
  { 2703, 19, 26, 16, -1, -26 },
  { 2765, 13, 32, 10, 0, -26 },
  { 2817, 5, 26, 11, 4, -26 },
  { 2834, 13, 32, 10, -2, -26 },
  { 2886, 16, 15, 18, 1, -26 },
  { 2916, 12, 1, 12, -3, 4 },
  { 2918, 4, 6, 8, 5, -28 },
  { 2921, 15, 19, 18, 2, -19 },
  { 2957, 15, 27, 18, 1, -27 },
  { 3008, 13, 19, 14, 2, -19 },
  { 3039, 17, 27, 18, 2, -27 },
  { 3097, 13, 19, 16, 2, -19 },
  { 3128, 19, 37, 9, -5, -28 },
  { 3216, 17, 28, 18, 0, -19 },
  { 3276, 15, 27, 18, 1, -27 },
  { 3327, 7, 26, 7, 1, -26 },
  { 3350, 13, 35, 7, -5, -26 },
  { 3407, 15, 27, 14, 1, -27 },
  { 3458, 7, 27, 7, 1, -27 },
  { 3482, 24, 19, 27, 1, -19 },
  { 3539, 15, 19, 18, 1, -19 },
  { 3575, 14, 19, 18, 2, -19 },
  { 3609, 17, 27, 18, -1, -19 },
  { 3667, 15, 27, 18, 2, -19 },
  { 3718, 12, 19, 12, 1, -19 },
  { 3747, 13, 19, 13, 0, -19 },
  { 3778, 10, 24, 10, 1, -24 },
  { 3808, 15, 19, 18, 2, -19 },
  { 3844, 13, 19, 13, 2, -19 },
  { 3875, 21, 19, 21, 2, -19 },
  { 3925, 16, 19, 14, -1, -19 },
  { 3963, 19, 28, 14, -4, -19 },
  { 4030, 15, 19, 13, -1, -19 },
  { 4066, 13, 32, 12, 1, -26 },
  { 4118, 2, 36, 17, 8, -27 },
  { 4127, 13, 32, 12, -2, -26 },
  { 4179, 15, 3, 18, 2, -14 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC36PT7B_H_
