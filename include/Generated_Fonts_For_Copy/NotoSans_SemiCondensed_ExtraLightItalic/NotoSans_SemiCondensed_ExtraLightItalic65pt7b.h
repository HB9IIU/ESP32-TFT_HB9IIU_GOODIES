#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC65PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x00, 0x1C, 0x0E, 0x30, 0x38, 0xE0, 0x71, 0xC0, 0xE3,
  0x01, 0x86, 0x03, 0x0C, 0x0E, 0x38, 0x1C, 0x60, 0x30, 0xC0, 0x61, 0x80,
  0xC3, 0x01, 0x86, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x30, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xF6, 0x7F, 0x00, 0x70, 0x60, 0x70, 0x0E, 0x06,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x70, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x38, 0x18, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x1E, 0x30, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x07,
  0xB0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x06, 0x78, 0x00, 0x00, 0x63, 0xC0, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x0C, 0x07, 0x00, 0x01, 0x80, 0x70, 0x00, 0x18, 0x07, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x00, 0xE0, 0x00, 0x30,
  0x1C, 0x00, 0x03, 0x03, 0x80, 0xC0, 0x30, 0xF0, 0x0F, 0xC3, 0x7E, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x1C, 0x07, 0x8F, 0x00, 0x01, 0x80, 0xE0, 0x30,
  0x00, 0x38, 0x0C, 0x03, 0x00, 0x07, 0x01, 0xC0, 0x38, 0x00, 0x60, 0x18,
  0x03, 0x80, 0x0E, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x30, 0x03, 0x80, 0x18,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x70, 0x03, 0x80, 0x30, 0x06, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x03, 0x00, 0xE0, 0x0E, 0x00, 0x30, 0x0C, 0x00, 0xE0,
  0x03, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x38, 0x00, 0xC0, 0x07, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x06, 0x0E, 0x00, 0x0C, 0x00, 0xE0,
  0xC1, 0xFC, 0xC0, 0x0C, 0x18, 0x3F, 0xEC, 0x00, 0xC3, 0x87, 0x07, 0xC0,
  0x18, 0x30, 0xE0, 0x7C, 0x01, 0x87, 0x1C, 0x03, 0xC0, 0x30, 0xE1, 0x80,
  0x3E, 0x07, 0x0C, 0x38, 0x03, 0x70, 0xE1, 0xC3, 0x00, 0x33, 0xFC, 0x38,
  0x70, 0x03, 0x1F, 0x03, 0x07, 0x00, 0x30, 0x00, 0x70, 0x60, 0x03, 0x00,
  0x0E, 0x06, 0x00, 0x30, 0x00, 0xC0, 0xE0, 0x03, 0x00, 0x1C, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0xC0, 0x07, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x1C, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x0E, 0x01,
  0xC0, 0x1C, 0x00, 0xC0, 0x18, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x1C, 0x01,
  0xC0, 0x70, 0x01, 0xC0, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x80, 0xE0, 0x00,
  0xC0, 0x70, 0x1C, 0x00, 0x0E, 0x0E, 0x01, 0x80, 0x00, 0x7B, 0xC0, 0x38,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x60, 0x01, 0xC0,
  0x00, 0x60, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38, 0x78, 0x00,
  0x00, 0x1D, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xE3, 0x00, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x03, 0x0E, 0x01, 0xC0, 0x07,
  0x1C, 0x00, 0xE0, 0x06, 0x38, 0x00, 0xE0, 0x0E, 0x30, 0x00, 0x70, 0x0C,
  0x70, 0x00, 0x30, 0x1C, 0x60, 0x00, 0x38, 0x18, 0xE0, 0x00, 0x18, 0x38,
  0xC0, 0x00, 0x1C, 0x70, 0xC0, 0x00, 0x0E, 0x60, 0xC0, 0x00, 0x0E, 0xE0,
  0xC0, 0x00, 0x07, 0xC0, 0xC0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x07, 0x80,
  0xC0, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x1D, 0xC0, 0xE0, 0x00, 0x38, 0xC0,
  0x70, 0x00, 0x70, 0xE0, 0x3C, 0x03, 0xE0, 0x70, 0x1F, 0xFF, 0x80, 0x70,
  0x0F, 0xFF, 0x00, 0x38, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x63, 0x8E, 0x30,
  0xC3, 0x1C, 0x61, 0x86, 0x18, 0x63, 0x0C, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x10, 0x03,
  0x00, 0x38, 0x06, 0x00, 0x7C, 0x0C, 0x00, 0x3C, 0x18, 0x00, 0x1E, 0x20,
  0x00, 0x0F, 0x40, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x76, 0x00, 0x01, 0xC6, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x1C, 0x00,
  0x70, 0x18, 0x03, 0xC0, 0x38, 0x03, 0x00, 0x30, 0x04, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x06, 0x06,
  0x03, 0x03, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x2F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x01,
  0xC0, 0x03, 0x80, 0x70, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xE0, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x06, 0x1C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x07,
  0x18, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x07, 0x30, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x38, 0x38, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x70,
  0x0E, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x01, 0xC0,
  0x78, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x0F, 0x60, 0x3C, 0xC1, 0xE3, 0x87,
  0x87, 0x1C, 0x0C, 0xF0, 0x18, 0xC0, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFC, 0x7E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x70, 0x00, 0x80,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x1F, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x38, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x30, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x07,
  0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x0E, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x31, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xF8, 0xFC, 0x00, 0x08, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x08, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xF0, 0x30, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x01, 0x83, 0xFF, 0x00, 0x38, 0xFF, 0xFC, 0x03, 0x9C, 0x01, 0xC0, 0x33,
  0x80, 0x0E, 0x03, 0x60, 0x00, 0x70, 0x7C, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x30, 0x78, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x70,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x38, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0xE0,
  0x00, 0x1F, 0x03, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x70, 0x01, 0xE0, 0x0F,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x07,
  0x80, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0xE0, 0x38, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x70, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x1E, 0x0C, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x7C,
  0x07, 0x00, 0x0E, 0xC0, 0x78, 0x01, 0xCC, 0x03, 0xC0, 0x79, 0xC0, 0x1F,
  0xFE, 0x18, 0x00, 0x7F, 0x81, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x80, 0x1E,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x00, 0x00, 0x04, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0xFC, 0x07, 0xE1, 0xF0, 0x30, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x0F, 0xF8, 0x01, 0x83, 0x80, 0x07, 0xFF, 0xC0, 0x30, 0x60, 0x01, 0xE0,
  0x30, 0x06, 0x1C, 0x00, 0x70, 0x06, 0x00, 0xC3, 0x00, 0x1C, 0x01, 0xC0,
  0x1C, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x18, 0x01, 0xC0, 0x06, 0x00, 0x63,
  0x00, 0x30, 0x00, 0xC0, 0x0C, 0xE0, 0x0E, 0x00, 0x38, 0x01, 0x9C, 0x01,
  0x80, 0x06, 0x00, 0x33, 0x00, 0x70, 0x00, 0xC0, 0x06, 0x60, 0x0C, 0x00,
  0x18, 0x01, 0xDC, 0x03, 0x80, 0x07, 0x00, 0x33, 0x80, 0x70, 0x00, 0xC0,
  0x06, 0x70, 0x0C, 0x00, 0x18, 0x01, 0xCC, 0x01, 0x80, 0x07, 0x00, 0x39,
  0x80, 0x30, 0x00, 0xE0, 0x06, 0x30, 0x06, 0x00, 0x1C, 0x01, 0xC6, 0x00,
  0xC0, 0x07, 0x00, 0x30, 0xC0, 0x18, 0x01, 0xE0, 0x0E, 0x18, 0x03, 0x00,
  0x3C, 0x03, 0x83, 0x00, 0x70, 0x0D, 0xC0, 0x60, 0x60, 0x0E, 0x03, 0x18,
  0x1C, 0x0C, 0x00, 0xF1, 0xE3, 0x8F, 0x01, 0xC0, 0x0F, 0xF0, 0x3F, 0x80,
  0x38, 0x00, 0x78, 0x03, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x03, 0x83, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x1C, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38,
  0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x01, 0x80, 0x06, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x18, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0x60,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0x80, 0x01, 0xE0, 0x06,
  0x00, 0x01, 0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x38, 0x07, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x80, 0x18, 0x00, 0x1E,
  0x00, 0x70, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0x00, 0x07, 0xC0, 0x06, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x03, 0x80, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x80, 0xC0, 0x00,
  0x1E, 0x01, 0x80, 0x00, 0xF8, 0x03, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0x80, 0x02, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x06, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xF0, 0x0C, 0x00, 0x00, 0x78, 0x03,
  0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x18, 0x00, 0x0F, 0x80, 0x06, 0x00, 0x0F, 0x80, 0x01, 0x80, 0x7F, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x07, 0xC0,
  0x00, 0xE0, 0x01, 0xE0, 0x00, 0x04, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0x0C, 0x00, 0x03,
  0xFF, 0xC3, 0x80, 0x00, 0x80, 0x38, 0x70, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x01, 0x80, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x01, 0x80, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x07, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x03, 0x80, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x03, 0x80, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x30, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x02, 0x03, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x01, 0xE0, 0x07,
  0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x18, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x07, 0x80,
  0x00, 0xC0, 0x03, 0xC0, 0x00, 0x30, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x60, 0x1E,
  0x00, 0x00, 0x18, 0x0F, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x01, 0xCF, 0xC0, 0x00, 0x00,
  0x67, 0x70, 0x00, 0x00, 0x1B, 0x8C, 0x00, 0x00, 0x07, 0xC3, 0x80, 0x00,
  0x03, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x30, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x1B, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x6C, 0x00, 0x00, 0x01, 0xD8, 0x01, 0xB0, 0x00, 0x00, 0x06, 0xE0,
  0x0E, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x3B, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0xCE, 0x00, 0x00, 0x07, 0x30, 0x03, 0x38, 0x00, 0x00, 0x19, 0xC0, 0x0C,
  0xE0, 0x00, 0x00, 0xE7, 0x00, 0x71, 0x80, 0x00, 0x03, 0x18, 0x01, 0xC6,
  0x00, 0x00, 0x1C, 0x60, 0x06, 0x18, 0x00, 0x00, 0xE1, 0x80, 0x18, 0x60,
  0x00, 0x03, 0x8E, 0x00, 0xE1, 0x80, 0x00, 0x1C, 0x38, 0x03, 0x86, 0x00,
  0x00, 0x60, 0xC0, 0x0E, 0x1C, 0x00, 0x03, 0x83, 0x00, 0x30, 0x70, 0x00,
  0x0C, 0x1C, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x70, 0x07, 0x03, 0x00, 0x01,
  0x81, 0xC0, 0x1C, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x18, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0xE0, 0x06, 0x03, 0x00, 0x0E, 0x03,
  0x80, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x07, 0x00, 0x60, 0x07,
  0x00, 0x60, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0xE0, 0x06, 0x00, 0x60,
  0x07, 0x03, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x30, 0xE0, 0x03, 0x00, 0x38, 0x00, 0xC3, 0x00, 0x0C, 0x00, 0xC0, 0x03,
  0x1C, 0x00, 0x70, 0x03, 0x00, 0x0C, 0x60, 0x01, 0xC0, 0x1C, 0x00, 0x33,
  0x80, 0x07, 0x00, 0x70, 0x00, 0xCC, 0x00, 0x18, 0x01, 0x80, 0x03, 0xF0,
  0x00, 0x60, 0x06, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x18, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x60,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x7C, 0x00,
  0x00, 0x30, 0x01, 0xB0, 0x00, 0x00, 0xC0, 0x0E, 0xE0, 0x00, 0x03, 0x00,
  0x3B, 0x80, 0x00, 0x1C, 0x00, 0xC6, 0x00, 0x00, 0x70, 0x03, 0x1C, 0x00,
  0x01, 0x80, 0x0C, 0x70, 0x00, 0x06, 0x00, 0x70, 0xC0, 0x00, 0x38, 0x01,
  0xC3, 0x80, 0x00, 0xE0, 0x06, 0x0E, 0x00, 0x03, 0x80, 0x18, 0x18, 0x00,
  0x0C, 0x00, 0xE0, 0x70, 0x00, 0x30, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0x0E,
  0x03, 0x00, 0x07, 0x00, 0x30, 0x0E, 0x00, 0x1C, 0x00, 0xC0, 0x38, 0x00,
  0x60, 0x07, 0x00, 0x60, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x03,
  0x00, 0x38, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x01, 0x80, 0x70, 0x03, 0x00,
  0x07, 0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x70, 0x00, 0x30, 0x18,
  0x01, 0xC0, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0x03, 0x83, 0x80, 0x18, 0x00,
  0x06, 0x0E, 0x00, 0x60, 0x00, 0x1C, 0x30, 0x03, 0x80, 0x00, 0x70, 0xC0,
  0x0E, 0x00, 0x00, 0xC7, 0x00, 0x38, 0x00, 0x03, 0x9C, 0x00, 0xC0, 0x00,
  0x0E, 0x70, 0x03, 0x00, 0x00, 0x19, 0x80, 0x1C, 0x00, 0x00, 0x76, 0x00,
  0x70, 0x00, 0x01, 0xF8, 0x01, 0x80, 0x00, 0x03, 0xE0, 0x06, 0x00, 0x00,
  0x0F, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x06, 0x38, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x78,
  0x01, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x78, 0x01, 0x80, 0x07, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x38,
  0x01, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x0F, 0x00, 0x70, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x38, 0x03, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x07,
  0x00, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x60, 0x00, 0xE0,
  0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x06, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x70, 0x03, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0x80,
  0x06, 0x00, 0x78, 0x00, 0x08, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x20, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x1C, 0x06,
  0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x0C,
  0x07, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x30, 0x1C, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x86, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x07, 0x00,
  0x30, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x38, 0x01, 0x80, 0x00, 0xE0, 0x0E,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x06, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06,
  0x1C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xB8, 0x00,
  0x03, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x33, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xB8, 0x00, 0x06, 0x38, 0x00, 0x06,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x39, 0x80, 0x00, 0xE3, 0x80, 0x00, 0xC6,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x60,
  0x00, 0x60, 0xE0, 0x00, 0xE1, 0x80, 0x03, 0x83, 0x80, 0x03, 0x06, 0x00,
  0x0C, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x38, 0x00, 0x60, 0x60, 0x01,
  0x80, 0xE0, 0x03, 0x81, 0x80, 0x0E, 0x03, 0x80, 0x0E, 0x06, 0x00, 0x38,
  0x0E, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x38, 0x01, 0xC0, 0x60, 0x07, 0x00,
  0x60, 0x06, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x06, 0x00, 0xE0, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x18, 0x07, 0x00, 0x60, 0x1C, 0x00, 0x60,
  0x18, 0x01, 0x80, 0x70, 0x01, 0x80, 0xE0, 0x06, 0x01, 0x80, 0x06, 0x03,
  0x00, 0x18, 0x0E, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x60, 0x70,
  0x01, 0x81, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x06, 0x0E, 0x00,
  0x18, 0x38, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x00, 0x61, 0xC0, 0x01,
  0x83, 0x00, 0x01, 0x86, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x38, 0x00, 0x18,
  0x60, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x80, 0x00, 0x63, 0x00, 0x01, 0x8C,
  0x00, 0x01, 0x9C, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80,
  0x00, 0x1B, 0x80, 0x00, 0x66, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB8, 0x00,
  0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x0E, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0C, 0x1C,
  0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x07, 0x00, 0x07,
  0x00, 0xE0, 0x01, 0xC0, 0x0C, 0x00, 0x38, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0x80, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x06, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x0C, 0x70, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x10, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x07, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0E, 0x1C,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x70, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0xE0, 0x07, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0x67, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xC1, 0xC3, 0x83, 0x87, 0x07, 0x06, 0x0E, 0x0C, 0x0C, 0x18, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xFE, 0x0C, 0x01, 0xF0, 0xE1, 0x80, 0xF0, 0x06,
  0x30, 0x3C, 0x00, 0x6E, 0x07, 0x00, 0x0D, 0x81, 0xC0, 0x00, 0xB0, 0x70,
  0x00, 0x1E, 0x0C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x78, 0x60, 0x00, 0x0E,
  0x1C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x38, 0x60, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x18, 0x60, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x1C, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x1C, 0x18,
  0x00, 0x03, 0x83, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x3E, 0x0E, 0x00, 0x07,
  0xC1, 0xC0, 0x01, 0xB0, 0x1C, 0x00, 0x66, 0x03, 0x80, 0x18, 0xC0, 0x38,
  0x0E, 0x18, 0x03, 0xFF, 0x86, 0x00, 0x3F, 0xE0, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x01, 0xF8, 0x00, 0x38, 0x3F, 0xF0, 0x01,
  0xC7, 0x83, 0xC0, 0x0C, 0x70, 0x0F, 0x00, 0x67, 0x00, 0x38, 0x03, 0x70,
  0x00, 0xE0, 0x3F, 0x00, 0x03, 0x01, 0xF0, 0x00, 0x18, 0x0F, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x03, 0x87, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x60, 0x70, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x38, 0x3C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x01,
  0xC0, 0x78, 0x00, 0x1C, 0x06, 0x60, 0x01, 0xE0, 0x33, 0x80, 0x1E, 0x01,
  0x8E, 0x01, 0xE0, 0x0C, 0x3F, 0xFE, 0x00, 0xE0, 0xFF, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xF0, 0x78,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0xF8, 0x0C, 0x00, 0x1F, 0xFC,
  0x38, 0x00, 0x7C, 0x3C, 0x70, 0x03, 0xC0, 0x1C, 0xC0, 0x0F, 0x00, 0x19,
  0x80, 0x1C, 0x00, 0x1B, 0x00, 0x70, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x3C,
  0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x07, 0x80, 0x60, 0x00, 0x0F, 0x00, 0xC0, 0x00,
  0x3E, 0x01, 0xC0, 0x00, 0xF8, 0x03, 0x80, 0x01, 0xB0, 0x07, 0x00, 0x07,
  0x60, 0x07, 0x00, 0x1C, 0xC0, 0x0E, 0x00, 0x73, 0x80, 0x0E, 0x03, 0xC6,
  0x00, 0x0F, 0xFF, 0x0C, 0x00, 0x0F, 0xF8, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x3C, 0x00, 0xF0,
  0x0E, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x06, 0x07, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x38, 0x70, 0x00, 0xF0, 0x70, 0x07,
  0xE0, 0x63, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x20, 0x1E, 0x00, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x30, 0x01, 0xF0, 0xF0, 0xC0, 0x1E, 0x00,
  0xE6, 0x00, 0xF0, 0x01, 0x98, 0x03, 0x80, 0x03, 0x60, 0x1C, 0x00, 0x0D,
  0x80, 0xE0, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x1E, 0x03,
  0x00, 0x00, 0xF8, 0x0C, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x1B, 0x00, 0xE0,
  0x00, 0xEC, 0x01, 0x80, 0x07, 0x70, 0x07, 0x00, 0x39, 0xC0, 0x0E, 0x03,
  0xC6, 0x00, 0x1F, 0xFE, 0x18, 0x00, 0x3F, 0xE0, 0xE0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x08, 0x00, 0x1C, 0x00, 0x38, 0x01, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x7E, 0x00, 0x0C, 0x3F, 0xF8, 0x01, 0xC7, 0xC7, 0xC0, 0x18, 0xE0,
  0x0E, 0x01, 0x9C, 0x00, 0xE0, 0x1B, 0x00, 0x06, 0x03, 0xE0, 0x00, 0x70,
  0x36, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x60, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x38, 0x18,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x30, 0x38, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x70, 0x30, 0x00, 0x07, 0x03, 0x00, 0x00, 0x60, 0x70, 0x00, 0x06, 0x07,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x06, 0x00,
  0x1C, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x00,
  0xC0, 0x1C, 0x00, 0x18, 0x07, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x1C, 0x00, 0x03, 0x07, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x1C,
  0x78, 0x00, 0x03, 0x9F, 0x00, 0x00, 0x67, 0x70, 0x00, 0x0D, 0xCE, 0x00,
  0x01, 0xF0, 0xC0, 0x00, 0x7C, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xC0,
  0x30, 0x00, 0x30, 0x07, 0x00, 0x06, 0x00, 0x60, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x80, 0x18, 0x00,
  0x70, 0x07, 0x00, 0x06, 0x00, 0xE0, 0x00, 0xE0, 0x18, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1C, 0x3F, 0xF0,
  0x1F, 0xFC, 0x01, 0x87, 0x8F, 0x83, 0xC3, 0xE0, 0x19, 0xC0, 0x38, 0x70,
  0x0E, 0x01, 0x98, 0x01, 0xCE, 0x00, 0x70, 0x1B, 0x00, 0x1D, 0xC0, 0x07,
  0x03, 0xE0, 0x00, 0xD8, 0x00, 0x30, 0x34, 0x00, 0x0F, 0x00, 0x03, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x70, 0x00, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1C, 0x3F, 0xF8, 0x01,
  0x87, 0xC7, 0xC0, 0x18, 0xE0, 0x0E, 0x01, 0x9C, 0x00, 0xE0, 0x1B, 0x00,
  0x07, 0x03, 0xF0, 0x00, 0x70, 0x3E, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70,
  0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x60, 0x70, 0x00, 0x06, 0x07, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x18, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x38, 0x18, 0x00, 0x03, 0x03, 0x80, 0x00, 0x30, 0x38,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x30, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xC3, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x07, 0x00,
  0xE0, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x38, 0x00, 0x07, 0x0C, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x30, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x37, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x07, 0x60,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x06,
  0xE0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x30, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x00,
  0xE0, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x18, 0x3F, 0xF0,
  0x00, 0x30, 0xF0, 0xF8, 0x00, 0x31, 0xC0, 0x3C, 0x00, 0x33, 0x80, 0x1C,
  0x00, 0x37, 0x00, 0x0E, 0x00, 0x76, 0x00, 0x0E, 0x00, 0x6C, 0x00, 0x06,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x78, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x80, 0x00, 0x38,
  0x07, 0x80, 0x00, 0x70, 0x07, 0x80, 0x00, 0x70, 0x07, 0x80, 0x00, 0xE0,
  0x07, 0x80, 0x01, 0xC0, 0x0E, 0xC0, 0x03, 0xC0, 0x0E, 0xE0, 0x07, 0x80,
  0x0C, 0x70, 0x0F, 0x00, 0x0C, 0x3F, 0xFC, 0x00, 0x0C, 0x1F, 0xF8, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x83, 0x00, 0x7C, 0x3C, 0x30, 0x1E,
  0x00, 0xE6, 0x03, 0xC0, 0x06, 0x60, 0x38, 0x00, 0x36, 0x07, 0x00, 0x03,
  0x60, 0xE0, 0x00, 0x1E, 0x0C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x18,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x18, 0x70, 0x00, 0x01, 0x87, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x1E, 0x0C, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x3E, 0x0E, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x6C, 0x0E, 0x00, 0x0E, 0xC0, 0x60, 0x01, 0xDC,
  0x07, 0x00, 0x39, 0xC0, 0x38, 0x0F, 0x18, 0x01, 0xFF, 0xE1, 0x80, 0x0F,
  0xF8, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFC, 0x03, 0x0F,
  0xF0, 0x18, 0x7C, 0xC0, 0x63, 0x80, 0x01, 0x9C, 0x00, 0x06, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xFC, 0x01, 0xF0, 0x3F, 0x03, 0xC0, 0x06, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x80, 0x01, 0xC0, 0xE0, 0x07, 0x80, 0xFF,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0E, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x83, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x0E, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0x70, 0x00, 0x06, 0x0E,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x38, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x07, 0x06, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x18, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x3C,
  0x18, 0x00, 0x07, 0x83, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x3C, 0x0C, 0x00,
  0x0D, 0x81, 0xC0, 0x03, 0x30, 0x38, 0x00, 0xCE, 0x03, 0x80, 0x71, 0x80,
  0x3F, 0xFC, 0x30, 0x03, 0xFE, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x1C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x70, 0x00, 0x30, 0x70,
  0x00, 0x70, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x30,
  0x01, 0xC0, 0x30, 0x03, 0x80, 0x30, 0x03, 0x80, 0x30, 0x07, 0x00, 0x30,
  0x06, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x38,
  0x18, 0x00, 0x38, 0x38, 0x00, 0x18, 0x30, 0x00, 0x18, 0x70, 0x00, 0x18,
  0x60, 0x00, 0x18, 0xE0, 0x00, 0x18, 0xC0, 0x00, 0x19, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x1B, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xB0, 0x00, 0x3C, 0x00, 0x1D, 0x80, 0x03, 0xE0, 0x00, 0xCC,
  0x00, 0x1B, 0x00, 0x0E, 0x60, 0x00, 0xD8, 0x00, 0x73, 0x00, 0x0C, 0xC0,
  0x03, 0x18, 0x00, 0x66, 0x00, 0x38, 0xC0, 0x07, 0x30, 0x01, 0x86, 0x00,
  0x31, 0x80, 0x1C, 0x30, 0x03, 0x8C, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x0E,
  0x0E, 0x01, 0xC3, 0x00, 0x60, 0x70, 0x0C, 0x18, 0x07, 0x03, 0x80, 0xE0,
  0xE0, 0x38, 0x1C, 0x06, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x07,
  0x03, 0x01, 0xC0, 0xC0, 0x38, 0x38, 0x0E, 0x0E, 0x01, 0xC1, 0x80, 0x30,
  0x60, 0x0E, 0x1C, 0x01, 0x87, 0x00, 0x70, 0xC0, 0x0C, 0x30, 0x01, 0x86,
  0x00, 0x61, 0x80, 0x0C, 0x60, 0x03, 0x1C, 0x00, 0x63, 0x00, 0x18, 0xC0,
  0x03, 0x38, 0x00, 0xCE, 0x00, 0x19, 0x80, 0x06, 0x60, 0x00, 0xDC, 0x00,
  0x37, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x3E, 0x00, 0x0D, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x03,
  0x80, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x03, 0x00, 0x70, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x03,
  0x80, 0x01, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x07,
  0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x71,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x27, 0xFF, 0x00, 0x07, 0xE1, 0xF8,
  0x01, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0xF9, 0x00, 0x01, 0xFE, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 13, 46, 14, 2, -46 },
  { 76, 15, 16, 20, 7, -46 },
  { 106, 34, 46, 35, 1, -46 },
  { 302, 28, 53, 31, 2, -49 },
  { 488, 36, 48, 45, 5, -47 },
  { 704, 32, 48, 36, 2, -47 },
  { 896, 6, 16, 11, 7, -46 },
  { 908, 18, 56, 16, 2, -46 },
  { 1034, 18, 56, 16, -4, -46 },
  { 1160, 23, 24, 30, 8, -49 },
  { 1229, 27, 30, 33, 4, -38 },
  { 1331, 9, 15, 12, -3, -7 },
  { 1348, 15, 3, 19, 2, -19 },
  { 1354, 4, 5, 13, 2, -5 },
  { 1357, 28, 46, 20, -3, -46 },
  { 1518, 27, 48, 31, 3, -47 },
  { 1680, 15, 46, 31, 9, -46 },
  { 1767, 30, 47, 31, 0, -47 },
  { 1944, 30, 48, 31, 0, -47 },
  { 2124, 30, 47, 31, 0, -47 },
  { 2301, 30, 47, 31, 1, -46 },
  { 2478, 28, 48, 31, 3, -47 },
  { 2646, 27, 46, 31, 5, -46 },
  { 2802, 29, 48, 31, 2, -47 },
  { 2976, 28, 48, 31, 2, -47 },
  { 3144, 11, 35, 13, 1, -35 },
  { 3193, 15, 43, 13, -3, -35 },
  { 3274, 27, 29, 33, 4, -38 },
  { 3372, 27, 16, 33, 4, -31 },
  { 3426, 27, 29, 33, 4, -38 },
  { 3524, 21, 47, 23, 4, -47 },
  { 3648, 43, 52, 47, 3, -46 },
  { 3928, 31, 47, 31, -4, -47 },
  { 4111, 31, 46, 34, 2, -46 },
  { 4290, 32, 48, 33, 4, -47 },
  { 4482, 34, 46, 38, 2, -46 },
  { 4678, 30, 46, 30, 2, -46 },
  { 4851, 30, 46, 28, 2, -46 },
  { 5024, 35, 48, 39, 4, -47 },
  { 5234, 37, 46, 39, 2, -46 },
  { 5447, 21, 46, 16, -1, -46 },
  { 5568, 25, 58, 14, -10, -46 },
  { 5750, 34, 46, 31, 2, -46 },
  { 5946, 20, 46, 28, 2, -46 },
  { 6061, 46, 46, 48, 2, -46 },
  { 6326, 38, 46, 39, 2, -46 },
  { 6545, 34, 48, 40, 4, -47 },
  { 6749, 30, 46, 32, 2, -46 },
  { 6922, 34, 58, 40, 4, -47 },
  { 7169, 30, 46, 32, 2, -46 },
  { 7342, 30, 48, 29, 0, -47 },
  { 7522, 27, 46, 27, 6, -46 },
  { 7678, 35, 47, 39, 4, -46 },
  { 7884, 30, 46, 31, 6, -46 },
  { 8057, 46, 46, 49, 7, -46 },
  { 8322, 37, 46, 28, -4, -46 },
  { 8535, 27, 46, 27, 6, -46 },
  { 8691, 33, 46, 30, -1, -46 },
  { 8881, 24, 56, 19, -1, -46 },
  { 9049, 9, 46, 21, 7, -46 },
  { 9101, 24, 56, 19, -4, -46 },
  { 9269, 28, 27, 32, 2, -47 },
  { 9364, 22, 3, 22, -5, 6 },
  { 9373, 7, 11, 15, 10, -50 },
  { 9383, 27, 36, 32, 3, -35 },
  { 9505, 29, 50, 33, 1, -49 },
  { 9687, 23, 36, 25, 3, -35 },
  { 9791, 31, 50, 33, 3, -49 },
  { 9985, 24, 36, 28, 3, -35 },
  { 10093, 33, 66, 16, -8, -50 },
  { 10366, 30, 51, 33, 1, -35 },
  { 10558, 28, 49, 32, 1, -49 },
  { 10730, 13, 47, 13, 1, -47 },
  { 10807, 23, 63, 13, -9, -47 },
  { 10989, 27, 49, 26, 1, -49 },
  { 11155, 13, 49, 13, 1, -49 },
  { 11235, 44, 35, 48, 1, -35 },
  { 11428, 28, 35, 32, 1, -35 },
  { 11551, 26, 36, 32, 3, -35 },
  { 11668, 32, 50, 33, -2, -35 },
  { 11868, 28, 50, 33, 3, -35 },
  { 12043, 22, 35, 21, 1, -35 },
  { 12140, 24, 36, 24, 0, -35 },
  { 12248, 16, 44, 17, 3, -43 },
  { 12336, 27, 35, 32, 3, -34 },
  { 12455, 24, 34, 24, 3, -34 },
  { 12557, 37, 34, 39, 4, -34 },
  { 12715, 30, 34, 26, -2, -34 },
  { 12843, 35, 50, 25, -7, -34 },
  { 13062, 25, 34, 24, -1, -34 },
  { 13169, 23, 56, 21, 2, -46 },
  { 13330, 2, 65, 30, 15, -49 },
  { 13347, 24, 56, 21, -4, -46 },
  { 13515, 27, 6, 33, 4, -26 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic65pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC65PT7B_H_
