#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC34PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x18, 0x20, 0x40, 0x83,
  0x06, 0x08, 0x10, 0x20, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x60, 0x62, 0x8D,
  0x1E, 0x28, 0x50, 0xA1, 0x44, 0x88, 0x00, 0xC3, 0x00, 0x20, 0x80, 0x08,
  0x20, 0x06, 0x08, 0x01, 0x04, 0x00, 0x41, 0x00, 0x30, 0x40, 0xFF, 0xFF,
  0x02, 0x08, 0x00, 0x82, 0x00, 0x40, 0x80, 0x10, 0x40, 0x04, 0x10, 0x03,
  0x04, 0x00, 0x83, 0x03, 0xFF, 0xF8, 0x18, 0x20, 0x04, 0x08, 0x01, 0x04,
  0x00, 0x41, 0x00, 0x20, 0x40, 0x08, 0x20, 0x02, 0x08, 0x01, 0x82, 0x00,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x0F, 0xC0, 0x64, 0xE1, 0x88, 0x06,
  0x10, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x62, 0x00, 0x44, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x70, 0x00, 0xB0, 0x01, 0x30, 0x04, 0x20, 0x08, 0x40,
  0x10, 0x80, 0x21, 0x00, 0x86, 0x21, 0x18, 0x7F, 0xC0, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x02, 0x00, 0x20, 0xF8, 0x04, 0x10, 0x80,
  0x83, 0x08, 0x08, 0x20, 0x81, 0x06, 0x08, 0x30, 0x40, 0x82, 0x04, 0x08,
  0x40, 0x40, 0x8C, 0x0C, 0x18, 0x80, 0xC1, 0x11, 0xCC, 0x13, 0x36, 0xC3,
  0x24, 0x34, 0x24, 0xC3, 0x7C, 0xC8, 0x31, 0x08, 0x83, 0x01, 0x18, 0x30,
  0x31, 0x02, 0x02, 0x10, 0x20, 0x41, 0x02, 0x0C, 0x10, 0x60, 0x81, 0x04,
  0x10, 0x10, 0xC3, 0x01, 0x08, 0x20, 0x0F, 0x00, 0x00, 0x60, 0x00, 0xFC,
  0x00, 0x83, 0x00, 0xC0, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x30, 0x08,
  0x10, 0x04, 0x10, 0x03, 0x10, 0x00, 0xB0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xCC, 0x00, 0xC2, 0x06, 0xC1, 0x82, 0x40, 0x43, 0x60, 0x11, 0x20, 0x0D,
  0x90, 0x02, 0x88, 0x01, 0x84, 0x00, 0xC3, 0x00, 0xB0, 0xC1, 0x88, 0x3F,
  0x86, 0x00, 0x69, 0x69, 0x24, 0x80, 0x00, 0xC0, 0x40, 0x20, 0x18, 0x04,
  0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x0C,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x80, 0x20, 0x00, 0x03, 0x00, 0x80, 0x40, 0x30,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x03, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x10, 0x18, 0x08, 0x08,
  0x0C, 0x0C, 0x0C, 0x00, 0x01, 0x00, 0x30, 0x02, 0x08, 0x20, 0x62, 0x01,
  0xA1, 0x07, 0xF0, 0xE0, 0x1A, 0x03, 0x10, 0x61, 0x04, 0x08, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x3F, 0xFF, 0xFF, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x13, 0x32, 0x64, 0xC8, 0xFF, 0xF0, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0F, 0xC0, 0xC1,
  0x82, 0x02, 0x18, 0x0C, 0xC0, 0x32, 0x00, 0xC8, 0x03, 0x60, 0x0D, 0x00,
  0x34, 0x00, 0xF0, 0x02, 0xC0, 0x0A, 0x00, 0x28, 0x01, 0xA0, 0x06, 0x80,
  0x12, 0x00, 0x48, 0x03, 0x20, 0x08, 0x80, 0x62, 0x01, 0x0C, 0x08, 0x18,
  0x60, 0x3E, 0x00, 0x07, 0x0E, 0x32, 0x62, 0xC6, 0x04, 0x04, 0x04, 0x0C,
  0x0C, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20,
  0x20, 0x60, 0x60, 0x00, 0x70, 0x07, 0xF8, 0x18, 0x18, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xFF, 0xF0, 0x00, 0x70, 0x03, 0xFC, 0x0E, 0x06, 0x08, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x70, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30,
  0xC0, 0x60, 0x7F, 0xC0, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x28, 0x00, 0xB0,
  0x02, 0x40, 0x0C, 0x80, 0x31, 0x00, 0x42, 0x01, 0x0C, 0x04, 0x10, 0x18,
  0x20, 0x60, 0x40, 0x81, 0x82, 0x03, 0x0C, 0x04, 0x30, 0x08, 0x40, 0x11,
  0xFF, 0xFC, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x07, 0xFE, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x22, 0x00, 0xFF, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x20, 0x30, 0x7F, 0x80, 0x00, 0x18,
  0x07, 0xF0, 0x30, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x7C, 0x17, 0x18, 0xF0, 0x33, 0x80, 0x4C, 0x01,
  0x20, 0x06, 0x80, 0x1A, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x32, 0x00,
  0x8C, 0x04, 0x18, 0x20, 0x3F, 0x00, 0x7F, 0xFC, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x07, 0xF0, 0x18, 0x10, 0x60, 0x30, 0x80, 0x21, 0x00, 0x42,
  0x00, 0x84, 0x03, 0x08, 0x04, 0x18, 0x10, 0x18, 0xC0, 0x1F, 0x00, 0x38,
  0x01, 0x88, 0x0C, 0x08, 0x30, 0x08, 0x40, 0x19, 0x80, 0x12, 0x00, 0x24,
  0x00, 0x48, 0x01, 0x90, 0x02, 0x30, 0x0C, 0x30, 0x30, 0x3F, 0x80, 0x00,
  0xC0, 0x07, 0xF0, 0x10, 0x20, 0x40, 0x21, 0x80, 0x42, 0x00, 0x8C, 0x01,
  0x90, 0x03, 0x20, 0x06, 0x40, 0x08, 0x80, 0x11, 0x00, 0x63, 0x01, 0xC2,
  0x07, 0x87, 0xFA, 0x03, 0x84, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0xFE, 0x00, 0x18, 0xC4,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x03,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x18, 0x10, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x00, 0x04, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x0C, 0x00, 0x00, 0x06, 0x07, 0xF0, 0x81, 0x00, 0x30, 0x02, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x80, 0x20, 0x04, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xC0, 0x60, 0x06, 0x00, 0x60,
  0x10, 0x00, 0x60, 0x40, 0x00, 0x41, 0x00, 0x00, 0x86, 0x00, 0x01, 0x88,
  0x0F, 0xC3, 0x30, 0x60, 0x82, 0x41, 0x83, 0x04, 0x82, 0x04, 0x1A, 0x0C,
  0x08, 0x34, 0x10, 0x10, 0x48, 0x60, 0x60, 0x90, 0xC0, 0x81, 0x21, 0x01,
  0x04, 0xC2, 0x06, 0x09, 0x84, 0x1C, 0x21, 0x04, 0x68, 0xC2, 0x0F, 0x9F,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x14, 0x00, 0x14, 0x00, 0x24, 0x00, 0x26, 0x00, 0x46, 0x00,
  0x46, 0x00, 0x82, 0x00, 0x82, 0x01, 0x02, 0x03, 0x02, 0x02, 0x02, 0x06,
  0x02, 0x07, 0xFE, 0x0C, 0x02, 0x08, 0x03, 0x18, 0x03, 0x10, 0x03, 0x30,
  0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x01, 0xC0, 0x01, 0x07, 0xFC, 0x04,
  0x06, 0x04, 0x03, 0x0C, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08,
  0x03, 0x18, 0x02, 0x10, 0x06, 0x10, 0x38, 0x1F, 0xF0, 0x30, 0x18, 0x30,
  0x0C, 0x20, 0x04, 0x20, 0x06, 0x20, 0x06, 0x60, 0x04, 0x60, 0x04, 0x40,
  0x0C, 0x40, 0x08, 0x40, 0x18, 0xC0, 0x60, 0xFF, 0x80, 0x00, 0x18, 0x00,
  0x7F, 0xC0, 0xE0, 0x20, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x70, 0x20,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x01, 0x01, 0x80, 0x40, 0x30, 0x30, 0x06,
  0x0C, 0x00, 0x82, 0x00, 0x20, 0x80, 0x0C, 0x20, 0x03, 0x18, 0x00, 0xC4,
  0x00, 0x31, 0x00, 0x0C, 0x40, 0x02, 0x30, 0x00, 0x8C, 0x00, 0x22, 0x00,
  0x18, 0x80, 0x04, 0x20, 0x01, 0x18, 0x00, 0xC6, 0x00, 0x61, 0x00, 0x30,
  0x40, 0x18, 0x10, 0x0C, 0x0C, 0x1E, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x1F, 0xF8, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x3F, 0xF8, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x3F, 0xF0, 0x38, 0x04, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x0F, 0xEC, 0x00, 0x13, 0x00, 0x04, 0xC0, 0x01, 0x30,
  0x00, 0xCC, 0x00, 0x23, 0x00, 0x08, 0x40, 0x02, 0x18, 0x01, 0x83, 0x00,
  0x60, 0x60, 0x30, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x20, 0x80, 0x04, 0x10,
  0x01, 0x86, 0x00, 0x30, 0xC0, 0x04, 0x10, 0x00, 0x82, 0x00, 0x10, 0x40,
  0x06, 0x18, 0x00, 0xC2, 0x00, 0x10, 0x40, 0x02, 0x0F, 0xFF, 0xC3, 0x00,
  0x18, 0x60, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08, 0x20, 0x03, 0x0C, 0x00,
  0x61, 0x80, 0x08, 0x20, 0x01, 0x04, 0x00, 0x20, 0x80, 0x0C, 0x30, 0x01,
  0x84, 0x00, 0x20, 0x07, 0xE0, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x07, 0xE0,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x09, 0xC0, 0x78,
  0x00, 0x06, 0x00, 0xC1, 0x00, 0x40, 0x40, 0x20, 0x30, 0x10, 0x0C, 0x08,
  0x02, 0x04, 0x00, 0x82, 0x00, 0x21, 0x00, 0x18, 0xC0, 0x04, 0x60, 0x01,
  0x30, 0x00, 0x54, 0x00, 0x39, 0x80, 0x0C, 0x20, 0x02, 0x08, 0x00, 0x83,
  0x00, 0x20, 0x40, 0x18, 0x18, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30,
  0x10, 0x04, 0x0C, 0x01, 0x82, 0x00, 0x20, 0x06, 0x00, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x30, 0x07, 0xFF, 0x06, 0x00, 0x03, 0x06, 0x00, 0x07, 0x06, 0x00,
  0x07, 0x0F, 0x00, 0x0A, 0x0B, 0x00, 0x1A, 0x09, 0x00, 0x12, 0x09, 0x00,
  0x36, 0x09, 0x00, 0x24, 0x19, 0x00, 0x64, 0x11, 0x00, 0x44, 0x11, 0x00,
  0xC4, 0x11, 0x80, 0x8C, 0x31, 0x81, 0x08, 0x30, 0x81, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x86, 0x18, 0x20, 0x84, 0x18, 0x60, 0x8C, 0x10, 0x60, 0x88,
  0x10, 0x40, 0xD8, 0x10, 0x40, 0xD0, 0x30, 0x40, 0x70, 0x20, 0xC0, 0x60,
  0x20, 0x80, 0x40, 0x20, 0x06, 0x00, 0x30, 0x60, 0x02, 0x06, 0x00, 0x20,
  0xF0, 0x02, 0x09, 0x00, 0x60, 0x90, 0x04, 0x09, 0x80, 0x40, 0x88, 0x04,
  0x18, 0x80, 0xC1, 0x0C, 0x0C, 0x10, 0x40, 0x81, 0x04, 0x08, 0x30, 0x60,
  0x83, 0x02, 0x18, 0x20, 0x21, 0x82, 0x03, 0x10, 0x20, 0x11, 0x06, 0x01,
  0x10, 0x60, 0x1B, 0x04, 0x00, 0xA0, 0x40, 0x0A, 0x04, 0x00, 0xE0, 0xC0,
  0x06, 0x08, 0x00, 0x60, 0x00, 0x78, 0x00, 0x7F, 0x80, 0x30, 0x30, 0x10,
  0x06, 0x08, 0x00, 0x86, 0x00, 0x31, 0x00, 0x04, 0xC0, 0x01, 0x20, 0x00,
  0x58, 0x00, 0x14, 0x00, 0x05, 0x00, 0x03, 0x40, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0B, 0x00, 0x02, 0xC0, 0x01, 0xB0, 0x00, 0x4C, 0x00, 0x13, 0x00,
  0x0C, 0x40, 0x06, 0x18, 0x01, 0x02, 0x00, 0xC0, 0xE0, 0xC0, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x04, 0x0E, 0x04, 0x02, 0x0C, 0x03, 0x0C, 0x03, 0x08,
  0x03, 0x08, 0x03, 0x08, 0x03, 0x18, 0x02, 0x10, 0x06, 0x10, 0x04, 0x10,
  0x08, 0x30, 0xF0, 0x3F, 0x80, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x7F, 0x80, 0x30, 0x30, 0x10, 0x06, 0x08, 0x00,
  0x86, 0x00, 0x31, 0x00, 0x04, 0xC0, 0x01, 0x20, 0x00, 0x58, 0x00, 0x14,
  0x00, 0x05, 0x00, 0x03, 0x40, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0B, 0x00,
  0x02, 0xC0, 0x01, 0xB0, 0x00, 0x4C, 0x00, 0x13, 0x00, 0x0C, 0x40, 0x06,
  0x18, 0x01, 0x02, 0x00, 0x80, 0xE0, 0xC0, 0x0F, 0xE0, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x07,
  0xF8, 0x04, 0x0E, 0x04, 0x02, 0x0C, 0x03, 0x0C, 0x03, 0x08, 0x03, 0x08,
  0x03, 0x08, 0x03, 0x18, 0x02, 0x10, 0x06, 0x10, 0x0C, 0x10, 0x18, 0x3F,
  0xE0, 0x30, 0xC0, 0x20, 0x40, 0x20, 0x40, 0x20, 0x60, 0x60, 0x20, 0x60,
  0x20, 0x40, 0x30, 0x40, 0x30, 0x40, 0x10, 0xC0, 0x10, 0xC0, 0x18, 0x00,
  0x30, 0x03, 0xFF, 0x06, 0x02, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0xC0, 0xE0, 0x7F,
  0x80, 0xFF, 0xFC, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x08, 0x00, 0x61, 0x00, 0x08,
  0x60, 0x01, 0x0C, 0x00, 0x61, 0x00, 0x0C, 0x20, 0x01, 0x04, 0x00, 0x21,
  0x80, 0x04, 0x20, 0x01, 0x84, 0x00, 0x20, 0x80, 0x04, 0x30, 0x00, 0x86,
  0x00, 0x30, 0x80, 0x06, 0x10, 0x00, 0x82, 0x00, 0x10, 0xC0, 0x02, 0x18,
  0x00, 0xC3, 0x00, 0x10, 0x60, 0x06, 0x0C, 0x00, 0x80, 0xC0, 0x30, 0x0C,
  0x1C, 0x00, 0xFE, 0x00, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x04, 0x40, 0x0C,
  0x40, 0x08, 0x40, 0x18, 0x40, 0x10, 0x40, 0x30, 0x40, 0x20, 0x40, 0x60,
  0x40, 0x40, 0x40, 0xC0, 0x60, 0x80, 0x61, 0x80, 0x61, 0x00, 0x63, 0x00,
  0x22, 0x00, 0x26, 0x00, 0x24, 0x00, 0x2C, 0x00, 0x28, 0x00, 0x28, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x80, 0x18, 0x03, 0x80, 0x38, 0x02, 0x80, 0x38,
  0x06, 0x80, 0x78, 0x04, 0x80, 0x58, 0x0C, 0x80, 0x58, 0x08, 0x80, 0x98,
  0x08, 0x80, 0x98, 0x18, 0x81, 0x88, 0x10, 0x81, 0x08, 0x30, 0x83, 0x08,
  0x20, 0x82, 0x08, 0x60, 0x86, 0x08, 0x40, 0x84, 0x08, 0x40, 0x84, 0x08,
  0x80, 0x88, 0x08, 0x80, 0x88, 0x09, 0x80, 0x98, 0x09, 0x00, 0x90, 0x0B,
  0x00, 0xB0, 0x0A, 0x00, 0xA0, 0x0A, 0x00, 0xA0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x02, 0x00, 0x60, 0x60, 0x18, 0x04, 0x02, 0x00,
  0x80, 0x80, 0x18, 0x30, 0x01, 0x04, 0x00, 0x21, 0x00, 0x04, 0x60, 0x00,
  0xD8, 0x00, 0x0A, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x40, 0x00, 0x4C, 0x00, 0x18, 0x80, 0x06, 0x10, 0x00, 0x83, 0x00, 0x20,
  0x20, 0x0C, 0x04, 0x01, 0x00, 0x80, 0x40, 0x18, 0x18, 0x01, 0x06, 0x00,
  0x20, 0xC0, 0x0F, 0x00, 0x24, 0x01, 0x90, 0x0C, 0x40, 0x21, 0x81, 0x82,
  0x04, 0x08, 0x20, 0x21, 0x80, 0xC4, 0x03, 0x20, 0x05, 0x80, 0x14, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0xFF,
  0xE0, 0x03, 0xF0, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0xFC, 0x00, 0xC1, 0x04, 0x10,
  0x41, 0x82, 0x08, 0x20, 0x82, 0x0C, 0x10, 0x41, 0x04, 0x10, 0x61, 0x82,
  0x08, 0x20, 0x83, 0x03, 0xF0, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0xFC, 0x00, 0x00,
  0xC0, 0x01, 0xC0, 0x04, 0x80, 0x19, 0x00, 0x23, 0x00, 0xC2, 0x01, 0x04,
  0x04, 0x0C, 0x18, 0x08, 0x20, 0x10, 0xC0, 0x31, 0x00, 0x24, 0x00, 0x58,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xC4, 0x42, 0x30, 0x03, 0xE2, 0x1C, 0x2C,
  0x20, 0x30, 0x80, 0x63, 0x00, 0xC4, 0x01, 0x98, 0x03, 0x20, 0x04, 0x40,
  0x08, 0x80, 0x11, 0x00, 0x66, 0x00, 0x8C, 0x01, 0x18, 0x06, 0x10, 0x14,
  0x20, 0x78, 0x61, 0xA0, 0x7E, 0x40, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x19, 0xF8, 0x24,
  0x18, 0x50, 0x10, 0xC0, 0x21, 0x80, 0x66, 0x00, 0xCC, 0x01, 0x90, 0x02,
  0x20, 0x04, 0x40, 0x09, 0x80, 0x32, 0x00, 0x64, 0x00, 0x88, 0x03, 0x38,
  0x04, 0x50, 0x10, 0xB0, 0x61, 0x3F, 0x00, 0x07, 0xF1, 0xC1, 0x10, 0x02,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x83, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x03, 0xF2, 0x07, 0x0D, 0x02, 0x03, 0x82, 0x01, 0xC3,
  0x00, 0x41, 0x00, 0x21, 0x80, 0x30, 0x80, 0x18, 0x40, 0x08, 0x20, 0x04,
  0x10, 0x02, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x01, 0x81, 0x01, 0xC0, 0x80,
  0xA0, 0x61, 0x90, 0x1F, 0x98, 0x00, 0x07, 0xE0, 0xC2, 0x10, 0x32, 0x01,
  0x60, 0x34, 0x02, 0xC0, 0x68, 0x1C, 0xFF, 0x0E, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x83, 0xF8, 0x00, 0x0F, 0x80,
  0x0C, 0x40, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x03, 0xFC, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF9,
  0x07, 0x0D, 0x04, 0x05, 0x08, 0x07, 0x18, 0x02, 0x10, 0x02, 0x30, 0x06,
  0x20, 0x06, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x60, 0x0C, 0x60, 0x0C,
  0x60, 0x18, 0x20, 0x38, 0x20, 0x28, 0x30, 0xD8, 0x1F, 0x98, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0xC1, 0xC0,
  0x7F, 0x00, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x19, 0xF8, 0x48, 0x31, 0x40, 0xC6, 0x01, 0x18,
  0x04, 0xC0, 0x33, 0x00, 0xC8, 0x02, 0x20, 0x08, 0x80, 0x26, 0x01, 0x90,
  0x06, 0x40, 0x11, 0x00, 0x4C, 0x01, 0x30, 0x0C, 0x80, 0x22, 0x00, 0x80,
  0x04, 0x30, 0xC0, 0x00, 0x00, 0x06, 0x18, 0x41, 0x04, 0x30, 0x82, 0x08,
  0x21, 0x84, 0x10, 0x43, 0x0C, 0x20, 0x80, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0xF0, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x0C, 0x60, 0x41, 0x02, 0x04, 0x18, 0x10, 0xC0, 0xC6, 0x02, 0x30, 0x09,
  0x80, 0x2E, 0x00, 0xE8, 0x07, 0x30, 0x18, 0x40, 0x41, 0x81, 0x02, 0x0C,
  0x08, 0x30, 0x30, 0x80, 0x42, 0x01, 0x80, 0x04, 0x10, 0x43, 0x0C, 0x20,
  0x82, 0x18, 0x61, 0x04, 0x10, 0xC2, 0x08, 0x20, 0x86, 0x10, 0x41, 0x0C,
  0x30, 0x82, 0x00, 0x19, 0xF0, 0xF8, 0x24, 0x32, 0x18, 0x50, 0x28, 0x10,
  0xC0, 0x60, 0x31, 0x00, 0xC0, 0x66, 0x01, 0x00, 0x8C, 0x02, 0x01, 0x10,
  0x0C, 0x02, 0x20, 0x10, 0x0C, 0x40, 0x20, 0x19, 0x80, 0x40, 0x22, 0x01,
  0x80, 0x44, 0x03, 0x00, 0x88, 0x04, 0x03, 0x30, 0x08, 0x04, 0x60, 0x10,
  0x08, 0x80, 0x60, 0x11, 0x00, 0x80, 0x60, 0x19, 0xF8, 0x48, 0x31, 0x40,
  0xC6, 0x01, 0x18, 0x04, 0xC0, 0x33, 0x00, 0xC8, 0x02, 0x20, 0x08, 0x80,
  0x26, 0x01, 0x90, 0x06, 0x40, 0x11, 0x00, 0x4C, 0x01, 0x30, 0x0C, 0x80,
  0x22, 0x00, 0x80, 0x03, 0xF0, 0x38, 0x60, 0x80, 0xC4, 0x01, 0x30, 0x04,
  0x80, 0x16, 0x00, 0x58, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00, 0xF0, 0x02,
  0xC0, 0x09, 0x00, 0x64, 0x03, 0x18, 0x08, 0x30, 0xC0, 0x7E, 0x00, 0x06,
  0x7E, 0x02, 0x61, 0x81, 0x40, 0x40, 0xC0, 0x20, 0x60, 0x18, 0x60, 0x0C,
  0x30, 0x06, 0x10, 0x02, 0x08, 0x01, 0x04, 0x00, 0x86, 0x00, 0x42, 0x00,
  0x61, 0x00, 0x20, 0x80, 0x30, 0xE0, 0x10, 0x70, 0x10, 0x2C, 0x18, 0x13,
  0xF0, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x03, 0xF2, 0x1C, 0x34, 0x20,
  0x28, 0x80, 0x73, 0x00, 0x44, 0x00, 0x98, 0x01, 0x20, 0x06, 0x40, 0x08,
  0x80, 0x11, 0x00, 0x26, 0x00, 0xCC, 0x01, 0x98, 0x06, 0x10, 0x1C, 0x20,
  0x28, 0x61, 0xB0, 0x7E, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x19, 0xE2, 0x40, 0x50,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x00, 0x0F, 0xF1, 0x81,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x81, 0x87, 0xF0,
  0x0C, 0x04, 0x02, 0x01, 0x07, 0xF8, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08,
  0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x03,
  0xE0, 0x18, 0x06, 0x20, 0x08, 0x40, 0x10, 0x80, 0x23, 0x00, 0xC4, 0x01,
  0x88, 0x02, 0x10, 0x04, 0x20, 0x08, 0xC0, 0x31, 0x00, 0x62, 0x00, 0x84,
  0x03, 0x08, 0x06, 0x30, 0x1C, 0x20, 0x70, 0x61, 0xA0, 0x7C, 0x40, 0x80,
  0x18, 0x03, 0x80, 0x28, 0x04, 0x80, 0x4C, 0x08, 0xC0, 0x8C, 0x10, 0x43,
  0x04, 0x20, 0x46, 0x04, 0x40, 0x4C, 0x04, 0x80, 0x58, 0x05, 0x00, 0x70,
  0x06, 0x00, 0x80, 0x40, 0x38, 0x0C, 0x02, 0x80, 0xE0, 0x48, 0x0E, 0x04,
  0x81, 0x60, 0xC8, 0x12, 0x08, 0x82, 0x21, 0x88, 0x22, 0x10, 0x84, 0x23,
  0x08, 0x42, 0x20, 0xC8, 0x22, 0x0C, 0x82, 0x40, 0xD8, 0x24, 0x0D, 0x02,
  0xC0, 0xF0, 0x28, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x04, 0x03, 0x00, 0x08,
  0x02, 0x18, 0x08, 0x10, 0x20, 0x20, 0xC0, 0x63, 0x00, 0x44, 0x00, 0x90,
  0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x24, 0x00, 0x84, 0x03,
  0x08, 0x0C, 0x18, 0x10, 0x10, 0x40, 0x21, 0x80, 0x60, 0x02, 0x00, 0x60,
  0x40, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x10, 0x10, 0x02, 0x06, 0x00,
  0x40, 0x80, 0x08, 0x30, 0x01, 0x04, 0x00, 0x21, 0x80, 0x04, 0x20, 0x00,
  0x8C, 0x00, 0x19, 0x00, 0x01, 0x60, 0x00, 0x28, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03,
  0x00, 0x08, 0x00, 0x40, 0x23, 0xFF, 0x00, 0x00, 0xF0, 0x18, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x08, 0x01, 0x00, 0xE0, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x04, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C,
  0x01, 0x80, 0xF0, 0x00, 0x18, 0x01, 0xFC, 0x18, 0x1F, 0xC0, 0x08,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 24, 7, 1, -24 },
  { 22, 7, 9, 10, 4, -24 },
  { 30, 18, 24, 18, 1, -24 },
  { 84, 15, 28, 16, 1, -26 },
  { 137, 20, 25, 23, 2, -25 },
  { 200, 17, 25, 19, 1, -25 },
  { 254, 3, 9, 6, 4, -24 },
  { 258, 10, 29, 8, 1, -24 },
  { 295, 9, 29, 8, -2, -24 },
  { 328, 12, 13, 16, 4, -26 },
  { 348, 14, 16, 17, 2, -20 },
  { 376, 4, 8, 6, -1, -4 },
  { 380, 8, 1, 10, 1, -10 },
  { 381, 2, 2, 7, 1, -2 },
  { 382, 15, 24, 11, -2, -24 },
  { 427, 14, 25, 16, 2, -25 },
  { 471, 8, 24, 16, 5, -24 },
  { 495, 15, 25, 16, 0, -25 },
  { 542, 16, 25, 16, 0, -25 },
  { 592, 15, 24, 16, 0, -24 },
  { 637, 15, 24, 16, 1, -24 },
  { 682, 14, 25, 16, 2, -25 },
  { 726, 14, 24, 16, 3, -24 },
  { 768, 15, 25, 16, 1, -25 },
  { 815, 15, 25, 16, 1, -25 },
  { 862, 5, 18, 7, 1, -18 },
  { 874, 8, 22, 7, -2, -18 },
  { 896, 14, 15, 17, 2, -20 },
  { 923, 14, 8, 17, 2, -16 },
  { 937, 14, 15, 17, 2, -20 },
  { 964, 11, 25, 12, 2, -25 },
  { 999, 23, 27, 25, 1, -24 },
  { 1077, 16, 24, 16, -2, -24 },
  { 1125, 16, 24, 18, 1, -24 },
  { 1173, 17, 25, 17, 2, -25 },
  { 1227, 18, 24, 20, 1, -24 },
  { 1281, 16, 24, 16, 1, -24 },
  { 1329, 16, 24, 14, 1, -24 },
  { 1377, 18, 25, 21, 2, -25 },
  { 1434, 19, 24, 20, 1, -24 },
  { 1491, 11, 24, 9, -1, -24 },
  { 1524, 13, 30, 7, -5, -24 },
  { 1573, 18, 24, 16, 1, -24 },
  { 1627, 11, 24, 14, 1, -24 },
  { 1660, 24, 24, 25, 1, -24 },
  { 1732, 20, 24, 21, 1, -24 },
  { 1792, 18, 25, 21, 2, -25 },
  { 1849, 16, 24, 17, 1, -24 },
  { 1897, 18, 31, 21, 2, -25 },
  { 1967, 16, 24, 17, 1, -24 },
  { 2015, 16, 25, 15, 0, -25 },
  { 2065, 14, 24, 14, 3, -24 },
  { 2107, 19, 24, 20, 2, -24 },
  { 2164, 16, 24, 16, 3, -24 },
  { 2212, 24, 24, 26, 4, -24 },
  { 2284, 19, 24, 15, -2, -24 },
  { 2341, 14, 24, 14, 3, -24 },
  { 2383, 18, 24, 15, -1, -24 },
  { 2437, 12, 29, 10, 0, -24 },
  { 2481, 6, 24, 11, 3, -24 },
  { 2499, 12, 29, 10, -2, -24 },
  { 2543, 15, 14, 17, 1, -24 },
  { 2570, 12, 2, 11, -3, 3 },
  { 2573, 4, 5, 8, 5, -26 },
  { 2576, 15, 18, 17, 1, -18 },
  { 2610, 15, 26, 17, 1, -26 },
  { 2659, 12, 18, 13, 2, -18 },
  { 2686, 17, 26, 17, 1, -26 },
  { 2742, 12, 18, 15, 2, -18 },
  { 2769, 17, 34, 8, -4, -26 },
  { 2842, 16, 26, 17, 0, -18 },
  { 2894, 14, 26, 17, 1, -26 },
  { 2940, 6, 25, 7, 1, -25 },
  { 2959, 12, 33, 7, -5, -25 },
  { 3009, 14, 26, 14, 1, -26 },
  { 3055, 6, 26, 7, 1, -26 },
  { 3075, 23, 18, 25, 1, -18 },
  { 3127, 14, 18, 17, 1, -18 },
  { 3159, 14, 18, 17, 1, -18 },
  { 3191, 17, 26, 17, -1, -18 },
  { 3247, 15, 26, 17, 1, -18 },
  { 3296, 11, 18, 11, 1, -18 },
  { 3321, 12, 18, 13, 0, -18 },
  { 3348, 9, 22, 9, 1, -22 },
  { 3373, 15, 18, 17, 1, -18 },
  { 3407, 12, 18, 13, 2, -18 },
  { 3434, 20, 18, 20, 2, -18 },
  { 3479, 15, 18, 14, -1, -18 },
  { 3513, 19, 26, 13, -4, -18 },
  { 3575, 14, 18, 12, -1, -18 },
  { 3607, 12, 29, 11, 1, -24 },
  { 3651, 1, 34, 16, 8, -26 },
  { 3656, 12, 29, 11, -2, -24 },
  { 3700, 14, 4, 17, 2, -14 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC34PT7B_H_
