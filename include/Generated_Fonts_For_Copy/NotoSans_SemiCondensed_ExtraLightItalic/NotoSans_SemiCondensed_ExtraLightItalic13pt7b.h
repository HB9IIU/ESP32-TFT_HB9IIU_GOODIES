#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC13PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x90, 0x80, 0x76, 0x80, 0x14, 0x29, 0x79, 0x22, 0x97,
  0x92, 0x28, 0x50, 0x08, 0xF5, 0x14, 0x30, 0x41, 0x8A, 0xA9, 0xC2, 0x00,
  0x73, 0x2A, 0xA5, 0x7B, 0xAD, 0x4A, 0xA5, 0x8C, 0x3C, 0x48, 0xA0, 0x83,
  0x0A, 0x63, 0x46, 0x74, 0x68, 0x12, 0x44, 0x48, 0x88, 0x88, 0x40, 0x11,
  0x11, 0x11, 0x12, 0x24, 0x80, 0x2A, 0x7A, 0xA0, 0x21, 0x09, 0xF2, 0x10,
  0x58, 0xE0, 0x80, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0x80, 0x7A, 0x63,
  0x18, 0xC6, 0x52, 0xE0, 0x75, 0x24, 0x94, 0x80, 0x3C, 0x10, 0x41, 0x08,
  0x42, 0x10, 0xF8, 0x3C, 0x10, 0x42, 0x30, 0x20, 0x82, 0xF0, 0x04, 0x31,
  0x4A, 0x4A, 0x2F, 0xC2, 0x10, 0x3C, 0x84, 0x1C, 0x08, 0x10, 0x42, 0xF0,
  0x3A, 0x21, 0xE8, 0xC6, 0x32, 0xE0, 0xF8, 0x44, 0x22, 0x11, 0x08, 0x80,
  0x3D, 0x12, 0x4A, 0x31, 0x28, 0x62, 0x78, 0x3D, 0x14, 0x51, 0x4C, 0xD0,
  0x82, 0xF0, 0x40, 0x08, 0x20, 0x00, 0x12, 0x80, 0x08, 0x99, 0x06, 0x0C,
  0xF8, 0x3E, 0x82, 0x0C, 0x13, 0x60, 0xF1, 0x12, 0x48, 0x80, 0x80, 0x3E,
  0x41, 0x9D, 0xA5, 0xA5, 0xC9, 0xAA, 0xB4, 0x80, 0x78, 0x04, 0x31, 0x45,
  0x24, 0xF4, 0x51, 0x84, 0x3C, 0x44, 0x8A, 0x27, 0x88, 0x91, 0x42, 0xF8,
  0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x78, 0x3C, 0x44, 0x8A, 0x14, 0x28,
  0x50, 0xC2, 0xF8, 0x3C, 0x82, 0x10, 0x79, 0x04, 0x20, 0xF8, 0x3C, 0x82,
  0x10, 0x79, 0x04, 0x20, 0x80, 0x3E, 0x82, 0x04, 0x09, 0xD0, 0xA1, 0x42,
  0x78, 0x21, 0x21, 0x22, 0x42, 0x7E, 0x42, 0x42, 0x84, 0x84, 0x32, 0x22,
  0x44, 0x44, 0xC0, 0x08, 0x42, 0x21, 0x08, 0x44, 0x21, 0x38, 0x22, 0x48,
  0xA2, 0x87, 0x0A, 0x12, 0x44, 0x88, 0x21, 0x08, 0x84, 0x21, 0x10, 0xF8,
  0x20, 0xC8, 0x22, 0x19, 0x4A, 0x52, 0x95, 0x25, 0x52, 0x64, 0x89, 0x00,
  0x21, 0x21, 0x31, 0x52, 0x4A, 0x4A, 0x4A, 0x84, 0x84, 0x3C, 0x86, 0x0C,
  0x18, 0x30, 0xA1, 0x42, 0x78, 0x3C, 0x92, 0x51, 0x79, 0x04, 0x20, 0x80,
  0x3C, 0x86, 0x0C, 0x18, 0x30, 0xA1, 0x42, 0x78, 0x20, 0x40, 0x3C, 0x92,
  0x51, 0x79, 0x24, 0xA2, 0x88, 0x3D, 0x04, 0x08, 0x10, 0x20, 0x82, 0xF0,
  0xFC, 0x82, 0x08, 0x41, 0x04, 0x10, 0x40, 0x42, 0x86, 0x0C, 0x28, 0x50,
  0xA1, 0x44, 0xF0, 0x86, 0x28, 0xA4, 0x92, 0x86, 0x10, 0x40, 0x88, 0x62,
  0x29, 0x4A, 0x54, 0xA5, 0x29, 0x8A, 0x61, 0x10, 0x84, 0x00, 0x23, 0x12,
  0x14, 0x08, 0x10, 0x18, 0x28, 0x44, 0x84, 0x8E, 0x25, 0x18, 0x61, 0x04,
  0x10, 0x40, 0x3C, 0x10, 0x84, 0x20, 0x84, 0x20, 0xF8, 0x39, 0x10, 0x84,
  0x21, 0x10, 0x84, 0x30, 0xA9, 0x55, 0x40, 0x38, 0x42, 0x21, 0x08, 0x42,
  0x21, 0x38, 0x10, 0xA2, 0x91, 0xC4, 0xF0, 0xC0, 0x7C, 0x63, 0x19, 0x4B,
  0xC0, 0x20, 0x82, 0x16, 0x65, 0x14, 0x51, 0x8B, 0xC0, 0x78, 0x88, 0x88,
  0xE0, 0x04, 0x10, 0x5E, 0x8A, 0x28, 0xA4, 0x93, 0xC0, 0x79, 0x9E, 0x88,
  0xF0, 0x06, 0x10, 0x20, 0xE1, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x0C,
  0x00, 0x3D, 0x14, 0x61, 0x8A, 0x27, 0x82, 0x0B, 0xC0, 0x20, 0x82, 0x16,
  0x65, 0x14, 0x52, 0x8A, 0x20, 0x21, 0x24, 0x94, 0x80, 0x08, 0x04, 0x21,
  0x08, 0x44, 0x21, 0x09, 0x80, 0x20, 0x82, 0x11, 0x49, 0x46, 0x14, 0x92,
  0x40, 0x24, 0xA4, 0x92, 0x90, 0x7B, 0xA2, 0x51, 0x29, 0x14, 0x8C, 0x4A,
  0x24, 0x59, 0x94, 0x51, 0x4A, 0x28, 0x80, 0x74, 0x63, 0x18, 0xCB, 0x80,
  0x59, 0x94, 0x51, 0x46, 0x2F, 0x20, 0x82, 0x00, 0x7C, 0x63, 0x19, 0x4B,
  0xC2, 0x11, 0x00, 0x5B, 0x10, 0x84, 0x42, 0x00, 0x7A, 0x10, 0x41, 0x0B,
  0xC0, 0x22, 0x74, 0x44, 0x88, 0xE0, 0x8C, 0x63, 0x19, 0x4B, 0xC0, 0x99,
  0xAA, 0xCC, 0x80, 0x93, 0x26, 0xD6, 0xAD, 0x51, 0x22, 0x00, 0x4D, 0x23,
  0x08, 0x62, 0x49, 0x00, 0x22, 0x48, 0x91, 0x42, 0x86, 0x08, 0x10, 0x41,
  0x80, 0x78, 0x84, 0x44, 0x43, 0xC0, 0x19, 0x08, 0x42, 0x61, 0x08, 0x42,
  0x18, 0xFF, 0xF8, 0x10, 0x44, 0x21, 0x04, 0x44, 0x21, 0x30, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 3, 4, 1, -9 },
  { 7, 7, 9, 7, 0, -9 },
  { 15, 6, 11, 6, 0, -10 },
  { 24, 7, 9, 9, 1, -9 },
  { 32, 7, 9, 7, 0, -9 },
  { 40, 2, 3, 2, 1, -9 },
  { 41, 4, 11, 3, 0, -9 },
  { 47, 4, 11, 3, -1, -9 },
  { 53, 4, 5, 6, 2, -10 },
  { 56, 5, 6, 7, 1, -8 },
  { 60, 2, 3, 2, -1, -1 },
  { 61, 3, 1, 4, 0, -4 },
  { 62, 1, 1, 3, 0, -1 },
  { 63, 6, 9, 4, -1, -9 },
  { 70, 5, 9, 6, 1, -9 },
  { 76, 3, 9, 6, 2, -9 },
  { 80, 6, 9, 6, 0, -9 },
  { 87, 6, 9, 6, 0, -9 },
  { 94, 6, 9, 6, 0, -9 },
  { 101, 6, 9, 6, 0, -9 },
  { 108, 5, 9, 6, 1, -9 },
  { 114, 5, 9, 6, 1, -9 },
  { 120, 6, 9, 6, 0, -9 },
  { 127, 6, 9, 6, 0, -9 },
  { 134, 2, 7, 3, 0, -7 },
  { 136, 3, 9, 3, -1, -7 },
  { 140, 5, 6, 7, 1, -8 },
  { 144, 5, 3, 7, 1, -6 },
  { 146, 5, 6, 7, 1, -8 },
  { 150, 4, 9, 5, 1, -9 },
  { 155, 8, 10, 9, 1, -9 },
  { 165, 6, 9, 6, -1, -9 },
  { 172, 7, 9, 7, 0, -9 },
  { 180, 6, 9, 7, 1, -9 },
  { 187, 7, 9, 8, 0, -9 },
  { 195, 6, 9, 6, 0, -9 },
  { 202, 6, 9, 6, 0, -9 },
  { 209, 7, 9, 8, 1, -9 },
  { 217, 8, 9, 8, 0, -9 },
  { 226, 4, 9, 3, 0, -9 },
  { 231, 5, 11, 3, -2, -9 },
  { 238, 7, 9, 6, 0, -9 },
  { 246, 5, 9, 6, 0, -9 },
  { 252, 10, 9, 10, 0, -9 },
  { 264, 8, 9, 8, 0, -9 },
  { 273, 7, 9, 8, 1, -9 },
  { 281, 6, 9, 6, 0, -9 },
  { 288, 7, 11, 8, 1, -9 },
  { 298, 6, 9, 6, 0, -9 },
  { 305, 6, 9, 6, 0, -9 },
  { 312, 6, 9, 5, 1, -9 },
  { 319, 7, 9, 8, 1, -9 },
  { 327, 6, 9, 6, 1, -9 },
  { 334, 10, 9, 10, 1, -9 },
  { 346, 8, 9, 6, -1, -9 },
  { 355, 6, 9, 5, 1, -9 },
  { 362, 6, 9, 6, 0, -9 },
  { 369, 5, 11, 4, 0, -9 },
  { 376, 2, 9, 4, 1, -9 },
  { 379, 5, 11, 4, -1, -9 },
  { 386, 6, 5, 6, 0, -9 },
  { 390, 4, 1, 4, -1, 1 },
  { 391, 1, 2, 3, 2, -10 },
  { 392, 5, 7, 6, 1, -7 },
  { 397, 6, 10, 7, 0, -10 },
  { 405, 4, 7, 5, 1, -7 },
  { 409, 6, 10, 7, 1, -10 },
  { 417, 4, 7, 6, 1, -7 },
  { 421, 7, 13, 3, -2, -10 },
  { 433, 6, 10, 7, 0, -7 },
  { 441, 6, 10, 6, 0, -10 },
  { 449, 3, 9, 3, 0, -9 },
  { 453, 5, 12, 3, -2, -9 },
  { 461, 6, 10, 5, 0, -10 },
  { 469, 3, 10, 3, 0, -10 },
  { 473, 9, 7, 10, 0, -7 },
  { 481, 6, 7, 6, 0, -7 },
  { 487, 5, 7, 6, 1, -7 },
  { 492, 6, 10, 7, 0, -7 },
  { 500, 5, 10, 7, 1, -7 },
  { 507, 5, 7, 4, 0, -7 },
  { 512, 5, 7, 5, 0, -7 },
  { 517, 4, 9, 4, 0, -9 },
  { 522, 5, 7, 6, 1, -7 },
  { 527, 4, 7, 5, 1, -7 },
  { 531, 7, 7, 8, 1, -7 },
  { 538, 6, 7, 5, 0, -7 },
  { 544, 7, 10, 5, -1, -7 },
  { 553, 5, 7, 5, 0, -7 },
  { 558, 5, 11, 4, 0, -9 },
  { 565, 1, 13, 6, 3, -10 },
  { 567, 5, 11, 4, -1, -9 },
  { 574, 5, 1, 7, 1, -5 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC13PT7B_H_
