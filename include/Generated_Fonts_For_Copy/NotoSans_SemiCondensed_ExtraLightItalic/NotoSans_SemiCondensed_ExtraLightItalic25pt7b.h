#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC25PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x21, 0x10, 0x84, 0x21, 0x10, 0x84, 0x20, 0x00, 0x84,
  0x00, 0x4A, 0x63, 0x19, 0x4A, 0x40, 0x02, 0x20, 0x21, 0x01, 0x08, 0x08,
  0x80, 0x44, 0x04, 0x21, 0xFF, 0xE1, 0x10, 0x10, 0x80, 0x84, 0x04, 0x41,
  0xBF, 0xC2, 0x10, 0x10, 0x80, 0x88, 0x08, 0x40, 0x42, 0x02, 0x20, 0x00,
  0x01, 0x00, 0x20, 0x1E, 0x0D, 0x32, 0x20, 0x44, 0x08, 0x81, 0x20, 0x14,
  0x01, 0x80, 0x18, 0x02, 0x80, 0x88, 0x11, 0x02, 0x20, 0x48, 0x93, 0x0F,
  0x80, 0x40, 0x08, 0x00, 0x3C, 0x09, 0x90, 0x44, 0x41, 0x21, 0x08, 0x84,
  0x42, 0x11, 0x08, 0x48, 0x21, 0x4E, 0x89, 0x46, 0x29, 0x17, 0x48, 0x41,
  0x21, 0x08, 0x84, 0x44, 0x11, 0x10, 0x88, 0x42, 0x21, 0x11, 0x03, 0x80,
  0x07, 0x80, 0x84, 0x10, 0x41, 0x04, 0x10, 0x41, 0x08, 0x09, 0x00, 0xA0,
  0x0C, 0x03, 0x40, 0x42, 0x1C, 0x22, 0x81, 0x28, 0x14, 0x80, 0xC8, 0x0C,
  0x83, 0x47, 0xC2, 0x5A, 0xA8, 0x02, 0x08, 0x20, 0x81, 0x04, 0x08, 0x20,
  0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x04, 0x08,
  0x00, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x81, 0x02, 0x08, 0x10, 0x41, 0x02, 0x18, 0x00, 0x04, 0x04, 0x22,
  0x0D, 0x01, 0xF8, 0xC0, 0x91, 0x88, 0x02, 0x00, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x24, 0xA5, 0x00, 0xFC, 0xC0, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x00, 0x07, 0x81, 0x08, 0x41, 0x10,
  0x12, 0x02, 0xC0, 0x50, 0x0A, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x40, 0x28,
  0x09, 0x01, 0x20, 0x44, 0x08, 0x42, 0x07, 0x80, 0x09, 0xDB, 0x11, 0x08,
  0x42, 0x11, 0x08, 0x42, 0x21, 0x08, 0x42, 0x00, 0x07, 0xC1, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x1F, 0xF0, 0x07, 0xC1, 0x82,
  0x00, 0x20, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x0C, 0x0F, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x81, 0x8F, 0xE0,
  0x00, 0x20, 0x0C, 0x02, 0x80, 0x90, 0x14, 0x04, 0x81, 0x10, 0x42, 0x08,
  0x42, 0x10, 0x82, 0x20, 0x48, 0x09, 0xFF, 0xC0, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x07, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01,
  0xE0, 0x31, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x08, 0x81, 0x87, 0xE0, 0x03, 0xE0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x78, 0x70, 0x88, 0x13, 0x01, 0x40, 0x28, 0x05, 0x01, 0x20,
  0x22, 0x0C, 0x41, 0x07, 0xC0, 0x7F, 0xC0, 0x10, 0x0C, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x0C, 0x02, 0x01,
  0x00, 0x40, 0x20, 0x00, 0x0F, 0x83, 0x08, 0x40, 0x90, 0x12, 0x02, 0x40,
  0x84, 0x30, 0x48, 0x06, 0x03, 0x41, 0x84, 0x40, 0x48, 0x09, 0x01, 0x20,
  0x24, 0x04, 0xC1, 0x0F, 0xC0, 0x0F, 0x84, 0x32, 0x04, 0x81, 0x40, 0x50,
  0x14, 0x05, 0x01, 0x40, 0xC8, 0x53, 0xE4, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x08, 0x04, 0x3E, 0x00, 0x18, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x8C,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x08, 0x21, 0x04,
  0x20, 0x00, 0x20, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x10, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x00, 0x3E, 0x21, 0x01, 0x01,
  0x01, 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x20, 0x40, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0xF8, 0x01, 0x82, 0x03, 0x00, 0x83, 0x00, 0x21, 0x00,
  0x11, 0x03, 0x89, 0x04, 0x42, 0x84, 0x21, 0x44, 0x11, 0x42, 0x10, 0xA2,
  0x08, 0x51, 0x04, 0x28, 0x86, 0x24, 0x43, 0x12, 0x1E, 0xF1, 0x00, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x40, 0x18,
  0x03, 0x00, 0xA0, 0x24, 0x04, 0x81, 0x10, 0x21, 0x08, 0x21, 0x04, 0x7F,
  0x88, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x80, 0x30, 0x04, 0x1F, 0x81,
  0x02, 0x10, 0x11, 0x01, 0x10, 0x12, 0x03, 0x20, 0x22, 0x04, 0x3F, 0x82,
  0x08, 0x40, 0x44, 0x04, 0x40, 0x44, 0x04, 0x40, 0x48, 0x0C, 0x81, 0x8F,
  0xE0, 0x03, 0xE0, 0xC1, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x03, 0xF0, 0x1F, 0x80, 0x83, 0x04, 0x04, 0x20, 0x21, 0x00,
  0x90, 0x04, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x90, 0x04, 0x80, 0x24,
  0x03, 0x20, 0x11, 0x01, 0x10, 0x10, 0x83, 0x07, 0xE0, 0x00, 0x1F, 0xE2,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x3F, 0x84, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x1F, 0xE0, 0x1F,
  0xE2, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x07,
  0xF1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x00,
  0x03, 0xF0, 0x60, 0x44, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x0F, 0xA0, 0x09, 0x00, 0x48, 0x02, 0x40, 0x12, 0x00,
  0x98, 0x08, 0x40, 0x41, 0xFE, 0x00, 0x18, 0x04, 0x40, 0x11, 0x00, 0x84,
  0x02, 0x10, 0x08, 0x80, 0x22, 0x00, 0x88, 0x04, 0x3F, 0xF0, 0x80, 0x44,
  0x01, 0x10, 0x04, 0x40, 0x21, 0x00, 0x84, 0x02, 0x20, 0x08, 0x80, 0x22,
  0x01, 0x00, 0x1F, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40, 0xF0, 0x00, 0x40, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x3C, 0x00,
  0x18, 0x18, 0x81, 0x84, 0x18, 0x21, 0x81, 0x18, 0x11, 0x80, 0x88, 0x04,
  0x80, 0x2C, 0x01, 0xA0, 0x19, 0x80, 0x84, 0x04, 0x20, 0x20, 0x82, 0x04,
  0x10, 0x20, 0x80, 0x84, 0x04, 0x00, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0xFF,
  0x18, 0x00, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x51, 0x40, 0x29, 0x20,
  0x28, 0x90, 0x24, 0x48, 0x12, 0x24, 0x11, 0x12, 0x09, 0x11, 0x08, 0x88,
  0x84, 0x44, 0x24, 0x22, 0x12, 0x12, 0x0A, 0x11, 0x05, 0x08, 0x83, 0x04,
  0x41, 0x02, 0x00, 0x18, 0x04, 0x60, 0x11, 0x80, 0x45, 0x01, 0x14, 0x08,
  0x90, 0x22, 0x20, 0x88, 0x82, 0x22, 0x10, 0x84, 0x44, 0x11, 0x10, 0x44,
  0x40, 0x91, 0x02, 0x88, 0x0A, 0x20, 0x18, 0x80, 0x62, 0x01, 0x80, 0x07,
  0xC0, 0xC1, 0x04, 0x04, 0x40, 0x24, 0x00, 0xA0, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x03, 0x40, 0x12, 0x01, 0x90,
  0x08, 0x40, 0x81, 0xF8, 0x00, 0x1F, 0x82, 0x08, 0x40, 0x88, 0x11, 0x02,
  0x40, 0x48, 0x09, 0x01, 0x20, 0x44, 0x71, 0xF0, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x10, 0x00, 0x07, 0xC0, 0xC1, 0x04, 0x04, 0x40,
  0x24, 0x00, 0xA0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xA0, 0x05,
  0x00, 0x28, 0x03, 0x40, 0x12, 0x01, 0x90, 0x08, 0x40, 0x81, 0xF8, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x1F, 0x82, 0x08, 0x40, 0x88, 0x11,
  0x02, 0x40, 0x48, 0x09, 0x02, 0x20, 0xC7, 0xE1, 0x08, 0x21, 0x04, 0x10,
  0x82, 0x10, 0x44, 0x08, 0x80, 0x90, 0x10, 0x07, 0xF0, 0x82, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80,
  0x08, 0x00, 0x80, 0x0C, 0x00, 0x80, 0x08, 0x81, 0x0F, 0xE0, 0xFF, 0xE0,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x00, 0x20,
  0x09, 0x00, 0x48, 0x02, 0x40, 0x24, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02,
  0x40, 0x24, 0x01, 0x20, 0x09, 0x00, 0x48, 0x04, 0x40, 0x22, 0x01, 0x10,
  0x10, 0xC1, 0x83, 0xF0, 0x00, 0x80, 0x18, 0x02, 0x40, 0x24, 0x04, 0x40,
  0x44, 0x08, 0x40, 0x84, 0x10, 0x41, 0x04, 0x20, 0x42, 0x04, 0x40, 0x44,
  0x04, 0x80, 0x48, 0x03, 0x00, 0x30, 0x02, 0x00, 0x80, 0x80, 0xE0, 0x20,
  0x28, 0x18, 0x12, 0x06, 0x04, 0x82, 0x81, 0x20, 0xA0, 0x88, 0x48, 0x22,
  0x12, 0x10, 0x88, 0x84, 0x22, 0x22, 0x08, 0x88, 0x82, 0x42, 0x20, 0x90,
  0x50, 0x28, 0x14, 0x0A, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10,
  0x00, 0x08, 0x0C, 0x20, 0x20, 0x41, 0x01, 0x08, 0x04, 0x60, 0x11, 0x00,
  0x28, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x50, 0x02, 0x40, 0x08, 0x80,
  0x42, 0x02, 0x08, 0x10, 0x20, 0x40, 0x42, 0x01, 0x00, 0x80, 0x68, 0x09,
  0x02, 0x20, 0x44, 0x10, 0x84, 0x08, 0x81, 0x20, 0x28, 0x05, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x00, 0x0F, 0xF8,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x07, 0xFE, 0x00, 0x0F, 0x84, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x07, 0xC0, 0x92, 0x49, 0x22, 0x49, 0x24, 0x49, 0x24,
  0x07, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x3E, 0x00, 0x02, 0x00, 0xA0, 0x14, 0x04, 0x80, 0x88, 0x21,
  0x08, 0x21, 0x02, 0x40, 0x50, 0x0C, 0xFF, 0x91, 0x10, 0x1F, 0x26, 0x18,
  0x81, 0x20, 0x24, 0x04, 0x80, 0xA0, 0x24, 0x04, 0x80, 0x90, 0x32, 0x0A,
  0x21, 0x87, 0xD0, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x82, 0xD8,
  0xC1, 0x30, 0x48, 0x14, 0x05, 0x01, 0x40, 0x50, 0x18, 0x07, 0x02, 0xC1,
  0xB0, 0x4B, 0xE0, 0x1F, 0x98, 0x08, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x08, 0x03, 0xE0, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x22, 0x1D, 0xA3, 0x0A, 0x20, 0x44, 0x04, 0x40, 0x48, 0x04,
  0x80, 0x48, 0x08, 0x80, 0x88, 0x18, 0x81, 0x84, 0x28, 0x7D, 0x00, 0x0F,
  0x88, 0x48, 0x28, 0x14, 0x12, 0x33, 0xC1, 0x00, 0x80, 0x40, 0x20, 0x08,
  0x03, 0xE0, 0x00, 0x70, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x0F,
  0xC0, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x03, 0x00, 0xE0, 0x00, 0x0F, 0xD1, 0x85, 0x10, 0x22, 0x02, 0x20, 0x24,
  0x02, 0x40, 0x24, 0x04, 0x40, 0x44, 0x0C, 0x40, 0xC2, 0x14, 0x3E, 0x80,
  0x08, 0x00, 0x80, 0x18, 0x01, 0x08, 0x20, 0x7C, 0x00, 0x18, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x02, 0xF8, 0xC1, 0x20, 0x48, 0x14, 0x05, 0x01,
  0x40, 0x90, 0x28, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x10, 0x11, 0x00, 0x02,
  0x22, 0x24, 0x44, 0x48, 0x88, 0x88, 0x01, 0x01, 0x00, 0x00, 0x00, 0x02,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x20, 0xE0, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x12, 0x08, 0x84, 0x22, 0x09, 0x04, 0x81, 0x60, 0x68, 0x12, 0x08,
  0x42, 0x10, 0x82, 0x20, 0x88, 0x30, 0x18, 0x84, 0x21, 0x10, 0x84, 0x21,
  0x10, 0x84, 0x22, 0x10, 0x84, 0x20, 0x2F, 0x9F, 0x30, 0xA1, 0x20, 0xC1,
  0x20, 0xC1, 0x40, 0x81, 0x40, 0x81, 0x40, 0x81, 0x40, 0x82, 0x81, 0x02,
  0x81, 0x02, 0x81, 0x02, 0x81, 0x02, 0x82, 0x04, 0x2F, 0x8C, 0x12, 0x04,
  0x81, 0x40, 0x50, 0x14, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x04, 0x81,
  0x00, 0x1F, 0x8C, 0x12, 0x05, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80,
  0xA0, 0x28, 0x19, 0x0C, 0x3E, 0x00, 0x0B, 0xE0, 0xC1, 0x0C, 0x10, 0x81,
  0x18, 0x11, 0x01, 0x10, 0x11, 0x01, 0x30, 0x13, 0x02, 0x30, 0x63, 0x04,
  0x2F, 0x84, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x00, 0x1F,
  0xA6, 0x14, 0x81, 0x20, 0x24, 0x05, 0x80, 0xA0, 0x14, 0x04, 0x80, 0x90,
  0x32, 0x06, 0x21, 0x47, 0xD0, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x08, 0x00, 0x2F, 0x30, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x1F, 0x90, 0x08, 0x04, 0x02, 0x00, 0xC0, 0x30, 0x04,
  0x02, 0x00, 0x80, 0x90, 0x4F, 0xC0, 0x10, 0x42, 0x3F, 0x20, 0x84, 0x10,
  0x41, 0x04, 0x20, 0x82, 0x08, 0x3C, 0x20, 0x64, 0x08, 0x81, 0x20, 0x24,
  0x04, 0x81, 0x10, 0x22, 0x04, 0x80, 0x90, 0x32, 0x0C, 0x41, 0x87, 0xD0,
  0x80, 0xE0, 0x24, 0x11, 0x04, 0x42, 0x11, 0x84, 0x41, 0x20, 0x48, 0x14,
  0x05, 0x01, 0x80, 0x20, 0x00, 0x81, 0x03, 0x06, 0x0A, 0x0C, 0x12, 0x28,
  0x44, 0x50, 0x89, 0x22, 0x12, 0x24, 0x24, 0x50, 0x50, 0xA0, 0xA1, 0x41,
  0x83, 0x03, 0x06, 0x04, 0x08, 0x00, 0x10, 0x30, 0x84, 0x08, 0x80, 0x88,
  0x05, 0x00, 0x60, 0x06, 0x00, 0xA0, 0x0A, 0x01, 0x10, 0x21, 0x04, 0x10,
  0xC0, 0x80, 0x0C, 0x0C, 0x10, 0x20, 0x41, 0x01, 0x04, 0x04, 0x20, 0x10,
  0x80, 0x44, 0x01, 0x10, 0x04, 0x80, 0x0A, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x0E, 0x00, 0x00,
  0x1F, 0xC0, 0x30, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04,
  0x02, 0x01, 0x00, 0xFF, 0x00, 0x03, 0x82, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x10, 0x18, 0x18, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x00, 0xE0, 0x60,
  0x40, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x06, 0x00, 0x78,
  0x30, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 18, 5, 1, -18 },
  { 13, 5, 7, 8, 3, -18 },
  { 18, 13, 18, 13, 1, -18 },
  { 48, 11, 20, 12, 1, -19 },
  { 76, 14, 18, 17, 2, -18 },
  { 108, 12, 18, 14, 1, -18 },
  { 135, 2, 7, 4, 3, -18 },
  { 137, 7, 22, 6, 1, -18 },
  { 157, 7, 22, 6, -2, -18 },
  { 177, 9, 9, 11, 3, -19 },
  { 188, 11, 12, 13, 1, -15 },
  { 205, 3, 6, 5, -1, -3 },
  { 208, 6, 1, 7, 1, -7 },
  { 209, 1, 2, 5, 1, -2 },
  { 210, 11, 18, 8, -1, -18 },
  { 235, 11, 18, 12, 1, -18 },
  { 260, 5, 18, 12, 4, -18 },
  { 272, 11, 18, 12, 0, -18 },
  { 297, 12, 18, 12, 0, -18 },
  { 324, 11, 18, 12, 0, -18 },
  { 349, 12, 18, 12, 0, -18 },
  { 376, 11, 18, 12, 1, -18 },
  { 401, 10, 18, 12, 2, -18 },
  { 424, 11, 18, 12, 1, -18 },
  { 449, 10, 18, 12, 1, -18 },
  { 472, 5, 13, 5, 0, -13 },
  { 481, 6, 16, 5, -1, -13 },
  { 493, 11, 12, 13, 1, -15 },
  { 510, 11, 6, 13, 1, -12 },
  { 519, 11, 12, 13, 1, -15 },
  { 536, 8, 18, 9, 1, -18 },
  { 554, 17, 20, 18, 1, -18 },
  { 597, 11, 18, 12, -1, -18 },
  { 622, 12, 18, 13, 1, -18 },
  { 649, 12, 18, 13, 2, -18 },
  { 676, 13, 18, 15, 1, -18 },
  { 706, 11, 18, 12, 1, -18 },
  { 731, 11, 18, 11, 1, -18 },
  { 756, 13, 18, 15, 2, -18 },
  { 786, 14, 18, 15, 1, -18 },
  { 818, 8, 18, 6, 0, -18 },
  { 836, 10, 22, 5, -4, -18 },
  { 864, 13, 18, 12, 1, -18 },
  { 894, 8, 18, 11, 1, -18 },
  { 912, 17, 18, 18, 1, -18 },
  { 951, 14, 18, 15, 1, -18 },
  { 983, 13, 18, 16, 2, -18 },
  { 1013, 11, 18, 12, 1, -18 },
  { 1038, 13, 22, 16, 2, -18 },
  { 1074, 11, 18, 12, 1, -18 },
  { 1099, 12, 18, 11, 0, -18 },
  { 1126, 11, 18, 11, 2, -18 },
  { 1151, 13, 18, 15, 2, -18 },
  { 1181, 12, 18, 12, 2, -18 },
  { 1208, 18, 18, 19, 3, -18 },
  { 1249, 14, 18, 11, -1, -18 },
  { 1281, 11, 18, 11, 2, -18 },
  { 1306, 13, 18, 11, -1, -18 },
  { 1336, 9, 22, 7, 0, -18 },
  { 1361, 3, 18, 8, 3, -18 },
  { 1368, 10, 22, 7, -2, -18 },
  { 1396, 11, 10, 12, 1, -18 },
  { 1410, 8, 1, 8, -2, 2 },
  { 1411, 3, 4, 6, 4, -19 },
  { 1413, 11, 13, 12, 1, -13 },
  { 1431, 10, 19, 13, 1, -19 },
  { 1455, 9, 13, 10, 1, -13 },
  { 1470, 12, 19, 13, 1, -19 },
  { 1499, 9, 13, 11, 1, -13 },
  { 1514, 12, 25, 6, -3, -19 },
  { 1552, 12, 19, 13, 0, -13 },
  { 1581, 10, 19, 12, 1, -19 },
  { 1605, 4, 18, 5, 1, -18 },
  { 1614, 8, 24, 5, -3, -18 },
  { 1638, 10, 19, 10, 1, -19 },
  { 1662, 5, 19, 5, 1, -19 },
  { 1674, 16, 13, 19, 1, -13 },
  { 1700, 10, 13, 12, 1, -13 },
  { 1717, 10, 13, 12, 1, -13 },
  { 1734, 12, 19, 13, -1, -13 },
  { 1763, 11, 19, 13, 1, -13 },
  { 1790, 8, 13, 8, 1, -13 },
  { 1803, 9, 13, 9, 0, -13 },
  { 1818, 6, 16, 7, 1, -16 },
  { 1830, 11, 13, 12, 1, -13 },
  { 1848, 10, 13, 9, 1, -13 },
  { 1865, 15, 13, 15, 1, -13 },
  { 1890, 12, 13, 10, -1, -13 },
  { 1910, 14, 19, 9, -3, -13 },
  { 1944, 10, 13, 9, -1, -13 },
  { 1961, 9, 22, 8, 1, -18 },
  { 1986, 1, 25, 12, 6, -19 },
  { 1990, 9, 22, 8, -1, -18 },
  { 2015, 11, 2, 13, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC25PT7B_H_
