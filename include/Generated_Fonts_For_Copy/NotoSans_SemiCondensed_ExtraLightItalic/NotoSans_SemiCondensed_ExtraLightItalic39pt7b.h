#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC39PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x08,
  0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x40, 0xC0, 0xC0, 0x31, 0x90, 0xC8, 0x4C, 0x26, 0x32, 0x19,
  0x08, 0x84, 0xC2, 0x43, 0x00, 0x00, 0x20, 0x40, 0x06, 0x04, 0x00, 0x60,
  0xC0, 0x04, 0x08, 0x00, 0x40, 0x80, 0x0C, 0x18, 0x00, 0x81, 0x00, 0x08,
  0x10, 0x01, 0x81, 0x03, 0xFF, 0xFF, 0x01, 0x02, 0x00, 0x30, 0x20, 0x03,
  0x06, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x60, 0xC0, 0x04, 0x0C, 0x00,
  0x40, 0x80, 0xFF, 0xFF, 0xC0, 0x81, 0x80, 0x08, 0x10, 0x00, 0x81, 0x00,
  0x18, 0x30, 0x01, 0x03, 0x00, 0x10, 0x20, 0x03, 0x02, 0x00, 0x20, 0x60,
  0x02, 0x04, 0x00, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x1F, 0xF0, 0x18, 0x8C, 0x10, 0x80, 0x18, 0x40, 0x08, 0x20, 0x0C, 0x10,
  0x06, 0x18, 0x01, 0x08, 0x00, 0xC4, 0x00, 0x72, 0x00, 0x1D, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x5C, 0x00, 0x23, 0x00, 0x11, 0x80, 0x18, 0x40,
  0x08, 0x20, 0x04, 0x10, 0x02, 0x08, 0x03, 0x0C, 0x01, 0x0C, 0x38, 0x9C,
  0x0F, 0xF8, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0F,
  0x80, 0x18, 0x62, 0x00, 0xC3, 0x0C, 0x02, 0x08, 0x10, 0x10, 0x60, 0x40,
  0xC1, 0x01, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x30, 0xC0, 0xC0, 0xC2, 0x02,
  0x02, 0x18, 0x08, 0x08, 0xC0, 0x20, 0x62, 0x3C, 0x81, 0x19, 0x9A, 0x04,
  0xCC, 0x3C, 0x22, 0x20, 0xF1, 0x99, 0x83, 0x7C, 0x44, 0x0C, 0x02, 0x30,
  0x30, 0x18, 0xC0, 0xC0, 0x42, 0x02, 0x02, 0x08, 0x08, 0x18, 0x20, 0x20,
  0x40, 0x81, 0x82, 0x02, 0x04, 0x18, 0x08, 0x30, 0x40, 0x20, 0x83, 0x00,
  0xC6, 0x18, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x38, 0xC0, 0x04, 0x0C, 0x01,
  0x80, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0xC0, 0x10, 0x10, 0x02,
  0x06, 0x00, 0x41, 0x80, 0x0C, 0x60, 0x00, 0xB8, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x01, 0xB0, 0x00, 0xC3, 0x01, 0x30, 0x20, 0x2C, 0x06, 0x0D, 0x00,
  0x41, 0x60, 0x0C, 0x6C, 0x00, 0x99, 0x00, 0x1A, 0x20, 0x01, 0xC4, 0x00,
  0x30, 0xC0, 0x0F, 0x08, 0x03, 0x21, 0xC1, 0x86, 0x1F, 0xE0, 0x60, 0x32,
  0x26, 0x64, 0x44, 0xC8, 0x00, 0x60, 0x18, 0x02, 0x00, 0x80, 0x30, 0x0C,
  0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x18,
  0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x20, 0x06, 0x00, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x20,
  0x1C, 0x00, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0xC3, 0x01, 0x88,
  0x01, 0xA0, 0x41, 0xFF, 0x06, 0x00, 0x24, 0x01, 0x10, 0x08, 0x60, 0xC0,
  0x81, 0x03, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x7F, 0xFF, 0xC0, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x0C, 0x21, 0x84, 0x30,
  0x82, 0x10, 0xC0, 0xFF, 0x80, 0x7C, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF8, 0x03, 0x8E, 0x06, 0x06,
  0x0C, 0x03, 0x08, 0x03, 0x18, 0x03, 0x10, 0x01, 0x30, 0x01, 0x30, 0x01,
  0x20, 0x03, 0x60, 0x03, 0x60, 0x03, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x02,
  0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x0C,
  0x80, 0x08, 0x80, 0x18, 0xC0, 0x10, 0xC0, 0x30, 0x60, 0x60, 0x70, 0xC0,
  0x3F, 0x80, 0x01, 0x07, 0x0D, 0x3B, 0x63, 0xC2, 0x82, 0x06, 0x06, 0x06,
  0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30,
  0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x00, 0xFE, 0x00, 0xF0, 0xC0, 0x60,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFE, 0x00,
  0xF0, 0xE0, 0x60, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x0C, 0x20, 0x07, 0x0E, 0x03, 0x81, 0xFF, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x28, 0x00, 0x1A, 0x00, 0x0D, 0x80,
  0x02, 0x60, 0x01, 0x10, 0x00, 0xC4, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x08,
  0x30, 0x04, 0x08, 0x03, 0x02, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x20, 0x10,
  0x18, 0x04, 0x0C, 0x01, 0x06, 0x00, 0xC1, 0x00, 0x31, 0xFF, 0xFF, 0x80,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x78, 0x01, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x40, 0x18, 0x30, 0x38,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x70, 0x40, 0x60, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x7E, 0x06, 0xE1, 0x82, 0xC0, 0x61, 0xC0, 0x11, 0xC0,
  0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xC8, 0x00, 0x44,
  0x00, 0x63, 0x00, 0x31, 0x80, 0x10, 0x40, 0x18, 0x30, 0x18, 0x0C, 0x18,
  0x03, 0xF8, 0x00, 0x3F, 0xFF, 0x7F, 0xFF, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00,
  0xFE, 0x01, 0xC3, 0x81, 0x80, 0x60, 0x80, 0x30, 0xC0, 0x08, 0x60, 0x04,
  0x30, 0x02, 0x18, 0x03, 0x0C, 0x01, 0x82, 0x01, 0x81, 0x81, 0x80, 0x61,
  0x80, 0x1B, 0x00, 0x0F, 0x00, 0x1C, 0xC0, 0x38, 0x30, 0x30, 0x0C, 0x30,
  0x02, 0x10, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x26, 0x00, 0x33, 0x00, 0x19,
  0x80, 0x0C, 0xC0, 0x0C, 0x30, 0x0C, 0x0C, 0x0C, 0x03, 0xFC, 0x00, 0x00,
  0xFC, 0x01, 0xC3, 0x01, 0x80, 0xC1, 0x80, 0x20, 0x80, 0x18, 0xC0, 0x0C,
  0x40, 0x06, 0x20, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00,
  0x33, 0x00, 0x31, 0x80, 0x38, 0x60, 0x34, 0x18, 0x36, 0x07, 0xE2, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x20, 0x60, 0x1F, 0xE0, 0x00, 0x0C,
  0x30, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x30, 0xC0, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x06,
  0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x00, 0x00, 0x00, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x40,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x1F,
  0xC1, 0xC3, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x38, 0x01, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x38, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x00,
  0x30, 0x20, 0x00, 0x08, 0x30, 0x00, 0x06, 0x30, 0x00, 0x01, 0x10, 0x07,
  0xC0, 0x98, 0x0C, 0x70, 0x48, 0x08, 0x10, 0x2C, 0x08, 0x08, 0x14, 0x0C,
  0x0C, 0x0A, 0x0C, 0x06, 0x07, 0x06, 0x02, 0x07, 0x82, 0x01, 0x03, 0x83,
  0x01, 0x81, 0x41, 0x80, 0xC0, 0xA0, 0xC0, 0x40, 0xD0, 0x60, 0x60, 0x48,
  0x30, 0x70, 0x64, 0x08, 0x28, 0x62, 0x07, 0xE7, 0xE1, 0x00, 0xC0, 0xC0,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x08, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x50, 0x00, 0x34, 0x00, 0x09,
  0x00, 0x06, 0x40, 0x01, 0x10, 0x00, 0xC4, 0x00, 0x21, 0x80, 0x18, 0x60,
  0x04, 0x18, 0x03, 0x06, 0x00, 0x81, 0x80, 0x60, 0x20, 0x10, 0x08, 0x0C,
  0x02, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x40, 0x08, 0x30, 0x03, 0x08, 0x00,
  0xC6, 0x00, 0x31, 0x00, 0x0C, 0xC0, 0x03, 0x20, 0x00, 0xD8, 0x00, 0x14,
  0x00, 0x07, 0x00, 0x01, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x08, 0x03, 0x03,
  0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x00, 0x18, 0x20, 0x03, 0x0C,
  0x00, 0x41, 0x80, 0x18, 0x20, 0x03, 0x04, 0x01, 0xC1, 0x80, 0xE0, 0x3F,
  0xF0, 0x06, 0x03, 0x80, 0x80, 0x18, 0x10, 0x01, 0x06, 0x00, 0x30, 0xC0,
  0x06, 0x18, 0x00, 0xC2, 0x00, 0x18, 0x40, 0x03, 0x18, 0x00, 0x43, 0x00,
  0x18, 0x40, 0x06, 0x08, 0x01, 0x81, 0x01, 0xE0, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x3C, 0x1C, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x20, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x02,
  0x01, 0xC0, 0x60, 0x06, 0x06, 0x00, 0x20, 0x60, 0x03, 0x04, 0x00, 0x30,
  0x40, 0x01, 0x0C, 0x00, 0x10, 0xC0, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01,
  0x18, 0x00, 0x11, 0x80, 0x01, 0x18, 0x00, 0x31, 0x00, 0x03, 0x10, 0x00,
  0x33, 0x00, 0x02, 0x30, 0x00, 0x63, 0x00, 0x04, 0x20, 0x00, 0xC2, 0x00,
  0x18, 0x60, 0x01, 0x86, 0x00, 0x30, 0x40, 0x0E, 0x04, 0x01, 0xC0, 0x41,
  0xF0, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x07, 0xFF, 0x81,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0xFF, 0xE0, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x1E, 0x0F, 0x03, 0x00, 0x10, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x1F, 0xC8,
  0x02, 0x04, 0x80, 0x00, 0xC8, 0x00, 0x0C, 0x80, 0x00, 0x88, 0x00, 0x08,
  0x80, 0x01, 0x88, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x10, 0x60, 0x01,
  0x03, 0x00, 0x30, 0x18, 0x07, 0x00, 0xFF, 0xC0, 0x03, 0x00, 0x04, 0x08,
  0x00, 0x10, 0x20, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x08, 0x18, 0x00,
  0x20, 0x40, 0x00, 0x81, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x40,
  0x80, 0x01, 0x02, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x7F, 0xFF, 0xC1, 0x80,
  0x02, 0x04, 0x00, 0x08, 0x10, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x04,
  0x0C, 0x00, 0x10, 0x20, 0x00, 0x40, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18,
  0x00, 0x20, 0x40, 0x00, 0x81, 0x00, 0x02, 0x04, 0x00, 0x18, 0x30, 0x00,
  0x60, 0x03, 0xF8, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x01, 0xFC, 0x00, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x06,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0x00, 0x18, 0x10, 0x01, 0x80, 0x80,
  0x18, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x02, 0x01, 0x80, 0x10, 0x18, 0x00,
  0x81, 0x80, 0x0C, 0x18, 0x00, 0x61, 0x80, 0x02, 0x18, 0x00, 0x11, 0x80,
  0x01, 0x98, 0x00, 0x0D, 0xE0, 0x00, 0x7B, 0x00, 0x03, 0x88, 0x00, 0x10,
  0x60, 0x01, 0x81, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x02, 0x01, 0x00,
  0x10, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x40, 0x0C, 0x02, 0x00,
  0x20, 0x10, 0x01, 0x81, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x03, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x70, 0x30, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0A, 0x07, 0x80, 0x01, 0xE0, 0x48,
  0x00, 0x36, 0x04, 0x80, 0x03, 0x40, 0x48, 0x00, 0x64, 0x0C, 0x80, 0x04,
  0x40, 0xC8, 0x00, 0xCC, 0x08, 0xC0, 0x08, 0xC0, 0x8C, 0x01, 0x88, 0x18,
  0xC0, 0x10, 0x81, 0x84, 0x03, 0x18, 0x18, 0x40, 0x21, 0x81, 0x04, 0x06,
  0x18, 0x10, 0x40, 0xC1, 0x03, 0x04, 0x0C, 0x10, 0x30, 0x61, 0x83, 0x02,
  0x06, 0x10, 0x30, 0x20, 0x63, 0x02, 0x02, 0x02, 0x20, 0x20, 0x60, 0x26,
  0x02, 0x06, 0x02, 0x40, 0x60, 0x40, 0x2C, 0x06, 0x04, 0x02, 0x80, 0x40,
  0x40, 0x38, 0x04, 0x0C, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x08, 0x0C, 0x00, 0x10, 0x3C, 0x00, 0x60, 0x68, 0x00, 0xC0, 0x90, 0x01,
  0x81, 0x30, 0x02, 0x02, 0x20, 0x04, 0x0C, 0x40, 0x18, 0x18, 0xC0, 0x30,
  0x20, 0x80, 0x60, 0x41, 0x00, 0x81, 0x83, 0x01, 0x03, 0x02, 0x06, 0x06,
  0x04, 0x0C, 0x08, 0x0C, 0x10, 0x10, 0x08, 0x20, 0x60, 0x10, 0x40, 0xC0,
  0x31, 0x81, 0x80, 0x63, 0x02, 0x00, 0x44, 0x04, 0x00, 0xC8, 0x18, 0x01,
  0x90, 0x30, 0x01, 0x60, 0x40, 0x03, 0xC0, 0x80, 0x07, 0x01, 0x00, 0x06,
  0x06, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0x80, 0x0E, 0x0E, 0x00, 0xC0, 0x18,
  0x0C, 0x00, 0x60, 0x40, 0x01, 0x06, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00,
  0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xC8, 0x00, 0x06, 0xC0, 0x00, 0x36,
  0x00, 0x01, 0xB0, 0x00, 0x0D, 0x00, 0x00, 0x68, 0x00, 0x02, 0x40, 0x00,
  0x36, 0x00, 0x01, 0xB0, 0x00, 0x08, 0x80, 0x00, 0xC4, 0x00, 0x06, 0x20,
  0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x30, 0x03, 0x01, 0x80, 0x38,
  0x07, 0x07, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x20,
  0x18, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x10, 0x40, 0x04, 0x10, 0x01,
  0x0C, 0x00, 0x43, 0x00, 0x30, 0x80, 0x0C, 0x20, 0x06, 0x18, 0x01, 0x86,
  0x00, 0xC1, 0x81, 0xE0, 0x7F, 0xE0, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x0E, 0x0E, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x60, 0x40, 0x01, 0x06, 0x00,
  0x0C, 0x60, 0x00, 0x63, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xC8,
  0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x00, 0x00,
  0x48, 0x00, 0x02, 0x40, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x08, 0x80,
  0x00, 0xC4, 0x00, 0x06, 0x20, 0x00, 0x21, 0x80, 0x03, 0x0C, 0x00, 0x30,
  0x30, 0x03, 0x01, 0x80, 0x30, 0x07, 0x07, 0x00, 0x0F, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x20, 0x18,
  0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x10, 0x40, 0x04, 0x10, 0x01, 0x0C,
  0x00, 0xC3, 0x00, 0x30, 0x80, 0x08, 0x20, 0x06, 0x18, 0x03, 0x06, 0x01,
  0x81, 0xFF, 0xC0, 0x7F, 0x80, 0x10, 0x20, 0x0C, 0x0C, 0x03, 0x01, 0x00,
  0xC0, 0x40, 0x20, 0x18, 0x08, 0x06, 0x06, 0x00, 0x81, 0x80, 0x30, 0x40,
  0x0C, 0x10, 0x01, 0x04, 0x00, 0x43, 0x00, 0x18, 0x00, 0xFF, 0x00, 0x70,
  0x70, 0x30, 0x04, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x0C, 0x07, 0x01, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x18, 0x40, 0x00, 0x86, 0x00, 0x04, 0x30, 0x00, 0x61, 0x00, 0x03,
  0x08, 0x00, 0x10, 0x40, 0x00, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x00,
  0x03, 0x08, 0x00, 0x10, 0xC0, 0x00, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61,
  0x00, 0x03, 0x08, 0x00, 0x10, 0xC0, 0x00, 0x86, 0x00, 0x0C, 0x30, 0x00,
  0x61, 0x00, 0x02, 0x08, 0x00, 0x10, 0x40, 0x01, 0x82, 0x00, 0x08, 0x10,
  0x00, 0xC0, 0xC0, 0x0C, 0x03, 0x00, 0xE0, 0x1C, 0x0C, 0x00, 0x3F, 0xC0,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x6C, 0x00, 0x26,
  0x00, 0x33, 0x00, 0x11, 0x80, 0x18, 0xC0, 0x08, 0x60, 0x0C, 0x10, 0x04,
  0x08, 0x06, 0x04, 0x02, 0x02, 0x03, 0x01, 0x01, 0x00, 0x81, 0x80, 0x40,
  0x80, 0x30, 0xC0, 0x18, 0x40, 0x0C, 0x60, 0x06, 0x20, 0x03, 0x30, 0x00,
  0x90, 0x00, 0x58, 0x00, 0x28, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x02, 0xC0, 0x0E, 0x00, 0x6C,
  0x00, 0xA0, 0x06, 0xC0, 0x1A, 0x00, 0x4C, 0x01, 0xA0, 0x0C, 0xC0, 0x12,
  0x00, 0x8C, 0x03, 0x20, 0x18, 0xC0, 0x22, 0x01, 0x0C, 0x06, 0x20, 0x30,
  0xC0, 0x42, 0x03, 0x0C, 0x0C, 0x20, 0x20, 0x40, 0x82, 0x06, 0x04, 0x18,
  0x20, 0x40, 0x41, 0x82, 0x0C, 0x04, 0x10, 0x20, 0x80, 0x43, 0x02, 0x18,
  0x04, 0x20, 0x21, 0x00, 0x46, 0x02, 0x10, 0x04, 0x40, 0x23, 0x00, 0x4C,
  0x02, 0x20, 0x04, 0x80, 0x26, 0x00, 0x58, 0x02, 0x40, 0x05, 0x00, 0x2C,
  0x00, 0x50, 0x02, 0x80, 0x07, 0x00, 0x28, 0x00, 0x60, 0x03, 0x80, 0x06,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x60, 0x08, 0x00, 0x80, 0x60, 0x03, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x10,
  0x40, 0x00, 0x43, 0x00, 0x01, 0x98, 0x00, 0x02, 0x40, 0x00, 0x0B, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x16, 0x00, 0x00,
  0xD8, 0x00, 0x06, 0x20, 0x00, 0x10, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x04,
  0x00, 0x30, 0x10, 0x00, 0x80, 0x60, 0x06, 0x01, 0x80, 0x30, 0x02, 0x00,
  0x80, 0x0C, 0x06, 0x00, 0x30, 0x30, 0x00, 0x40, 0x80, 0x03, 0x80, 0x06,
  0xC0, 0x04, 0xC0, 0x0C, 0x40, 0x18, 0x40, 0x10, 0x40, 0x30, 0x60, 0x20,
  0x60, 0x60, 0x20, 0xC0, 0x20, 0x80, 0x31, 0x80, 0x33, 0x00, 0x12, 0x00,
  0x16, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFE, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x01, 0xFE, 0x00, 0x83, 0x0C, 0x30, 0x41, 0x04, 0x10,
  0x61, 0x82, 0x08, 0x20, 0x83, 0x0C, 0x10, 0x41, 0x04, 0x18, 0x60, 0x82,
  0x08, 0x20, 0xC3, 0x01, 0xFE, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x01, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x14, 0x00, 0x1B, 0x00, 0x08, 0x80, 0x0C, 0x40, 0x0C, 0x30, 0x04, 0x08,
  0x06, 0x06, 0x06, 0x03, 0x02, 0x00, 0x83, 0x00, 0x61, 0x00, 0x31, 0x80,
  0x09, 0x80, 0x07, 0x80, 0x01, 0xFF, 0xF8, 0x8C, 0x46, 0x21, 0x01, 0xE1,
  0x07, 0x39, 0x0C, 0x09, 0x18, 0x07, 0x30, 0x06, 0x20, 0x06, 0x60, 0x06,
  0x60, 0x06, 0x40, 0x06, 0xC0, 0x04, 0xC0, 0x04, 0x80, 0x0C, 0x80, 0x0C,
  0x80, 0x08, 0x80, 0x18, 0x80, 0x18, 0x80, 0x38, 0xC0, 0x78, 0xC0, 0x50,
  0x61, 0x90, 0x3F, 0x10, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x3E, 0x02, 0x73, 0x81, 0x60, 0x60, 0xA0, 0x10, 0xE0, 0x0C, 0x70, 0x06,
  0x30, 0x03, 0x18, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x22, 0x00,
  0x11, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x04, 0x60, 0x06, 0x30, 0x02, 0x18,
  0x03, 0x1A, 0x03, 0x09, 0x83, 0x04, 0x7F, 0x00, 0x01, 0xF8, 0x1C, 0x70,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x10, 0x1F, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x3E, 0x30, 0x1C, 0xE4, 0x06,
  0x06, 0x81, 0x80, 0x50, 0x60, 0x0E, 0x08, 0x00, 0xC3, 0x00, 0x10, 0x40,
  0x02, 0x08, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x08, 0x00, 0x41, 0x00,
  0x18, 0x20, 0x03, 0x04, 0x00, 0xE0, 0x80, 0x18, 0x10, 0x07, 0x03, 0x00,
  0xA0, 0x60, 0x2C, 0x06, 0x19, 0x80, 0x7E, 0x20, 0x00, 0x01, 0xF0, 0x1C,
  0x60, 0xC0, 0xC6, 0x03, 0x30, 0x0C, 0x80, 0x36, 0x00, 0xD0, 0x06, 0x40,
  0x33, 0x07, 0x8F, 0xF0, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x18, 0x1F, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x7F, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x07, 0xF0, 0x01,
  0xFF, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x60, 0x39, 0xC8, 0x0C, 0x0D, 0x03, 0x00, 0xA0, 0xC0, 0x1C,
  0x10, 0x01, 0x86, 0x00, 0x20, 0x80, 0x04, 0x10, 0x01, 0x86, 0x00, 0x30,
  0xC0, 0x04, 0x10, 0x00, 0x82, 0x00, 0x30, 0x40, 0x06, 0x08, 0x01, 0xC1,
  0x00, 0x30, 0x20, 0x0E, 0x06, 0x03, 0x40, 0xC0, 0x58, 0x0C, 0x33, 0x00,
  0xFC, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x0C, 0x0E, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x7C, 0x09, 0xCE, 0x0B, 0x03,
  0x0E, 0x01, 0x1C, 0x01, 0x18, 0x01, 0x18, 0x03, 0x10, 0x03, 0x30, 0x03,
  0x30, 0x02, 0x30, 0x02, 0x20, 0x06, 0x20, 0x06, 0x60, 0x06, 0x60, 0x04,
  0x60, 0x04, 0x40, 0x0C, 0x40, 0x0C, 0xC0, 0x08, 0xC0, 0x08, 0x80, 0x18,
  0x06, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x82,
  0x04, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x04,
  0x00, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x06, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x03, 0x08, 0x06, 0x08, 0x0C, 0x08, 0x18, 0x18, 0x30, 0x18, 0x60,
  0x10, 0xC0, 0x11, 0x80, 0x31, 0x00, 0x33, 0x00, 0x25, 0x00, 0x29, 0x80,
  0x30, 0x80, 0x60, 0x80, 0x60, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x40, 0x60,
  0xC0, 0x20, 0xC0, 0x30, 0x80, 0x30, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06,
  0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x30,
  0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80,
  0x08, 0x78, 0x1F, 0x02, 0x73, 0x0C, 0xE0, 0xB0, 0x64, 0x0C, 0x38, 0x0A,
  0x03, 0x1C, 0x03, 0x00, 0x46, 0x00, 0xC0, 0x11, 0x80, 0x20, 0x0C, 0x40,
  0x18, 0x03, 0x30, 0x06, 0x00, 0x8C, 0x01, 0x80, 0x23, 0x00, 0x40, 0x08,
  0x80, 0x10, 0x06, 0x20, 0x0C, 0x01, 0x98, 0x03, 0x00, 0x46, 0x00, 0x80,
  0x11, 0x00, 0x20, 0x0C, 0x40, 0x08, 0x03, 0x10, 0x06, 0x00, 0xCC, 0x01,
  0x80, 0x23, 0x00, 0x40, 0x08, 0x80, 0x10, 0x06, 0x00, 0x08, 0x7C, 0x09,
  0xCE, 0x0B, 0x03, 0x0E, 0x01, 0x1C, 0x01, 0x18, 0x01, 0x18, 0x03, 0x10,
  0x03, 0x30, 0x03, 0x30, 0x02, 0x30, 0x02, 0x20, 0x06, 0x20, 0x06, 0x60,
  0x06, 0x60, 0x04, 0x60, 0x04, 0x40, 0x0C, 0x40, 0x0C, 0xC0, 0x08, 0xC0,
  0x08, 0x80, 0x18, 0x01, 0xF0, 0x07, 0x1C, 0x0C, 0x0C, 0x18, 0x06, 0x30,
  0x02, 0x20, 0x02, 0x60, 0x02, 0x40, 0x03, 0x40, 0x02, 0xC0, 0x02, 0xC0,
  0x02, 0x80, 0x06, 0x80, 0x06, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80,
  0x08, 0xC0, 0x18, 0x40, 0x30, 0x70, 0xE0, 0x3F, 0x80, 0x02, 0x1F, 0x00,
  0x4E, 0x70, 0x0B, 0x03, 0x01, 0x40, 0x20, 0x70, 0x06, 0x0E, 0x00, 0xC1,
  0x80, 0x18, 0x30, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x84,
  0x00, 0x20, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x20, 0xC0, 0x0C, 0x18,
  0x01, 0x03, 0x00, 0x60, 0xD0, 0x18, 0x1B, 0x06, 0x02, 0x3F, 0x80, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xF1, 0x83,
  0x9C, 0x83, 0x03, 0x43, 0x00, 0xA3, 0x00, 0x71, 0x00, 0x19, 0x80, 0x08,
  0xC0, 0x04, 0x40, 0x06, 0x60, 0x03, 0x30, 0x01, 0x90, 0x00, 0x88, 0x00,
  0xC4, 0x00, 0x62, 0x00, 0x71, 0x00, 0x30, 0x80, 0x38, 0x60, 0x14, 0x30,
  0x16, 0x0C, 0x33, 0x03, 0xF1, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x08, 0x78, 0x4E, 0x42, 0xC0, 0x14, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x00,
  0x03, 0xF0, 0x3C, 0xF1, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x30, 0x30, 0x7F,
  0x80, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x83, 0xFF, 0xFE, 0x20, 0x30, 0x18,
  0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08,
  0x04, 0x02, 0x01, 0x00, 0xC0, 0x7E, 0x00, 0x10, 0x01, 0x10, 0x03, 0x10,
  0x03, 0x30, 0x02, 0x30, 0x02, 0x20, 0x06, 0x20, 0x06, 0x60, 0x06, 0x60,
  0x04, 0x60, 0x04, 0x40, 0x0C, 0x40, 0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0x80,
  0x18, 0x80, 0x18, 0x80, 0x38, 0x80, 0x70, 0xC0, 0xD0, 0xC1, 0x90, 0x7F,
  0x30, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xB0, 0x06, 0xC0, 0x11, 0x00, 0xC4,
  0x02, 0x10, 0x18, 0x40, 0x41, 0x03, 0x04, 0x18, 0x18, 0x60, 0x63, 0x01,
  0x8C, 0x06, 0x60, 0x19, 0x00, 0x2C, 0x00, 0xA0, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x10, 0x07, 0x80, 0x60, 0x0B, 0x00, 0xC0, 0x36, 0x03,
  0x80, 0x4C, 0x05, 0x01, 0x98, 0x1A, 0x02, 0x30, 0x26, 0x0C, 0x60, 0xCC,
  0x18, 0x41, 0x18, 0x20, 0x86, 0x30, 0xC1, 0x08, 0x61, 0x02, 0x10, 0xC6,
  0x04, 0x60, 0x88, 0x08, 0x81, 0x30, 0x13, 0x02, 0x40, 0x24, 0x04, 0x80,
  0x58, 0x0B, 0x00, 0xA0, 0x14, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC1, 0x00, 0x60, 0x60, 0x30, 0x18, 0x18,
  0x02, 0x04, 0x00, 0xC2, 0x00, 0x31, 0x80, 0x04, 0xC0, 0x01, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x40, 0x01, 0x98, 0x00, 0x42,
  0x00, 0x30, 0x80, 0x18, 0x30, 0x0C, 0x04, 0x06, 0x01, 0x81, 0x00, 0x60,
  0xC0, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x18, 0x00, 0x80, 0x40, 0x0C, 0x02,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x60, 0x04, 0x03, 0x00, 0x30, 0x30,
  0x01, 0x81, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x80, 0x01, 0x0C, 0x00, 0x08,
  0x40, 0x00, 0x46, 0x00, 0x02, 0x20, 0x00, 0x13, 0x00, 0x00, 0x90, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF,
  0x07, 0xFE, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xFF, 0xF0, 0x00, 0x1C, 0x01, 0xE0, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0xF0, 0x03, 0x80, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x38, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0x80, 0x07,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x3F,
  0xC0, 0x70, 0x38, 0xD0, 0x07, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 28, 8, 1, -28 },
  { 29, 9, 10, 12, 4, -28 },
  { 41, 20, 28, 21, 1, -28 },
  { 111, 17, 32, 19, 1, -30 },
  { 179, 22, 28, 27, 3, -28 },
  { 256, 19, 28, 22, 1, -28 },
  { 323, 4, 10, 7, 4, -28 },
  { 328, 11, 34, 10, 1, -28 },
  { 375, 11, 34, 10, -3, -28 },
  { 422, 14, 15, 18, 5, -30 },
  { 449, 17, 18, 20, 2, -23 },
  { 488, 6, 9, 7, -2, -4 },
  { 495, 9, 1, 11, 1, -11 },
  { 497, 2, 3, 8, 1, -3 },
  { 498, 17, 28, 12, -2, -28 },
  { 558, 16, 28, 19, 2, -28 },
  { 614, 8, 28, 19, 6, -28 },
  { 642, 18, 28, 19, 0, -28 },
  { 705, 18, 28, 19, 0, -28 },
  { 768, 18, 28, 19, 0, -28 },
  { 831, 17, 28, 19, 1, -28 },
  { 891, 17, 28, 19, 2, -28 },
  { 951, 16, 28, 19, 3, -28 },
  { 1007, 17, 28, 19, 1, -28 },
  { 1067, 17, 28, 19, 1, -28 },
  { 1127, 6, 21, 8, 1, -21 },
  { 1143, 9, 26, 8, -2, -21 },
  { 1173, 17, 18, 20, 2, -23 },
  { 1212, 17, 9, 20, 2, -18 },
  { 1232, 17, 18, 20, 2, -23 },
  { 1271, 13, 28, 14, 2, -28 },
  { 1317, 25, 32, 28, 2, -28 },
  { 1417, 18, 28, 18, -2, -28 },
  { 1480, 19, 28, 20, 1, -28 },
  { 1547, 19, 28, 20, 3, -28 },
  { 1614, 20, 28, 23, 1, -28 },
  { 1684, 18, 28, 18, 1, -28 },
  { 1747, 18, 28, 17, 1, -28 },
  { 1810, 20, 28, 24, 3, -28 },
  { 1880, 22, 28, 23, 1, -28 },
  { 1957, 13, 28, 10, -1, -28 },
  { 2003, 15, 35, 8, -6, -28 },
  { 2069, 21, 28, 19, 1, -28 },
  { 2143, 13, 28, 17, 1, -28 },
  { 2189, 28, 28, 29, 1, -28 },
  { 2287, 23, 28, 24, 1, -28 },
  { 2368, 21, 28, 24, 2, -28 },
  { 2442, 18, 28, 19, 1, -28 },
  { 2505, 21, 35, 24, 2, -28 },
  { 2597, 18, 28, 19, 1, -28 },
  { 2660, 18, 28, 17, 0, -28 },
  { 2723, 17, 28, 16, 3, -28 },
  { 2783, 21, 28, 23, 3, -28 },
  { 2857, 17, 28, 18, 4, -28 },
  { 2917, 28, 28, 29, 4, -28 },
  { 3015, 22, 28, 17, -2, -28 },
  { 3092, 16, 28, 16, 4, -28 },
  { 3148, 20, 28, 18, -1, -28 },
  { 3218, 15, 34, 11, -1, -28 },
  { 3282, 6, 28, 12, 4, -28 },
  { 3303, 15, 34, 11, -3, -28 },
  { 3367, 17, 16, 19, 1, -28 },
  { 3401, 13, 1, 13, -3, 4 },
  { 3403, 4, 6, 9, 6, -30 },
  { 3406, 16, 21, 19, 2, -21 },
  { 3448, 17, 30, 20, 1, -30 },
  { 3512, 14, 21, 15, 2, -21 },
  { 3549, 19, 30, 20, 2, -30 },
  { 3621, 14, 21, 17, 2, -21 },
  { 3658, 20, 39, 10, -5, -30 },
  { 3756, 19, 30, 20, 0, -21 },
  { 3828, 16, 30, 19, 1, -30 },
  { 3888, 7, 28, 8, 1, -28 },
  { 3913, 14, 37, 8, -5, -28 },
  { 3978, 16, 30, 16, 1, -30 },
  { 4038, 8, 30, 8, 1, -30 },
  { 4068, 26, 21, 29, 1, -21 },
  { 4137, 16, 21, 19, 1, -21 },
  { 4179, 16, 21, 19, 2, -21 },
  { 4221, 19, 30, 20, -1, -21 },
  { 4293, 17, 30, 20, 2, -21 },
  { 4357, 13, 21, 13, 1, -21 },
  { 4392, 14, 21, 15, 0, -21 },
  { 4429, 9, 26, 10, 2, -26 },
  { 4459, 16, 21, 19, 2, -21 },
  { 4501, 14, 21, 14, 2, -21 },
  { 4538, 23, 21, 23, 2, -21 },
  { 4599, 18, 21, 16, -1, -21 },
  { 4647, 21, 30, 15, -4, -21 },
  { 4726, 16, 21, 14, -1, -21 },
  { 4768, 14, 34, 13, 1, -28 },
  { 4828, 1, 39, 18, 9, -30 },
  { 4833, 14, 34, 13, -2, -28 },
  { 4893, 17, 4, 20, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC39PT7B_H_
