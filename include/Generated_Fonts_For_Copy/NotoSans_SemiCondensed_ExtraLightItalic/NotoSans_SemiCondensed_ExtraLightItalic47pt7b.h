#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC47PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x38, 0x00, 0x30, 0x66, 0x18, 0xC3,
  0x10, 0x66, 0x0C, 0xC1, 0x18, 0x62, 0x0C, 0x41, 0x98, 0x23, 0x04, 0x40,
  0x88, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x04, 0x06, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x01, 0x00, 0x01, 0x00, 0x80, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x20, 0x00, 0x20, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x08,
  0x03, 0xFF, 0xFF, 0xF0, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01,
  0x00, 0x01, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x40, 0x00, 0x40,
  0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x10, 0x00, 0x10, 0x08, 0x03, 0xFF,
  0xFF, 0xF0, 0x0C, 0x06, 0x00, 0x06, 0x02, 0x00, 0x02, 0x03, 0x00, 0x03,
  0x01, 0x80, 0x01, 0x80, 0x80, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x30, 0x10, 0x00, 0x10, 0x18, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0x10, 0xE0, 0x60, 0x80, 0x06, 0x0C,
  0x00, 0x30, 0x60, 0x03, 0x02, 0x00, 0x18, 0x10, 0x00, 0xC0, 0x80, 0x06,
  0x0C, 0x00, 0x18, 0x60, 0x00, 0xC2, 0x00, 0x03, 0x90, 0x00, 0x0E, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x02, 0xE0, 0x00, 0x13, 0x80, 0x01,
  0x8E, 0x00, 0x0C, 0x30, 0x00, 0x40, 0x80, 0x02, 0x06, 0x00, 0x10, 0x30,
  0x01, 0x81, 0x00, 0x0C, 0x18, 0x00, 0x40, 0xC0, 0x02, 0x0C, 0x1C, 0x11,
  0xC0, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x80,
  0xFE, 0x00, 0x30, 0x30, 0xC0, 0x0C, 0x0C, 0x0C, 0x01, 0x81, 0x01, 0x80,
  0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0xC0, 0xC0, 0x60,
  0x10, 0x30, 0x0C, 0x02, 0x06, 0x01, 0x80, 0xC1, 0x80, 0x20, 0x18, 0x20,
  0x0C, 0x03, 0x0C, 0x01, 0x80, 0x43, 0x00, 0x30, 0x18, 0x43, 0xF6, 0x03,
  0x18, 0xC6, 0xC0, 0x46, 0x30, 0x68, 0x18, 0x8C, 0x0D, 0x86, 0x31, 0x01,
  0xBF, 0x8C, 0x60, 0x33, 0xE1, 0x0C, 0x06, 0x00, 0x61, 0x00, 0xC0, 0x18,
  0x60, 0x18, 0x03, 0x0C, 0x03, 0x00, 0xC1, 0x80, 0x40, 0x30, 0x20, 0x18,
  0x06, 0x04, 0x03, 0x01, 0x80, 0x80, 0x60, 0x60, 0x10, 0x18, 0x0C, 0x02,
  0x03, 0x03, 0x00, 0x40, 0xC0, 0x40, 0x0C, 0x18, 0x18, 0x01, 0x86, 0x06,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0x30, 0x01, 0x80, 0x30, 0x01, 0x80, 0x20, 0x01, 0x80, 0x60, 0x01, 0x80,
  0x60, 0x01, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xB0,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x03, 0x18, 0x0C, 0x06, 0x30, 0x0C,
  0x06, 0x60, 0x06, 0x0C, 0x60, 0x03, 0x0C, 0xC0, 0x03, 0x18, 0xC0, 0x01,
  0xB0, 0xC0, 0x01, 0xB0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xC0, 0xC0, 0x01,
  0xE0, 0x60, 0x03, 0x60, 0x70, 0x0E, 0x30, 0x38, 0x3C, 0x18, 0x1F, 0xF0,
  0x18, 0x33, 0x32, 0x66, 0x64, 0x4C, 0xC8, 0x80, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0x40, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04,
  0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x80,
  0x80, 0xC0, 0x80, 0x70, 0x80, 0x1D, 0x80, 0x07, 0x3F, 0x01, 0xF8, 0x02,
  0x80, 0x0C, 0x80, 0x18, 0xC0, 0x30, 0x40, 0xE0, 0x60, 0x40, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x7F, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x0E, 0x18, 0x30, 0xC1,
  0x82, 0x0C, 0x10, 0x60, 0x83, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01, 0xC0, 0xC0, 0x38, 0x06, 0x03, 0x00,
  0x60, 0x60, 0x02, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x31, 0x80,
  0x03, 0x18, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x20,
  0x00, 0x26, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x64,
  0x00, 0x06, 0x40, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x18,
  0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x40, 0x06,
  0x06, 0x00, 0xE0, 0x60, 0x0C, 0x03, 0x01, 0x80, 0x3C, 0x70, 0x00, 0xFE,
  0x00, 0x00, 0x40, 0x70, 0x3C, 0x3B, 0x1C, 0xCC, 0x2E, 0x1A, 0x06, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0x00, 0x70, 0x1C, 0x02, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x1C, 0x03, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x01, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x20, 0x01, 0xC0, 0xF0, 0x1E, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xB0, 0x00,
  0x0D, 0x00, 0x00, 0xC8, 0x00, 0x0C, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30,
  0x00, 0x61, 0x00, 0x06, 0x18, 0x00, 0x60, 0xC0, 0x06, 0x06, 0x00, 0x30,
  0x30, 0x03, 0x01, 0x00, 0x30, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01,
  0x80, 0x30, 0x18, 0x01, 0x01, 0x80, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06,
  0x0C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x10, 0x01, 0xC0, 0xF0, 0x78, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x3C,
  0x00, 0xC7, 0xF8, 0x06, 0xE0, 0x60, 0x2C, 0x01, 0x83, 0xC0, 0x06, 0x1C,
  0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x03,
  0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x04, 0x30, 0x00, 0x60, 0x80,
  0x03, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x18, 0x06, 0x01, 0x80,
  0x1C, 0x38, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x70, 0x1C, 0x03,
  0x00, 0x60, 0x30, 0x01, 0x81, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03,
  0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x06, 0x00, 0x60, 0x30,
  0x06, 0x00, 0xC0, 0xE0, 0x03, 0x0C, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0xE0, 0x01, 0xC1, 0x80, 0x18, 0x06, 0x01, 0x80, 0x18, 0x18, 0x00,
  0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30,
  0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x06,
  0x06, 0x00, 0xE0, 0x1C, 0x1E, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xFE, 0x00, 0x70, 0x38, 0x06, 0x00, 0xC0, 0x70, 0x03, 0x03, 0x00,
  0x18, 0x30, 0x00, 0xC1, 0x80, 0x02, 0x08, 0x00, 0x18, 0xC0, 0x00, 0xC6,
  0x00, 0x06, 0x30, 0x00, 0x21, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0xC3, 0x00, 0x0E, 0x18, 0x00, 0xF0, 0x60, 0x0D, 0x03, 0x80, 0xD8, 0x0F,
  0xFC, 0xC0, 0x1F, 0x86, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC1, 0xE0, 0x07,
  0xFC, 0x00, 0x00, 0x06, 0x07, 0x0E, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0xE0, 0xC0, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x30, 0x00,
  0x02, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0xF0, 0xC0, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3E, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x01, 0x80, 0x70, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x06, 0x10, 0x03, 0xF8,
  0x0C, 0x60, 0x0F, 0xF8, 0x18, 0x80, 0x70, 0x30, 0x33, 0x01, 0xC0, 0x40,
  0x66, 0x03, 0x01, 0x80, 0xD8, 0x0C, 0x03, 0x01, 0xB0, 0x30, 0x06, 0x03,
  0x60, 0x60, 0x08, 0x04, 0x80, 0x80, 0x30, 0x0B, 0x03, 0x00, 0x60, 0x36,
  0x06, 0x00, 0xC0, 0x6C, 0x0C, 0x03, 0x00, 0x98, 0x18, 0x06, 0x03, 0x30,
  0x30, 0x0C, 0x06, 0x60, 0x60, 0x38, 0x18, 0xC0, 0xC0, 0xD0, 0x61, 0x81,
  0xC3, 0x21, 0xC3, 0x01, 0xFC, 0x7F, 0x06, 0x01, 0xE0, 0x78, 0x04, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x40, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x36, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x88, 0x00, 0x06, 0x10,
  0x00, 0x0C, 0x20, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x81, 0x80,
  0x03, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x18, 0x00,
  0xC0, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x40, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01,
  0x8C, 0x00, 0x01, 0x18, 0x00, 0x02, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x0C,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0x60,
  0x18, 0x00, 0xE0, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x03,
  0x00, 0x06, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x60, 0x60,
  0x01, 0xC0, 0xC0, 0x07, 0x01, 0x00, 0x1C, 0x06, 0x03, 0xE0, 0x0F, 0xFF,
  0x00, 0x18, 0x07, 0x80, 0x30, 0x01, 0x80, 0x40, 0x01, 0x81, 0x80, 0x03,
  0x03, 0x00, 0x02, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x10,
  0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x82, 0x00, 0x06, 0x0C,
  0x00, 0x1C, 0x18, 0x00, 0x70, 0x30, 0x03, 0xC0, 0x7F, 0xFE, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xC0, 0x18, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x0F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x60,
  0x3E, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x01, 0x01, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x10, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x83, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x0E, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x06, 0x02, 0x00, 0x06, 0x03, 0x00,
  0x06, 0x01, 0x80, 0x0E, 0x00, 0xC0, 0x1E, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x18, 0x00, 0x10,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x01, 0xFF, 0x30, 0x01, 0xFF, 0x18, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x10, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xE0, 0x00, 0xC0,
  0x38, 0x00, 0x60, 0x0F, 0x03, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30,
  0x18, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x80, 0x40, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x02, 0x01, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x18, 0x0F, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x60, 0x30,
  0x00, 0x08, 0x04, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C,
  0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x04, 0x02, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x10, 0x18, 0x00, 0x06, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x8F, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x60, 0x01,
  0x80, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x01,
  0x80, 0x06, 0x01, 0x80, 0x03, 0x01, 0x80, 0x01, 0x01, 0xC0, 0x01, 0x81,
  0xC0, 0x00, 0xC1, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x31, 0xC0, 0x00, 0x11,
  0xC0, 0x00, 0x19, 0xC0, 0x00, 0x0D, 0xB0, 0x00, 0x07, 0x98, 0x00, 0x03,
  0x86, 0x00, 0x01, 0x83, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03, 0x00,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x0C,
  0x01, 0x80, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x60, 0x00,
  0x70, 0x00, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x1E, 0x01,
  0x60, 0x00, 0x07, 0x80, 0xD8, 0x00, 0x03, 0x60, 0x36, 0x00, 0x00, 0x90,
  0x0D, 0x80, 0x00, 0x6C, 0x03, 0x60, 0x00, 0x33, 0x00, 0x88, 0x00, 0x0C,
  0xC0, 0x62, 0x00, 0x06, 0x30, 0x18, 0xC0, 0x01, 0x88, 0x06, 0x30, 0x00,
  0xC6, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x43, 0x00, 0x18, 0x60, 0x30, 0xC0,
  0x06, 0x18, 0x0C, 0x30, 0x03, 0x0C, 0x03, 0x04, 0x00, 0x83, 0x00, 0xC1,
  0x00, 0x60, 0xC0, 0x20, 0x40, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x08, 0x06,
  0x06, 0x06, 0x06, 0x01, 0x81, 0x81, 0x81, 0x80, 0x40, 0x60, 0xC0, 0x60,
  0x30, 0x18, 0x30, 0x18, 0x0C, 0x02, 0x18, 0x04, 0x03, 0x00, 0x86, 0x03,
  0x00, 0xC0, 0x23, 0x00, 0xC0, 0x20, 0x0C, 0x80, 0x30, 0x18, 0x03, 0x60,
  0x0C, 0x06, 0x00, 0xF0, 0x02, 0x01, 0x80, 0x3C, 0x01, 0x80, 0x60, 0x0E,
  0x00, 0x60, 0x30, 0x01, 0x80, 0x18, 0x00, 0x00, 0x80, 0x00, 0x30, 0x1C,
  0x00, 0x02, 0x01, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x06, 0x01, 0x60, 0x00,
  0x60, 0x36, 0x00, 0x06, 0x03, 0x20, 0x00, 0xC0, 0x33, 0x00, 0x0C, 0x03,
  0x30, 0x00, 0xC0, 0x21, 0x00, 0x0C, 0x06, 0x18, 0x00, 0x80, 0x61, 0x80,
  0x18, 0x06, 0x08, 0x01, 0x80, 0x60, 0xC0, 0x18, 0x04, 0x0C, 0x01, 0x80,
  0xC0, 0x40, 0x10, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x02,
  0x03, 0x00, 0x80, 0x30, 0x30, 0x18, 0x03, 0x02, 0x01, 0x80, 0x10, 0x60,
  0x18, 0x01, 0x86, 0x01, 0x00, 0x18, 0x60, 0x30, 0x00, 0x86, 0x03, 0x00,
  0x0C, 0xC0, 0x30, 0x00, 0xCC, 0x03, 0x00, 0x0C, 0xC0, 0x20, 0x00, 0x6C,
  0x06, 0x00, 0x06, 0x80, 0x60, 0x00, 0x68, 0x06, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x38, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x38, 0x07, 0x00, 0x30, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x30, 0x00,
  0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x18, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x02, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x03, 0x80, 0x0F, 0x0F,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x18,
  0x0F, 0x00, 0x60, 0x0E, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x30, 0x30, 0x00,
  0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x60, 0x00, 0xC1,
  0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x40, 0x01, 0x83, 0x00,
  0x0C, 0x0C, 0x00, 0x60, 0x30, 0x07, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x38, 0x07,
  0x00, 0x30, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x30, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x06, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x02, 0x60, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x26, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x03, 0x03, 0x00, 0x03,
  0x00, 0xC0, 0x03, 0x80, 0x30, 0x03, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x18, 0x0F, 0x00,
  0x60, 0x0E, 0x01, 0x80, 0x1C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0,
  0x03, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x03,
  0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x40, 0x03, 0x03, 0x00, 0x1C, 0x0C,
  0x00, 0xE0, 0x30, 0x3E, 0x00, 0xFF, 0xE0, 0x02, 0x03, 0x00, 0x18, 0x0C,
  0x00, 0x60, 0x10, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x20, 0x01, 0x81, 0x80,
  0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x00, 0xC3, 0x00, 0x03,
  0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x1E, 0x01, 0x80, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x20, 0x01, 0x80, 0xF8, 0x3C, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x06, 0x08, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x01, 0x83, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x10, 0x60,
  0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x06, 0x01, 0x80, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x80, 0x00, 0xCC, 0x00, 0x06,
  0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00,
  0x18, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x20, 0x06, 0x01,
  0x00, 0x30, 0x08, 0x03, 0x00, 0x40, 0x18, 0x03, 0x01, 0x80, 0x18, 0x0C,
  0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0C,
  0x30, 0x00, 0x61, 0x80, 0x03, 0x18, 0x00, 0x08, 0xC0, 0x00, 0x4C, 0x00,
  0x02, 0x60, 0x00, 0x12, 0x00, 0x00, 0xB0, 0x00, 0x05, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30,
  0x00, 0x6C, 0x00, 0x1C, 0x00, 0x1B, 0x00, 0x07, 0x00, 0x0C, 0xC0, 0x03,
  0xC0, 0x03, 0x30, 0x00, 0xB0, 0x01, 0x8C, 0x00, 0x6C, 0x00, 0x63, 0x00,
  0x1B, 0x00, 0x18, 0xC0, 0x0C, 0xC0, 0x0C, 0x30, 0x03, 0x30, 0x03, 0x0C,
  0x00, 0x8C, 0x01, 0x83, 0x00, 0x63, 0x00, 0x60, 0xC0, 0x10, 0xC0, 0x30,
  0x30, 0x0C, 0x30, 0x0C, 0x0C, 0x02, 0x04, 0x02, 0x03, 0x01, 0x81, 0x01,
  0x80, 0xC0, 0x60, 0x40, 0x60, 0x30, 0x30, 0x10, 0x30, 0x04, 0x0C, 0x04,
  0x0C, 0x01, 0x06, 0x01, 0x06, 0x00, 0x41, 0x80, 0x41, 0x80, 0x10, 0x40,
  0x10, 0x40, 0x04, 0x30, 0x04, 0x30, 0x01, 0x08, 0x01, 0x0C, 0x00, 0x46,
  0x00, 0x46, 0x00, 0x11, 0x80, 0x11, 0x80, 0x04, 0xC0, 0x04, 0xC0, 0x01,
  0x30, 0x01, 0x30, 0x00, 0x48, 0x00, 0x48, 0x00, 0x16, 0x00, 0x16, 0x00,
  0x05, 0x00, 0x05, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00,
  0x18, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x30, 0x00,
  0x60, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x18,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x06, 0x0C, 0x00, 0x01, 0x80, 0x80, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03,
  0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x01, 0x80, 0x01, 0x00, 0x60, 0x00, 0x30, 0x1C, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x34, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0C, 0x60,
  0x01, 0x86, 0x00, 0x18, 0x20, 0x03, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03,
  0x00, 0xC0, 0x10, 0x0C, 0x01, 0x81, 0x80, 0x18, 0x30, 0x01, 0x83, 0x00,
  0x18, 0x60, 0x00, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x81, 0x83, 0x06, 0x0C, 0x08, 0x10, 0x30,
  0x60, 0xC1, 0x81, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x40, 0x81, 0x83,
  0x06, 0x04, 0x08, 0x10, 0x30, 0x60, 0xC1, 0x81, 0x02, 0x06, 0x0C, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x40, 0x00, 0x66, 0x00, 0x0C, 0x60, 0x00, 0xC2, 0x00, 0x18, 0x30, 0x01,
  0x83, 0x00, 0x30, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x00, 0x81,
  0x80, 0x0C, 0x18, 0x00, 0xC3, 0x00, 0x04, 0x30, 0x00, 0x66, 0x00, 0x06,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xC6, 0x18, 0xC3, 0x08, 0x61,
  0x00, 0xFE, 0x30, 0x3C, 0x73, 0x07, 0x01, 0x30, 0xE0, 0x1A, 0x0C, 0x00,
  0xE1, 0x80, 0x0E, 0x30, 0x00, 0xE3, 0x00, 0x0C, 0x30, 0x00, 0xC6, 0x00,
  0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x00, 0x8C, 0x00, 0x18, 0xC0,
  0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00, 0x30, 0xC0, 0x07, 0x0C,
  0x00, 0x70, 0xC0, 0x0F, 0x06, 0x01, 0xA0, 0x60, 0x32, 0x03, 0x8E, 0x20,
  0x1F, 0xC6, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x3F, 0x00, 0x67,
  0x1E, 0x02, 0x60, 0x30, 0x16, 0x00, 0xC1, 0xE0, 0x06, 0x0E, 0x00, 0x30,
  0x70, 0x00, 0x83, 0x00, 0x06, 0x38, 0x00, 0x31, 0x80, 0x01, 0x0C, 0x00,
  0x18, 0x60, 0x00, 0xC2, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C,
  0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x38, 0x00, 0x61, 0xC0, 0x03,
  0x0E, 0x00, 0x30, 0x58, 0x03, 0x02, 0x40, 0x30, 0x33, 0x87, 0x01, 0x8F,
  0xF0, 0x00, 0x00, 0xFF, 0x81, 0xF1, 0xC1, 0xC0, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x78, 0x30, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x07, 0xF0, 0x80, 0x3C, 0x73, 0x00, 0xE0, 0x36,
  0x03, 0x80, 0x2C, 0x06, 0x00, 0x78, 0x18, 0x00, 0x60, 0x60, 0x00, 0xC0,
  0xC0, 0x01, 0x81, 0x00, 0x03, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x03, 0x00,
  0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x70, 0x30, 0x01,
  0xC0, 0x60, 0x07, 0x80, 0x60, 0x1B, 0x00, 0xC0, 0x66, 0x00, 0xE3, 0x8C,
  0x00, 0xFE, 0x10, 0x00, 0x00, 0xFE, 0x00, 0xE3, 0x81, 0xC0, 0x61, 0xC0,
  0x30, 0xC0, 0x18, 0xC0, 0x0C, 0x40, 0x06, 0x60, 0x03, 0x20, 0x03, 0x30,
  0x03, 0x18, 0x07, 0x0C, 0x7F, 0x07, 0xFC, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x10, 0x38, 0x38, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x9C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x84, 0x03, 0xC7,
  0x10, 0x1C, 0x06, 0xC0, 0xE0, 0x0B, 0x03, 0x00, 0x3C, 0x18, 0x00, 0x60,
  0xC0, 0x01, 0x83, 0x00, 0x06, 0x08, 0x00, 0x18, 0x60, 0x00, 0x41, 0x80,
  0x03, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x06,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x83, 0x00, 0x1E, 0x0C,
  0x00, 0x70, 0x30, 0x03, 0xC0, 0x60, 0x1B, 0x01, 0x80, 0xCC, 0x03, 0x8E,
  0x30, 0x07, 0xF0, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x02, 0x00, 0x70, 0x0F, 0x87, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x61, 0xFC, 0x06, 0x79, 0xE0, 0x4C, 0x06, 0x05, 0x80, 0x30,
  0xF0, 0x03, 0x0E, 0x00, 0x30, 0xE0, 0x03, 0x0C, 0x00, 0x20, 0xC0, 0x06,
  0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x61, 0x00, 0x04, 0x30, 0x00,
  0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x20, 0x00, 0x86, 0x00,
  0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x84, 0x00, 0x10, 0xC0,
  0x03, 0x0C, 0x00, 0x30, 0x01, 0x81, 0xC0, 0xE0, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x9C, 0x00, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x30, 0x60, 0x0C, 0x0C, 0x03, 0x01, 0x00,
  0xC0, 0x60, 0x30, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x20, 0xC0, 0x0C, 0x38,
  0x01, 0x8E, 0x00, 0x31, 0x80, 0x06, 0x70, 0x00, 0x9E, 0x00, 0x36, 0x60,
  0x07, 0x8C, 0x00, 0xE0, 0x80, 0x18, 0x18, 0x02, 0x03, 0x00, 0xC0, 0x30,
  0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x08, 0x01, 0x83, 0x00, 0x30,
  0x60, 0x03, 0x00, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x02,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x00, 0x06, 0x3F, 0x81, 0xFC,
  0x06, 0x73, 0xC7, 0x9E, 0x04, 0xC0, 0xCC, 0x06, 0x05, 0x80, 0x48, 0x02,
  0x0F, 0x00, 0x50, 0x03, 0x0E, 0x00, 0x70, 0x03, 0x0C, 0x00, 0x60, 0x03,
  0x0C, 0x00, 0x60, 0x02, 0x1C, 0x00, 0xC0, 0x06, 0x18, 0x00, 0xC0, 0x06,
  0x18, 0x00, 0xC0, 0x06, 0x18, 0x00, 0xC0, 0x06, 0x10, 0x00, 0x80, 0x04,
  0x30, 0x01, 0x80, 0x0C, 0x30, 0x01, 0x80, 0x0C, 0x30, 0x01, 0x80, 0x0C,
  0x30, 0x01, 0x80, 0x08, 0x20, 0x01, 0x00, 0x18, 0x60, 0x03, 0x00, 0x18,
  0x60, 0x03, 0x00, 0x18, 0x60, 0x03, 0x00, 0x18, 0x60, 0x02, 0x00, 0x10,
  0x40, 0x06, 0x00, 0x30, 0xC0, 0x06, 0x00, 0x30, 0xC0, 0x06, 0x00, 0x30,
  0x06, 0x1F, 0xC0, 0x67, 0x9E, 0x04, 0xC0, 0x60, 0x58, 0x03, 0x0F, 0x00,
  0x30, 0xE0, 0x03, 0x0E, 0x00, 0x30, 0xC0, 0x02, 0x1C, 0x00, 0x61, 0x80,
  0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x10, 0x00, 0x43, 0x00, 0x0C, 0x30,
  0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC2, 0x00, 0x08, 0x60, 0x01, 0x86,
  0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0x40, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x00, 0x00, 0xFE, 0x00, 0x78, 0xF0, 0x1C, 0x07, 0x07, 0x00,
  0x60, 0xC0, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00,
  0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x06,
  0x60, 0x01, 0x84, 0x00, 0x30, 0xC0, 0x0C, 0x1C, 0x03, 0x01, 0xE1, 0xC0,
  0x1F, 0xF0, 0x00, 0x01, 0x87, 0xE0, 0x03, 0x38, 0xF0, 0x04, 0xC0, 0x60,
  0x0B, 0x00, 0x60, 0x34, 0x00, 0xC0, 0x78, 0x01, 0x80, 0xE0, 0x01, 0x01,
  0x80, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x10, 0x30,
  0x00, 0x60, 0x40, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00,
  0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x70, 0x00, 0xC0, 0xE0, 0x01,
  0x81, 0xC0, 0x06, 0x03, 0x80, 0x18, 0x04, 0x80, 0x60, 0x19, 0xC3, 0x80,
  0x31, 0xFE, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x10, 0x3C, 0x71, 0x07, 0x01, 0xB0, 0xE0, 0x0B, 0x0C, 0x00, 0xF1,
  0x80, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x66, 0x00, 0x04,
  0x60, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01,
  0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x03, 0x8C, 0x00,
  0x70, 0xC0, 0x0F, 0x06, 0x01, 0xB0, 0x60, 0x33, 0x03, 0x8E, 0x30, 0x1F,
  0xC2, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x06, 0x3F, 0x06, 0x7B, 0x04, 0xC0, 0x05,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0x03, 0xC7, 0xC3,
  0x80, 0x21, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x62, 0x00, 0x61, 0xC0, 0xE0, 0x7F, 0xE0,
  0x00, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x7F, 0xF7,
  0xFE, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x20, 0x7E, 0x00,
  0x0C, 0x00, 0x30, 0xC0, 0x02, 0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00,
  0x61, 0x80, 0x06, 0x10, 0x00, 0x43, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00,
  0x0C, 0x30, 0x00, 0xC2, 0x00, 0x08, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60,
  0x01, 0x86, 0x00, 0x18, 0x40, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x07, 0x0C,
  0x00, 0x70, 0xC0, 0x0A, 0x0C, 0x01, 0xA0, 0xE0, 0x36, 0x07, 0x0E, 0x60,
  0x3F, 0x86, 0x00, 0xC0, 0x00, 0xD0, 0x00, 0x64, 0x00, 0x19, 0x80, 0x0C,
  0x60, 0x02, 0x18, 0x01, 0x86, 0x00, 0x41, 0x80, 0x30, 0x60, 0x18, 0x18,
  0x06, 0x06, 0x03, 0x00, 0x80, 0xC0, 0x20, 0x60, 0x08, 0x18, 0x03, 0x0C,
  0x00, 0xC3, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x30, 0x00, 0xCC, 0x00,
  0x36, 0x00, 0x05, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x1A, 0x00, 0x70, 0x03, 0x60, 0x0A,
  0x00, 0xCC, 0x03, 0x40, 0x19, 0x80, 0x68, 0x02, 0x30, 0x19, 0x00, 0xC6,
  0x03, 0x30, 0x10, 0xC0, 0xC6, 0x06, 0x18, 0x18, 0xC0, 0xC3, 0x02, 0x18,
  0x30, 0x60, 0xC3, 0x06, 0x0C, 0x10, 0x61, 0x81, 0x86, 0x0C, 0x30, 0x30,
  0x81, 0x84, 0x06, 0x30, 0x31, 0x80, 0xC4, 0x06, 0x20, 0x19, 0x80, 0xCC,
  0x03, 0x20, 0x09, 0x80, 0x6C, 0x01, 0x60, 0x0D, 0x80, 0x2C, 0x01, 0xE0,
  0x05, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18,
  0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x10, 0xC0, 0x00,
  0x66, 0x00, 0x01, 0x98, 0x00, 0x02, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x00, 0x01, 0x8C, 0x00,
  0x0C, 0x30, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x0C, 0x02, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x30, 0x18, 0x00, 0x60, 0xE0, 0x01, 0x80, 0x00, 0xC0,
  0x01, 0x80, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x01, 0x00, 0x30, 0x00, 0x80, 0x30, 0x00,
  0x40, 0x18, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x0C, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x21, 0x80, 0x00, 0x11, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x23, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0x3E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x0F, 0xF8, 0x07, 0x03, 0xC1, 0xC0, 0x1F, 0xE0, 0x00, 0x30,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 10, 34, 10, 1, -34 },
  { 44, 11, 13, 14, 5, -34 },
  { 62, 25, 34, 25, 1, -34 },
  { 169, 21, 39, 22, 1, -36 },
  { 272, 27, 35, 32, 3, -34 },
  { 391, 24, 34, 26, 1, -34 },
  { 493, 4, 13, 8, 5, -34 },
  { 500, 14, 41, 12, 1, -34 },
  { 572, 13, 41, 12, -3, -34 },
  { 639, 16, 18, 22, 6, -36 },
  { 675, 19, 22, 24, 3, -28 },
  { 728, 7, 11, 9, -2, -5 },
  { 738, 11, 2, 14, 1, -14 },
  { 741, 3, 3, 9, 1, -3 },
  { 743, 20, 34, 15, -2, -34 },
  { 828, 20, 34, 22, 2, -34 },
  { 913, 10, 34, 22, 7, -34 },
  { 956, 21, 34, 22, 0, -34 },
  { 1046, 22, 34, 22, 0, -34 },
  { 1140, 21, 34, 22, 0, -34 },
  { 1230, 21, 34, 22, 1, -34 },
  { 1320, 21, 34, 22, 2, -34 },
  { 1410, 19, 34, 22, 4, -34 },
  { 1491, 21, 34, 22, 1, -34 },
  { 1581, 21, 34, 22, 1, -34 },
  { 1671, 8, 25, 9, 1, -25 },
  { 1696, 11, 31, 9, -2, -25 },
  { 1739, 19, 21, 24, 3, -27 },
  { 1789, 19, 11, 24, 3, -22 },
  { 1816, 19, 21, 24, 3, -27 },
  { 1866, 15, 34, 17, 3, -34 },
  { 1930, 31, 37, 34, 2, -33 },
  { 2074, 23, 34, 22, -3, -34 },
  { 2172, 23, 34, 24, 1, -34 },
  { 2270, 23, 34, 24, 3, -34 },
  { 2368, 25, 34, 27, 1, -34 },
  { 2475, 22, 34, 22, 1, -34 },
  { 2569, 22, 34, 20, 1, -34 },
  { 2663, 25, 34, 28, 3, -34 },
  { 2770, 27, 34, 28, 1, -34 },
  { 2885, 15, 34, 12, -1, -34 },
  { 2949, 17, 42, 10, -7, -34 },
  { 3039, 25, 34, 22, 1, -34 },
  { 3146, 15, 34, 20, 1, -34 },
  { 3210, 34, 34, 35, 1, -34 },
  { 3355, 28, 34, 28, 1, -34 },
  { 3474, 25, 34, 29, 3, -34 },
  { 3581, 22, 34, 23, 1, -34 },
  { 3675, 25, 42, 29, 3, -34 },
  { 3807, 22, 34, 23, 1, -34 },
  { 3901, 22, 34, 21, 0, -34 },
  { 3995, 20, 34, 20, 4, -34 },
  { 4080, 25, 34, 28, 3, -34 },
  { 4187, 21, 34, 22, 5, -34 },
  { 4277, 34, 34, 35, 5, -34 },
  { 4422, 27, 34, 20, -3, -34 },
  { 4537, 20, 34, 20, 4, -34 },
  { 4622, 24, 34, 21, -1, -34 },
  { 4724, 18, 41, 14, -1, -34 },
  { 4817, 7, 34, 15, 5, -34 },
  { 4847, 17, 41, 14, -3, -34 },
  { 4935, 20, 20, 23, 2, -34 },
  { 4985, 16, 1, 16, -4, 5 },
  { 4987, 5, 8, 11, 7, -36 },
  { 4992, 20, 25, 23, 2, -25 },
  { 5055, 21, 36, 24, 1, -36 },
  { 5150, 17, 25, 18, 2, -25 },
  { 5204, 23, 36, 24, 2, -36 },
  { 5308, 17, 25, 20, 2, -25 },
  { 5362, 24, 47, 12, -6, -36 },
  { 5503, 22, 36, 24, 0, -25 },
  { 5602, 20, 36, 23, 1, -36 },
  { 5692, 9, 34, 9, 1, -34 },
  { 5731, 16, 45, 9, -6, -34 },
  { 5821, 19, 36, 19, 1, -36 },
  { 5907, 9, 36, 9, 1, -36 },
  { 5948, 32, 25, 35, 1, -25 },
  { 6048, 20, 25, 23, 1, -25 },
  { 6111, 19, 25, 23, 2, -25 },
  { 6171, 23, 36, 24, -1, -25 },
  { 6275, 20, 36, 24, 2, -25 },
  { 6365, 16, 25, 15, 1, -25 },
  { 6415, 17, 25, 18, 0, -25 },
  { 6469, 12, 31, 13, 2, -31 },
  { 6516, 20, 25, 23, 2, -25 },
  { 6579, 18, 25, 17, 2, -25 },
  { 6636, 27, 25, 28, 3, -25 },
  { 6721, 22, 25, 19, -2, -25 },
  { 6790, 25, 36, 18, -5, -25 },
  { 6903, 19, 25, 17, -1, -25 },
  { 6963, 17, 41, 15, 1, -34 },
  { 7051, 2, 47, 22, 11, -36 },
  { 7063, 17, 41, 15, -3, -34 },
  { 7151, 19, 5, 24, 3, -19 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC47PT7B_H_
