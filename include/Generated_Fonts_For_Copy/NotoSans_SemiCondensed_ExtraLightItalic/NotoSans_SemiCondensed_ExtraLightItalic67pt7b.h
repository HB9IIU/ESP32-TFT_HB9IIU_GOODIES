#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC67PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0x1C, 0x0E, 0x38, 0x1C, 0x60,
  0x38, 0xC0, 0x63, 0x80, 0xC7, 0x03, 0x8C, 0x07, 0x18, 0x0C, 0x30, 0x18,
  0xE0, 0x31, 0xC0, 0xE3, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x60,
  0x30, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x38,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x38, 0x01, 0x80, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x0E, 0x00, 0x00, 0x18, 0x01, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x3E, 0x31, 0xF8, 0x03, 0x81, 0x81, 0x80, 0x38, 0x18,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18,
  0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x18,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x86, 0x00, 0x00, 0x1E, 0x30, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0x3C, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x18,
  0x07, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x06, 0x03, 0x81, 0x00, 0x60, 0x78,
  0x0E, 0x03, 0x07, 0x80, 0x7F, 0x9F, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xC0, 0x3F, 0xF0, 0x00, 0x0E, 0x01, 0xE0, 0xC0, 0x00, 0x30,
  0x06, 0x03, 0x80, 0x01, 0x80, 0x38, 0x06, 0x00, 0x0E, 0x01, 0xC0, 0x18,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x01, 0xC0, 0x38, 0x01, 0x80, 0x0E, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0x60,
  0x0E, 0x00, 0x70, 0x01, 0x80, 0x30, 0x01, 0x80, 0x06, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x03, 0x01,
  0xC0, 0x03, 0x00, 0x0C, 0x0E, 0x00, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x30,
  0x01, 0xC1, 0xC0, 0x00, 0xC0, 0x06, 0x06, 0x0F, 0xE3, 0x00, 0x18, 0x30,
  0x7F, 0xCC, 0x00, 0xE1, 0xC3, 0x87, 0xB0, 0x03, 0x06, 0x1C, 0x0E, 0xC0,
  0x1C, 0x30, 0xE0, 0x1B, 0x80, 0x61, 0xC3, 0x00, 0x7E, 0x03, 0x86, 0x1C,
  0x01, 0xDC, 0x1C, 0x38, 0x60, 0x07, 0x7F, 0xE1, 0xC3, 0x80, 0x1C, 0xFF,
  0x06, 0x0E, 0x00, 0x70, 0x40, 0x38, 0x30, 0x01, 0xC0, 0x01, 0xC1, 0xC0,
  0x06, 0x00, 0x06, 0x07, 0x00, 0x18, 0x00, 0x38, 0x18, 0x00, 0x60, 0x01,
  0xC0, 0x60, 0x01, 0x80, 0x06, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x38, 0x00, 0xC0, 0x06, 0x00, 0xE0, 0x03, 0x00, 0x38,
  0x03, 0x00, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x38, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x06, 0x00,
  0x0E, 0x01, 0xC0, 0x38, 0x00, 0x18, 0x0E, 0x00, 0xC0, 0x00, 0x70, 0x70,
  0x07, 0x00, 0x01, 0xF7, 0x80, 0x38, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x06,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x30, 0x07,
  0x80, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x30, 0xF0,
  0x0E, 0x00, 0x38, 0xF0, 0x07, 0x00, 0x18, 0x70, 0x01, 0xC0, 0x1C, 0x70,
  0x00, 0xE0, 0x0C, 0x70, 0x00, 0x38, 0x0E, 0x38, 0x00, 0x1C, 0x06, 0x38,
  0x00, 0x07, 0x07, 0x1C, 0x00, 0x01, 0x83, 0x0C, 0x00, 0x00, 0xE3, 0x86,
  0x00, 0x00, 0x3B, 0x83, 0x00, 0x00, 0x1F, 0x81, 0x80, 0x00, 0x07, 0xC0,
  0xC0, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xF0,
  0x1C, 0x00, 0x01, 0xDC, 0x07, 0x00, 0x03, 0xC6, 0x03, 0xC0, 0x03, 0xC3,
  0x80, 0xF0, 0x07, 0x80, 0xE0, 0x3F, 0xFF, 0x80, 0x70, 0x0F, 0xFF, 0x00,
  0x1C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x0C,
  0x31, 0xC7, 0x18, 0x61, 0x86, 0x30, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x0C, 0x00, 0xF0, 0x0C,
  0x00, 0x78, 0x08, 0x00, 0x1E, 0x18, 0x00, 0x07, 0x98, 0x01, 0x01, 0xD8,
  0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0x8C, 0x00, 0x07, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x1C, 0x07,
  0x00, 0x38, 0x03, 0x00, 0x70, 0x03, 0x80, 0x20, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x06, 0x03,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x6F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x70, 0x38, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x1C, 0x60,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x1C, 0x06, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0x60, 0x3D, 0xC0, 0xF3, 0x87, 0x87, 0x1E, 0x0C,
  0x78, 0x19, 0xC0, 0x73, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x0F,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x70, 0x18, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x60, 0x0E, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x06, 0x00, 0x38,
  0x00, 0x38, 0x00, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x00, 0x38, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x18, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x3C, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xC0,
  0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xC0, 0x10, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC1, 0xFF, 0x80, 0x0C,
  0x3F, 0xFE, 0x00, 0xE7, 0x80, 0x78, 0x07, 0x70, 0x01, 0xE0, 0x37, 0x00,
  0x07, 0x01, 0xB0, 0x00, 0x1C, 0x1F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03,
  0x07, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x00, 0x60, 0x00, 0x38, 0x03, 0x80,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x78, 0x07, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x18, 0x07, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x70, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x38, 0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xEF, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x38, 0x03, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0xF0, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0x80, 0x1C, 0x00,
  0x78, 0x00, 0x70, 0x07, 0x80, 0x01, 0x80, 0x38, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x70, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3E, 0x0E, 0x00, 0x03, 0xE0,
  0x38, 0x00, 0x3B, 0x01, 0xE0, 0x03, 0xB8, 0x07, 0x80, 0x79, 0xC0, 0x1F,
  0xFF, 0x8C, 0x00, 0x7F, 0xF0, 0x60, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x02, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x3C, 0x07, 0x80,
  0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x70, 0x1F, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x0C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x3E, 0x03, 0xC0, 0x80,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x03, 0xFE, 0x00, 0x70, 0xE0, 0x00, 0xFF, 0xF8,
  0x07, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x71, 0xC0, 0x07, 0x80, 0x30, 0x07,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x71, 0x80, 0x0C, 0x00, 0x70, 0x07, 0x38,
  0x01, 0xC0, 0x06, 0x00, 0x73, 0x00, 0x38, 0x00, 0x60, 0x07, 0x30, 0x03,
  0x00, 0x0E, 0x00, 0x77, 0x00, 0x70, 0x00, 0xE0, 0x06, 0x70, 0x06, 0x00,
  0x0C, 0x00, 0x66, 0x00, 0xE0, 0x00, 0xC0, 0x06, 0x60, 0x0C, 0x00, 0x1C,
  0x00, 0xEE, 0x00, 0xC0, 0x01, 0xC0, 0x0E, 0xE0, 0x1C, 0x00, 0x18, 0x00,
  0xCE, 0x01, 0xC0, 0x03, 0x80, 0x0C, 0xE0, 0x1C, 0x00, 0x38, 0x01, 0xCC,
  0x01, 0xC0, 0x03, 0x80, 0x18, 0xC0, 0x18, 0x00, 0x70, 0x03, 0x8C, 0x01,
  0xC0, 0x07, 0x00, 0x30, 0xC0, 0x1C, 0x00, 0xF0, 0x07, 0x0C, 0x01, 0xC0,
  0x1B, 0x00, 0xE0, 0xC0, 0x0C, 0x03, 0xB8, 0x1C, 0x0E, 0x00, 0xE0, 0x71,
  0x83, 0xC0, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x0E, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x60, 0x00, 0xE0, 0x01, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x30,
  0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x07, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x70, 0x03, 0x80, 0x01, 0xE0, 0x03, 0x00, 0x1F, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x06, 0x00,
  0x03, 0xC0, 0x06, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x0F, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x60, 0x07, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x10, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x38,
  0x00, 0x7E, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x07, 0x80, 0x30, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x06, 0x00, 0x0F,
  0xC0, 0x00, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x0F, 0x80,
  0x00, 0x60, 0x01, 0xE0, 0x00, 0x02, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xF8,
  0x60, 0x00, 0x1F, 0xFF, 0x06, 0x00, 0x01, 0xFF, 0xF0, 0xE0, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x3C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x03, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x0F, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x3C, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x01, 0x80, 0xF0,
  0x00, 0x00, 0x18, 0x1E, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00, 0x38,
  0x78, 0x00, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x00, 0x31, 0xF0, 0x00, 0x00,
  0x07, 0x3F, 0x00, 0x00, 0x00, 0x77, 0x30, 0x00, 0x00, 0x07, 0x63, 0x80,
  0x00, 0x00, 0x6C, 0x18, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x00, 0xF0,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x18, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x0D, 0xC0, 0x00,
  0x00, 0x1D, 0x80, 0x1B, 0x80, 0x00, 0x00, 0x3B, 0x00, 0x37, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0xE6, 0x00, 0x00, 0x01, 0xDC, 0x01, 0xCC, 0x00, 0x00,
  0x07, 0x30, 0x03, 0x98, 0x00, 0x00, 0x0C, 0x60, 0x06, 0x30, 0x00, 0x00,
  0x39, 0xC0, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x80, 0x38, 0xE0, 0x00, 0x01,
  0xC7, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0xC3, 0x80, 0x00, 0x0E,
  0x18, 0x01, 0x83, 0x00, 0x00, 0x38, 0x70, 0x03, 0x06, 0x00, 0x00, 0x70,
  0xE0, 0x0E, 0x0C, 0x00, 0x01, 0xC1, 0xC0, 0x1C, 0x18, 0x00, 0x03, 0x83,
  0x00, 0x30, 0x30, 0x00, 0x0E, 0x06, 0x00, 0x60, 0x70, 0x00, 0x18, 0x1C,
  0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x00, 0xC0, 0x70,
  0x07, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80,
  0x18, 0x06, 0x00, 0x1C, 0x07, 0x00, 0x70, 0x0C, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x18, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x00, 0xC0, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80, 0xE0, 0x06, 0x00, 0x60,
  0x03, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x0C, 0x0C, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0x0E, 0x00,
  0x38, 0xE0, 0x01, 0x80, 0x18, 0x00, 0x71, 0xC0, 0x03, 0x00, 0x30, 0x00,
  0x67, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xCC, 0x00, 0x1C, 0x01, 0xC0, 0x01,
  0xB8, 0x00, 0x38, 0x03, 0x80, 0x03, 0x60, 0x00, 0x60, 0x06, 0x00, 0x07,
  0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x00, 0x30,
  0x03, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xC0, 0x0D, 0xC0,
  0x00, 0x03, 0x80, 0x1B, 0x80, 0x00, 0x06, 0x00, 0x33, 0x00, 0x00, 0x0C,
  0x00, 0xE7, 0x00, 0x00, 0x38, 0x01, 0xCE, 0x00, 0x00, 0x70, 0x03, 0x8C,
  0x00, 0x00, 0xE0, 0x06, 0x1C, 0x00, 0x01, 0x80, 0x0C, 0x38, 0x00, 0x03,
  0x00, 0x38, 0x30, 0x00, 0x0E, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x03, 0x01, 0xC0, 0x01,
  0xC0, 0x0E, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x03, 0x00, 0x07, 0x00, 0x30,
  0x07, 0x00, 0x0C, 0x00, 0x60, 0x0E, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x70, 0x06, 0x00, 0x70, 0x00, 0xE0,
  0x1C, 0x00, 0xE0, 0x00, 0xC0, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x03,
  0x00, 0x03, 0x80, 0xC0, 0x06, 0x00, 0x03, 0x03, 0x80, 0x1C, 0x00, 0x07,
  0x07, 0x00, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x70, 0x00, 0x0C, 0x18, 0x00,
  0xC0, 0x00, 0x1C, 0x30, 0x03, 0x80, 0x00, 0x38, 0x60, 0x07, 0x00, 0x00,
  0x31, 0xC0, 0x0E, 0x00, 0x00, 0x73, 0x80, 0x18, 0x00, 0x00, 0xE6, 0x00,
  0x30, 0x00, 0x00, 0xCC, 0x00, 0xE0, 0x00, 0x01, 0xD8, 0x01, 0xC0, 0x00,
  0x03, 0xF0, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x06, 0x00, 0x00, 0x07, 0x80,
  0x0C, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x70, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x38, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x07, 0x00, 0x30, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x0F,
  0x80, 0x0C, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x06,
  0x38, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0x80, 0x07, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x07, 0x00, 0x30, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x78, 0x03, 0x80, 0x03, 0xE0, 0x07, 0x00, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x70, 0x03, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x07,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x38, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xC0,
  0x00, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x18, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x73, 0x00, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x07, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x70, 0x01, 0x80, 0x01, 0xC0,
  0x03, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x01, 0x80, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x38, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x86, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x06, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1C, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0D, 0xC0, 0x00,
  0x38, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x19, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x31, 0xC0, 0x00,
  0xE0, 0x60, 0x00, 0x71, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x71, 0xC0, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0xC0, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x80, 0x60, 0x01, 0xC0, 0xC0, 0x03,
  0x00, 0x60, 0x01, 0x80, 0xC0, 0x07, 0x00, 0x60, 0x03, 0x80, 0xC0, 0x07,
  0x00, 0x60, 0x03, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x1C,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x38,
  0x00, 0x60, 0x1C, 0x00, 0xC0, 0x38, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x70,
  0x00, 0x60, 0x38, 0x00, 0xC0, 0x70, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x70, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0xE0, 0x00, 0xC1, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0x80,
  0x00, 0x60, 0xC0, 0x00, 0xC3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0xC3, 0x80,
  0x00, 0x71, 0x80, 0x00, 0xC3, 0x00, 0x00, 0x73, 0x80, 0x00, 0xC7, 0x00,
  0x00, 0x73, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x77, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x76, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x76, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x03, 0x80, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0,
  0x38, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x80, 0x18, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x0C, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x37, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xE0,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0xC0, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x02, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x38,
  0x0C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x60, 0x06, 0x00, 0x0E, 0x00, 0x60,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x03, 0x80, 0x03, 0x00, 0x30,
  0x00, 0x38, 0x07, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x70, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xE1, 0xC1, 0xC3, 0x83, 0x83, 0x07, 0x06, 0x06,
  0x0C, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x83, 0x00, 0x7C, 0x3C, 0x30,
  0x0F, 0x00, 0xE3, 0x01, 0xC0, 0x06, 0x70, 0x38, 0x00, 0x36, 0x07, 0x00,
  0x03, 0x60, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C,
  0x1C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x01, 0x87, 0x00, 0x00, 0x18, 0x70, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1E, 0x0E,
  0x00, 0x03, 0xE0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x06, 0xC0, 0x60, 0x00,
  0xEC, 0x07, 0x00, 0x1C, 0xC0, 0x78, 0x03, 0x9C, 0x03, 0xC0, 0x71, 0x80,
  0x1F, 0xFE, 0x18, 0x00, 0xFF, 0x81, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x1F, 0xC0, 0x00,
  0xC1, 0xFF, 0xC0, 0x07, 0x1F, 0x0F, 0x80, 0x1C, 0xF0, 0x0F, 0x00, 0x77,
  0x00, 0x1C, 0x01, 0x98, 0x00, 0x38, 0x06, 0xC0, 0x00, 0xE0, 0x3E, 0x00,
  0x01, 0x80, 0xF8, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03,
  0x03, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0x80,
  0xD8, 0x00, 0x1C, 0x07, 0x60, 0x00, 0xE0, 0x19, 0xC0, 0x07, 0x00, 0x63,
  0x80, 0x78, 0x01, 0x87, 0xFF, 0xC0, 0x0E, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x7E, 0x0F, 0x00,
  0xF0, 0x01, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0xC0, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0xF0, 0x38, 0x00, 0x3F, 0xFC,
  0x38, 0x00, 0x7E, 0x1E, 0x38, 0x00, 0xF0, 0x07, 0x30, 0x01, 0xC0, 0x03,
  0x30, 0x03, 0x80, 0x01, 0xB0, 0x07, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x01,
  0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x0F,
  0x00, 0xC0, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x36,
  0x00, 0xE0, 0x00, 0x76, 0x00, 0x60, 0x00, 0xEE, 0x00, 0x70, 0x01, 0xCC,
  0x00, 0x78, 0x03, 0x8C, 0x00, 0x3C, 0x07, 0x0C, 0x00, 0x1F, 0xFE, 0x0C,
  0x00, 0x0F, 0xF8, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x7E, 0x1E, 0x00, 0xF0, 0x0F, 0x01, 0xC0, 0x07,
  0x03, 0x80, 0x03, 0x07, 0x00, 0x03, 0x07, 0x00, 0x03, 0x0E, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x06, 0x38, 0x00, 0x0E,
  0x30, 0x00, 0x1C, 0x30, 0x00, 0x78, 0x70, 0x01, 0xF0, 0x70, 0x1F, 0xC0,
  0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x10,
  0x1E, 0x00, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1E,
  0x04, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC7, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x0C, 0x00, 0x7E, 0x1E, 0x38, 0x01, 0xE0, 0x0E,
  0x60, 0x07, 0x00, 0x0C, 0xC0, 0x1C, 0x00, 0x0D, 0x80, 0x70, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x3E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0xC0, 0x60, 0x00,
  0x07, 0x80, 0xC0, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0xD8, 0x07, 0x00, 0x03, 0xF0, 0x06, 0x00, 0x0E, 0xE0, 0x0E, 0x00, 0x39,
  0x80, 0x1C, 0x00, 0xE3, 0x00, 0x1E, 0x03, 0x86, 0x00, 0x1F, 0xFE, 0x1C,
  0x00, 0x1F, 0xF0, 0x38, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x40,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x07, 0xF0, 0x00, 0xC1, 0xFF, 0xC0, 0x0C, 0x7E, 0x3E, 0x01, 0xCE,
  0x00, 0xF0, 0x1D, 0xC0, 0x07, 0x01, 0xB8, 0x00, 0x30, 0x1B, 0x00, 0x03,
  0x03, 0xE0, 0x00, 0x30, 0x3C, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x30, 0x38,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x30, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x0C, 0x0C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x38, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x07, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x87, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x30, 0x0E,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x63, 0xE0, 0x00, 0x0E, 0x7E,
  0x00, 0x00, 0xEE, 0x60, 0x00, 0x0D, 0xC7, 0x00, 0x00, 0xF8, 0x70, 0x00,
  0x1F, 0x03, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0x80,
  0x1C, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x70, 0x07, 0x00, 0x03, 0x00, 0x70, 0x00, 0x38, 0x06, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x0C,
  0x78, 0x78, 0x1E, 0x1F, 0x00, 0x73, 0x80, 0x70, 0xE0, 0x1E, 0x01, 0x98,
  0x00, 0xC7, 0x00, 0x38, 0x06, 0xE0, 0x03, 0xB8, 0x00, 0x60, 0x1B, 0x00,
  0x0E, 0xC0, 0x01, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x18, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x06, 0x0F, 0xFE, 0x00, 0x71, 0xF8,
  0xF8, 0x03, 0x9E, 0x01, 0xE0, 0x19, 0xC0, 0x07, 0x00, 0xDC, 0x00, 0x18,
  0x06, 0xC0, 0x00, 0xC0, 0x7C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x30, 0x1E,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x38, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x18,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x30, 0x18, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x70, 0x78, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x60, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0C,
  0x1F, 0xFC, 0x00, 0x06, 0x1E, 0x1F, 0x00, 0x07, 0x3C, 0x03, 0xC0, 0x03,
  0x18, 0x00, 0xE0, 0x01, 0x98, 0x00, 0x38, 0x00, 0xD8, 0x00, 0x1C, 0x00,
  0x7C, 0x00, 0x06, 0x00, 0x7C, 0x00, 0x03, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x1E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x70, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x06, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x1B, 0x00,
  0x03, 0x80, 0x1D, 0x80, 0x03, 0x80, 0x0E, 0xE0, 0x03, 0x80, 0x07, 0x38,
  0x07, 0x80, 0x03, 0x0F, 0xFF, 0x80, 0x01, 0x83, 0xFF, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0xC0, 0x1F, 0x07, 0x8E, 0x01, 0xE0, 0x0E, 0x60, 0x1C, 0x00, 0x33, 0x01,
  0xC0, 0x00, 0xD8, 0x1C, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x3E, 0x0E, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0F, 0x06,
  0x00, 0x00, 0x78, 0x30, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x3C, 0x0E, 0x00,
  0x03, 0xE0, 0x70, 0x00, 0x3B, 0x01, 0x80, 0x03, 0xB8, 0x0E, 0x00, 0x39,
  0x80, 0x70, 0x03, 0x8C, 0x01, 0xE0, 0x38, 0x60, 0x07, 0xFF, 0x87, 0x00,
  0x1F, 0xF0, 0x38, 0x00, 0x1E, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x01, 0x83, 0xFC, 0x03, 0x1F, 0x98, 0x0E,
  0x70, 0x00, 0x19, 0xC0, 0x00, 0x37, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xF8, 0x3F, 0x01, 0xC0, 0x03, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x80, 0x01,
  0xE0, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0xBF, 0xFF, 0x9F, 0xFF,
  0xC0, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x1C,
  0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x18, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x0E,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x6C, 0x0E, 0x00, 0x0D, 0xC0, 0xE0, 0x01,
  0xD8, 0x07, 0x00, 0x39, 0x80, 0x78, 0x0F, 0x18, 0x03, 0xFF, 0xC1, 0x80,
  0x1F, 0xF8, 0x38, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xB0, 0x00,
  0x03, 0x98, 0x00, 0x01, 0xCC, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x30, 0x38,
  0x00, 0x38, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x0C, 0x01,
  0x80, 0x0E, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x00,
  0x1C, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x01, 0x81, 0xC0,
  0x00, 0xC0, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x18, 0x70,
  0x00, 0x0C, 0x38, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x03, 0xB0,
  0x00, 0x36, 0x00, 0x0E, 0xC0, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x07, 0x60,
  0x01, 0xCE, 0x00, 0x19, 0x80, 0x06, 0x38, 0x00, 0xE6, 0x00, 0x38, 0xE0,
  0x03, 0x18, 0x00, 0xC3, 0x80, 0x1C, 0x60, 0x07, 0x0E, 0x00, 0x61, 0x80,
  0x1C, 0x38, 0x03, 0x86, 0x00, 0x60, 0xE0, 0x0C, 0x18, 0x03, 0x83, 0x80,
  0x70, 0x60, 0x0C, 0x0E, 0x01, 0x81, 0x80, 0x70, 0x38, 0x0E, 0x06, 0x01,
  0x80, 0xE0, 0x30, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x0E, 0x07,
  0x01, 0x81, 0xC0, 0x18, 0x18, 0x07, 0x07, 0x00, 0x60, 0xE0, 0x1C, 0x18,
  0x01, 0x83, 0x00, 0x70, 0xE0, 0x06, 0x1C, 0x01, 0xC3, 0x00, 0x18, 0x60,
  0x07, 0x1C, 0x00, 0x63, 0x80, 0x1C, 0x60, 0x01, 0x8C, 0x00, 0x33, 0x80,
  0x06, 0x70, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x6E, 0x00,
  0x0D, 0xC0, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x00, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x03,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0x38, 0x00, 0x38, 0x00, 0x60,
  0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x00, 0x70, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x18, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x87, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0x7C, 0xFE,
  0x00, 0x3E, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xFF, 0xE8, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x08, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 13, 48, 14, 2, -48 },
  { 79, 15, 17, 21, 7, -48 },
  { 111, 35, 48, 36, 1, -48 },
  { 321, 29, 55, 32, 2, -51 },
  { 521, 38, 50, 46, 5, -49 },
  { 759, 33, 50, 37, 2, -49 },
  { 966, 6, 17, 11, 7, -48 },
  { 979, 19, 59, 17, 2, -48 },
  { 1120, 19, 59, 17, -4, -48 },
  { 1261, 24, 25, 31, 8, -51 },
  { 1336, 28, 31, 34, 4, -39 },
  { 1445, 10, 16, 12, -3, -7 },
  { 1465, 15, 2, 20, 2, -19 },
  { 1469, 4, 5, 13, 2, -5 },
  { 1472, 29, 48, 21, -3, -48 },
  { 1646, 28, 50, 32, 3, -49 },
  { 1821, 15, 48, 32, 10, -48 },
  { 1911, 30, 49, 32, 0, -49 },
  { 2095, 31, 50, 32, 0, -49 },
  { 2289, 30, 48, 32, 0, -48 },
  { 2469, 31, 49, 32, 1, -48 },
  { 2659, 29, 50, 32, 3, -49 },
  { 2841, 28, 48, 32, 5, -48 },
  { 3009, 30, 50, 32, 2, -49 },
  { 3197, 29, 50, 32, 2, -49 },
  { 3379, 11, 36, 13, 1, -36 },
  { 3429, 15, 45, 13, -3, -36 },
  { 3514, 28, 30, 34, 4, -39 },
  { 3619, 28, 16, 34, 4, -32 },
  { 3675, 28, 30, 34, 4, -39 },
  { 3780, 21, 49, 24, 4, -49 },
  { 3909, 44, 54, 48, 3, -48 },
  { 4206, 32, 48, 32, -4, -48 },
  { 4398, 32, 48, 35, 2, -48 },
  { 4590, 33, 50, 34, 4, -49 },
  { 4797, 35, 48, 39, 2, -48 },
  { 5007, 31, 48, 31, 2, -48 },
  { 5193, 31, 48, 28, 2, -48 },
  { 5379, 36, 50, 40, 4, -49 },
  { 5604, 38, 48, 40, 2, -48 },
  { 5832, 21, 48, 17, -1, -48 },
  { 5958, 26, 60, 14, -11, -48 },
  { 6153, 36, 48, 32, 2, -48 },
  { 6369, 21, 48, 28, 2, -48 },
  { 6495, 47, 48, 49, 2, -48 },
  { 6777, 39, 48, 40, 2, -48 },
  { 7011, 36, 50, 42, 4, -49 },
  { 7236, 31, 48, 33, 2, -48 },
  { 7422, 36, 60, 42, 4, -49 },
  { 7692, 31, 48, 33, 2, -48 },
  { 7878, 31, 50, 30, 0, -49 },
  { 8072, 28, 48, 28, 6, -48 },
  { 8240, 37, 49, 40, 4, -48 },
  { 8467, 31, 48, 32, 6, -48 },
  { 8653, 48, 48, 50, 7, -48 },
  { 8941, 38, 48, 29, -4, -48 },
  { 9169, 28, 48, 28, 6, -48 },
  { 9337, 34, 48, 30, -1, -48 },
  { 9541, 25, 59, 20, -1, -48 },
  { 9726, 10, 48, 21, 7, -48 },
  { 9786, 25, 59, 20, -5, -48 },
  { 9971, 28, 27, 33, 3, -48 },
  { 10066, 23, 2, 23, -6, 7 },
  { 10072, 7, 10, 15, 10, -51 },
  { 10081, 28, 37, 33, 3, -36 },
  { 10211, 30, 52, 34, 1, -51 },
  { 10406, 24, 37, 26, 3, -36 },
  { 10517, 32, 52, 34, 3, -51 },
  { 10725, 24, 37, 29, 3, -36 },
  { 10836, 34, 67, 16, -9, -51 },
  { 11121, 31, 52, 34, 1, -36 },
  { 11323, 28, 51, 33, 1, -51 },
  { 11502, 14, 48, 13, 1, -48 },
  { 11586, 24, 64, 13, -9, -48 },
  { 11778, 28, 51, 27, 1, -51 },
  { 11957, 14, 51, 13, 1, -51 },
  { 12047, 46, 36, 50, 1, -36 },
  { 12254, 29, 36, 33, 1, -36 },
  { 12385, 27, 37, 33, 3, -36 },
  { 12510, 33, 52, 34, -2, -36 },
  { 12725, 29, 52, 34, 3, -36 },
  { 12914, 23, 36, 22, 1, -36 },
  { 13018, 24, 37, 25, 0, -36 },
  { 13129, 17, 45, 18, 3, -44 },
  { 13225, 28, 36, 33, 3, -35 },
  { 13351, 25, 35, 25, 3, -35 },
  { 13461, 38, 35, 40, 4, -35 },
  { 13628, 30, 35, 27, -2, -35 },
  { 13760, 36, 51, 25, -7, -35 },
  { 13990, 26, 35, 25, -1, -35 },
  { 14104, 24, 59, 22, 2, -48 },
  { 14281, 2, 67, 31, 16, -51 },
  { 14298, 24, 59, 22, -4, -48 },
  { 14475, 28, 7, 34, 4, -27 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC67PT7B_H_
