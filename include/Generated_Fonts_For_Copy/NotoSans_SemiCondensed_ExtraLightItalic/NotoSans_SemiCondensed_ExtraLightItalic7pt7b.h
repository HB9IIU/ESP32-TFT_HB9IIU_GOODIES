#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC7PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0x80, 0xC0, 0x57, 0x6C, 0xA0, 0x79, 0x3C, 0x5A, 0xB7, 0x70,
  0x66, 0x5A, 0xE0, 0xC0, 0x6A, 0xA0, 0x55, 0xA0, 0xB0, 0x5D, 0x00, 0xC0,
  0xC0, 0x80, 0x29, 0x48, 0x76, 0xDE, 0xDA, 0x80, 0x64, 0xAE, 0x65, 0x1E,
  0x2E, 0xF2, 0x68, 0x9E, 0x73, 0xDE, 0xE9, 0x48, 0x6D, 0x5E, 0x77, 0x9C,
  0x90, 0x98, 0x38, 0x80, 0xE0, 0xC7, 0x00, 0x65, 0x48, 0x7D, 0xF7, 0xBA,
  0x30, 0x2D, 0xDA, 0x75, 0xE9, 0xE0, 0x78, 0x88, 0xE0, 0x75, 0x99, 0xE0,
  0x6B, 0xCC, 0x69, 0xC8, 0x78, 0xA9, 0xF0, 0x55, 0xF9, 0x90, 0x5A, 0x80,
  0x25, 0x25, 0x80, 0x56, 0xCA, 0xA0, 0x5A, 0xC0, 0x4A, 0x77, 0xDA, 0x80,
  0x55, 0xBB, 0xA0, 0x79, 0x99, 0xE0, 0x6F, 0xC8, 0x79, 0x99, 0xE2, 0x6F,
  0xDA, 0x71, 0x1E, 0xF2, 0x48, 0x55, 0x99, 0xE0, 0xBB, 0x48, 0xAE, 0xAD,
  0x4A, 0x00, 0x56, 0x4C, 0xA0, 0xBA, 0x48, 0x65, 0x4E, 0x6A, 0x49, 0x00,
  0xF8, 0x55, 0x60, 0x4E, 0x80, 0xE0, 0x80, 0x76, 0xF0, 0x4E, 0xDE, 0x72,
  0x60, 0x16, 0xAA, 0xE0, 0x77, 0x60, 0x36, 0x44, 0x44, 0x80, 0x76, 0xF3,
  0x80, 0x4E, 0xDA, 0x5A, 0x80, 0x25, 0x24, 0xA0, 0x4F, 0x6A, 0x5A, 0x80,
  0x7D, 0x6B, 0x50, 0xF6, 0xD0, 0x76, 0xF0, 0x76, 0xF9, 0x00, 0x76, 0xF2,
  0x40, 0x72, 0x40, 0x71, 0x60, 0x7A, 0x80, 0xB6, 0xF0, 0xB7, 0x40, 0xBB,
  0xEA, 0xA9, 0x60, 0x55, 0x64, 0x48, 0x6A, 0x60, 0x69, 0x49, 0x00, 0xFE,
  0x55, 0xA0, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 1, 2, 2, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 3, 5, 3, 0, -5 },
  { 9, 4, 5, 5, 0, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 2, 1, 1, -5 },
  { 16, 2, 6, 2, 0, -5 },
  { 18, 2, 6, 2, 0, -5 },
  { 20, 2, 2, 3, 1, -5 },
  { 21, 3, 3, 4, 0, -4 },
  { 23, 1, 2, 1, 0, -1 },
  { 24, 2, 1, 2, 0, -2 },
  { 25, 1, 1, 1, 0, -1 },
  { 26, 3, 5, 2, 0, -5 },
  { 28, 3, 5, 3, 0, -5 },
  { 30, 2, 5, 3, 1, -5 },
  { 32, 3, 5, 3, 0, -5 },
  { 34, 3, 5, 3, 0, -5 },
  { 36, 3, 5, 3, 0, -5 },
  { 38, 3, 5, 3, 0, -5 },
  { 40, 3, 5, 3, 0, -5 },
  { 42, 3, 5, 3, 1, -5 },
  { 44, 3, 5, 3, 0, -5 },
  { 46, 3, 5, 3, 0, -5 },
  { 48, 1, 4, 1, 0, -4 },
  { 49, 1, 5, 1, 0, -4 },
  { 50, 3, 3, 4, 0, -4 },
  { 52, 3, 1, 4, 0, -3 },
  { 53, 3, 3, 4, 0, -4 },
  { 55, 3, 5, 2, 0, -5 },
  { 57, 5, 6, 5, 0, -5 },
  { 61, 3, 5, 3, 0, -5 },
  { 63, 4, 5, 4, 0, -5 },
  { 66, 4, 5, 4, 0, -5 },
  { 69, 4, 5, 4, 0, -5 },
  { 72, 3, 5, 3, 0, -5 },
  { 74, 3, 5, 3, 0, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 4, 5, 4, 0, -5 },
  { 82, 2, 5, 2, 0, -5 },
  { 84, 3, 6, 1, -1, -5 },
  { 87, 4, 5, 3, 0, -5 },
  { 90, 2, 5, 3, 0, -5 },
  { 92, 5, 5, 5, 0, -5 },
  { 96, 4, 5, 4, 0, -5 },
  { 99, 4, 5, 4, 0, -5 },
  { 102, 3, 5, 3, 0, -5 },
  { 104, 4, 6, 4, 0, -5 },
  { 107, 3, 5, 3, 0, -5 },
  { 109, 3, 5, 3, 0, -5 },
  { 111, 3, 5, 3, 1, -5 },
  { 113, 4, 5, 4, 0, -5 },
  { 116, 3, 5, 3, 1, -5 },
  { 118, 5, 5, 5, 1, -5 },
  { 122, 4, 5, 3, 0, -5 },
  { 125, 3, 5, 3, 1, -5 },
  { 127, 3, 5, 3, 0, -5 },
  { 129, 3, 6, 2, 0, -5 },
  { 132, 1, 5, 2, 1, -5 },
  { 133, 2, 6, 2, 0, -5 },
  { 135, 3, 3, 3, 0, -5 },
  { 137, 3, 1, 2, -1, 0 },
  { 138, 1, 1, 2, 1, -5 },
  { 139, 3, 4, 3, 0, -4 },
  { 141, 3, 5, 4, 0, -5 },
  { 143, 3, 4, 3, 0, -4 },
  { 145, 4, 5, 4, 0, -5 },
  { 148, 3, 4, 3, 0, -4 },
  { 150, 4, 7, 2, -1, -5 },
  { 154, 3, 6, 4, 0, -4 },
  { 157, 3, 5, 3, 0, -5 },
  { 159, 2, 5, 1, 0, -5 },
  { 161, 3, 7, 1, -1, -5 },
  { 164, 3, 5, 3, 0, -5 },
  { 166, 2, 5, 1, 0, -5 },
  { 168, 5, 4, 5, 0, -4 },
  { 171, 3, 4, 3, 0, -4 },
  { 173, 3, 4, 3, 0, -4 },
  { 175, 3, 6, 4, 0, -4 },
  { 178, 3, 6, 4, 0, -4 },
  { 181, 3, 4, 2, 0, -4 },
  { 183, 3, 4, 3, 0, -4 },
  { 185, 2, 5, 2, 0, -5 },
  { 187, 3, 4, 3, 0, -4 },
  { 189, 3, 4, 3, 0, -4 },
  { 191, 4, 4, 4, 0, -4 },
  { 193, 3, 4, 3, 0, -4 },
  { 195, 4, 6, 3, -1, -4 },
  { 198, 3, 4, 3, 0, -4 },
  { 200, 3, 6, 2, 0, -5 },
  { 203, 1, 7, 3, 1, -5 },
  { 204, 2, 6, 2, 0, -5 },
  { 206, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC7PT7B_H_
