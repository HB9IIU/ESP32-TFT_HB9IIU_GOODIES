#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC19PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x22, 0x22, 0x24, 0x40, 0x0C, 0x55, 0x99, 0x90, 0x04,
  0x41, 0x20, 0x88, 0x22, 0x3F, 0xC2, 0x41, 0x10, 0x44, 0x12, 0x3F, 0xE2,
  0x20, 0x90, 0x24, 0x11, 0x00, 0x04, 0x1E, 0x29, 0x48, 0x48, 0x48, 0x30,
  0x18, 0x14, 0x12, 0x12, 0x24, 0xF8, 0x20, 0x20, 0x18, 0x25, 0x09, 0x12,
  0x24, 0x48, 0x91, 0x14, 0x22, 0xBC, 0xA9, 0x69, 0x21, 0x44, 0x48, 0x91,
  0x12, 0x24, 0x87, 0x00, 0x06, 0x02, 0x41, 0x10, 0x44, 0x11, 0x04, 0x80,
  0xC0, 0x50, 0x64, 0x50, 0xA8, 0x2A, 0x04, 0x43, 0x1F, 0x20, 0x5A, 0x80,
  0x08, 0x88, 0x44, 0x22, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x80, 0x10,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x21, 0x10, 0x88, 0x80, 0x09, 0x21,
  0xC8, 0xE2, 0x89, 0x02, 0x00, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x08, 0x08,
  0x08, 0x08, 0x29, 0x40, 0xF0, 0xC0, 0x01, 0x01, 0x02, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0x0C, 0x12, 0x21, 0x41,
  0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x84, 0x84, 0x78, 0x13, 0xD9,
  0x22, 0x22, 0x44, 0x44, 0x48, 0x0E, 0x08, 0x80, 0x20, 0x10, 0x08, 0x08,
  0x08, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x07, 0xF0, 0x0E, 0x18, 0x80,
  0x20, 0x10, 0x08, 0x08, 0x78, 0x0C, 0x02, 0x00, 0x80, 0x40, 0x40, 0x27,
  0xE0, 0x00, 0x80, 0x80, 0xC0, 0xA0, 0x90, 0x48, 0x48, 0x44, 0x42, 0x41,
  0x3F, 0xE0, 0x80, 0x40, 0x20, 0x0F, 0x88, 0x04, 0x02, 0x02, 0x01, 0x00,
  0xF8, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x27, 0xE0, 0x07, 0x18, 0x20,
  0x20, 0x40, 0x48, 0xB4, 0xC2, 0x82, 0x82, 0x82, 0x82, 0x84, 0x78, 0xFE,
  0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x00,
  0x0F, 0x08, 0x44, 0x24, 0x12, 0x08, 0x88, 0x38, 0x28, 0x62, 0x20, 0xA0,
  0x50, 0x24, 0x21, 0xE0, 0x1C, 0x22, 0x41, 0x41, 0x41, 0x81, 0x82, 0x46,
  0x3A, 0x02, 0x04, 0x04, 0x08, 0xF0, 0x20, 0x00, 0x00, 0x18, 0x10, 0x00,
  0x00, 0x00, 0x24, 0x48, 0x01, 0x06, 0x18, 0x60, 0xC0, 0x30, 0x0C, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x70, 0x0C, 0x02, 0x03, 0x0C, 0x30,
  0xC0, 0x39, 0x10, 0x41, 0x04, 0x21, 0x08, 0x41, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x80, 0xC6, 0x10, 0x12, 0x01, 0x43, 0x94, 0x49, 0x88, 0x99, 0x09,
  0x91, 0x19, 0x11, 0x93, 0x28, 0xCC, 0x80, 0x04, 0x00, 0x61, 0x01, 0xE0,
  0x01, 0x01, 0x80, 0xC0, 0xA0, 0x50, 0x48, 0x24, 0x22, 0x1F, 0x10, 0x48,
  0x28, 0x14, 0x0C, 0x04, 0x3E, 0x10, 0x88, 0x24, 0x14, 0x0A, 0x09, 0xF8,
  0x84, 0x41, 0x40, 0xA0, 0x50, 0x48, 0x27, 0xE0, 0x07, 0x86, 0x12, 0x00,
  0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40,
  0x0F, 0x80, 0x3C, 0x11, 0x88, 0x24, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x40,
  0xC0, 0x60, 0x50, 0x48, 0x47, 0xC0, 0x3F, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x7E, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0xFC, 0x3F, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x7E, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x07, 0x86,
  0x12, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x0E, 0x80, 0xA0, 0x28, 0x0A,
  0x02, 0x41, 0x0F, 0xC0, 0x20, 0x48, 0x12, 0x04, 0x81, 0x40, 0x50, 0x27,
  0xF9, 0x02, 0x40, 0xA0, 0x28, 0x12, 0x04, 0x81, 0x20, 0x40, 0x3C, 0x41,
  0x04, 0x10, 0x42, 0x08, 0x20, 0x84, 0x10, 0x43, 0x80, 0x02, 0x04, 0x08,
  0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0xE0,
  0x20, 0x48, 0x22, 0x10, 0x88, 0x44, 0x12, 0x05, 0x01, 0xA0, 0x48, 0x22,
  0x08, 0x42, 0x10, 0x84, 0x20, 0x80, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10,
  0x42, 0x08, 0x20, 0x83, 0xF0, 0x30, 0x09, 0x80, 0xCC, 0x06, 0x60, 0x55,
  0x03, 0x28, 0x29, 0x42, 0x49, 0x12, 0x49, 0x24, 0x49, 0x22, 0x89, 0x14,
  0x48, 0xC2, 0x44, 0x20, 0x20, 0x26, 0x08, 0xC1, 0x18, 0x24, 0x84, 0x90,
  0x92, 0x22, 0x24, 0x44, 0x90, 0x92, 0x0A, 0x41, 0x88, 0x31, 0x02, 0x00,
  0x0F, 0x04, 0x22, 0x04, 0x81, 0x40, 0x50, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x0A, 0x02, 0x41, 0x0F, 0x80, 0x3C, 0x23, 0x21, 0x21, 0x41, 0x41,
  0x41, 0x7E, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x0F, 0x04, 0x22, 0x04,
  0x81, 0x40, 0x50, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x41,
  0x0F, 0x80, 0x80, 0x10, 0x02, 0x00, 0x3C, 0x23, 0x21, 0x21, 0x41, 0x41,
  0x42, 0x7C, 0x48, 0x84, 0x84, 0x84, 0x84, 0x82, 0x0F, 0x08, 0x48, 0x04,
  0x02, 0x01, 0x00, 0x40, 0x18, 0x02, 0x01, 0x00, 0x80, 0x40, 0x27, 0xE0,
  0xFF, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x20, 0x24, 0x08, 0x81, 0x10, 0x24, 0x04, 0x80, 0x90, 0x22,
  0x04, 0x80, 0x90, 0x12, 0x04, 0x40, 0x84, 0x20, 0xF8, 0x00, 0x81, 0x81,
  0x81, 0x82, 0x82, 0x84, 0x84, 0x88, 0x88, 0x90, 0x90, 0x60, 0x40, 0x40,
  0x82, 0x06, 0x08, 0x28, 0x60, 0xA1, 0x84, 0x86, 0x12, 0x24, 0x48, 0x92,
  0x24, 0x48, 0x91, 0x42, 0x85, 0x0A, 0x18, 0x30, 0x60, 0xC1, 0x02, 0x04,
  0x00, 0x10, 0x22, 0x08, 0x22, 0x04, 0x80, 0x90, 0x0C, 0x01, 0x00, 0x20,
  0x0C, 0x02, 0x40, 0x88, 0x11, 0x04, 0x11, 0x02, 0x00, 0x81, 0x82, 0x84,
  0x84, 0x88, 0x48, 0x50, 0x60, 0x20, 0x40, 0x40, 0x40, 0x40, 0x80, 0x1F,
  0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x10, 0x08, 0x08,
  0x08, 0x07, 0xF0, 0x1E, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81,
  0x02, 0x04, 0x10, 0x20, 0x40, 0xE0, 0x92, 0x48, 0x92, 0x49, 0x12, 0x40,
  0x1E, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02,
  0x04, 0x08, 0xE0, 0x08, 0x08, 0x14, 0x24, 0x22, 0x42, 0x42, 0x81, 0xFE,
  0xA4, 0x3D, 0x43, 0x42, 0x82, 0x82, 0x82, 0x82, 0x84, 0x8C, 0x74, 0x10,
  0x08, 0x04, 0x04, 0x02, 0xF1, 0x84, 0x82, 0x41, 0x40, 0xA0, 0x50, 0x48,
  0x24, 0x25, 0xE0, 0x3E, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0xF0,
  0x00, 0x80, 0x40, 0x20, 0x23, 0xD2, 0x19, 0x05, 0x04, 0x82, 0x41, 0x20,
  0x90, 0x88, 0xC3, 0xA0, 0x3C, 0x85, 0x0C, 0x2F, 0x90, 0x20, 0x40, 0x80,
  0xF0, 0x01, 0x81, 0x01, 0x00, 0x80, 0x40, 0xF0, 0x20, 0x10, 0x08, 0x04,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x10, 0x00,
  0x1E, 0x90, 0xC8, 0x28, 0x24, 0x12, 0x09, 0x04, 0x84, 0x46, 0x1D, 0x00,
  0x80, 0x40, 0x44, 0x41, 0xC0, 0x10, 0x10, 0x10, 0x20, 0x2F, 0x31, 0x21,
  0x21, 0x41, 0x41, 0x41, 0x42, 0x42, 0x82, 0x11, 0x00, 0x22, 0x22, 0x44,
  0x44, 0x48, 0x02, 0x04, 0x00, 0x00, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20,
  0x40, 0x82, 0x04, 0x08, 0x10, 0x43, 0x00, 0x10, 0x10, 0x10, 0x20, 0x21,
  0x22, 0x24, 0x28, 0x50, 0x68, 0x48, 0x44, 0x44, 0x84, 0x11, 0x12, 0x22,
  0x22, 0x44, 0x44, 0x48, 0x2F, 0x79, 0x8C, 0x48, 0x42, 0x42, 0x14, 0x10,
  0xA1, 0x05, 0x08, 0x48, 0x42, 0x42, 0x14, 0x10, 0x80, 0x2F, 0x31, 0x21,
  0x21, 0x41, 0x41, 0x41, 0x42, 0x42, 0x82, 0x3E, 0x42, 0x41, 0x81, 0x81,
  0x82, 0x82, 0x82, 0x84, 0x78, 0x17, 0x86, 0x11, 0x04, 0x41, 0x20, 0x48,
  0x12, 0x08, 0x82, 0x21, 0x17, 0x84, 0x01, 0x00, 0x40, 0x30, 0x00, 0x3D,
  0x43, 0x41, 0x82, 0x82, 0x82, 0x82, 0x84, 0x8C, 0x74, 0x04, 0x04, 0x04,
  0x08, 0x2E, 0x60, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x00, 0x3E, 0x81,
  0x01, 0x03, 0x01, 0x01, 0x02, 0x05, 0xF0, 0x21, 0x11, 0xF4, 0x21, 0x10,
  0x84, 0x21, 0x0E, 0x00, 0x41, 0x41, 0x42, 0x42, 0x82, 0x82, 0x84, 0x84,
  0x8C, 0xF4, 0x83, 0x0A, 0x14, 0x48, 0x92, 0x24, 0x30, 0x60, 0x80, 0x84,
  0x30, 0x8A, 0x31, 0x4A, 0x29, 0x49, 0x49, 0x29, 0x45, 0x18, 0xC2, 0x10,
  0x40, 0x10, 0x88, 0x84, 0x81, 0x80, 0x80, 0x40, 0x50, 0x48, 0x42, 0x61,
  0x00, 0x10, 0x44, 0x21, 0x08, 0x44, 0x11, 0x02, 0x80, 0xA0, 0x30, 0x0C,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x0C, 0x00, 0x3E, 0x08, 0x10, 0x41,
  0x04, 0x08, 0x20, 0x81, 0xF0, 0x02, 0x18, 0x20, 0x41, 0x02, 0x04, 0x08,
  0x61, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x30, 0xFF, 0xFF, 0xE0, 0x18,
  0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x06, 0x10, 0x40, 0x81, 0x02, 0x04,
  0x10, 0xC0, 0x70, 0x8F,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 14, 4, 0, -14 },
  { 8, 4, 5, 6, 2, -14 },
  { 11, 10, 14, 10, 0, -14 },
  { 29, 8, 15, 9, 1, -14 },
  { 44, 11, 14, 13, 1, -14 },
  { 64, 10, 14, 11, 0, -14 },
  { 82, 2, 5, 3, 2, -14 },
  { 84, 5, 17, 5, 1, -14 },
  { 95, 5, 17, 5, -1, -14 },
  { 106, 7, 7, 9, 2, -14 },
  { 113, 8, 9, 10, 1, -11 },
  { 122, 3, 4, 4, -1, -2 },
  { 124, 4, 1, 6, 1, -6 },
  { 125, 2, 1, 4, 0, -1 },
  { 126, 8, 14, 6, -1, -14 },
  { 140, 8, 14, 9, 1, -14 },
  { 154, 4, 14, 9, 3, -14 },
  { 161, 9, 14, 9, 0, -14 },
  { 177, 9, 14, 9, 0, -14 },
  { 193, 9, 14, 9, 0, -14 },
  { 209, 9, 14, 9, 0, -14 },
  { 225, 8, 14, 9, 1, -14 },
  { 239, 7, 14, 9, 2, -14 },
  { 252, 9, 14, 9, 0, -14 },
  { 268, 8, 14, 9, 1, -14 },
  { 282, 3, 10, 4, 0, -10 },
  { 286, 4, 12, 4, -1, -10 },
  { 292, 8, 8, 10, 1, -11 },
  { 300, 8, 5, 10, 1, -9 },
  { 305, 8, 8, 10, 1, -11 },
  { 313, 6, 14, 7, 1, -14 },
  { 324, 12, 16, 14, 1, -14 },
  { 348, 9, 14, 9, -1, -14 },
  { 364, 9, 14, 10, 1, -14 },
  { 380, 10, 14, 10, 1, -14 },
  { 398, 9, 14, 11, 1, -14 },
  { 414, 8, 14, 9, 1, -14 },
  { 428, 8, 14, 8, 1, -14 },
  { 442, 10, 14, 11, 1, -14 },
  { 460, 10, 14, 11, 1, -14 },
  { 478, 6, 14, 5, 0, -14 },
  { 489, 7, 17, 4, -3, -14 },
  { 504, 10, 14, 9, 1, -14 },
  { 522, 6, 14, 8, 1, -14 },
  { 533, 13, 14, 14, 1, -14 },
  { 556, 11, 14, 11, 1, -14 },
  { 576, 10, 14, 12, 1, -14 },
  { 594, 8, 14, 9, 1, -14 },
  { 608, 10, 17, 12, 1, -14 },
  { 630, 8, 14, 9, 1, -14 },
  { 644, 9, 14, 8, 0, -14 },
  { 660, 8, 14, 8, 2, -14 },
  { 674, 11, 14, 11, 1, -14 },
  { 694, 8, 14, 9, 2, -14 },
  { 708, 14, 14, 14, 2, -14 },
  { 733, 11, 14, 8, -1, -14 },
  { 753, 8, 14, 8, 2, -14 },
  { 767, 9, 14, 9, 0, -14 },
  { 783, 7, 17, 6, 0, -14 },
  { 798, 3, 14, 6, 2, -14 },
  { 804, 7, 17, 6, -1, -14 },
  { 819, 8, 8, 9, 1, -14 },
  { 827, 7, 1, 6, -2, 2 },
  { 828, 2, 3, 4, 3, -15 },
  { 829, 8, 10, 9, 1, -10 },
  { 839, 9, 14, 10, 0, -14 },
  { 855, 7, 10, 7, 1, -10 },
  { 864, 9, 14, 10, 1, -14 },
  { 880, 7, 10, 8, 1, -10 },
  { 889, 9, 20, 5, -2, -15 },
  { 912, 9, 15, 10, 0, -10 },
  { 929, 8, 14, 9, 0, -14 },
  { 943, 4, 14, 4, 0, -14 },
  { 950, 7, 19, 4, -3, -14 },
  { 967, 8, 14, 8, 0, -14 },
  { 981, 4, 14, 4, 0, -14 },
  { 988, 13, 10, 14, 0, -10 },
  { 1005, 8, 10, 9, 0, -10 },
  { 1015, 8, 10, 9, 1, -10 },
  { 1025, 10, 14, 10, -1, -10 },
  { 1043, 8, 14, 10, 1, -10 },
  { 1057, 7, 10, 6, 0, -10 },
  { 1066, 7, 10, 7, 0, -10 },
  { 1075, 5, 13, 5, 1, -13 },
  { 1084, 8, 10, 9, 1, -10 },
  { 1094, 7, 10, 7, 1, -10 },
  { 1103, 11, 10, 11, 1, -10 },
  { 1117, 9, 10, 8, -1, -10 },
  { 1129, 10, 15, 7, -2, -10 },
  { 1148, 7, 10, 7, 0, -10 },
  { 1157, 7, 17, 6, 0, -14 },
  { 1172, 1, 19, 9, 4, -14 },
  { 1175, 7, 17, 6, -1, -14 },
  { 1190, 8, 2, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC19PT7B_H_
