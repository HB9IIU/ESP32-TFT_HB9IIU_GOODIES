#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC71PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x10, 0x00, 0x0E, 0x07, 0x87, 0x03,
  0x87, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x60, 0xE0, 0x30, 0x60, 0x38, 0x70,
  0x1C, 0x38, 0x0E, 0x1C, 0x06, 0x0C, 0x03, 0x06, 0x03, 0x83, 0x01, 0xC3,
  0x80, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x38, 0x30, 0x18, 0x30, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x78, 0x30, 0x38,
  0x01, 0xC0, 0x60, 0x10, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x38, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x00, 0xF9,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0x8F,
  0x00, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x06, 0x0F, 0x00, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x03, 0x01, 0xE0, 0x20, 0x06, 0x07, 0x80, 0x78,
  0x0C, 0x3E, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1C, 0x01,
  0xFF, 0x80, 0x00, 0x18, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x07, 0x01, 0xC0,
  0x00, 0x70, 0x07, 0x00, 0xC0, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x00, 0xE0,
  0x0C, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x01, 0x80, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x00, 0xC0, 0x1C, 0x00, 0x70,
  0x00, 0xC0, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x30, 0x00, 0x60, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x01, 0x80, 0xE0, 0x00,
  0xE0, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x03,
  0x83, 0x81, 0xF8, 0xE0, 0x03, 0x03, 0x07, 0xFC, 0xE0, 0x07, 0x07, 0x0F,
  0x9E, 0xE0, 0x07, 0x0E, 0x1C, 0x0E, 0xE0, 0x0E, 0x0C, 0x38, 0x07, 0xE0,
  0x0E, 0x1C, 0x38, 0x07, 0xE0, 0x1C, 0x38, 0x70, 0x03, 0x70, 0x38, 0x30,
  0x60, 0x03, 0x78, 0x70, 0x70, 0xE0, 0x03, 0x3F, 0xE0, 0xE0, 0xE0, 0x03,
  0x1F, 0xC0, 0xC0, 0xC0, 0x03, 0x00, 0x01, 0xC1, 0xC0, 0x03, 0x00, 0x03,
  0x81, 0xC0, 0x07, 0x00, 0x03, 0x01, 0x80, 0x07, 0x00, 0x07, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x06, 0x00,
  0x1C, 0x03, 0x80, 0x06, 0x00, 0x18, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x03,
  0x00, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x03, 0x00, 0x38, 0x03, 0x80, 0x03, 0x00, 0x30, 0x07, 0x00, 0x03, 0x00,
  0x70, 0x06, 0x00, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x1C,
  0x00, 0x01, 0xFF, 0x80, 0x38, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x1D,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xB8, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0xE0,
  0x01, 0xC3, 0x80, 0x1C, 0x00, 0x30, 0xE0, 0x01, 0xC0, 0x0E, 0x38, 0x00,
  0x1C, 0x01, 0x87, 0x00, 0x03, 0x80, 0x71, 0xC0, 0x00, 0x38, 0x0C, 0x30,
  0x00, 0x07, 0x03, 0x8E, 0x00, 0x00, 0x70, 0xE1, 0xC0, 0x00, 0x0E, 0x1C,
  0x38, 0x00, 0x00, 0xE7, 0x06, 0x00, 0x00, 0x1D, 0xC0, 0xC0, 0x00, 0x01,
  0xF8, 0x18, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0xF8, 0x0E, 0x00, 0x00, 0x3F, 0x01, 0xE0, 0x00, 0x0E, 0x70, 0x1C,
  0x00, 0x07, 0x8E, 0x03, 0xC0, 0x01, 0xE0, 0xE0, 0x3E, 0x01, 0xF0, 0x1C,
  0x03, 0xFF, 0xFC, 0x01, 0xC0, 0x1F, 0xFE, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x70, 0xC1,
  0x83, 0x0E, 0x18, 0x30, 0x60, 0xC3, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x02,
  0x00, 0x30, 0x01, 0xC0, 0x18, 0x00, 0xF0, 0x0C, 0x00, 0x3E, 0x06, 0x00,
  0x07, 0xC6, 0x00, 0x00, 0xF3, 0x00, 0x70, 0x1F, 0x9F, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xCC, 0x00, 0x01, 0xC3,
  0x00, 0x01, 0xC1, 0x80, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x30, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x06, 0x00, 0x40, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x70, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0,
  0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE4, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x00, 0xE0, 0x07,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x38,
  0x60, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7F, 0x00,
  0xF6, 0x03, 0xE6, 0x07, 0x8E, 0x0F, 0x0E, 0x3C, 0x0E, 0x78, 0x0C, 0xE0,
  0x1C, 0x40, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x40, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0xF0, 0x01, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1E, 0x02, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x60, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x03,
  0x80, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x01, 0x80, 0x38, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1D, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x02, 0x00, 0x00, 0x78, 0x01, 0x80, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0x00, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x1F, 0xF0, 0x00, 0xE1, 0xFF, 0xF0,
  0x03, 0x0F, 0x83, 0xE0, 0x0C, 0xF0, 0x03, 0xC0, 0x77, 0x00, 0x07, 0x81,
  0xD8, 0x00, 0x0E, 0x06, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x30, 0xE0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x1C, 0x30, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x07, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0,
  0x1E, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0x03,
  0xF0, 0x1E, 0x00, 0x0E, 0xE0, 0x1E, 0x00, 0x39, 0xC0, 0x1E, 0x01, 0xE3,
  0x00, 0x1F, 0xFF, 0x8E, 0x00, 0x1F, 0xFC, 0x1C, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0xC0, 0x1F, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x78, 0x0F, 0x80,
  0xF8, 0x07, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7E,
  0x07, 0xC0, 0x60, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x7F, 0xE0, 0x03, 0x03, 0x80, 0x03, 0xFF, 0xF0, 0x07, 0x0E, 0x00, 0x0F,
  0x01, 0xE0, 0x0E, 0x1C, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x70, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x71, 0x80, 0x0E, 0x00,
  0x18, 0x00, 0xE7, 0x00, 0x38, 0x00, 0x30, 0x01, 0xCE, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x18, 0x01, 0xC0, 0x01, 0xC0, 0x06, 0x70, 0x03, 0x80, 0x03,
  0x00, 0x0C, 0xE0, 0x0E, 0x00, 0x06, 0x00, 0x39, 0xC0, 0x1C, 0x00, 0x1C,
  0x00, 0x73, 0x00, 0x30, 0x00, 0x38, 0x00, 0xE6, 0x00, 0x60, 0x00, 0x60,
  0x01, 0x8C, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x38, 0x03, 0x80, 0x03, 0x80,
  0x0E, 0x70, 0x07, 0x00, 0x07, 0x00, 0x18, 0xE0, 0x0E, 0x00, 0x1C, 0x00,
  0x71, 0xC0, 0x18, 0x00, 0x38, 0x00, 0xC3, 0x80, 0x30, 0x00, 0xF0, 0x03,
  0x87, 0x00, 0x70, 0x01, 0xE0, 0x06, 0x0E, 0x00, 0xE0, 0x06, 0xC0, 0x1C,
  0x1C, 0x01, 0xC0, 0x1D, 0x80, 0x70, 0x38, 0x01, 0xC0, 0x73, 0x81, 0xC0,
  0x70, 0x03, 0xC1, 0xC3, 0x8F, 0x00, 0xE0, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x1F, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x3E, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x7C,
  0x01, 0xC0, 0x00, 0x7E, 0x00, 0x60, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x60,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x04, 0x00,
  0x07, 0xC0, 0x07, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0xFC,
  0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0xC0,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x3C, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x03, 0xE0, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x00,
  0x60, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x01,
  0xF0, 0x00, 0x01, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xF1, 0xC0, 0x00, 0x1F,
  0xFF, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0x00, 0x60, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x70, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x08, 0x0F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x60, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x18,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x3C, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x78, 0x00, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x00, 0x0E, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0xF8, 0x00, 0x00, 0x00, 0xE7, 0xE0, 0x00, 0x00,
  0x03, 0x9F, 0x80, 0x00, 0x00, 0x0C, 0xE7, 0x00, 0x00, 0x00, 0x77, 0x1C,
  0x00, 0x00, 0x01, 0xF8, 0x38, 0x00, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x36, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x0D, 0x80, 0x00, 0x00,
  0x07, 0x60, 0x03, 0x70, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xDC, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x77, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x00,
  0x00, 0x1C, 0xC0, 0x06, 0x30, 0x00, 0x00, 0x06, 0x30, 0x01, 0x8C, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0xE3, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x00, 0x00, 0x38, 0x60, 0x03, 0x0E,
  0x00, 0x00, 0x0E, 0x38, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x70,
  0xE0, 0x00, 0x01, 0xC3, 0x80, 0x1C, 0x18, 0x00, 0x00, 0xE0, 0xE0, 0x07,
  0x06, 0x00, 0x00, 0x38, 0x30, 0x01, 0x81, 0x80, 0x00, 0x1C, 0x1C, 0x00,
  0xE0, 0x60, 0x00, 0x06, 0x07, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0,
  0x0E, 0x07, 0x00, 0x01, 0xC0, 0x60, 0x03, 0x01, 0xC0, 0x00, 0x70, 0x18,
  0x00, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x03,
  0x80, 0x1C, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xC0, 0x01, 0xC0,
  0x30, 0x01, 0x80, 0x30, 0x00, 0xE0, 0x0C, 0x00, 0x60, 0x0E, 0x00, 0x30,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x07, 0x00, 0x0C, 0x00, 0x60, 0x01, 0xC1, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0x70, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x70, 0x03, 0x80,
  0x03, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x33, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x0D, 0xC0, 0x00, 0xE0, 0x07,
  0x00, 0x03, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x3E, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x07,
  0xC0, 0x00, 0x00, 0x70, 0x03, 0xE0, 0x00, 0x00, 0x30, 0x01, 0xB0, 0x00,
  0x00, 0x38, 0x00, 0xDC, 0x00, 0x00, 0x1C, 0x00, 0xEE, 0x00, 0x00, 0x0E,
  0x00, 0x73, 0x00, 0x00, 0x06, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x00, 0x18,
  0xE0, 0x00, 0x03, 0x80, 0x0C, 0x30, 0x00, 0x01, 0xC0, 0x0E, 0x1C, 0x00,
  0x00, 0xE0, 0x07, 0x0E, 0x00, 0x00, 0x60, 0x03, 0x83, 0x00, 0x00, 0x70,
  0x01, 0x81, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x00, 0xE0,
  0x30, 0x00, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x06, 0x00, 0x38, 0x0E, 0x00,
  0x07, 0x00, 0x18, 0x03, 0x00, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0x00, 0x30, 0x00, 0x60, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00,
  0x30, 0x00, 0x30, 0x07, 0x00, 0x18, 0x00, 0x1C, 0x03, 0x80, 0x1C, 0x00,
  0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x00, 0xC0, 0x07, 0x00, 0x01, 0xC0,
  0xE0, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x00, 0x30, 0x38, 0x01,
  0xC0, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x0C, 0x00, 0x70, 0x00,
  0x03, 0x0E, 0x00, 0x30, 0x00, 0x01, 0xC7, 0x00, 0x38, 0x00, 0x00, 0xE3,
  0x80, 0x1C, 0x00, 0x00, 0x31, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0xC0, 0x07,
  0x00, 0x00, 0x0E, 0xE0, 0x03, 0x00, 0x00, 0x03, 0x70, 0x03, 0x80, 0x00,
  0x01, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x60, 0x00, 0x00, 0x1E, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x1F, 0x80, 0x03,
  0x80, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x78, 0x01, 0x80, 0x00, 0xF8, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x03,
  0x98, 0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x1F, 0x80, 0x03, 0x80,
  0x01, 0xE0, 0x01, 0xC0, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xF0,
  0x01, 0x80, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x10, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x01, 0x80, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x03,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0x30, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0x30, 0x00, 0x03, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xCE,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x63, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07,
  0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC0, 0xE0, 0x00,
  0xE0, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x0E, 0x00,
  0x0C, 0x0E, 0x00, 0x0C, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x00, 0xE0,
  0x01, 0x80, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x0E,
  0x00, 0x38, 0x06, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x60, 0x07, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80,
  0x0E, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x03, 0x80, 0x30, 0x01, 0x80, 0x30,
  0x00, 0xE0, 0x1C, 0x00, 0x60, 0x1C, 0x00, 0x38, 0x06, 0x00, 0x18, 0x07,
  0x00, 0x0E, 0x03, 0x80, 0x06, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x01, 0x80,
  0xE0, 0x00, 0xE0, 0x70, 0x00, 0x60, 0x30, 0x00, 0x38, 0x1C, 0x00, 0x18,
  0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x01, 0x83, 0x80, 0x01,
  0x83, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x70, 0x00,
  0x18, 0x70, 0x00, 0x06, 0x18, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x8E, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x63, 0x00, 0x00, 0x63, 0x80, 0x00, 0x19, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x06, 0x70, 0x00, 0x01, 0x98,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xF0, 0xC0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x70, 0x07, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x60, 0x0E, 0x00, 0x01, 0x80, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01,
  0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x1C, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x38,
  0x03, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x1C, 0x07,
  0x01, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x00, 0x07, 0xF8,
  0x0C, 0x00, 0x7F, 0xF8, 0x30, 0x03, 0xE0, 0xF0, 0xC0, 0x3E, 0x00, 0xC7,
  0x01, 0xE0, 0x01, 0x98, 0x07, 0x00, 0x06, 0x60, 0x38, 0x00, 0x0D, 0x81,
  0xC0, 0x00, 0x3E, 0x07, 0x00, 0x00, 0xF8, 0x38, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x78, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x7C, 0x0E, 0x00, 0x01, 0xF0, 0x18, 0x00, 0x0D, 0xC0, 0x70, 0x00, 0x76,
  0x01, 0xC0, 0x03, 0x98, 0x03, 0x80, 0x1C, 0x60, 0x0F, 0x01, 0xE1, 0x80,
  0x1F, 0xFF, 0x0E, 0x00, 0x1F, 0xF0, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x3F, 0xC0, 0x00, 0xE0, 0xFF, 0xE0,
  0x00, 0xE3, 0xE0, 0xF8, 0x00, 0xC7, 0x80, 0x38, 0x00, 0xCE, 0x00, 0x1C,
  0x01, 0xDC, 0x00, 0x1C, 0x01, 0xD8, 0x00, 0x0E, 0x01, 0xF8, 0x00, 0x0E,
  0x01, 0xF0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x06, 0x03, 0xE0, 0x00, 0x06,
  0x03, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x06,
  0x07, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x36, 0x00, 0x01, 0xC0,
  0x36, 0x00, 0x03, 0x80, 0x77, 0x00, 0x07, 0x00, 0x73, 0x80, 0x0F, 0x00,
  0x61, 0xC0, 0x3E, 0x00, 0x60, 0xFF, 0xF8, 0x00, 0xE0, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03,
  0xF0, 0x38, 0x03, 0xE0, 0x02, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x01, 0x00, 0x7C, 0x01,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFC, 0x0E, 0x00,
  0x07, 0xFF, 0x83, 0x80, 0x03, 0xF0, 0xF0, 0xC0, 0x03, 0xE0, 0x0E, 0x30,
  0x01, 0xE0, 0x01, 0xDC, 0x00, 0x70, 0x00, 0x37, 0x00, 0x38, 0x00, 0x07,
  0xC0, 0x1C, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x1C, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x18, 0x07,
  0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00,
  0x78, 0x03, 0x80, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x38, 0x00,
  0x03, 0xE0, 0x0E, 0x00, 0x01, 0xF8, 0x01, 0x80, 0x00, 0xEC, 0x00, 0x70,
  0x00, 0x73, 0x00, 0x1C, 0x00, 0x38, 0xC0, 0x03, 0x80, 0x1C, 0x70, 0x00,
  0xF0, 0x1E, 0x1C, 0x00, 0x1F, 0xFF, 0x06, 0x00, 0x01, 0xFF, 0x01, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xF0, 0xF8, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x01, 0xC0, 0x70, 0x00,
  0x70, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x8E,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0xF0, 0x70, 0x01, 0xF8,
  0x1C, 0x07, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x80, 0x3C,
  0x01, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xF0, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xCF, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x01,
  0x80, 0x03, 0xFF, 0xC1, 0xC0, 0x03, 0xF0, 0xF0, 0xE0, 0x07, 0xC0, 0x1C,
  0x60, 0x07, 0x80, 0x07, 0x30, 0x03, 0x80, 0x01, 0xB8, 0x03, 0x80, 0x00,
  0x7C, 0x03, 0x80, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x78, 0x07,
  0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x1F, 0x00,
  0xE0, 0x00, 0x1F, 0x80, 0x30, 0x00, 0x1D, 0x80, 0x1C, 0x00, 0x1C, 0xC0,
  0x0E, 0x00, 0x1C, 0xE0, 0x03, 0x80, 0x1C, 0x70, 0x01, 0xE0, 0x3C, 0x30,
  0x00, 0x7F, 0xFC, 0x18, 0x00, 0x0F, 0xF8, 0x1C, 0x00, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x20, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x7F, 0x80, 0x0E, 0x0F, 0xFF,
  0x00, 0x71, 0xF0, 0xFC, 0x03, 0x1E, 0x00, 0xE0, 0x19, 0xC0, 0x03, 0x81,
  0xDC, 0x00, 0x1C, 0x0E, 0xC0, 0x00, 0xE0, 0x6C, 0x00, 0x03, 0x03, 0xC0,
  0x00, 0x18, 0x1E, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x03, 0x83, 0x00, 0x00, 0x18, 0x38, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x03, 0x83, 0x00, 0x00, 0x18, 0x38, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x77, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x01, 0x80, 0x1C, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x0C, 0x0F, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x18, 0x7C, 0x00, 0x00, 0x63, 0xF0,
  0x00, 0x03, 0x9D, 0xC0, 0x00, 0x0E, 0xE3, 0x80, 0x00, 0x37, 0x0E, 0x00,
  0x00, 0xF8, 0x18, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x70, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x30, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x60, 0x07, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0xE1, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xC3, 0xC3, 0xE0, 0x7C,
  0x3E, 0x00, 0xC7, 0x00, 0xF0, 0xE0, 0x0E, 0x00, 0xCE, 0x00, 0x71, 0xC0,
  0x07, 0x01, 0xD8, 0x00, 0x33, 0x80, 0x07, 0x01, 0xF8, 0x00, 0x37, 0x00,
  0x07, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x03, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x3F, 0xC0, 0x03,
  0x83, 0xFF, 0xC0, 0x0C, 0x3E, 0x1F, 0x80, 0x31, 0xE0, 0x0E, 0x00, 0xCE,
  0x00, 0x1C, 0x07, 0x70, 0x00, 0x70, 0x1F, 0x80, 0x01, 0xC0, 0x6C, 0x00,
  0x03, 0x01, 0xE0, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x03, 0x80, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xF8, 0x00, 0x03, 0x83, 0xFF,
  0xC0, 0x00, 0x61, 0xF0, 0x7C, 0x00, 0x0C, 0x78, 0x03, 0x80, 0x01, 0x9C,
  0x00, 0x38, 0x00, 0x73, 0x00, 0x07, 0x00, 0x0E, 0xC0, 0x00, 0x70, 0x01,
  0xB8, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x18,
  0x01, 0xF0, 0x00, 0x03, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x30, 0x07, 0x00,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x03,
  0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x36, 0x00, 0x01, 0xC0,
  0x06, 0xC0, 0x00, 0x70, 0x01, 0xDC, 0x00, 0x1C, 0x00, 0x39, 0xC0, 0x07,
  0x80, 0x07, 0x1C, 0x03, 0xC0, 0x00, 0xE1, 0xFF, 0xF0, 0x00, 0x18, 0x1F,
  0xF8, 0x00, 0x07, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x06, 0x00, 0x3F, 0xFC, 0x1C, 0x00, 0xFC, 0x3C,
  0x38, 0x07, 0xC0, 0x1C, 0x60, 0x1E, 0x00, 0x1C, 0xC0, 0x38, 0x00, 0x1B,
  0x80, 0xE0, 0x00, 0x1F, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0xF8, 0x1C, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x07,
  0xE0, 0x30, 0x00, 0x1D, 0x80, 0x70, 0x00, 0x73, 0x00, 0xE0, 0x01, 0xCE,
  0x00, 0xE0, 0x07, 0x1C, 0x01, 0xE0, 0x3C, 0x38, 0x01, 0xFF, 0xF0, 0x60,
  0x00, 0xFF, 0x81, 0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0xFE, 0x03, 0x87, 0xFC, 0x06, 0x1F, 0x98, 0x0C, 0x78, 0x00, 0x19,
  0xC0, 0x00, 0x77, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xC0, 0xFC, 0x07,
  0x80, 0x06, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x03, 0xC0, 0x0F, 0x80, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0x80, 0x00, 0x1E, 0x06, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x7C,
  0x0E, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x0D, 0x80, 0xE0, 0x00, 0x66, 0x03,
  0xC0, 0x03, 0x98, 0x07, 0x00, 0x1C, 0xE0, 0x1F, 0x01, 0xE3, 0x00, 0x3F,
  0xFE, 0x0C, 0x00, 0x7F, 0xF0, 0x30, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1C,
  0xE0, 0x00, 0x07, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x81, 0x80,
  0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0C, 0x01,
  0xC0, 0x07, 0x00, 0x70, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x00, 0xC0, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x01,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03,
  0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00,
  0x01, 0x9C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06, 0xE0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xB8, 0x00, 0x0F, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x80, 0x00, 0xEE,
  0x00, 0x07, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x60, 0x00, 0x73, 0x80, 0x03,
  0xB0, 0x00, 0x71, 0xC0, 0x01, 0x98, 0x00, 0x38, 0xE0, 0x01, 0xCC, 0x00,
  0x18, 0x70, 0x00, 0xE6, 0x00, 0x1C, 0x38, 0x00, 0x63, 0x00, 0x0C, 0x1C,
  0x00, 0x71, 0xC0, 0x0E, 0x06, 0x00, 0x30, 0xE0, 0x07, 0x03, 0x00, 0x38,
  0x70, 0x07, 0x01, 0x80, 0x18, 0x38, 0x03, 0x80, 0xC0, 0x1C, 0x1C, 0x01,
  0x80, 0x60, 0x0C, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x07, 0x00, 0xC0, 0x18,
  0x06, 0x03, 0x80, 0xE0, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x06, 0x03, 0x00,
  0x60, 0x70, 0x03, 0x03, 0x80, 0x30, 0x38, 0x01, 0x81, 0x80, 0x18, 0x38,
  0x00, 0xC1, 0xC0, 0x0C, 0x1C, 0x00, 0x60, 0xE0, 0x06, 0x0C, 0x00, 0x30,
  0xE0, 0x03, 0x0E, 0x00, 0x18, 0x70, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00,
  0xC7, 0x00, 0x07, 0x38, 0x00, 0x63, 0x00, 0x03, 0x98, 0x00, 0x33, 0x80,
  0x01, 0xDC, 0x00, 0x19, 0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x00, 0x7E,
  0x00, 0x06, 0xE0, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x03, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x38, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x18, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x38, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC7, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x06, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x04, 0xFF, 0xF8, 0x00, 0x37, 0x81, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x1E, 0xC0, 0x00, 0xFF, 0xF2, 0x00, 0x00, 0xFF, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 14, 52, 15, 2, -51 },
  { 92, 17, 19, 22, 7, -51 },
  { 133, 37, 51, 38, 2, -51 },
  { 369, 31, 58, 34, 2, -54 },
  { 594, 40, 52, 49, 5, -51 },
  { 854, 35, 52, 40, 2, -51 },
  { 1082, 7, 19, 12, 7, -51 },
  { 1099, 20, 62, 18, 2, -51 },
  { 1254, 20, 62, 18, -5, -51 },
  { 1409, 25, 27, 33, 9, -54 },
  { 1494, 30, 33, 36, 4, -42 },
  { 1618, 10, 17, 13, -3, -8 },
  { 1640, 17, 3, 21, 2, -21 },
  { 1647, 4, 6, 14, 2, -5 },
  { 1650, 31, 51, 22, -3, -51 },
  { 1848, 30, 52, 34, 3, -51 },
  { 2043, 16, 51, 34, 10, -51 },
  { 2145, 33, 51, 34, -1, -51 },
  { 2356, 33, 52, 34, 0, -51 },
  { 2571, 32, 51, 34, 0, -51 },
  { 2775, 33, 52, 34, 1, -51 },
  { 2990, 30, 52, 34, 4, -51 },
  { 3185, 29, 51, 34, 6, -51 },
  { 3370, 31, 52, 34, 2, -51 },
  { 3572, 31, 52, 34, 2, -51 },
  { 3774, 12, 39, 14, 1, -38 },
  { 3833, 16, 47, 14, -3, -38 },
  { 3927, 30, 31, 36, 4, -41 },
  { 4044, 30, 18, 36, 4, -34 },
  { 4112, 30, 31, 36, 4, -41 },
  { 4229, 23, 52, 25, 4, -51 },
  { 4379, 47, 56, 51, 3, -50 },
  { 4708, 34, 51, 34, -4, -51 },
  { 4925, 34, 51, 37, 2, -51 },
  { 5142, 35, 52, 36, 5, -51 },
  { 5370, 37, 51, 41, 2, -51 },
  { 5606, 33, 51, 33, 2, -51 },
  { 5817, 33, 51, 30, 2, -51 },
  { 6028, 37, 52, 43, 5, -51 },
  { 6269, 41, 51, 42, 2, -51 },
  { 6531, 23, 51, 18, -1, -51 },
  { 6678, 27, 64, 15, -11, -51 },
  { 6894, 38, 51, 34, 2, -51 },
  { 7137, 23, 51, 30, 2, -51 },
  { 7284, 50, 51, 52, 2, -51 },
  { 7603, 41, 51, 43, 2, -51 },
  { 7865, 37, 52, 44, 5, -51 },
  { 8106, 33, 51, 35, 2, -51 },
  { 8317, 37, 63, 44, 5, -51 },
  { 8609, 33, 51, 35, 2, -51 },
  { 8820, 33, 52, 32, 0, -51 },
  { 9035, 30, 51, 30, 6, -51 },
  { 9227, 38, 52, 42, 5, -51 },
  { 9474, 32, 51, 34, 7, -51 },
  { 9678, 50, 51, 53, 8, -51 },
  { 9997, 40, 51, 31, -4, -51 },
  { 10252, 30, 51, 30, 6, -51 },
  { 10444, 36, 51, 32, -1, -51 },
  { 10674, 26, 62, 21, -1, -51 },
  { 10876, 11, 51, 23, 7, -51 },
  { 10947, 26, 62, 21, -5, -51 },
  { 11149, 30, 29, 35, 3, -51 },
  { 11258, 24, 2, 24, -6, 7 },
  { 11264, 9, 11, 16, 10, -54 },
  { 11277, 30, 39, 35, 3, -38 },
  { 11424, 32, 55, 36, 1, -54 },
  { 11644, 26, 39, 28, 3, -38 },
  { 11771, 34, 55, 36, 3, -54 },
  { 12005, 26, 39, 31, 3, -38 },
  { 12132, 36, 71, 17, -9, -54 },
  { 12452, 33, 55, 36, 1, -38 },
  { 12679, 29, 54, 35, 2, -54 },
  { 12875, 14, 51, 14, 1, -51 },
  { 12965, 25, 68, 14, -10, -51 },
  { 13178, 30, 54, 28, 1, -54 },
  { 13381, 15, 54, 14, 1, -54 },
  { 13483, 48, 38, 53, 1, -38 },
  { 13711, 30, 38, 35, 1, -38 },
  { 13854, 29, 39, 35, 3, -38 },
  { 13996, 35, 54, 36, -2, -38 },
  { 14233, 31, 55, 36, 3, -38 },
  { 14447, 23, 38, 23, 2, -38 },
  { 14557, 26, 39, 26, 0, -38 },
  { 14684, 18, 48, 19, 3, -47 },
  { 14792, 30, 39, 35, 3, -38 },
  { 14939, 26, 38, 26, 4, -38 },
  { 15063, 41, 38, 42, 4, -38 },
  { 15258, 33, 38, 28, -3, -38 },
  { 15415, 38, 55, 27, -8, -38 },
  { 15677, 28, 38, 26, -1, -38 },
  { 15810, 25, 62, 23, 2, -51 },
  { 16004, 3, 71, 33, 16, -54 },
  { 16031, 25, 62, 23, -4, -51 },
  { 16225, 30, 6, 36, 4, -28 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic71pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC71PT7B_H_
