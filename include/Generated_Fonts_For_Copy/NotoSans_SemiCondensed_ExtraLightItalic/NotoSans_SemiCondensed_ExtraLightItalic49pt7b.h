#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC49PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x38, 0x0E, 0x00, 0x38, 0x66, 0x0C,
  0xC1, 0x98, 0x62, 0x0C, 0xC1, 0x98, 0x33, 0x04, 0x40, 0x88, 0x31, 0x06,
  0x60, 0x8C, 0x10, 0x00, 0x0C, 0x02, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x20, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01,
  0x00, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00,
  0x02, 0x01, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x60, 0x30, 0x00, 0x10, 0x08,
  0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x80, 0x60, 0x00, 0x60,
  0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x00, 0x80, 0x00,
  0xC0, 0x60, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x06, 0x03, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x30, 0x08, 0x00, 0x0C, 0x06,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x80, 0x40, 0x00, 0x60, 0x30, 0x00, 0x18,
  0x0C, 0x00, 0x04, 0x02, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0xF0, 0x1C, 0x61, 0x80, 0xC1, 0x80, 0x06, 0x04, 0x00, 0x18, 0x10,
  0x00, 0x60, 0x40, 0x01, 0x03, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x20, 0x00,
  0x60, 0x80, 0x01, 0xC6, 0x00, 0x03, 0x98, 0x00, 0x07, 0x60, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xDC, 0x00, 0x03, 0x18,
  0x00, 0x08, 0x30, 0x00, 0x20, 0xC0, 0x01, 0x81, 0x00, 0x06, 0x04, 0x00,
  0x10, 0x30, 0x00, 0x40, 0xC0, 0x01, 0x03, 0x00, 0x0C, 0x18, 0x20, 0x30,
  0xC0, 0xE0, 0x8E, 0x01, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x60, 0x63, 0x80, 0x0C, 0x0C, 0x18, 0x01, 0x81, 0x81, 0x80,
  0x10, 0x18, 0x08, 0x03, 0x03, 0x00, 0x80, 0x60, 0x30, 0x08, 0x04, 0x02,
  0x00, 0x80, 0xC0, 0x60, 0x18, 0x18, 0x06, 0x01, 0x81, 0x80, 0x60, 0x18,
  0x30, 0x06, 0x01, 0x86, 0x00, 0x40, 0x10, 0x60, 0x04, 0x03, 0x0C, 0x00,
  0xC0, 0x31, 0x87, 0xEC, 0x02, 0x18, 0xC6, 0x40, 0x63, 0x18, 0x34, 0x04,
  0x63, 0x03, 0x60, 0xC6, 0x30, 0x37, 0x18, 0xC6, 0x03, 0x3F, 0x08, 0x60,
  0x30, 0x01, 0x84, 0x03, 0x00, 0x30, 0xC0, 0x30, 0x02, 0x0C, 0x03, 0x00,
  0x60, 0xC0, 0x30, 0x0C, 0x08, 0x03, 0x00, 0x81, 0x80, 0x20, 0x18, 0x18,
  0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0xC0, 0x18, 0x18, 0x0C, 0x00, 0xC1, 0x81, 0x80, 0x0C, 0x30, 0x30, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x0E, 0x38, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0xC0,
  0x02, 0x00, 0x60, 0x03, 0x00, 0x20, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18,
  0x00, 0x60, 0x1C, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x76, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xE0, 0xC0, 0x18, 0xE0,
  0x60, 0x18, 0xE0, 0x18, 0x0C, 0x60, 0x0C, 0x0C, 0x60, 0x03, 0x06, 0x30,
  0x01, 0x86, 0x30, 0x00, 0x63, 0x18, 0x00, 0x1B, 0x0C, 0x00, 0x0F, 0x06,
  0x00, 0x03, 0x83, 0x00, 0x03, 0x81, 0x80, 0x03, 0xE0, 0x60, 0x03, 0xB0,
  0x38, 0x03, 0x8C, 0x0F, 0x0F, 0x06, 0x03, 0xFF, 0x01, 0x80, 0x39, 0x8C,
  0x62, 0x31, 0x8C, 0x42, 0x11, 0x8C, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x08,
  0x04, 0x07, 0x06, 0x00, 0xE3, 0x00, 0x19, 0x01, 0x03, 0xBF, 0x80, 0xF8,
  0x00, 0xF0, 0x00, 0xC8, 0x00, 0xC6, 0x00, 0xC1, 0x01, 0xC0, 0xC0, 0xC0,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x18, 0x30, 0xC1, 0x83, 0x0C, 0x18, 0x60,
  0x83, 0x00, 0xFF, 0xFF, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFC, 0x00, 0x3C, 0x78, 0x03,
  0x80, 0xC0, 0x18, 0x03, 0x01, 0x80, 0x18, 0x18, 0x00, 0x40, 0xC0, 0x03,
  0x0C, 0x00, 0x18, 0x60, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80,
  0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x46, 0x00, 0x06, 0x20, 0x00, 0x33,
  0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x02, 0x30, 0x00,
  0x31, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30,
  0x00, 0x31, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x20, 0x01, 0x81, 0x80, 0x0C,
  0x0C, 0x00, 0xC0, 0x60, 0x0C, 0x01, 0x80, 0xE0, 0x07, 0x1E, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x60, 0x3C, 0x0F, 0x87, 0x21, 0xCC, 0x71, 0xB8, 0x32,
  0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xE3, 0xC0, 0x1C, 0x01, 0x80,
  0x40, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xF0, 0xF0, 0x0F, 0x00,
  0x70, 0x08, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0xC0, 0x07, 0x01, 0xF0, 0x3C, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xC8, 0x00,
  0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0xC6, 0x00, 0x06, 0x10, 0x00, 0x30,
  0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x30, 0x01, 0x80, 0x80,
  0x0C, 0x06, 0x00, 0x30, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x60,
  0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x00, 0x08,
  0x18, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xDF, 0xC0, 0x03, 0xFF, 0xC0, 0x08, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x80, 0x0E, 0x03, 0xC1, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x1F, 0xF0, 0x01, 0xE0, 0x80, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x01, 0x80, 0x0C, 0x7F, 0xC0, 0x33, 0x83, 0x80, 0xD8, 0x07,
  0x06, 0x80, 0x0C, 0x1E, 0x00, 0x18, 0x70, 0x00, 0x61, 0x80, 0x01, 0x86,
  0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00,
  0x06, 0x10, 0x00, 0x30, 0x40, 0x00, 0xC1, 0x80, 0x07, 0x06, 0x00, 0x18,
  0x18, 0x00, 0xC0, 0x30, 0x07, 0x00, 0xE0, 0x38, 0x01, 0xC3, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xC3, 0xC0,
  0x0C, 0x03, 0x80, 0x60, 0x06, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x20,
  0x00, 0xC0, 0x80, 0x03, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x30, 0x01,
  0x80, 0xC0, 0x0E, 0x01, 0x80, 0x70, 0x06, 0x03, 0x80, 0x0C, 0x18, 0x00,
  0x1D, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x38, 0x70, 0x03, 0x80,
  0xE0, 0x1C, 0x01, 0x80, 0xC0, 0x03, 0x07, 0x00, 0x06, 0x18, 0x00, 0x18,
  0x60, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0,
  0x00, 0x63, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x38, 0x03,
  0x80, 0x78, 0x78, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0x87,
  0x00, 0x70, 0x1C, 0x07, 0x00, 0x60, 0x30, 0x01, 0x83, 0x00, 0x0C, 0x38,
  0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x08, 0xC0, 0x00, 0x46, 0x00, 0x02,
  0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00,
  0x07, 0x18, 0x00, 0x78, 0x60, 0x06, 0x83, 0x80, 0x6C, 0x0E, 0x0E, 0x60,
  0x3F, 0xE3, 0x00, 0x38, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x07, 0x07, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0x07, 0x07, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0xE0, 0xE0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x3E, 0x3C, 0x10, 0x0E, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1E, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0xFE, 0x03, 0x18,
  0x03, 0xFF, 0x03, 0x18, 0x07, 0x03, 0x01, 0x30, 0x0C, 0x02, 0x01, 0x30,
  0x18, 0x06, 0x03, 0x20, 0x18, 0x06, 0x03, 0x60, 0x30, 0x06, 0x03, 0x60,
  0x20, 0x04, 0x03, 0x60, 0x60, 0x0C, 0x03, 0x40, 0x60, 0x0C, 0x03, 0xC0,
  0x40, 0x0C, 0x06, 0xC0, 0xC0, 0x08, 0x06, 0xC0, 0xC0, 0x18, 0x06, 0xC0,
  0xC0, 0x18, 0x0C, 0xC0, 0xC0, 0x38, 0x0C, 0xC0, 0xC0, 0x38, 0x18, 0xC0,
  0x60, 0x58, 0x30, 0xC0, 0x61, 0xCC, 0x70, 0xC0, 0x3F, 0x8F, 0xC0, 0x40,
  0x0C, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x08, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00,
  0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00,
  0x60, 0x40, 0x00, 0xC0, 0x80, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x18,
  0x06, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x60, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x60, 0x03, 0x01, 0x80, 0x02,
  0x03, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x60, 0x00, 0x30,
  0xC0, 0x00, 0x63, 0x00, 0x00, 0xCE, 0x00, 0x01, 0x98, 0x00, 0x03, 0x70,
  0x00, 0x06, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x08, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x0C, 0x00, 0xF0, 0x18, 0x00, 0x60, 0x30, 0x00, 0x60, 0x60,
  0x00, 0xC0, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x0C, 0x18, 0x00, 0x10, 0x60, 0x00, 0x60, 0xC0, 0x01, 0xC1, 0x80, 0x07,
  0x03, 0x00, 0x1C, 0x06, 0x01, 0xE0, 0x1F, 0xFF, 0x00, 0x30, 0x3F, 0x00,
  0x60, 0x03, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x06, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x08, 0x30, 0x00, 0x30, 0x40, 0x00, 0x61, 0x80,
  0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x30, 0x60, 0x00, 0xE0, 0xC0, 0x07, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3E, 0x0F, 0x00, 0x70, 0x01, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0xC0, 0x1E, 0x00, 0x60, 0x03, 0x80, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x38, 0x08, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06,
  0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x61, 0x80, 0x00, 0x30,
  0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x06, 0x18, 0x00, 0x06, 0x0C, 0x00,
  0x07, 0x06, 0x00, 0x07, 0x03, 0x00, 0x07, 0x03, 0x00, 0x07, 0x01, 0x80,
  0x0F, 0x00, 0xC0, 0x1E, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC3, 0xF0, 0x07, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x3F, 0xF3, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x08,
  0x1C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x1C, 0x00,
  0x38, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x30, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00,
  0x04, 0x06, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x02, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x18, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x60, 0x00, 0x08,
  0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x10, 0x18,
  0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x10, 0x70, 0x03, 0xFC, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80,
  0x60, 0x01, 0x80, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x01, 0x80,
  0x0C, 0x01, 0x80, 0x06, 0x01, 0x80, 0x03, 0x01, 0x80, 0x01, 0x81, 0x80,
  0x01, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x61, 0x80, 0x00, 0x31, 0x80,
  0x00, 0x19, 0xC0, 0x00, 0x19, 0xE0, 0x00, 0x0D, 0x98, 0x00, 0x07, 0x8C,
  0x00, 0x03, 0x86, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0,
  0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x10, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x03,
  0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x60,
  0x30, 0x00, 0x30, 0x00, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x1A, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xD0, 0x00, 0x03, 0x60,
  0x24, 0x00, 0x00, 0xD8, 0x19, 0x80, 0x00, 0x66, 0x06, 0x60, 0x00, 0x19,
  0x01, 0x98, 0x00, 0x0C, 0xC0, 0x66, 0x00, 0x06, 0x30, 0x31, 0x80, 0x01,
  0x8C, 0x0C, 0x60, 0x00, 0xC3, 0x03, 0x08, 0x00, 0x31, 0x80, 0xC2, 0x00,
  0x18, 0x60, 0x20, 0xC0, 0x06, 0x18, 0x18, 0x30, 0x03, 0x06, 0x06, 0x0C,
  0x00, 0xC1, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x60, 0xC0, 0x18, 0x30, 0x10,
  0x30, 0x0C, 0x0C, 0x0C, 0x04, 0x06, 0x03, 0x03, 0x01, 0x01, 0x80, 0x80,
  0xC0, 0x60, 0xC0, 0x60, 0x30, 0x18, 0x30, 0x18, 0x08, 0x06, 0x18, 0x06,
  0x06, 0x01, 0x86, 0x01, 0x81, 0x80, 0x63, 0x00, 0xC0, 0x60, 0x18, 0xC0,
  0x30, 0x18, 0x02, 0x60, 0x0C, 0x0C, 0x00, 0x90, 0x03, 0x03, 0x00, 0x3C,
  0x00, 0xC0, 0xC0, 0x0E, 0x00, 0x60, 0x30, 0x03, 0x80, 0x18, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x02, 0x03, 0xC0,
  0x00, 0x60, 0x3C, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x60, 0x36, 0x00, 0x06,
  0x02, 0x60, 0x00, 0x40, 0x66, 0x00, 0x0C, 0x06, 0x30, 0x00, 0xC0, 0x63,
  0x00, 0x0C, 0x06, 0x30, 0x00, 0xC0, 0xC1, 0x80, 0x18, 0x0C, 0x18, 0x01,
  0x80, 0xC1, 0x80, 0x18, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0xC0, 0x18, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x10, 0x03, 0x02, 0x03, 0x00, 0x30, 0x60, 0x30, 0x03, 0x06, 0x03,
  0x00, 0x18, 0x60, 0x30, 0x01, 0x86, 0x02, 0x00, 0x18, 0x40, 0x60, 0x00,
  0xCC, 0x06, 0x00, 0x0C, 0xC0, 0x60, 0x00, 0xCC, 0x06, 0x00, 0x06, 0xC0,
  0xC0, 0x00, 0x68, 0x0C, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x38, 0x0C, 0x00,
  0x03, 0x80, 0x80, 0x00, 0x38, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0x83, 0xC0, 0x03, 0x80, 0x38, 0x01, 0x80, 0x03, 0x00, 0xC0,
  0x00, 0xE0, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x30, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x37, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x38, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x07, 0x06, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0xC0, 0x38, 0x00, 0x60, 0x07, 0x00, 0x70, 0x00, 0xF8, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x30, 0x07, 0x00,
  0xC0, 0x0E, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x20, 0x00, 0xC1, 0x80,
  0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC3, 0x00, 0x03,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x0C, 0x18,
  0x00, 0x60, 0x60, 0x07, 0x01, 0x83, 0xF8, 0x07, 0xFF, 0x80, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0x83, 0xC0, 0x03, 0x80, 0x38, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0xE0,
  0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x03, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x07, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0,
  0x38, 0x00, 0x60, 0x07, 0x00, 0x70, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x30, 0x07, 0x00,
  0xC0, 0x06, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x30, 0x20, 0x00, 0xC1, 0x80,
  0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC3, 0x00, 0x03,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x03, 0x00, 0x1C, 0x18,
  0x00, 0xE0, 0x60, 0x1F, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x18, 0x0C,
  0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x18, 0x06, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80,
  0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x03,
  0x0C, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0xFC, 0x07, 0x00,
  0x10, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x80, 0x07, 0x01, 0xF8, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18,
  0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x30, 0x30, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x30,
  0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x02,
  0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xC0, 0x18, 0x00,
  0x18, 0x03, 0x80, 0x06, 0x00, 0x38, 0x03, 0x80, 0x03, 0xE3, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x04, 0x00, 0x18, 0x10, 0x00,
  0xC0, 0x40, 0x03, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x60,
  0x30, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x08, 0x30, 0x00, 0x20, 0xC0,
  0x00, 0x86, 0x00, 0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00,
  0xD8, 0x00, 0x03, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x03, 0x60, 0x00, 0xF0, 0x00, 0x6C, 0x00,
  0x1E, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x03, 0x30, 0x00, 0xD8, 0x00, 0xC6,
  0x00, 0x13, 0x00, 0x18, 0xC0, 0x06, 0x60, 0x03, 0x08, 0x00, 0xCC, 0x00,
  0xC1, 0x00, 0x31, 0x80, 0x18, 0x20, 0x06, 0x30, 0x06, 0x04, 0x01, 0x86,
  0x00, 0xC0, 0x80, 0x30, 0xC0, 0x30, 0x10, 0x0C, 0x18, 0x06, 0x02, 0x01,
  0x83, 0x00, 0x80, 0x40, 0x20, 0x60, 0x30, 0x0C, 0x0C, 0x04, 0x06, 0x01,
  0x81, 0x80, 0x81, 0x80, 0x30, 0x60, 0x10, 0x30, 0x06, 0x0C, 0x02, 0x0C,
  0x00, 0xC3, 0x00, 0x41, 0x80, 0x18, 0x60, 0x08, 0x20, 0x03, 0x18, 0x01,
  0x0C, 0x00, 0x63, 0x00, 0x21, 0x80, 0x0C, 0x40, 0x04, 0x60, 0x01, 0x98,
  0x00, 0x8C, 0x00, 0x32, 0x00, 0x13, 0x00, 0x06, 0xC0, 0x02, 0x60, 0x00,
  0xD8, 0x00, 0x48, 0x00, 0x1E, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x01, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x70, 0x06, 0x00, 0x06, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x30, 0x03, 0x80, 0x03, 0x00, 0x30,
  0x00, 0x10, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00,
  0x1C, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x30, 0x06, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x1B, 0x00, 0x01, 0x98,
  0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x18, 0x00, 0xE0, 0xC0, 0x06,
  0x06, 0x00, 0x60, 0x30, 0x07, 0x00, 0x80, 0x30, 0x06, 0x03, 0x00, 0x30,
  0x18, 0x01, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00,
  0x0C, 0xC0, 0x00, 0x66, 0x00, 0x01, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0xC1,
  0x83, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x81, 0x83, 0x06, 0x0C,
  0x18, 0x10, 0x30, 0x60, 0xC1, 0x83, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x60,
  0x40, 0x81, 0x83, 0x06, 0x0C, 0x08, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x6C, 0x00, 0x06, 0x20, 0x00, 0x31, 0x80, 0x03,
  0x0C, 0x00, 0x18, 0x20, 0x01, 0x81, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x20,
  0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00,
  0x0C, 0x30, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0D, 0x80, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE1, 0x86, 0x0C, 0x10, 0x60, 0xC0, 0x00,
  0xFE, 0x18, 0x0F, 0x38, 0xC0, 0xC0, 0x64, 0x0C, 0x01, 0xA0, 0xC0, 0x07,
  0x0C, 0x00, 0x38, 0x60, 0x01, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x00,
  0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0x63,
  0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00,
  0xE1, 0x80, 0x07, 0x0C, 0x00, 0x78, 0x60, 0x02, 0x81, 0x80, 0x24, 0x0E,
  0x07, 0x60, 0x38, 0x63, 0x00, 0xFE, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x3F, 0x80, 0x63, 0x8E, 0x03, 0x70, 0x18, 0x1B, 0x00, 0x60,
  0xB0, 0x03, 0x0F, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x80, 0x02, 0x18, 0x00,
  0x10, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x03, 0x10,
  0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x03,
  0x18, 0x00, 0x31, 0xC0, 0x01, 0x8E, 0x00, 0x18, 0x70, 0x01, 0xC2, 0xC0,
  0x1C, 0x13, 0x01, 0xC1, 0x9E, 0x3C, 0x0C, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x78, 0x60, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x1C, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0x18, 0x01, 0xE7, 0x98,
  0x03, 0x00, 0xD8, 0x06, 0x00, 0x58, 0x0C, 0x00, 0x50, 0x18, 0x00, 0x70,
  0x18, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60,
  0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0xC0,
  0xC0, 0x01, 0xC0, 0xC0, 0x03, 0x80, 0xC0, 0x07, 0x80, 0xC0, 0x05, 0x80,
  0x60, 0x0D, 0x80, 0x70, 0x39, 0x00, 0x38, 0x71, 0x00, 0x1F, 0xC3, 0x00,
  0x00, 0x7F, 0x00, 0x78, 0xE0, 0x38, 0x1C, 0x18, 0x03, 0x0C, 0x00, 0xC6,
  0x00, 0x31, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x01, 0x88, 0x00, 0xC6, 0x00,
  0xE1, 0x80, 0xF0, 0x7F, 0xF0, 0x1F, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x08, 0x1E, 0x1C, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x70, 0x80, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC2,
  0x00, 0xF3, 0xC4, 0x03, 0x00, 0xD8, 0x0C, 0x00, 0xB0, 0x30, 0x01, 0x40,
  0xC0, 0x03, 0x81, 0x80, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x30,
  0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x86, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x70, 0x60, 0x00,
  0xE0, 0xC0, 0x01, 0xC1, 0x80, 0x07, 0x03, 0x00, 0x1E, 0x06, 0x00, 0x3C,
  0x06, 0x00, 0xD8, 0x0E, 0x07, 0x20, 0x0E, 0x1C, 0xC0, 0x0F, 0xE1, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x02, 0x00,
  0x38, 0x07, 0x01, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x3F, 0x80, 0x63, 0x8F, 0x03, 0x70, 0x18,
  0x1A, 0x00, 0xC0, 0xA0, 0x03, 0x0F, 0x00, 0x18, 0x70, 0x00, 0x83, 0x00,
  0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0xC3, 0x00, 0x0C, 0x18, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60,
  0x00, 0x83, 0x00, 0x0C, 0x10, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x70, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x03, 0x06, 0x00, 0x60, 0x60, 0x0C, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C,
  0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x18, 0x00, 0xC3, 0x00, 0x08, 0x60, 0x01,
  0x8C, 0x00, 0x19, 0xC0, 0x01, 0xB6, 0x00, 0x16, 0x60, 0x03, 0xC6, 0x00,
  0x38, 0x30, 0x03, 0x03, 0x00, 0x30, 0x18, 0x02, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x40, 0x06, 0x0C, 0x00,
  0x60, 0xC0, 0x07, 0x00, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03,
  0x00, 0xC0, 0x00, 0x06, 0x1F, 0x80, 0xFE, 0x03, 0x38, 0xE1, 0xE7, 0x81,
  0xB0, 0x19, 0xC0, 0xE0, 0xB0, 0x0C, 0x80, 0x30, 0x50, 0x02, 0x80, 0x18,
  0x70, 0x01, 0xC0, 0x0C, 0x38, 0x00, 0xC0, 0x06, 0x18, 0x00, 0xE0, 0x03,
  0x0C, 0x00, 0x60, 0x01, 0x86, 0x00, 0x30, 0x00, 0x86, 0x00, 0x18, 0x00,
  0xC3, 0x00, 0x08, 0x00, 0x61, 0x80, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x00,
  0x18, 0xC0, 0x03, 0x00, 0x18, 0x60, 0x01, 0x80, 0x0C, 0x30, 0x00, 0x80,
  0x06, 0x18, 0x00, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0x01, 0x0C, 0x00, 0x30,
  0x01, 0x86, 0x00, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x00, 0x61, 0x80, 0x0C,
  0x00, 0x30, 0x80, 0x06, 0x00, 0x10, 0xC0, 0x03, 0x00, 0x18, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x06, 0x1F, 0xC0, 0x31, 0xC7, 0x81, 0xB8, 0x0C, 0x0B,
  0x00, 0x60, 0x50, 0x01, 0x87, 0x80, 0x0C, 0x38, 0x00, 0x61, 0x80, 0x06,
  0x0C, 0x00, 0x30, 0x60, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80,
  0x06, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61,
  0x80, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00,
  0x41, 0x80, 0x06, 0x08, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0x00, 0x1E, 0x3C, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x0C, 0x00,
  0x61, 0x80, 0x03, 0x18, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x36, 0x00,
  0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x00, 0xCC,
  0x00, 0x1C, 0xC0, 0x01, 0x86, 0x00, 0x30, 0x60, 0x07, 0x03, 0x00, 0xE0,
  0x3E, 0x3C, 0x00, 0xFF, 0x00, 0x01, 0x87, 0xF0, 0x03, 0x1C, 0x70, 0x06,
  0x60, 0x30, 0x09, 0x80, 0x70, 0x16, 0x00, 0x60, 0x78, 0x00, 0xC0, 0xE0,
  0x01, 0x81, 0xC0, 0x01, 0x03, 0x00, 0x02, 0x06, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x01,
  0x86, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x60,
  0xE0, 0x00, 0xC1, 0xC0, 0x03, 0x03, 0x80, 0x0E, 0x07, 0x80, 0x38, 0x09,
  0x80, 0xE0, 0x33, 0x87, 0x80, 0x61, 0xFC, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x08, 0x0F, 0x3C, 0x40, 0xC0, 0x36,
  0x0C, 0x00, 0xB0, 0xC0, 0x05, 0x0C, 0x00, 0x38, 0x60, 0x00, 0xC6, 0x00,
  0x06, 0x30, 0x00, 0x33, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6,
  0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0xC6, 0x00, 0x0E, 0x30, 0x00, 0x71, 0x80, 0x07, 0x0C, 0x00, 0x78, 0x60,
  0x03, 0xC1, 0x80, 0x36, 0x0E, 0x03, 0x20, 0x38, 0x73, 0x00, 0xFE, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x1F, 0x83, 0x3C, 0x81, 0xB8,
  0x00, 0x90, 0x00, 0x50, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xFF, 0x01, 0xE1, 0xF0, 0x60, 0x08, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC2, 0x00, 0x70, 0xF0, 0x78, 0x1F, 0xF8,
  0x00, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x7F, 0xF7,
  0xFF, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE1, 0x07,
  0xF0, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x83, 0x00, 0x0C, 0x10, 0x00, 0x61,
  0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x30, 0x00,
  0x61, 0x80, 0x03, 0x0C, 0x00, 0x10, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x30,
  0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x82, 0x00, 0x0C,
  0x30, 0x00, 0xE1, 0x80, 0x07, 0x0C, 0x00, 0x70, 0x60, 0x07, 0x83, 0x00,
  0x6C, 0x0C, 0x06, 0x60, 0x70, 0xE3, 0x01, 0xFE, 0x10, 0x00, 0x80, 0x01,
  0xF0, 0x00, 0x6C, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x06, 0x30, 0x01, 0x8C,
  0x00, 0xC3, 0x00, 0x30, 0xC0, 0x18, 0x30, 0x06, 0x04, 0x03, 0x01, 0x00,
  0xC0, 0x60, 0x60, 0x18, 0x18, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x61, 0x80,
  0x18, 0xC0, 0x06, 0x30, 0x01, 0x98, 0x00, 0x26, 0x00, 0x0B, 0x00, 0x02,
  0xC0, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x3C, 0x00, 0xE0, 0x06, 0xC0, 0x0E, 0x00, 0x6C, 0x01, 0xA0, 0x06, 0xC0,
  0x1A, 0x00, 0xCC, 0x01, 0x20, 0x0C, 0xC0, 0x32, 0x01, 0x8C, 0x02, 0x20,
  0x18, 0xC0, 0x62, 0x03, 0x0C, 0x04, 0x20, 0x30, 0xC0, 0xC2, 0x02, 0x0C,
  0x0C, 0x20, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xC0, 0xC3, 0x03,
  0x0C, 0x0C, 0x30, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x33, 0x00,
  0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x32, 0x00, 0xD8, 0x03, 0x60, 0x05, 0x80,
  0x36, 0x00, 0x50, 0x03, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x38, 0x06, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x66, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x30, 0x00, 0xE0, 0x30, 0x01, 0x80, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x00,
  0xC0, 0x70, 0x01, 0x81, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x30,
  0x00, 0x60, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x04, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x60, 0x0C,
  0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x18, 0x18, 0x00, 0x02, 0x06, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x40, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC0, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x1F,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFC, 0x01, 0xE0, 0xF0, 0x38,
  0x03, 0xFF, 0x80, 0x0F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 10, 35, 11, 1, -35 },
  { 45, 11, 13, 15, 5, -35 },
  { 63, 26, 35, 26, 1, -35 },
  { 177, 22, 40, 23, 1, -37 },
  { 287, 28, 36, 34, 3, -35 },
  { 413, 25, 36, 27, 1, -36 },
  { 526, 5, 13, 8, 5, -35 },
  { 535, 14, 43, 12, 1, -35 },
  { 611, 14, 43, 12, -3, -35 },
  { 687, 17, 18, 22, 6, -37 },
  { 726, 20, 23, 25, 3, -29 },
  { 784, 7, 11, 9, -2, -5 },
  { 794, 11, 2, 14, 2, -14 },
  { 797, 3, 3, 10, 1, -3 },
  { 799, 21, 35, 15, -2, -35 },
  { 891, 21, 36, 23, 2, -36 },
  { 986, 11, 35, 23, 7, -35 },
  { 1035, 22, 35, 23, 0, -35 },
  { 1132, 23, 35, 23, 0, -35 },
  { 1233, 22, 35, 23, 0, -35 },
  { 1330, 22, 35, 23, 1, -35 },
  { 1427, 22, 36, 23, 2, -36 },
  { 1526, 20, 35, 23, 4, -35 },
  { 1614, 22, 35, 23, 1, -35 },
  { 1711, 21, 35, 23, 1, -35 },
  { 1803, 8, 26, 10, 1, -26 },
  { 1829, 11, 32, 10, -2, -26 },
  { 1873, 20, 21, 25, 3, -28 },
  { 1926, 20, 12, 25, 3, -23 },
  { 1956, 20, 21, 25, 3, -28 },
  { 2009, 16, 35, 17, 3, -35 },
  { 2079, 32, 39, 35, 2, -35 },
  { 2235, 23, 35, 23, -3, -35 },
  { 2336, 23, 35, 25, 2, -35 },
  { 2437, 24, 35, 25, 3, -35 },
  { 2542, 25, 35, 29, 2, -35 },
  { 2652, 22, 35, 23, 2, -35 },
  { 2749, 22, 35, 21, 2, -35 },
  { 2846, 26, 35, 30, 3, -35 },
  { 2960, 27, 35, 29, 2, -35 },
  { 3079, 16, 35, 12, -1, -35 },
  { 3149, 19, 44, 10, -8, -35 },
  { 3254, 25, 35, 23, 2, -35 },
  { 3364, 15, 35, 21, 2, -35 },
  { 3430, 34, 35, 36, 2, -35 },
  { 3579, 28, 35, 30, 2, -35 },
  { 3702, 26, 36, 30, 3, -36 },
  { 3819, 22, 35, 24, 2, -35 },
  { 3916, 26, 44, 30, 3, -36 },
  { 4059, 22, 35, 24, 2, -35 },
  { 4156, 23, 35, 22, 0, -35 },
  { 4257, 21, 35, 21, 4, -35 },
  { 4349, 27, 35, 29, 3, -35 },
  { 4468, 22, 35, 23, 5, -35 },
  { 4565, 35, 35, 37, 5, -35 },
  { 4719, 28, 35, 21, -3, -35 },
  { 4842, 21, 35, 21, 4, -35 },
  { 4934, 25, 35, 22, -1, -35 },
  { 5044, 19, 43, 14, -1, -35 },
  { 5147, 7, 35, 16, 5, -35 },
  { 5178, 18, 43, 14, -3, -35 },
  { 5275, 21, 20, 24, 2, -35 },
  { 5328, 17, 2, 17, -4, 5 },
  { 5333, 6, 7, 11, 7, -37 },
  { 5339, 21, 26, 24, 2, -26 },
  { 5408, 21, 37, 25, 1, -37 },
  { 5506, 18, 26, 19, 2, -26 },
  { 5565, 24, 37, 25, 2, -37 },
  { 5676, 18, 26, 21, 2, -26 },
  { 5735, 25, 49, 12, -6, -37 },
  { 5889, 23, 38, 25, 0, -26 },
  { 5999, 21, 37, 24, 1, -37 },
  { 6097, 10, 35, 10, 1, -35 },
  { 6141, 18, 47, 10, -7, -35 },
  { 6247, 20, 37, 20, 1, -37 },
  { 6340, 10, 37, 10, 1, -37 },
  { 6387, 33, 26, 36, 1, -26 },
  { 6495, 21, 26, 24, 1, -26 },
  { 6564, 20, 26, 24, 2, -26 },
  { 6629, 23, 37, 25, -1, -26 },
  { 6736, 21, 37, 25, 2, -26 },
  { 6834, 17, 26, 16, 1, -26 },
  { 6890, 18, 26, 18, 0, -26 },
  { 6949, 12, 32, 13, 2, -32 },
  { 6997, 21, 26, 24, 2, -26 },
  { 7066, 18, 26, 18, 3, -26 },
  { 7125, 28, 26, 29, 3, -26 },
  { 7216, 23, 26, 20, -2, -26 },
  { 7291, 26, 38, 19, -5, -26 },
  { 7415, 19, 26, 18, -1, -26 },
  { 7477, 18, 43, 16, 1, -35 },
  { 7574, 2, 49, 23, 11, -37 },
  { 7587, 18, 43, 16, -3, -35 },
  { 7684, 20, 5, 25, 3, -20 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC49PT7B_H_
