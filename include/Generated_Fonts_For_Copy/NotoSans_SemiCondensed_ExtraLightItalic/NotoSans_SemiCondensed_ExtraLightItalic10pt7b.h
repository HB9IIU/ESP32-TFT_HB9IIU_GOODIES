#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC10PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x48, 0xF0, 0x29, 0x5E, 0xAF, 0xAA, 0x80, 0x11, 0xD8, 0xC2,
  0x18, 0xD8, 0x40, 0xED, 0xB5, 0xF5, 0xB6, 0x60, 0x3A, 0x4C, 0xC9, 0xCB,
  0xE0, 0xC0, 0x29, 0x49, 0x24, 0x40, 0x24, 0x92, 0x4A, 0x80, 0x2A, 0x5A,
  0x44, 0xF4, 0x40, 0xC0, 0xE0, 0x80, 0x12, 0x24, 0x48, 0x80, 0x3A, 0x53,
  0x19, 0x49, 0x80, 0x75, 0x24, 0x90, 0x78, 0x42, 0x22, 0x23, 0xC0, 0x78,
  0x44, 0x41, 0x0B, 0xC0, 0x19, 0x8C, 0xA9, 0xB8, 0x80, 0x7A, 0x18, 0x21,
  0x0B, 0x80, 0x78, 0xCA, 0x9A, 0xE0, 0xF1, 0x24, 0x48, 0x80, 0x7A, 0x54,
  0xC9, 0x4B, 0xC0, 0x7A, 0x52, 0xA3, 0x0B, 0x80, 0x40, 0x80, 0x40, 0xA0,
  0x16, 0x86, 0x10, 0xF0, 0xF0, 0x84, 0x34, 0x80, 0xE4, 0xA8, 0x20, 0x3C,
  0x85, 0x7D, 0x5A, 0xB7, 0xA0, 0x3C, 0x08, 0xCA, 0x55, 0xA6, 0x20, 0x7A,
  0x52, 0xE4, 0xC7, 0xC0, 0x7C, 0x21, 0x08, 0x43, 0xC0, 0x79, 0x14, 0x51,
  0x4A, 0x2F, 0x00, 0x7A, 0x10, 0xE4, 0x43, 0xC0, 0x7A, 0x10, 0xE4, 0x42,
  0x00, 0x7C, 0x21, 0x68, 0xCB, 0xC0, 0x45, 0x14, 0x5F, 0x4A, 0x28, 0x80,
  0x69, 0x25, 0x30, 0x11, 0x11, 0x12, 0x22, 0xC0, 0x4D, 0x46, 0x18, 0x62,
  0x49, 0x00, 0x49, 0x25, 0x38, 0x42, 0xC5, 0x9B, 0x56, 0xB6, 0xA5, 0x00,
  0x25, 0x96, 0x55, 0x5A, 0x68, 0x80, 0x7C, 0x63, 0x18, 0xCB, 0x80, 0x7A,
  0x52, 0xE4, 0x42, 0x00, 0x7C, 0x63, 0x18, 0xCB, 0x84, 0x20, 0x7A, 0x52,
  0xE5, 0x4A, 0x40, 0x7A, 0x10, 0x41, 0x0B, 0x80, 0xF4, 0x44, 0x48, 0x80,
  0x8C, 0x63, 0x19, 0x4B, 0x80, 0x9C, 0xA9, 0x4C, 0x62, 0x00, 0x93, 0x66,
  0xD5, 0xAD, 0x91, 0x24, 0x00, 0x24, 0xA1, 0x04, 0x31, 0x28, 0x80, 0x9A,
  0xA4, 0x48, 0x80, 0x78, 0x84, 0x44, 0x43, 0xC0, 0x74, 0x44, 0x88, 0x88,
  0xC0, 0xAA, 0x94, 0x31, 0x11, 0x22, 0x22, 0xC0, 0x21, 0x95, 0x10, 0xF0,
  0x90, 0x7C, 0x65, 0x2F, 0x00, 0x42, 0x1C, 0x94, 0xC6, 0x5E, 0x78, 0x88,
  0x70, 0x08, 0x4E, 0x98, 0xCA, 0x5E, 0x79, 0xE8, 0x70, 0x19, 0x0C, 0x42,
  0x11, 0x08, 0x46, 0x00, 0x7C, 0x65, 0x2F, 0x0B, 0x80, 0x44, 0x65, 0x59,
  0x99, 0x45, 0xA8, 0x20, 0x94, 0x92, 0xC0, 0x44, 0x45, 0x64, 0xA9, 0x55,
  0x6A, 0x7E, 0xA6, 0x4C, 0x99, 0x20, 0x75, 0x99, 0x90, 0x79, 0x99, 0x70,
  0x7A, 0x63, 0x2F, 0x42, 0x00, 0x7C, 0x65, 0x2F, 0x08, 0x40, 0x74, 0x88,
  0x80, 0xF4, 0x22, 0xE0, 0x4D, 0x29, 0x30, 0x4A, 0x65, 0x2F, 0x00, 0xB7,
  0x48, 0xAF, 0x6D, 0x2A, 0x00, 0x56, 0x46, 0xA0, 0x4A, 0x4C, 0x42, 0x13,
  0x00, 0x72, 0x48, 0xE0, 0x32, 0x44, 0xC4, 0x48, 0x40, 0xFF, 0xC0, 0x31,
  0x12, 0x12, 0x22, 0xC0, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 2, 2, 3, 1, -7 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 5, 9, 5, 0, -8 },
  { 15, 5, 7, 7, 1, -7 },
  { 20, 5, 7, 6, 0, -7 },
  { 25, 1, 2, 2, 1, -7 },
  { 26, 3, 9, 2, 0, -7 },
  { 30, 3, 9, 2, -1, -7 },
  { 34, 4, 4, 5, 1, -8 },
  { 36, 4, 5, 5, 1, -6 },
  { 39, 1, 2, 2, 0, -1 },
  { 40, 3, 1, 3, 0, -3 },
  { 41, 1, 1, 2, 0, -1 },
  { 42, 4, 7, 3, 0, -7 },
  { 46, 5, 7, 5, 0, -7 },
  { 51, 3, 7, 5, 1, -7 },
  { 54, 5, 7, 5, 0, -7 },
  { 59, 5, 7, 5, 0, -7 },
  { 64, 5, 7, 5, 0, -7 },
  { 69, 5, 7, 5, 0, -7 },
  { 74, 4, 7, 5, 1, -7 },
  { 78, 4, 7, 5, 1, -7 },
  { 82, 5, 7, 5, 0, -7 },
  { 87, 5, 7, 5, 0, -7 },
  { 92, 2, 5, 2, 0, -5 },
  { 94, 2, 6, 2, 0, -5 },
  { 96, 4, 5, 5, 1, -6 },
  { 99, 4, 3, 5, 1, -5 },
  { 101, 4, 5, 5, 1, -6 },
  { 104, 3, 7, 4, 1, -7 },
  { 107, 7, 8, 7, 0, -7 },
  { 114, 5, 7, 5, -1, -7 },
  { 119, 5, 7, 5, 0, -7 },
  { 124, 5, 7, 5, 1, -7 },
  { 129, 6, 7, 6, 0, -7 },
  { 135, 5, 7, 5, 0, -7 },
  { 140, 5, 7, 4, 0, -7 },
  { 145, 5, 7, 6, 1, -7 },
  { 150, 6, 7, 6, 0, -7 },
  { 156, 3, 7, 3, 0, -7 },
  { 159, 4, 9, 2, -2, -7 },
  { 164, 6, 7, 5, 0, -7 },
  { 170, 3, 7, 4, 0, -7 },
  { 173, 7, 7, 7, 0, -7 },
  { 180, 6, 7, 6, 0, -7 },
  { 186, 5, 7, 6, 1, -7 },
  { 191, 5, 7, 5, 0, -7 },
  { 196, 5, 9, 6, 1, -7 },
  { 202, 5, 7, 5, 0, -7 },
  { 207, 5, 7, 4, 0, -7 },
  { 212, 4, 7, 4, 1, -7 },
  { 216, 5, 7, 6, 1, -7 },
  { 221, 5, 7, 5, 1, -7 },
  { 226, 7, 7, 8, 1, -7 },
  { 233, 6, 7, 4, -1, -7 },
  { 239, 4, 7, 4, 1, -7 },
  { 243, 5, 7, 5, 0, -7 },
  { 248, 4, 9, 3, 0, -7 },
  { 253, 2, 7, 3, 1, -7 },
  { 255, 4, 9, 3, -1, -7 },
  { 260, 5, 4, 5, 0, -7 },
  { 263, 4, 1, 3, -1, 1 },
  { 264, 2, 2, 2, 1, -8 },
  { 265, 5, 5, 5, 0, -5 },
  { 269, 5, 8, 5, 0, -8 },
  { 274, 4, 5, 4, 0, -5 },
  { 277, 5, 8, 5, 0, -8 },
  { 282, 4, 5, 4, 0, -5 },
  { 285, 5, 10, 2, -1, -8 },
  { 292, 5, 7, 5, 0, -5 },
  { 297, 4, 8, 5, 0, -8 },
  { 301, 2, 7, 2, 0, -7 },
  { 303, 3, 9, 2, -1, -7 },
  { 307, 4, 8, 4, 0, -8 },
  { 311, 2, 8, 2, 0, -8 },
  { 313, 7, 5, 7, 0, -5 },
  { 318, 4, 5, 5, 0, -5 },
  { 321, 4, 5, 5, 0, -5 },
  { 324, 5, 7, 5, 0, -5 },
  { 329, 5, 7, 5, 0, -5 },
  { 334, 4, 5, 3, 0, -5 },
  { 337, 4, 5, 4, 0, -5 },
  { 340, 3, 7, 3, 0, -7 },
  { 343, 5, 5, 5, 0, -5 },
  { 347, 3, 5, 4, 1, -5 },
  { 349, 5, 5, 6, 1, -5 },
  { 353, 4, 5, 4, 0, -5 },
  { 356, 5, 7, 4, -1, -5 },
  { 361, 4, 5, 4, 0, -5 },
  { 364, 4, 9, 3, 0, -7 },
  { 369, 1, 10, 5, 2, -8 },
  { 371, 4, 9, 3, -1, -7 },
  { 376, 4, 1, 5, 1, -4 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC10PT7B_H_
