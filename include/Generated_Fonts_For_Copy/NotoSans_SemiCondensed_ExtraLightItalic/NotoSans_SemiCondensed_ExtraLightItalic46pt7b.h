#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC46PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x40, 0x60, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x81,
  0xC0, 0xE0, 0x00, 0x30, 0xCC, 0x32, 0x0D, 0x82, 0x61, 0x98, 0x64, 0x19,
  0x04, 0xC1, 0x30, 0x48, 0x32, 0x08, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x08,
  0x00, 0x18, 0x08, 0x00, 0x10, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x10,
  0x00, 0x30, 0x30, 0x00, 0x20, 0x30, 0x00, 0x60, 0x20, 0x00, 0x60, 0x20,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x00, 0xC0, 0x40, 0x00, 0x80, 0xC0,
  0x00, 0x80, 0xC0, 0x01, 0x80, 0x80, 0x01, 0x81, 0x80, 0x01, 0x01, 0x80,
  0x03, 0x01, 0x00, 0x03, 0x01, 0x00, 0x02, 0x03, 0x00, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0x04, 0x06, 0x00, 0x04, 0x06, 0x00, 0x0C, 0x04, 0x00,
  0x0C, 0x04, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x08, 0x00,
  0x10, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xC0, 0x0F, 0xFF,
  0x03, 0x8C, 0x30, 0x70, 0xC0, 0x06, 0x08, 0x00, 0xC0, 0x80, 0x0C, 0x08,
  0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x00, 0x06, 0x10, 0x00, 0x71,
  0x00, 0x03, 0xB0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x2E, 0x00, 0x06, 0x30, 0x00, 0x41, 0x80, 0x04, 0x18, 0x00, 0x41, 0x80,
  0x0C, 0x18, 0x00, 0xC1, 0x80, 0x08, 0x18, 0x00, 0x83, 0x00, 0x08, 0x70,
  0xC1, 0x8E, 0x0F, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x03, 0xE0, 0x01, 0x83,
  0x9C, 0x00, 0xC0, 0x83, 0x00, 0x20, 0x60, 0x40, 0x18, 0x30, 0x10, 0x0C,
  0x0C, 0x04, 0x02, 0x02, 0x01, 0x01, 0x81, 0x80, 0x40, 0xC0, 0x60, 0x30,
  0x20, 0x10, 0x0C, 0x18, 0x04, 0x03, 0x0C, 0x03, 0x00, 0xC3, 0x00, 0xC0,
  0x21, 0x80, 0x30, 0x18, 0xC3, 0xCC, 0x06, 0x31, 0xFB, 0x03, 0x18, 0xC3,
  0xC0, 0xC4, 0x60, 0xD0, 0x63, 0x30, 0x16, 0x31, 0x8C, 0x04, 0xF8, 0x42,
  0x01, 0x00, 0x31, 0x80, 0x40, 0x18, 0x60, 0x30, 0x04, 0x10, 0x0C, 0x03,
  0x04, 0x03, 0x01, 0x83, 0x00, 0xC0, 0x40, 0xC0, 0x20, 0x30, 0x30, 0x18,
  0x18, 0x0C, 0x06, 0x04, 0x03, 0x01, 0x03, 0x00, 0xC0, 0xC1, 0x80, 0x30,
  0x60, 0x60, 0x06, 0x30, 0x30, 0x00, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0xE3, 0x80, 0x03, 0x81, 0x80, 0x06, 0x03, 0x00, 0x18,
  0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x80, 0x30, 0x01, 0x00,
  0x60, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x60,
  0x00, 0x1B, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xB0, 0x00,
  0x0E, 0x60, 0x00, 0x30, 0x60, 0x18, 0xC0, 0xC0, 0x33, 0x00, 0xC0, 0xCC,
  0x00, 0xC1, 0x98, 0x01, 0x86, 0x20, 0x01, 0x8C, 0xC0, 0x03, 0x31, 0x80,
  0x03, 0xC3, 0x00, 0x07, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x0C, 0x00,
  0x6C, 0x18, 0x03, 0x8C, 0x1C, 0x1C, 0x18, 0x1F, 0xF0, 0x18, 0x33, 0x26,
  0x66, 0x44, 0xCC, 0x88, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x80, 0x80,
  0xE1, 0x80, 0x71, 0x80, 0x1D, 0x03, 0x07, 0xFF, 0x03, 0x00, 0x06, 0x80,
  0x0C, 0x80, 0x18, 0xC0, 0x70, 0x40, 0xE0, 0x60, 0x40, 0x20, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x0E, 0x18, 0x30, 0xC1, 0x82, 0x0C, 0x10, 0x60, 0x83, 0x00,
  0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1C, 0x70, 0x06, 0x03, 0x01, 0x80,
  0x30, 0x60, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x01, 0x18, 0x00,
  0x23, 0x00, 0x04, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0x40, 0x00,
  0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x09, 0x00, 0x03,
  0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C,
  0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0xC0,
  0xC0, 0x38, 0x0C, 0x0E, 0x01, 0xC3, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0xC0,
  0xF0, 0x7C, 0x32, 0x39, 0x9C, 0x6C, 0x1A, 0x06, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x80, 0x60, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0x8F, 0x00, 0xE0, 0x1C,
  0x02, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x07, 0x8F,
  0x00, 0xE0, 0x0C, 0x04, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x82, 0x00, 0x1C, 0x1E, 0x03, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x14, 0x00, 0x01, 0xA0, 0x00, 0x1B, 0x00,
  0x01, 0x98, 0x00, 0x08, 0xC0, 0x00, 0xC4, 0x00, 0x0C, 0x60, 0x00, 0xC3,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0x80, 0x06, 0x04, 0x00, 0x60, 0x60, 0x06,
  0x03, 0x00, 0x20, 0x18, 0x03, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x60,
  0x30, 0x03, 0x01, 0x00, 0x18, 0x18, 0x00, 0x81, 0x80, 0x0C, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x78, 0x00, 0x3F, 0xF8, 0x01, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x02, 0x00, 0x30, 0x1E, 0x0F,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xE3, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x1F, 0xC0, 0x33, 0x8F, 0x02, 0xC0, 0x30, 0x68, 0x01, 0x87, 0x00,
  0x18, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xCC, 0x00, 0x0C, 0xC0,
  0x00, 0xCC, 0x00, 0x08, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x04,
  0x00, 0x30, 0x60, 0x07, 0x06, 0x00, 0x60, 0x30, 0x0C, 0x01, 0xC3, 0x80,
  0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x07, 0x8F, 0x00, 0x60, 0x1C, 0x06, 0x00, 0x60, 0x30, 0x01, 0x03,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x10, 0x30, 0x01,
  0x81, 0x80, 0x0C, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0xC1, 0xC0, 0x03,
  0xB8, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x3C, 0x70, 0x03, 0x81, 0xC0,
  0x30, 0x06, 0x03, 0x00, 0x18, 0x30, 0x00, 0x41, 0x80, 0x03, 0x18, 0x00,
  0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x04,
  0x00, 0x18, 0x30, 0x01, 0x80, 0xC0, 0x1C, 0x07, 0x83, 0x80, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x0E, 0x3C, 0x01, 0x80, 0xE0, 0x30, 0x06, 0x06,
  0x00, 0x20, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0x31,
  0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03,
  0x18, 0x00, 0x71, 0x80, 0x0E, 0x18, 0x01, 0xE0, 0xC0, 0x36, 0x07, 0x0E,
  0x60, 0x3F, 0x84, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x1E, 0x00, 0xFF, 0x80, 0x00,
  0x02, 0x0C, 0x38, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x70, 0xC0, 0x00, 0x40,
  0x30, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xE0, 0xF9, 0xE2,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x0C, 0x30, 0x01, 0x00, 0x31, 0x80, 0x3F, 0xE0, 0xC4,
  0x01, 0x81, 0x03, 0x30, 0x0C, 0x0C, 0x04, 0xC0, 0x60, 0x30, 0x16, 0x03,
  0x00, 0x80, 0xD8, 0x18, 0x02, 0x03, 0x60, 0x60, 0x18, 0x0D, 0x01, 0x00,
  0x60, 0x3C, 0x0C, 0x01, 0x00, 0xB0, 0x30, 0x0C, 0x06, 0xC0, 0x80, 0x30,
  0x1B, 0x02, 0x00, 0xC0, 0x4C, 0x08, 0x07, 0x03, 0x30, 0x20, 0x18, 0x08,
  0xC0, 0xC0, 0xB0, 0x63, 0x03, 0x06, 0xC3, 0x0C, 0x07, 0xF1, 0xF8, 0x30,
  0x0F, 0x03, 0xC0, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x01, 0x00, 0x00, 0xF9, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x2C,
  0x00, 0x01, 0xB0, 0x00, 0x04, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x8C, 0x00,
  0x06, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x00, 0x06, 0x04, 0x00, 0x18,
  0x10, 0x00, 0xC0, 0x40, 0x03, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0C,
  0x00, 0x60, 0x30, 0x00, 0x81, 0x80, 0x02, 0x06, 0x00, 0x08, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x33,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0xE0, 0x00, 0x0C, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x06, 0x00, 0xE0, 0x08, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60,
  0x00, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x02, 0x02, 0x00, 0x04, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x80, 0x0E,
  0x03, 0x00, 0x78, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x18, 0x01, 0x80,
  0x20, 0x01, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x04,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0,
  0x01, 0x81, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x18, 0x01,
  0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7C,
  0x7C, 0x03, 0x80, 0x10, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x01, 0x80, 0x78, 0x01, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x06,
  0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x02, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x04, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x10, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x38,
  0x30, 0x00, 0x70, 0x20, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0x60, 0x03, 0x80,
  0x60, 0x0F, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0xE0, 0x03, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x07, 0xFC, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x10, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x70,
  0x00, 0x30, 0x30, 0x00, 0x20, 0x1C, 0x00, 0x60, 0x0F, 0x03, 0xE0, 0x03,
  0xFF, 0x80, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x08, 0x06, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x60, 0x18, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30,
  0x18, 0x00, 0x04, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x08, 0x00,
  0x06, 0x03, 0x00, 0x00, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x02, 0x01, 0x80, 0x00,
  0xC0, 0x30, 0x00, 0x18, 0x04, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30,
  0x00, 0x08, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x10, 0x00, 0x0C,
  0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x20, 0x18, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x30, 0x00, 0x01, 0xFE, 0x01, 0xF0, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0x80, 0x03, 0x80, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x80, 0x20, 0x03,
  0x80, 0x30, 0x03, 0x80, 0x18, 0x03, 0x80, 0x0C, 0x03, 0x80, 0x06, 0x03,
  0x80, 0x02, 0x03, 0x80, 0x03, 0x03, 0x80, 0x01, 0x83, 0x80, 0x00, 0xC3,
  0x80, 0x00, 0x63, 0x80, 0x00, 0x23, 0x80, 0x00, 0x33, 0x80, 0x00, 0x1B,
  0xC0, 0x00, 0x0D, 0xB0, 0x00, 0x05, 0x98, 0x00, 0x07, 0x06, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x40, 0x30, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x06,
  0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x28,
  0x00, 0x01, 0xA0, 0x34, 0x00, 0x00, 0xF0, 0x1B, 0x00, 0x00, 0xD8, 0x0D,
  0x80, 0x00, 0x6C, 0x06, 0xC0, 0x00, 0x64, 0x02, 0x60, 0x00, 0x26, 0x03,
  0x30, 0x00, 0x33, 0x01, 0x88, 0x00, 0x11, 0x80, 0xC4, 0x00, 0x18, 0xC0,
  0x62, 0x00, 0x18, 0x40, 0x21, 0x80, 0x0C, 0x60, 0x30, 0xC0, 0x0C, 0x30,
  0x18, 0x60, 0x06, 0x18, 0x0C, 0x30, 0x06, 0x0C, 0x04, 0x18, 0x03, 0x04,
  0x06, 0x04, 0x03, 0x06, 0x03, 0x02, 0x01, 0x03, 0x01, 0x81, 0x01, 0x81,
  0x80, 0xC0, 0xC0, 0x80, 0x80, 0x40, 0x60, 0xC0, 0xC0, 0x60, 0x30, 0xC0,
  0x60, 0x30, 0x18, 0x60, 0x30, 0x18, 0x0C, 0x60, 0x18, 0x0C, 0x02, 0x30,
  0x08, 0x04, 0x01, 0x30, 0x0C, 0x06, 0x00, 0x98, 0x06, 0x03, 0x00, 0x78,
  0x03, 0x01, 0x80, 0x38, 0x01, 0x80, 0x80, 0x1C, 0x00, 0x80, 0xC0, 0x0C,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x60, 0x38, 0x00, 0x0C, 0x07, 0x00,
  0x01, 0x00, 0xA0, 0x00, 0x60, 0x36, 0x00, 0x0C, 0x06, 0xC0, 0x01, 0x80,
  0xD8, 0x00, 0x30, 0x19, 0x80, 0x04, 0x02, 0x30, 0x01, 0x80, 0xC6, 0x00,
  0x30, 0x18, 0x60, 0x06, 0x03, 0x0C, 0x00, 0xC0, 0x61, 0x80, 0x10, 0x08,
  0x18, 0x06, 0x03, 0x03, 0x00, 0xC0, 0x60, 0x60, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x00, 0xC0, 0x40, 0x60, 0x18, 0x18, 0x0C, 0x01, 0x83, 0x01, 0x80,
  0x30, 0x60, 0x30, 0x06, 0x08, 0x04, 0x00, 0x63, 0x01, 0x80, 0x0C, 0x60,
  0x30, 0x01, 0x8C, 0x06, 0x00, 0x19, 0x80, 0xC0, 0x03, 0x20, 0x10, 0x00,
  0x6C, 0x06, 0x00, 0x07, 0x80, 0xC0, 0x00, 0xF0, 0x18, 0x00, 0x1E, 0x02,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x78,
  0xF8, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x70, 0x60, 0x00, 0x60, 0x30, 0x00,
  0xC0, 0x38, 0x03, 0x80, 0x1E, 0x0F, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x18, 0x07, 0x00, 0x40, 0x0E, 0x03, 0x00, 0x18,
  0x0C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x02, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0x60, 0x00, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x10, 0x00,
  0xC0, 0xC0, 0x03, 0x03, 0x00, 0x18, 0x0C, 0x01, 0xC0, 0x30, 0x7E, 0x01,
  0xFF, 0xE0, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x78, 0xF8, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x70, 0x60, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x38,
  0x03, 0x80, 0x1E, 0x0F, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x18, 0x07, 0x00, 0x40, 0x0E, 0x03, 0x00, 0x18, 0x0C, 0x00,
  0x20, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x02, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x10, 0x00, 0xC0, 0xC0,
  0x07, 0x03, 0x00, 0x38, 0x0C, 0x03, 0x80, 0x3F, 0xFC, 0x01, 0x80, 0x80,
  0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x10, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x08, 0x00,
  0xC0, 0x60, 0x01, 0x01, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60,
  0xC0, 0x00, 0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xCF, 0xC0, 0x70, 0x02, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x82, 0x00, 0x38,
  0x1F, 0x07, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x08, 0x10,
  0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30,
  0x60, 0x00, 0x18, 0x20, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x02, 0x00, 0x01, 0x83, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x30, 0x30, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x01, 0xC0,
  0x1C, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x1A,
  0x00, 0x00, 0xD0, 0x00, 0x0C, 0x80, 0x00, 0x64, 0x00, 0x06, 0x30, 0x00,
  0x31, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18,
  0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x60, 0x30, 0x03, 0x00, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x20, 0x18, 0x01, 0x00, 0xC0, 0x0C, 0x0C, 0x00, 0x60,
  0x60, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00,
  0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x26, 0x00, 0x01, 0x60,
  0x00, 0x0B, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0xE0, 0x00, 0xC0, 0x01, 0xB0, 0x00, 0x60, 0x00,
  0xD8, 0x00, 0x70, 0x00, 0xCC, 0x00, 0x28, 0x00, 0x66, 0x00, 0x34, 0x00,
  0x23, 0x00, 0x12, 0x00, 0x31, 0x80, 0x19, 0x80, 0x18, 0xC0, 0x0C, 0xC0,
  0x18, 0x60, 0x0C, 0x60, 0x0C, 0x30, 0x06, 0x30, 0x0C, 0x18, 0x06, 0x18,
  0x06, 0x0C, 0x03, 0x0C, 0x02, 0x06, 0x01, 0x06, 0x03, 0x03, 0x01, 0x83,
  0x01, 0x81, 0x80, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60,
  0x60, 0xC0, 0x30, 0x60, 0x30, 0x60, 0x18, 0x30, 0x18, 0x20, 0x0C, 0x30,
  0x0C, 0x30, 0x06, 0x18, 0x06, 0x10, 0x03, 0x08, 0x03, 0x18, 0x00, 0x8C,
  0x01, 0x8C, 0x00, 0x44, 0x00, 0xCC, 0x00, 0x26, 0x00, 0x66, 0x00, 0x13,
  0x00, 0x32, 0x00, 0x0B, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x0D, 0x00, 0x02,
  0x80, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x10, 0x00, 0x60,
  0x06, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x0C, 0x03,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x10, 0x30, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x23, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x06, 0x00, 0x03,
  0x00, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x03, 0x00,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x18, 0x03, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x80, 0xE0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0x40, 0x00,
  0xC6, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x30, 0x20, 0x06, 0x03, 0x00,
  0x60, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x30, 0x18, 0x01, 0x03, 0x00, 0x18,
  0x30, 0x01, 0x86, 0x00, 0x18, 0xC0, 0x00, 0x8C, 0x00, 0x0D, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xFF, 0x00, 0x81, 0x03, 0x06, 0x0C,
  0x08, 0x10, 0x20, 0x60, 0xC1, 0x83, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x60,
  0x40, 0x81, 0x83, 0x06, 0x0C, 0x08, 0x10, 0x30, 0x60, 0xC1, 0x81, 0x02,
  0x06, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x01,
  0xFF, 0x00, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x36, 0x00,
  0x04, 0x40, 0x01, 0x8C, 0x00, 0x61, 0x80, 0x0C, 0x10, 0x03, 0x03, 0x00,
  0x40, 0x60, 0x18, 0x04, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x30, 0x01, 0x8C,
  0x00, 0x31, 0x80, 0x02, 0x60, 0x00, 0x68, 0x00, 0x0F, 0x00, 0x00, 0x80,
  0xFF, 0xFF, 0xC6, 0x18, 0xC3, 0x08, 0x20, 0x00, 0x78, 0x10, 0x1F, 0xE2,
  0x03, 0x03, 0x20, 0x60, 0x16, 0x0C, 0x01, 0xE1, 0x80, 0x0E, 0x18, 0x00,
  0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0x86, 0x00,
  0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x30, 0xC0,
  0x03, 0x0C, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x0A, 0x04,
  0x01, 0xA0, 0x60, 0x36, 0x03, 0x0E, 0x60, 0x1F, 0x86, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x0F, 0x00, 0x63, 0xFC, 0x04, 0xE0, 0xE0, 0x58, 0x06, 0x0D, 0x00, 0x30,
  0xF0, 0x03, 0x0E, 0x00, 0x30, 0xC0, 0x03, 0x1C, 0x00, 0x31, 0x80, 0x03,
  0x18, 0x00, 0x31, 0x80, 0x03, 0x10, 0x00, 0x33, 0x00, 0x02, 0x30, 0x00,
  0x63, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0C, 0x70, 0x00, 0xC7, 0x00,
  0x18, 0x70, 0x01, 0x85, 0x00, 0x30, 0xD8, 0x06, 0x0C, 0xE1, 0xC0, 0xC7,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0xE0, 0x40, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x70, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x07, 0x83, 0x00, 0x7F, 0x8C, 0x03, 0x83, 0x30, 0x18, 0x06, 0x80, 0xC0,
  0x0E, 0x06, 0x00, 0x38, 0x18, 0x00, 0xE0, 0xC0, 0x03, 0x83, 0x00, 0x0C,
  0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x08, 0x30,
  0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x38, 0x30, 0x00,
  0xC0, 0xC0, 0x07, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0xF0, 0x10, 0x06, 0xC0,
  0x60, 0x32, 0x00, 0xC3, 0x88, 0x01, 0xFC, 0x60, 0x00, 0x00, 0x7C, 0x00,
  0xFF, 0x00, 0xE0, 0xC0, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06,
  0x60, 0x02, 0x30, 0x03, 0x30, 0x03, 0x18, 0x07, 0x0C, 0x1F, 0x07, 0xFC,
  0x07, 0x80, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x10, 0x78, 0x70,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xEC, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFE, 0x30, 0x0E, 0x0C,
  0xC0, 0x60, 0x1A, 0x03, 0x00, 0x28, 0x18, 0x00, 0xE0, 0x60, 0x03, 0x83,
  0x00, 0x0E, 0x0C, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00,
  0x0C, 0x30, 0x00, 0x20, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0xE0, 0xC0, 0x03, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x70, 0x30,
  0x03, 0xC0, 0x40, 0x1B, 0x01, 0x80, 0xC8, 0x03, 0x0E, 0x60, 0x07, 0xF1,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00,
  0x60, 0x0F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x3C, 0x03, 0x1F, 0xE0,
  0x4E, 0x0E, 0x0B, 0x00, 0xC3, 0x40, 0x18, 0x70, 0x03, 0x0E, 0x00, 0x61,
  0x80, 0x0C, 0x70, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x04, 0x30, 0x00, 0x84,
  0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x10, 0xC0, 0x06, 0x10,
  0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x43, 0x00, 0x18, 0x40,
  0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30,
  0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10,
  0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x83, 0x00, 0x60, 0x60, 0x18, 0x08, 0x06, 0x03, 0x01,
  0x80, 0x60, 0x60, 0x0C, 0x1C, 0x01, 0x07, 0x00, 0x60, 0xC0, 0x0C, 0x30,
  0x01, 0x8C, 0x00, 0x33, 0x80, 0x04, 0xF0, 0x01, 0xB2, 0x00, 0x3C, 0x60,
  0x07, 0x0C, 0x00, 0xC0, 0x80, 0x10, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30,
  0x18, 0x06, 0x02, 0x00, 0xC0, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x18,
  0x00, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80,
  0x80, 0xC0, 0x60, 0x30, 0x00, 0x02, 0x1E, 0x00, 0xF0, 0x08, 0xFF, 0x07,
  0xF0, 0x13, 0x06, 0x38, 0x30, 0x2C, 0x06, 0x40, 0x30, 0xF0, 0x0D, 0x00,
  0x61, 0xC0, 0x1E, 0x00, 0xC3, 0x80, 0x38, 0x01, 0x86, 0x00, 0x60, 0x03,
  0x1C, 0x00, 0xC0, 0x06, 0x30, 0x01, 0x80, 0x08, 0x60, 0x02, 0x00, 0x30,
  0xC0, 0x04, 0x00, 0x61, 0x00, 0x18, 0x00, 0xC6, 0x00, 0x30, 0x01, 0x8C,
  0x00, 0x60, 0x02, 0x18, 0x00, 0x80, 0x0C, 0x30, 0x03, 0x00, 0x18, 0x40,
  0x06, 0x00, 0x31, 0x80, 0x0C, 0x00, 0x43, 0x00, 0x18, 0x01, 0x86, 0x00,
  0x20, 0x03, 0x08, 0x00, 0xC0, 0x06, 0x30, 0x01, 0x80, 0x0C, 0x60, 0x03,
  0x00, 0x10, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x0F, 0x00, 0x87, 0xF8, 0x13,
  0x83, 0x82, 0xC0, 0x30, 0xF0, 0x06, 0x1C, 0x00, 0xC3, 0x80, 0x18, 0x60,
  0x03, 0x1C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x0C, 0x00, 0x21, 0x00,
  0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x04, 0x30, 0x01, 0x84, 0x00,
  0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x10, 0xC0, 0x06, 0x30, 0x00,
  0xC6, 0x00, 0x18, 0xC0, 0x03, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x0E,
  0x0E, 0x03, 0x00, 0xC0, 0xC0, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x11, 0x80,
  0x03, 0x30, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x2C, 0x00,
  0x0D, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x01, 0x98, 0x00,
  0x33, 0x00, 0x06, 0x60, 0x01, 0x8C, 0x00, 0x60, 0xC0, 0x0C, 0x1C, 0x07,
  0x01, 0xE1, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x83, 0xC0, 0x04, 0x3F, 0xC0,
  0x13, 0x83, 0x80, 0x58, 0x06, 0x03, 0x40, 0x0C, 0x0F, 0x00, 0x30, 0x38,
  0x00, 0xC0, 0xC0, 0x03, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00,
  0xC1, 0x80, 0x03, 0x04, 0x00, 0x0C, 0x30, 0x00, 0x20, 0xC0, 0x01, 0x83,
  0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0xC1, 0xC0, 0x03, 0x07, 0x00,
  0x18, 0x1C, 0x00, 0x60, 0x50, 0x03, 0x01, 0x60, 0x18, 0x0C, 0xE1, 0xC0,
  0x31, 0xFE, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x1F, 0xE3, 0x03, 0x03, 0x30, 0x60, 0x1A, 0x0C, 0x00, 0xA1, 0x80, 0x0E,
  0x18, 0x00, 0xE3, 0x00, 0x0E, 0x30, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00,
  0xC6, 0x00, 0x0C, 0xC0, 0x00, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00,
  0x18, 0xC0, 0x03, 0x8C, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00, 0x70, 0xC0,
  0x0F, 0x04, 0x01, 0xB0, 0x60, 0x32, 0x03, 0x0E, 0x60, 0x1F, 0xC6, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x02, 0x1F, 0x04, 0x7E, 0x04, 0xE0, 0x05, 0x80, 0x0D,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xC1, 0x80, 0xC1,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC2, 0x00, 0x61, 0xC0, 0xE0, 0x7F, 0xE0, 0x00, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x1F, 0xF8, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x20, 0xFC, 0x00, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01,
  0x8C, 0x00, 0x31, 0x80, 0x04, 0x20, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06,
  0x30, 0x00, 0x86, 0x00, 0x30, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18,
  0xC0, 0x02, 0x10, 0x00, 0xC2, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xE3,
  0x00, 0x38, 0x60, 0x05, 0x0C, 0x01, 0xE1, 0x80, 0x6C, 0x1C, 0x39, 0x01,
  0xFC, 0x20, 0xC0, 0x01, 0xA0, 0x00, 0x90, 0x00, 0xC8, 0x00, 0xC6, 0x00,
  0x63, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x18, 0x18,
  0x0C, 0x04, 0x0C, 0x02, 0x06, 0x01, 0x06, 0x00, 0xC3, 0x00, 0x63, 0x00,
  0x31, 0x80, 0x19, 0x80, 0x0C, 0x80, 0x06, 0xC0, 0x03, 0x40, 0x01, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x28,
  0x01, 0xC0, 0x1A, 0x00, 0xF0, 0x04, 0x80, 0x2C, 0x03, 0x30, 0x19, 0x00,
  0xCC, 0x06, 0x40, 0x63, 0x03, 0x10, 0x18, 0xC0, 0xC4, 0x0C, 0x30, 0x61,
  0x03, 0x0C, 0x18, 0x40, 0x83, 0x04, 0x10, 0x60, 0xC3, 0x04, 0x10, 0x30,
  0x81, 0x8C, 0x0C, 0x60, 0x63, 0x03, 0x10, 0x19, 0x80, 0xCC, 0x06, 0x60,
  0x32, 0x01, 0xB0, 0x0D, 0x80, 0x6C, 0x03, 0x40, 0x1A, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x03,
  0x00, 0x18, 0x18, 0x01, 0x80, 0x60, 0x18, 0x03, 0x01, 0x80, 0x08, 0x0C,
  0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x08, 0xC0, 0x00, 0x66, 0x00, 0x03,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x6C, 0x00,
  0x03, 0x60, 0x00, 0x31, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x20, 0x01, 0x81,
  0x80, 0x18, 0x0C, 0x01, 0x80, 0x20, 0x18, 0x01, 0x81, 0x80, 0x0C, 0x1C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x01, 0x80, 0x30, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x60,
  0x00, 0x80, 0x30, 0x00, 0x40, 0x30, 0x00, 0x20, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x86,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x23, 0x00, 0x00, 0x11, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x06, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x07,
  0x80, 0x0F, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x01, 0xF8, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0xF0,
  0x00, 0x7F, 0x80, 0x3C, 0x3C, 0x0E, 0x01, 0xFF, 0x40, 0x0F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 33, 10, 1, -33 },
  { 39, 10, 12, 14, 5, -33 },
  { 54, 24, 33, 24, 1, -33 },
  { 153, 20, 38, 22, 1, -35 },
  { 248, 26, 34, 32, 3, -33 },
  { 359, 23, 33, 26, 1, -33 },
  { 454, 4, 12, 8, 5, -33 },
  { 460, 13, 40, 11, 1, -33 },
  { 525, 13, 40, 11, -3, -33 },
  { 590, 16, 17, 21, 6, -35 },
  { 624, 19, 21, 23, 3, -27 },
  { 674, 7, 11, 9, -2, -5 },
  { 684, 11, 1, 14, 1, -13 },
  { 686, 3, 3, 9, 1, -3 },
  { 688, 20, 33, 14, -2, -33 },
  { 771, 19, 33, 22, 2, -33 },
  { 850, 10, 33, 22, 7, -33 },
  { 892, 21, 33, 22, 0, -33 },
  { 979, 21, 33, 22, 0, -33 },
  { 1066, 21, 33, 22, 0, -33 },
  { 1153, 21, 33, 22, 1, -33 },
  { 1240, 20, 33, 22, 2, -33 },
  { 1323, 19, 33, 22, 4, -33 },
  { 1402, 21, 33, 22, 1, -33 },
  { 1489, 20, 33, 22, 1, -33 },
  { 1572, 7, 25, 9, 1, -25 },
  { 1594, 10, 31, 9, -2, -25 },
  { 1633, 19, 21, 23, 3, -27 },
  { 1683, 19, 11, 23, 3, -22 },
  { 1710, 19, 21, 23, 3, -27 },
  { 1760, 14, 33, 16, 3, -33 },
  { 1818, 30, 37, 33, 2, -33 },
  { 1957, 22, 33, 22, -3, -33 },
  { 2048, 23, 33, 24, 1, -33 },
  { 2143, 23, 33, 23, 3, -33 },
  { 2238, 24, 33, 27, 1, -33 },
  { 2337, 22, 33, 21, 1, -33 },
  { 2428, 22, 33, 20, 1, -33 },
  { 2519, 24, 33, 28, 3, -33 },
  { 2618, 27, 33, 27, 1, -33 },
  { 2730, 15, 33, 12, -1, -33 },
  { 2792, 17, 41, 10, -7, -33 },
  { 2880, 25, 33, 22, 1, -33 },
  { 2984, 15, 33, 19, 1, -33 },
  { 3046, 33, 33, 34, 1, -33 },
  { 3183, 27, 33, 28, 1, -33 },
  { 3295, 24, 33, 29, 3, -33 },
  { 3394, 22, 33, 22, 1, -33 },
  { 3485, 24, 41, 29, 3, -33 },
  { 3608, 22, 33, 23, 1, -33 },
  { 3699, 21, 33, 20, 0, -33 },
  { 3786, 19, 33, 19, 4, -33 },
  { 3865, 25, 33, 27, 3, -33 },
  { 3969, 21, 33, 22, 4, -33 },
  { 4056, 33, 33, 35, 5, -33 },
  { 4193, 26, 33, 20, -3, -33 },
  { 4301, 20, 33, 19, 4, -33 },
  { 4384, 24, 33, 21, -1, -33 },
  { 4483, 17, 40, 13, -1, -33 },
  { 4568, 7, 33, 15, 5, -33 },
  { 4597, 17, 40, 13, -3, -33 },
  { 4682, 19, 19, 23, 2, -33 },
  { 4728, 16, 1, 16, -4, 5 },
  { 4730, 5, 7, 10, 7, -35 },
  { 4735, 20, 25, 23, 2, -25 },
  { 4798, 20, 35, 23, 1, -35 },
  { 4886, 17, 25, 18, 2, -25 },
  { 4940, 22, 35, 23, 2, -35 },
  { 5037, 17, 25, 20, 2, -25 },
  { 5091, 23, 46, 11, -6, -35 },
  { 5224, 22, 36, 23, 0, -25 },
  { 5323, 19, 35, 23, 1, -35 },
  { 5407, 9, 33, 9, 1, -33 },
  { 5445, 16, 44, 9, -6, -33 },
  { 5533, 19, 35, 18, 1, -35 },
  { 5617, 9, 35, 9, 1, -35 },
  { 5657, 31, 25, 34, 1, -25 },
  { 5754, 19, 25, 23, 1, -25 },
  { 5814, 19, 25, 23, 2, -25 },
  { 5874, 22, 36, 23, -1, -25 },
  { 5973, 20, 36, 23, 2, -25 },
  { 6063, 16, 25, 15, 1, -25 },
  { 6113, 17, 25, 17, 0, -25 },
  { 6167, 11, 30, 12, 2, -30 },
  { 6209, 19, 24, 23, 2, -24 },
  { 6266, 17, 24, 17, 2, -24 },
  { 6317, 26, 24, 27, 3, -24 },
  { 6395, 21, 24, 18, -2, -24 },
  { 6458, 25, 35, 17, -5, -24 },
  { 6568, 18, 24, 17, -1, -24 },
  { 6622, 17, 40, 15, 1, -33 },
  { 6707, 1, 46, 22, 11, -35 },
  { 6713, 16, 40, 15, -2, -33 },
  { 6793, 19, 4, 23, 3, -18 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC46PT7B_H_
