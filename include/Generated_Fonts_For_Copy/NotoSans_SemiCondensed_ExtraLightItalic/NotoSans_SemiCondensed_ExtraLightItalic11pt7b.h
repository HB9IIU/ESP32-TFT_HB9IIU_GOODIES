#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC11PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x52, 0xB7, 0x00, 0x14, 0xA7, 0xCA, 0x53, 0xE5, 0x14, 0x3A,
  0x94, 0xC1, 0x14, 0xDC, 0x40, 0x66, 0xAB, 0x2B, 0xF5, 0x55, 0x66, 0x38,
  0xA2, 0x8C, 0x56, 0x58, 0xBE, 0xE0, 0x25, 0x29, 0x24, 0x88, 0x24, 0x92,
  0x49, 0x50, 0xA5, 0x61, 0x44, 0xF4, 0x40, 0xC0, 0xE0, 0x80, 0x11, 0x22,
  0x44, 0x88, 0x79, 0x99, 0x99, 0xAE, 0x75, 0xAA, 0x38, 0x42, 0x11, 0x11,
  0x1E, 0x78, 0x42, 0x61, 0x04, 0x3E, 0x08, 0xCA, 0x55, 0x7C, 0x42, 0x3A,
  0x10, 0xE0, 0x84, 0x3E, 0x34, 0x8E, 0x99, 0x9E, 0xF1, 0x12, 0x24, 0x88,
  0x3A, 0x52, 0x65, 0x46, 0x2E, 0x3A, 0x52, 0x97, 0x84, 0x5C, 0x40, 0x20,
  0x20, 0x00, 0xB0, 0x3C, 0xC3, 0xFF, 0xC3, 0x3C, 0xE4, 0xA9, 0x04, 0x1E,
  0x21, 0x4D, 0x55, 0xA5, 0xAA, 0x94, 0x40, 0x38, 0x08, 0x61, 0x8A, 0x3D,
  0x14, 0x61, 0x39, 0x14, 0x5E, 0x49, 0x28, 0xBC, 0x3A, 0x21, 0x08, 0x42,
  0x1E, 0x39, 0x14, 0x51, 0x45, 0x18, 0xBC, 0x3A, 0x10, 0xF4, 0x22, 0x1E,
  0x3A, 0x10, 0x87, 0x22, 0x10, 0x3D, 0x08, 0x20, 0x9A, 0x28, 0xBC, 0x22,
  0x85, 0x13, 0xE4, 0x48, 0xA1, 0x44, 0x65, 0x24, 0x96, 0x11, 0x11, 0x11,
  0x22, 0x2C, 0x25, 0x25, 0x18, 0x51, 0x49, 0x22, 0x24, 0x44, 0x44, 0x8F,
  0x21, 0x21, 0x63, 0x65, 0x66, 0x5A, 0x92, 0x92, 0x22, 0x45, 0x92, 0xA5,
  0x4A, 0xA2, 0x44, 0x3A, 0x63, 0x18, 0xC6, 0x3E, 0x3A, 0x52, 0x97, 0x22,
  0x10, 0x3A, 0x63, 0x18, 0xC6, 0x3A, 0x20, 0x80, 0x3A, 0x52, 0x97, 0x2A,
  0x51, 0x3A, 0x10, 0xC1, 0x08, 0x5E, 0xF9, 0x10, 0x84, 0x22, 0x10, 0x46,
  0x18, 0xA2, 0x8A, 0x29, 0x3C, 0x8C, 0x65, 0x2A, 0x51, 0x10, 0x89, 0x91,
  0x92, 0xAA, 0xAC, 0xCC, 0x88, 0x88, 0x22, 0x48, 0x60, 0x81, 0x05, 0x12,
  0x44, 0x8C, 0xA9, 0x44, 0x22, 0x10, 0x78, 0x44, 0x22, 0x22, 0x1E, 0x34,
  0x44, 0x48, 0x88, 0x8C, 0xAA, 0x55, 0x31, 0x11, 0x12, 0x22, 0x2C, 0x11,
  0x92, 0x98, 0x80, 0xF0, 0x80, 0x3A, 0x63, 0x19, 0x38, 0x22, 0x1E, 0x94,
  0xC6, 0x3E, 0x34, 0x88, 0x87, 0x04, 0x13, 0x92, 0x8A, 0x29, 0x1C, 0x69,
  0xE8, 0x8E, 0x19, 0x0C, 0x42, 0x11, 0x08, 0x42, 0x20, 0x3A, 0x63, 0x19,
  0x38, 0x42, 0xE0, 0x22, 0x1E, 0x94, 0xC6, 0x32, 0x45, 0x6A, 0x10, 0x11,
  0x12, 0x22, 0x22, 0xC0, 0x22, 0x12, 0xA6, 0x32, 0x92, 0x55, 0x6A, 0x76,
  0x49, 0x49, 0x89, 0x92, 0x92, 0x7A, 0x53, 0x18, 0xC8, 0x32, 0x63, 0x18,
  0xB8, 0x7A, 0x53, 0x18, 0xFA, 0x10, 0x80, 0x3A, 0x63, 0x19, 0x38, 0x42,
  0x10, 0x74, 0x48, 0x88, 0x78, 0x42, 0x1E, 0x4D, 0x29, 0x30, 0x4A, 0x53,
  0x19, 0x78, 0x9A, 0xAC, 0x88, 0xA6, 0x9E, 0xAA, 0x92, 0x40, 0x4A, 0x88,
  0xCA, 0x48, 0x45, 0x22, 0x8C, 0x20, 0x82, 0x10, 0x80, 0x71, 0x24, 0x8E,
  0x12, 0x24, 0xC4, 0x44, 0x84, 0xFF, 0xE0, 0x31, 0x11, 0x12, 0x22, 0x2C,
  0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 8, 2, 0, -8 },
  { 3, 3, 3, 3, 1, -8 },
  { 5, 6, 8, 6, 0, -8 },
  { 11, 5, 9, 5, 0, -8 },
  { 17, 6, 8, 8, 1, -8 },
  { 23, 6, 8, 6, 0, -8 },
  { 29, 1, 3, 2, 1, -8 },
  { 30, 3, 10, 3, 0, -8 },
  { 34, 3, 10, 3, -1, -8 },
  { 38, 4, 4, 5, 1, -8 },
  { 40, 4, 5, 6, 1, -6 },
  { 43, 1, 2, 2, 0, -1 },
  { 44, 3, 1, 3, 0, -3 },
  { 45, 1, 1, 2, 0, -1 },
  { 46, 4, 8, 3, 0, -8 },
  { 50, 4, 8, 5, 1, -8 },
  { 54, 2, 8, 5, 2, -8 },
  { 56, 5, 8, 5, 0, -8 },
  { 61, 5, 8, 5, 0, -8 },
  { 66, 5, 8, 5, 0, -8 },
  { 71, 5, 8, 5, 0, -8 },
  { 76, 4, 8, 5, 1, -8 },
  { 80, 4, 8, 5, 1, -8 },
  { 84, 5, 8, 5, 0, -8 },
  { 89, 5, 8, 5, 0, -8 },
  { 94, 2, 6, 2, 0, -6 },
  { 96, 3, 7, 2, -1, -6 },
  { 99, 4, 4, 6, 1, -6 },
  { 101, 4, 2, 6, 1, -5 },
  { 102, 4, 4, 6, 1, -6 },
  { 104, 3, 8, 4, 1, -8 },
  { 107, 8, 9, 8, 0, -8 },
  { 116, 6, 8, 5, -1, -8 },
  { 122, 6, 8, 6, 0, -8 },
  { 128, 5, 8, 6, 1, -8 },
  { 133, 6, 8, 6, 0, -8 },
  { 139, 5, 8, 5, 0, -8 },
  { 144, 5, 8, 5, 0, -8 },
  { 149, 6, 8, 7, 1, -8 },
  { 155, 7, 8, 7, 0, -8 },
  { 162, 3, 8, 3, 0, -8 },
  { 165, 4, 10, 2, -2, -8 },
  { 170, 6, 8, 5, 0, -8 },
  { 176, 4, 8, 5, 0, -8 },
  { 180, 8, 8, 8, 0, -8 },
  { 188, 7, 8, 7, 0, -8 },
  { 195, 5, 8, 7, 1, -8 },
  { 200, 5, 8, 5, 0, -8 },
  { 205, 5, 10, 7, 1, -8 },
  { 212, 5, 8, 5, 0, -8 },
  { 217, 5, 8, 5, 0, -8 },
  { 222, 5, 8, 5, 1, -8 },
  { 227, 6, 8, 7, 1, -8 },
  { 233, 5, 8, 5, 1, -8 },
  { 238, 8, 8, 8, 1, -8 },
  { 246, 7, 8, 5, -1, -8 },
  { 253, 5, 8, 5, 1, -8 },
  { 258, 5, 8, 5, 0, -8 },
  { 263, 4, 10, 3, 0, -8 },
  { 268, 2, 8, 4, 1, -8 },
  { 270, 4, 10, 3, -1, -8 },
  { 275, 5, 5, 5, 0, -8 },
  { 279, 4, 1, 4, -1, 1 },
  { 280, 1, 1, 3, 2, -8 },
  { 281, 5, 6, 5, 0, -6 },
  { 285, 5, 8, 6, 0, -8 },
  { 290, 4, 6, 4, 0, -6 },
  { 293, 6, 8, 6, 0, -8 },
  { 299, 4, 6, 5, 1, -6 },
  { 302, 5, 11, 3, -1, -8 },
  { 309, 5, 9, 6, 0, -6 },
  { 315, 5, 8, 5, 0, -8 },
  { 320, 2, 8, 2, 0, -8 },
  { 322, 4, 11, 2, -2, -8 },
  { 328, 5, 8, 4, 0, -8 },
  { 333, 2, 8, 2, 0, -8 },
  { 335, 8, 6, 8, 0, -6 },
  { 341, 5, 6, 5, 0, -6 },
  { 345, 5, 6, 5, 0, -6 },
  { 349, 5, 9, 6, 0, -6 },
  { 355, 5, 9, 6, 0, -6 },
  { 361, 4, 6, 4, 0, -6 },
  { 364, 4, 6, 4, 0, -6 },
  { 367, 3, 7, 3, 0, -7 },
  { 370, 5, 6, 5, 0, -6 },
  { 374, 4, 6, 4, 1, -6 },
  { 377, 6, 6, 7, 1, -6 },
  { 382, 5, 6, 4, 0, -6 },
  { 386, 6, 9, 4, -1, -6 },
  { 393, 4, 6, 4, 0, -6 },
  { 396, 4, 10, 4, 0, -8 },
  { 401, 1, 11, 5, 2, -8 },
  { 403, 4, 10, 4, -1, -8 },
  { 408, 4, 1, 6, 1, -4 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC11PT7B_H_
