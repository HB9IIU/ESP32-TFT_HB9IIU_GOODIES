#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC64PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x18, 0x1C,
  0x60, 0x73, 0x81, 0xCE, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x03, 0x9C, 0x0C,
  0x60, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x18, 0x60, 0x63, 0x01, 0x8C, 0x06,
  0x30, 0x10, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x38, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x1C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x07,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x38, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x7C, 0x63, 0xF0, 0x0F, 0x06, 0x06, 0x01, 0xC0, 0x40, 0x00, 0x38,
  0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x70, 0x18, 0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x1C, 0x30,
  0x00, 0x01, 0xE3, 0x00, 0x00, 0x0F, 0xB0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x06,
  0xF0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x0E,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x03, 0x80, 0xC0,
  0x30, 0xF0, 0x0F, 0xC2, 0x7E, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xC0, 0x3F, 0xE0, 0x00, 0x18, 0x07,
  0x06, 0x00, 0x03, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x1C, 0x03, 0x00, 0x06,
  0x01, 0x80, 0x30, 0x00, 0xC0, 0x38, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x30, 0x07, 0x00, 0x60,
  0x03, 0x00, 0x60, 0x06, 0x00, 0x30, 0x0E, 0x00, 0xE0, 0x03, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x18, 0x00, 0xC0, 0x07, 0x03, 0x80, 0x0C, 0x00, 0x60,
  0x30, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x0C, 0x00, 0x60, 0xE0, 0x00, 0xC0,
  0x0E, 0x0C, 0x0F, 0x0C, 0x00, 0xC1, 0x83, 0xFC, 0xC0, 0x0C, 0x38, 0x71,
  0xEC, 0x01, 0x83, 0x0E, 0x06, 0xC0, 0x18, 0x61, 0xC0, 0x6C, 0x03, 0x0E,
  0x18, 0x07, 0xE0, 0x70, 0xC3, 0x00, 0x7E, 0x0E, 0x18, 0x30, 0x07, 0x7F,
  0xC3, 0x87, 0x00, 0x73, 0xF8, 0x30, 0x60, 0x07, 0x00, 0x06, 0x0E, 0x00,
  0x70, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x01, 0xC0,
  0xC0, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x60, 0x03, 0x01, 0xC0, 0x06, 0x00,
  0x70, 0x1C, 0x00, 0xE0, 0x0E, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x18, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x01,
  0x80, 0x18, 0x07, 0x00, 0x18, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x0C,
  0x00, 0x1C, 0x06, 0x01, 0xC0, 0x00, 0xC0, 0xE0, 0x18, 0x00, 0x0F, 0x3C,
  0x03, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60,
  0x01, 0xC0, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x00, 0x60,
  0x03, 0x80, 0x00, 0x60, 0x03, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x07, 0x83, 0x80, 0x07, 0x0E, 0x01, 0xC0, 0x06, 0x1C, 0x01,
  0xC0, 0x0E, 0x38, 0x00, 0xE0, 0x0C, 0x30, 0x00, 0x60, 0x1C, 0x70, 0x00,
  0x70, 0x18, 0x60, 0x00, 0x30, 0x38, 0xE0, 0x00, 0x38, 0x30, 0xC0, 0x00,
  0x1C, 0x70, 0xC0, 0x00, 0x1C, 0xE0, 0xC0, 0x00, 0x0E, 0xC0, 0xC0, 0x00,
  0x07, 0xC0, 0xC0, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x0F, 0x80, 0xE0, 0x00, 0x1D, 0x80, 0xE0, 0x00, 0x39, 0xC0, 0x70, 0x00,
  0xF0, 0xE0, 0x3C, 0x03, 0xE0, 0xE0, 0x1F, 0xFF, 0x80, 0x70, 0x0F, 0xFE,
  0x00, 0x70, 0x01, 0xD0, 0x00, 0x00, 0x18, 0xCE, 0x73, 0x18, 0xCE, 0x63,
  0x18, 0xC6, 0x63, 0x18, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x70, 0x0C, 0x00, 0x78, 0x10, 0x00, 0x3C, 0x60, 0x00, 0x1C, 0xC0,
  0x18, 0x0F, 0x9F, 0xF0, 0x07, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x34, 0x00,
  0x01, 0xCC, 0x00, 0x07, 0x08, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x30, 0x01,
  0xC0, 0x30, 0x07, 0x00, 0x60, 0x04, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x30, 0x38,
  0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x03, 0x03, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x2E, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x01,
  0xC0, 0x0F, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x30, 0x1C,
  0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x60, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30, 0x70, 0x00, 0x0E,
  0x0E, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x80, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x0F, 0x00,
  0x0E, 0x03, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x60, 0x3D, 0xC0,
  0xF3, 0x83, 0x86, 0x1E, 0x0C, 0x78, 0x19, 0xC0, 0x71, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xC0, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x02, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xF0, 0x1E, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x38, 0x01,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x3E,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x38, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30,
  0x03, 0x00, 0x03, 0x80, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x38, 0x01,
  0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x0E, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x20, 0x00, 0x1C, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xC0, 0x20, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x1F, 0xE0, 0x01, 0x87, 0xFF,
  0x80, 0x39, 0xE0, 0x7C, 0x03, 0x38, 0x01, 0xE0, 0x37, 0x00, 0x0E, 0x07,
  0xC0, 0x00, 0x70, 0x78, 0x00, 0x07, 0x07, 0x80, 0x00, 0x30, 0x70, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x38, 0x03, 0x00, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xE0, 0x3C,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3C, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x70, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x70, 0x18, 0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00,
  0x06, 0x01, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1C,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xDE, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x01, 0xC0,
  0x01, 0xC0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x03, 0xE0, 0x0F, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x01, 0x87, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1E, 0x18, 0x00, 0x07, 0x83,
  0x80, 0x01, 0xF0, 0x70, 0x00, 0x76, 0x07, 0x00, 0x1D, 0xC0, 0x70, 0x0F,
  0x30, 0x07, 0xFF, 0xC6, 0x00, 0x7F, 0xE1, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x40, 0x0F,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x3C, 0x07, 0x01, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF8,
  0x1E, 0x03, 0xC1, 0x80, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x78, 0x00, 0x60, 0xE0, 0x00, 0xFF, 0xE0, 0x1C, 0x30, 0x00, 0xF8,
  0xF8, 0x07, 0x1C, 0x00, 0x70, 0x0E, 0x01, 0xC6, 0x00, 0x38, 0x03, 0x00,
  0x73, 0x80, 0x1C, 0x00, 0xC0, 0x1C, 0xE0, 0x0E, 0x00, 0x30, 0x07, 0x30,
  0x03, 0x00, 0x1C, 0x01, 0xDC, 0x01, 0x80, 0x06, 0x00, 0x77, 0x00, 0xE0,
  0x01, 0x80, 0x19, 0x80, 0x30, 0x00, 0x60, 0x06, 0x60, 0x0C, 0x00, 0x38,
  0x01, 0xB8, 0x07, 0x00, 0x0C, 0x00, 0xEE, 0x01, 0x80, 0x03, 0x00, 0x3B,
  0x00, 0x60, 0x01, 0xC0, 0x0C, 0xC0, 0x18, 0x00, 0x70, 0x03, 0x30, 0x06,
  0x00, 0x18, 0x01, 0xCC, 0x03, 0x80, 0x0E, 0x00, 0x63, 0x00, 0xE0, 0x03,
  0x80, 0x38, 0xC0, 0x38, 0x01, 0xE0, 0x0C, 0x30, 0x06, 0x00, 0x78, 0x07,
  0x0C, 0x01, 0x80, 0x36, 0x03, 0x83, 0x00, 0x70, 0x19, 0x81, 0xC0, 0xC0,
  0x0E, 0x1C, 0x70, 0xE0, 0x30, 0x03, 0xFE, 0x0F, 0xF0, 0x0E, 0x00, 0x3E,
  0x01, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x70,
  0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x80, 0x60, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x70, 0x03, 0x00, 0x00, 0xC0, 0x07,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x03, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0x80,
  0x07, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x03, 0x00, 0x70, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x1E, 0x00, 0x70, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0x00, 0x0F, 0x80, 0x06, 0x00, 0x07, 0x80, 0x1C,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x00, 0x60, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x38, 0x0C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xF0, 0x03, 0x00, 0x1F, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x00,
  0x02, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x0E, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0E, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x06, 0x00,
  0x07, 0x80, 0x03, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x18, 0x00,
  0x3E, 0x00, 0x0C, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x40, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xF8, 0xE0, 0x00, 0x3F, 0xFE, 0x38,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x60, 0x07, 0x80, 0x00, 0x18, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x1C,
  0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x1C, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00,
  0x1C, 0x01, 0x80, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x18, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x81, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xC0, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x18, 0x07,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x01, 0xCF, 0x80, 0x00, 0x00, 0x67, 0x70, 0x00, 0x00,
  0x1B, 0x9C, 0x00, 0x00, 0x07, 0xC3, 0x00, 0x00, 0x03, 0xE0, 0xE0, 0x00,
  0x00, 0xF0, 0x18, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD8, 0x03, 0xB0, 0x00, 0x00, 0x0E,
  0xC0, 0x1D, 0x80, 0x00, 0x00, 0xEE, 0x00, 0xCC, 0x00, 0x00, 0x07, 0x70,
  0x06, 0x60, 0x00, 0x00, 0x73, 0x00, 0x73, 0x00, 0x00, 0x03, 0x18, 0x03,
  0x9C, 0x00, 0x00, 0x39, 0xC0, 0x18, 0xE0, 0x00, 0x01, 0x8E, 0x00, 0xC3,
  0x00, 0x00, 0x1C, 0x60, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x70, 0xC0,
  0x00, 0x0E, 0x18, 0x03, 0x86, 0x00, 0x00, 0x61, 0xC0, 0x18, 0x30, 0x00,
  0x07, 0x0E, 0x00, 0xC1, 0x80, 0x00, 0x70, 0x60, 0x06, 0x0E, 0x00, 0x03,
  0x03, 0x00, 0x70, 0x70, 0x00, 0x38, 0x18, 0x03, 0x81, 0x80, 0x01, 0x81,
  0xC0, 0x18, 0x0C, 0x00, 0x1C, 0x0E, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60,
  0x06, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x70, 0x18, 0x00, 0x60, 0x38, 0x03,
  0x80, 0xC0, 0x07, 0x01, 0xC0, 0x18, 0x07, 0x00, 0x30, 0x0C, 0x00, 0xC0,
  0x38, 0x03, 0x80, 0x60, 0x0E, 0x00, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x06,
  0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x0E, 0x00, 0x60, 0x0E, 0x00, 0x60, 0x60,
  0x03, 0x00, 0x70, 0x03, 0x87, 0x00, 0x38, 0x03, 0x00, 0x1C, 0x30, 0x01,
  0xC0, 0x18, 0x00, 0x63, 0x80, 0x0C, 0x00, 0xC0, 0x03, 0x18, 0x00, 0x60,
  0x0E, 0x00, 0x19, 0xC0, 0x03, 0x00, 0x70, 0x00, 0xDC, 0x00, 0x38, 0x03,
  0x00, 0x06, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0xC0,
  0x01, 0xE0, 0x00, 0x60, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x07,
  0xC0, 0x00, 0x03, 0x00, 0x3E, 0x00, 0x00, 0x38, 0x03, 0xB0, 0x00, 0x01,
  0xC0, 0x19, 0xC0, 0x00, 0x0C, 0x00, 0xCE, 0x00, 0x00, 0x60, 0x06, 0x30,
  0x00, 0x03, 0x00, 0x71, 0xC0, 0x00, 0x38, 0x03, 0x8E, 0x00, 0x01, 0xC0,
  0x18, 0x30, 0x00, 0x0C, 0x00, 0xC1, 0xC0, 0x00, 0x60, 0x06, 0x0E, 0x00,
  0x07, 0x00, 0x70, 0x30, 0x00, 0x38, 0x03, 0x81, 0xC0, 0x01, 0x80, 0x18,
  0x0E, 0x00, 0x0C, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x06, 0x01, 0xC0, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x30, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x0E, 0x01, 0x80, 0x18, 0x00, 0x30,
  0x0C, 0x00, 0xC0, 0x01, 0x80, 0xE0, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x70,
  0x00, 0x30, 0x38, 0x03, 0x80, 0x01, 0x81, 0x80, 0x18, 0x00, 0x0E, 0x0C,
  0x00, 0xC0, 0x00, 0x30, 0xE0, 0x0E, 0x00, 0x01, 0x87, 0x00, 0x70, 0x00,
  0x0E, 0x30, 0x03, 0x00, 0x00, 0x31, 0x80, 0x18, 0x00, 0x01, 0x8C, 0x00,
  0xC0, 0x00, 0x0E, 0xE0, 0x0E, 0x00, 0x00, 0x37, 0x00, 0x70, 0x00, 0x01,
  0xB0, 0x03, 0x00, 0x00, 0x0F, 0x80, 0x18, 0x00, 0x00, 0x3C, 0x00, 0xC0,
  0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x60, 0x00, 0xF0, 0x01, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x1C,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0x60, 0x00, 0x38, 0x01,
  0x80, 0x03, 0xC0, 0x06, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x60, 0x00, 0xF0,
  0x01, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x0F, 0x00, 0x60, 0x00, 0xF0, 0x01, 0x80, 0x7F, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x70, 0x01, 0x80, 0x01, 0xC0, 0x07,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x70, 0x03, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x08,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x1C, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x38,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x18, 0x03, 0x80, 0x01, 0xC0, 0x0C, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0xE0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x38, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x1C,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x03, 0x80, 0x00, 0x18,
  0x18, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x03, 0x38, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x70, 0x00, 0x03, 0xB0, 0x00, 0x03, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x73, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0x8C, 0x00, 0x01, 0xB0, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x33, 0x00, 0x01, 0xC3, 0x00, 0x01, 0xCC, 0x00, 0x07, 0x0E,
  0x00, 0x06, 0x30, 0x00, 0x18, 0x38, 0x00, 0x18, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0xE3, 0x00, 0x03, 0x03, 0x80, 0x03, 0x0C, 0x00, 0x1C, 0x0E, 0x00,
  0x1C, 0x30, 0x00, 0x60, 0x38, 0x00, 0x60, 0xC0, 0x03, 0x80, 0xE0, 0x03,
  0x83, 0x00, 0x0C, 0x03, 0x80, 0x0C, 0x0E, 0x00, 0x30, 0x0E, 0x00, 0x70,
  0x38, 0x01, 0xC0, 0x38, 0x01, 0x80, 0xE0, 0x06, 0x00, 0xE0, 0x06, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x38,
  0x07, 0x00, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x18, 0x03, 0x80,
  0xE0, 0x01, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x06, 0x03, 0x00, 0x38, 0x0C,
  0x00, 0x18, 0x1C, 0x00, 0x60, 0x70, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80,
  0x01, 0x81, 0x80, 0x06, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x18, 0x30, 0x00,
  0x18, 0x30, 0x00, 0x61, 0xC0, 0x00, 0x61, 0xC0, 0x01, 0x87, 0x00, 0x01,
  0x86, 0x00, 0x06, 0x18, 0x00, 0x06, 0x38, 0x00, 0x18, 0xE0, 0x00, 0x18,
  0xC0, 0x00, 0x63, 0x00, 0x00, 0x67, 0x00, 0x01, 0x9C, 0x00, 0x01, 0x98,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x1B, 0x80,
  0x00, 0x6C, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x38, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x0C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x18,
  0x06, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x03, 0x80, 0x06, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00,
  0x1C, 0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x06, 0x06,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x08, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x00,
  0xC0, 0x30, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x1C, 0x1C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x70, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x30, 0x03, 0x80, 0x03, 0x00, 0x30, 0x00, 0x38, 0x07, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x18, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x6F, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0xE0,
  0x70, 0x70, 0x30, 0x38, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x03, 0xFC, 0x0C, 0x01, 0xFF, 0xE1, 0x80, 0x78, 0x0C, 0x60, 0x1C,
  0x00, 0xCC, 0x07, 0x00, 0x0D, 0x81, 0xC0, 0x01, 0xB0, 0x70, 0x00, 0x3E,
  0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x38, 0x60, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x38, 0x60, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x18, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x1C, 0x30,
  0x00, 0x03, 0x06, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x07,
  0x83, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x3C, 0x0E, 0x00, 0x0D, 0x81, 0xC0,
  0x01, 0xB0, 0x18, 0x00, 0x66, 0x03, 0x80, 0x19, 0xC0, 0x38, 0x0E, 0x30,
  0x03, 0xFF, 0x86, 0x00, 0x3F, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x10, 0x00, 0x1C, 0x1F, 0xF0, 0x01, 0xC3, 0xFF, 0x80, 0x18,
  0xF0, 0x3C, 0x01, 0x9C, 0x00, 0xE0, 0x1B, 0x80, 0x0E, 0x03, 0xB0, 0x00,
  0x70, 0x36, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x30, 0x3C, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x30, 0x78, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C,
  0x18, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x18, 0x38, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x70, 0x3C, 0x00, 0x07, 0x07, 0xC0, 0x00, 0xE0, 0x66, 0x00, 0x1C,
  0x06, 0x60, 0x03, 0xC0, 0x63, 0x80, 0xF0, 0x06, 0x1F, 0xFE, 0x00, 0xC0,
  0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xF8, 0x07, 0x80, 0x20, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x40, 0x1C,
  0x00, 0x0F, 0xF8, 0x30, 0x00, 0x7F, 0xF8, 0x60, 0x01, 0xE0, 0x38, 0xC0,
  0x07, 0x00, 0x3B, 0x80, 0x1C, 0x00, 0x37, 0x00, 0x70, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0x78, 0x03, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x07, 0x80, 0x60, 0x00, 0x1E,
  0x00, 0xC0, 0x00, 0x3C, 0x01, 0x80, 0x00, 0xF8, 0x03, 0x80, 0x03, 0xB0,
  0x07, 0x00, 0x06, 0xE0, 0x06, 0x00, 0x1D, 0x80, 0x0E, 0x00, 0x73, 0x00,
  0x0E, 0x03, 0xC6, 0x00, 0x0F, 0xFE, 0x0C, 0x00, 0x0F, 0xF8, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xE0, 0x07, 0x80, 0xE0, 0x1C, 0x00, 0xE0, 0x70, 0x01, 0xC1, 0xC0, 0x01,
  0x83, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x38, 0x00, 0x1C, 0x60, 0x00, 0x39,
  0xC0, 0x00, 0x63, 0x00, 0x01, 0xC6, 0x00, 0x07, 0x1C, 0x00, 0x3C, 0x38,
  0x01, 0xF0, 0x60, 0x3F, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x10,
  0x1E, 0x00, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xC3,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xF0, 0x30,
  0x01, 0xFF, 0xE1, 0x80, 0x0F, 0x01, 0xC6, 0x00, 0x70, 0x03, 0x98, 0x03,
  0x80, 0x06, 0x60, 0x1C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0xF0, 0x1C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x18, 0x0E, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xE0, 0x30, 0x00,
  0x07, 0x80, 0xC0, 0x00, 0x3C, 0x03, 0x00, 0x00, 0xF0, 0x0C, 0x00, 0x07,
  0xC0, 0x38, 0x00, 0x3B, 0x00, 0xE0, 0x00, 0xDC, 0x01, 0x80, 0x07, 0x60,
  0x07, 0x00, 0x39, 0x80, 0x0E, 0x03, 0xC6, 0x00, 0x3F, 0xFC, 0x38, 0x00,
  0x3F, 0xE0, 0xE0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x08, 0x00, 0x3C, 0x00,
  0x38, 0x03, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x04, 0x00, 0x0E, 0x0F, 0xF8, 0x01, 0xC7, 0xFF, 0x80, 0x31, 0xE0,
  0x78, 0x06, 0x70, 0x03, 0x80, 0xDC, 0x00, 0x70, 0x3F, 0x00, 0x06, 0x06,
  0xC0, 0x00, 0xC0, 0xF0, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x60, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x0C, 0x0C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E,
  0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x18, 0x18, 0x00, 0x03, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x18,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x06, 0x00,
  0x1C, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x00,
  0xC0, 0x1C, 0x00, 0x18, 0x07, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x1C, 0x00, 0x03, 0x07, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x1C,
  0x78, 0x00, 0x03, 0x9F, 0x00, 0x00, 0x67, 0x60, 0x00, 0x0C, 0xCE, 0x00,
  0x01, 0xB1, 0xC0, 0x00, 0x7C, 0x18, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xC0,
  0x30, 0x00, 0x30, 0x07, 0x00, 0x06, 0x00, 0xE0, 0x01, 0xC0, 0x0C, 0x00,
  0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x38, 0x00,
  0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xC0, 0x18, 0x00, 0x1C, 0x03,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x38, 0x3F, 0xC0,
  0x1F, 0xE0, 0x06, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0xC7, 0x03, 0xC3, 0x80,
  0xE0, 0x19, 0x80, 0x38, 0xE0, 0x0E, 0x03, 0x60, 0x03, 0x38, 0x01, 0xC0,
  0xF8, 0x00, 0x66, 0x00, 0x18, 0x1B, 0x00, 0x0F, 0x80, 0x03, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x3C, 0x00, 0x0C, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0x83, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC1, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x06, 0x00, 0x03, 0x83, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x83, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x83, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x38, 0x3F, 0xE0, 0x06, 0x1F, 0xFE, 0x00, 0xC7,
  0x81, 0xE0, 0x19, 0xC0, 0x0E, 0x03, 0x70, 0x01, 0xC0, 0xFC, 0x00, 0x18,
  0x1B, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x60, 0x78, 0x00, 0x0C, 0x0E, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x30, 0x70, 0x00, 0x06, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x38, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03,
  0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70,
  0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xC0, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x38, 0x00,
  0x0E, 0x0E, 0x00, 0x01, 0x87, 0x00, 0x00, 0x71, 0x80, 0x00, 0x1C, 0xE0,
  0x00, 0x07, 0x38, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x18, 0x00, 0x0E,
  0x07, 0x00, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x70, 0x7F, 0xC0, 0x00, 0xC1, 0xFF, 0xC0, 0x01, 0x8F, 0x03, 0xC0,
  0x03, 0x38, 0x01, 0xC0, 0x06, 0xE0, 0x03, 0x80, 0x1D, 0x80, 0x03, 0x80,
  0x36, 0x00, 0x07, 0x00, 0x7C, 0x00, 0x06, 0x00, 0xF0, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x18, 0x07, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x60, 0x1C,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x60, 0x1C, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x03, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0x38, 0x03, 0xB0, 0x00, 0xE0, 0x07, 0x60, 0x03, 0x80,
  0x0C, 0x70, 0x1E, 0x00, 0x18, 0x7F, 0xF8, 0x00, 0x30, 0x7F, 0xE0, 0x00,
  0xE0, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0xFF, 0x03, 0x00, 0x7F, 0xF8, 0x60, 0x0F, 0x01, 0xC6,
  0x01, 0xC0, 0x0E, 0x60, 0x38, 0x00, 0x66, 0x07, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x18, 0x38, 0x00, 0x01, 0x83, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x1E, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x3C, 0x0C, 0x00, 0x07, 0xC0,
  0xE0, 0x00, 0x6C, 0x0E, 0x00, 0x0D, 0xC0, 0x60, 0x01, 0xD8, 0x07, 0x00,
  0x39, 0x80, 0x38, 0x0F, 0x18, 0x03, 0xFF, 0xC3, 0x80, 0x0F, 0xF8, 0x38,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC1, 0xFC, 0x06, 0x1F, 0xF0, 0x18,
  0xF0, 0x00, 0x67, 0x00, 0x01, 0xB8, 0x00, 0x0E, 0xC0, 0x00, 0x36, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF8,
  0x0F, 0x00, 0x70, 0x38, 0x00, 0x20, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x40, 0x00, 0xE0, 0xE0,
  0x07, 0x81, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0x9F, 0xFF, 0x80, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x18, 0x18, 0x00, 0x03, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C,
  0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x1C, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x70, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x30, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x30, 0x30, 0x00, 0x06, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x07, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x03, 0x00,
  0x01, 0xE0, 0x60, 0x00, 0x6C, 0x0C, 0x00, 0x1F, 0x81, 0xC0, 0x03, 0x60,
  0x38, 0x01, 0xCC, 0x03, 0x80, 0x71, 0x80, 0x3F, 0xFC, 0x30, 0x03, 0xFE,
  0x0E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06,
  0x60, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x38,
  0x60, 0x00, 0x38, 0x60, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0x70, 0x00, 0xC0, 0x70, 0x01, 0xC0, 0x30, 0x01, 0x80, 0x30, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x30, 0x06, 0x00, 0x30, 0x0E, 0x00,
  0x30, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x30, 0x00, 0x18, 0x70, 0x00, 0x18, 0x60, 0x00, 0x18, 0xE0, 0x00,
  0x18, 0xC0, 0x00, 0x19, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x1B, 0x80, 0x00,
  0x1B, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x03, 0xB0, 0x00, 0x38,
  0x00, 0x19, 0x80, 0x03, 0xE0, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x0E, 0x60,
  0x01, 0xD8, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x07, 0x18, 0x00, 0x66, 0x00,
  0x30, 0xC0, 0x06, 0x30, 0x03, 0x86, 0x00, 0x31, 0x80, 0x18, 0x30, 0x03,
  0x0C, 0x01, 0xC1, 0x80, 0x18, 0x60, 0x0C, 0x0C, 0x01, 0xC3, 0x00, 0x60,
  0x60, 0x0C, 0x18, 0x07, 0x03, 0x00, 0xE0, 0xC0, 0x30, 0x18, 0x06, 0x06,
  0x03, 0x80, 0xE0, 0x70, 0x30, 0x18, 0x07, 0x03, 0x01, 0x81, 0xC0, 0x38,
  0x38, 0x0C, 0x0C, 0x01, 0xC1, 0x80, 0x60, 0x60, 0x0E, 0x1C, 0x03, 0x06,
  0x00, 0x70, 0xC0, 0x1C, 0x30, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x1C, 0x60,
  0x07, 0x18, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00,
  0x19, 0x80, 0x06, 0xE0, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x01,
  0xB0, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x38, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x1C, 0x03, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xE0, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x60, 0x06, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x18, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x18, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x05, 0xFF, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x00, 0x7F, 0xF9, 0x00, 0x03, 0xFE, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 12, 46, 14, 2, -46 },
  { 70, 14, 17, 20, 7, -46 },
  { 100, 34, 46, 34, 1, -46 },
  { 296, 28, 53, 31, 2, -49 },
  { 482, 36, 47, 44, 5, -46 },
  { 694, 32, 47, 36, 2, -46 },
  { 882, 5, 17, 11, 7, -46 },
  { 893, 18, 56, 16, 2, -46 },
  { 1019, 18, 56, 16, -4, -46 },
  { 1145, 23, 24, 29, 8, -49 },
  { 1214, 27, 29, 33, 4, -37 },
  { 1312, 9, 15, 12, -3, -7 },
  { 1329, 15, 3, 19, 2, -19 },
  { 1335, 4, 5, 13, 2, -5 },
  { 1338, 28, 46, 20, -3, -46 },
  { 1499, 27, 47, 31, 3, -46 },
  { 1658, 15, 46, 31, 9, -46 },
  { 1745, 29, 46, 31, 0, -46 },
  { 1912, 30, 47, 31, 0, -46 },
  { 2089, 29, 46, 31, 0, -46 },
  { 2256, 29, 47, 31, 1, -46 },
  { 2427, 28, 47, 31, 3, -46 },
  { 2592, 27, 46, 31, 5, -46 },
  { 2748, 28, 47, 31, 2, -46 },
  { 2913, 27, 47, 31, 2, -46 },
  { 3072, 11, 34, 13, 1, -34 },
  { 3119, 15, 42, 13, -3, -34 },
  { 3198, 27, 28, 33, 4, -37 },
  { 3293, 27, 15, 33, 4, -30 },
  { 3344, 27, 28, 33, 4, -37 },
  { 3439, 20, 46, 22, 4, -46 },
  { 3554, 42, 52, 46, 3, -46 },
  { 3827, 31, 46, 30, -4, -46 },
  { 4006, 31, 46, 33, 2, -46 },
  { 4185, 32, 47, 32, 4, -46 },
  { 4373, 33, 46, 37, 2, -46 },
  { 4563, 30, 46, 30, 2, -46 },
  { 4736, 30, 46, 27, 2, -46 },
  { 4909, 34, 47, 39, 4, -46 },
  { 5109, 36, 46, 38, 2, -46 },
  { 5316, 20, 46, 16, -1, -46 },
  { 5431, 24, 57, 14, -10, -46 },
  { 5602, 34, 46, 31, 2, -46 },
  { 5798, 20, 46, 27, 2, -46 },
  { 5913, 45, 46, 47, 2, -46 },
  { 6172, 37, 46, 39, 2, -46 },
  { 6385, 34, 47, 40, 4, -46 },
  { 6585, 30, 46, 31, 2, -46 },
  { 6758, 34, 57, 40, 4, -46 },
  { 7001, 30, 46, 32, 2, -46 },
  { 7174, 30, 47, 28, 0, -46 },
  { 7351, 26, 46, 27, 6, -46 },
  { 7501, 35, 47, 38, 4, -46 },
  { 7707, 29, 46, 30, 6, -46 },
  { 7874, 46, 46, 48, 7, -46 },
  { 8139, 36, 46, 28, -4, -46 },
  { 8346, 27, 46, 27, 6, -46 },
  { 8502, 33, 46, 29, -1, -46 },
  { 8692, 24, 56, 19, -1, -46 },
  { 8860, 10, 46, 20, 6, -46 },
  { 8918, 23, 56, 19, -4, -46 },
  { 9079, 28, 26, 32, 2, -46 },
  { 9170, 22, 3, 22, -5, 6 },
  { 9179, 8, 10, 15, 9, -49 },
  { 9189, 27, 36, 31, 3, -35 },
  { 9311, 28, 50, 32, 1, -49 },
  { 9486, 23, 36, 25, 3, -35 },
  { 9590, 31, 50, 32, 3, -49 },
  { 9784, 23, 36, 28, 3, -35 },
  { 9888, 32, 64, 16, -8, -49 },
  { 10144, 30, 50, 32, 1, -35 },
  { 10332, 27, 49, 31, 1, -49 },
  { 10498, 13, 46, 13, 1, -46 },
  { 10573, 23, 61, 13, -9, -46 },
  { 10749, 27, 49, 26, 1, -49 },
  { 10915, 13, 49, 12, 1, -49 },
  { 10995, 43, 35, 47, 1, -35 },
  { 11184, 27, 35, 31, 1, -35 },
  { 11303, 26, 36, 32, 3, -35 },
  { 11420, 31, 50, 32, -2, -35 },
  { 11614, 28, 50, 32, 3, -35 },
  { 11789, 22, 34, 21, 1, -34 },
  { 11883, 23, 36, 24, 0, -35 },
  { 11987, 17, 43, 17, 2, -42 },
  { 12079, 27, 35, 31, 3, -34 },
  { 12198, 24, 34, 24, 3, -34 },
  { 12300, 37, 34, 38, 4, -34 },
  { 12458, 29, 34, 26, -2, -34 },
  { 12582, 34, 49, 24, -7, -34 },
  { 12791, 25, 34, 23, -1, -34 },
  { 12898, 22, 56, 21, 2, -46 },
  { 13052, 2, 64, 30, 15, -49 },
  { 13068, 22, 56, 21, -3, -46 },
  { 13222, 27, 6, 33, 4, -26 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC64PT7B_H_
