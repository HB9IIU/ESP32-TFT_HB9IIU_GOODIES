#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC44PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03,
  0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x07, 0x03, 0x80,
  0x30, 0xD8, 0x66, 0x19, 0x86, 0x41, 0x10, 0x4C, 0x33, 0x0C, 0x82, 0x20,
  0x88, 0x20, 0x00, 0x18, 0x18, 0x00, 0x20, 0x20, 0x00, 0xC0, 0xC0, 0x01,
  0x81, 0x80, 0x02, 0x02, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x18, 0x00, 0x20,
  0x30, 0x00, 0x40, 0x40, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x04, 0x04,
  0x00, 0x18, 0x08, 0x00, 0x30, 0x30, 0x00, 0x40, 0x40, 0x01, 0x80, 0x80,
  0x03, 0x03, 0x00, 0x04, 0x06, 0x00, 0x08, 0x08, 0x00, 0x30, 0x30, 0x0F,
  0xFF, 0xFF, 0x00, 0x80, 0x80, 0x03, 0x01, 0x00, 0x06, 0x06, 0x00, 0x08,
  0x0C, 0x00, 0x10, 0x10, 0x00, 0x60, 0x60, 0x00, 0x80, 0xC0, 0x01, 0x01,
  0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x0F, 0x80, 0x0F, 0xFE, 0x07, 0x10, 0xC1, 0x82,
  0x00, 0x30, 0x40, 0x0C, 0x18, 0x01, 0x82, 0x00, 0x30, 0x40, 0x06, 0x08,
  0x00, 0xC3, 0x00, 0x0C, 0x60, 0x01, 0xC8, 0x00, 0x1D, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x27, 0x00, 0x04, 0x30, 0x00, 0x86,
  0x00, 0x30, 0x40, 0x04, 0x08, 0x00, 0x81, 0x00, 0x10, 0x60, 0x06, 0x0C,
  0x00, 0xC3, 0x08, 0x10, 0xC1, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x03, 0xC0,
  0x01, 0x07, 0xF0, 0x03, 0x06, 0x08, 0x01, 0x03, 0x06, 0x01, 0x83, 0x03,
  0x01, 0x81, 0x01, 0x80, 0x81, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0x40, 0x40,
  0x20, 0x60, 0x20, 0x10, 0x60, 0x30, 0x08, 0x20, 0x18, 0x0C, 0x30, 0x0C,
  0x06, 0x30, 0x06, 0x02, 0x10, 0xF3, 0x03, 0x19, 0xCD, 0x81, 0x18, 0x83,
  0xC1, 0x88, 0xC1, 0xA1, 0x8C, 0xC0, 0xDF, 0x8C, 0x60, 0x67, 0x84, 0x20,
  0x30, 0x06, 0x30, 0x18, 0x06, 0x18, 0x0C, 0x02, 0x0C, 0x06, 0x03, 0x04,
  0x02, 0x03, 0x02, 0x01, 0x01, 0x03, 0x01, 0x81, 0x81, 0x80, 0xC1, 0x80,
  0xC0, 0x40, 0xC0, 0x20, 0x60, 0xC0, 0x10, 0x60, 0x40, 0x0C, 0x60, 0x60,
  0x03, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFE, 0x00,
  0x0C, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0x40, 0x04, 0x01, 0x00, 0x30,
  0x04, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x10, 0x38,
  0x00, 0x61, 0xC0, 0x01, 0x8E, 0x00, 0x03, 0x60, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x60, 0x00, 0x38, 0xC0, 0x01, 0x81, 0x00, 0xCC, 0x06,
  0x02, 0x20, 0x0C, 0x19, 0x80, 0x30, 0x64, 0x00, 0x63, 0x30, 0x01, 0x88,
  0xC0, 0x03, 0x63, 0x00, 0x0F, 0x0C, 0x00, 0x18, 0x30, 0x00, 0xE0, 0xC0,
  0x06, 0xC1, 0x80, 0x31, 0x83, 0x83, 0x86, 0x07, 0xF8, 0x0C, 0x36, 0x66,
  0x44, 0xCC, 0x88, 0x80, 0x00, 0x38, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x80, 0x80, 0xE0, 0x80, 0x38, 0x80, 0x0C, 0x81, 0x03, 0x7F,
  0x01, 0x80, 0x06, 0x80, 0x0C, 0xC0, 0x18, 0x40, 0x30, 0x60, 0x60, 0x20,
  0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x0F, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x30, 0xC6, 0x18, 0xC3, 0x08, 0x61, 0x0C,
  0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F,
  0xC0, 0x18, 0x18, 0x0C, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x04,
  0x60, 0x01, 0x18, 0x00, 0x44, 0x00, 0x13, 0x00, 0x04, 0xC0, 0x01, 0x20,
  0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00, 0xD0, 0x00,
  0x2C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x4C, 0x00, 0x33,
  0x00, 0x0C, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xC1, 0x00, 0x30, 0x60,
  0x18, 0x18, 0x0C, 0x03, 0x8E, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0xF0, 0x6C,
  0x73, 0x30, 0xB8, 0x64, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03,
  0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x00,
  0x1F, 0x00, 0x0F, 0xFC, 0x03, 0xC0, 0xE0, 0x10, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0xFC,
  0x03, 0xC0, 0x60, 0x30, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x08, 0x00, 0xE0, 0xF0, 0x3C,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x1A, 0x00, 0x01, 0x20, 0x00, 0x36, 0x00, 0x06, 0x60, 0x00, 0xC6, 0x00,
  0x08, 0x40, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0xC0, 0x80,
  0x08, 0x08, 0x01, 0x81, 0x80, 0x30, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x10,
  0x0C, 0x01, 0x01, 0x80, 0x30, 0x30, 0x03, 0x06, 0x00, 0x30, 0x40, 0x02,
  0x0F, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x01,
  0xFF, 0xF0, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0B, 0xF0, 0x01, 0xFF, 0xC0, 0x08, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x80, 0x1C, 0x0E,
  0x07, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x63, 0xF8, 0x09, 0xC3, 0x83, 0x60, 0x18, 0x70, 0x03, 0x0E, 0x00, 0x31,
  0x80, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x66,
  0x00, 0x08, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x18, 0x20, 0x03, 0x06,
  0x00, 0xC0, 0x60, 0x30, 0x0E, 0x1C, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xF8,
  0x01, 0x80, 0xC0, 0x30, 0x06, 0x02, 0x00, 0x20, 0x60, 0x03, 0x06, 0x00,
  0x30, 0x60, 0x03, 0x04, 0x00, 0x20, 0x60, 0x06, 0x06, 0x00, 0x60, 0x20,
  0x0C, 0x03, 0x01, 0x80, 0x18, 0x70, 0x00, 0xDC, 0x00, 0x07, 0x00, 0x03,
  0xD8, 0x00, 0x70, 0xC0, 0x1C, 0x06, 0x03, 0x00, 0x30, 0x60, 0x01, 0x06,
  0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18,
  0xC0, 0x01, 0x8C, 0x00, 0x30, 0x60, 0x03, 0x07, 0x00, 0x60, 0x38, 0x1C,
  0x00, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x06, 0x06, 0x01, 0x80,
  0x60, 0x60, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00,
  0x63, 0x00, 0x0C, 0x40, 0x01, 0x88, 0x00, 0x31, 0x00, 0x06, 0x20, 0x00,
  0xC4, 0x00, 0x38, 0xC0, 0x0E, 0x18, 0x03, 0x41, 0x80, 0xD8, 0x1F, 0xF3,
  0x01, 0xF8, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x20, 0x70, 0x07, 0xFC, 0x00, 0x04, 0x1C, 0x38, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x38, 0x60, 0x00, 0x80, 0x70, 0x1C, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x30, 0x0C,
  0x06, 0x01, 0x80, 0x40, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x03, 0xE0, 0x3F, 0xF0, 0x60, 0x70, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x18,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x02, 0x08, 0x00, 0x00, 0x18, 0xC0, 0x3F,
  0xC0, 0xCC, 0x03, 0x02, 0x06, 0x60, 0x30, 0x30, 0x32, 0x03, 0x01, 0x81,
  0xB0, 0x30, 0x08, 0x0D, 0x81, 0x00, 0x40, 0x68, 0x18, 0x06, 0x02, 0xC0,
  0xC0, 0x30, 0x16, 0x04, 0x01, 0x01, 0xB0, 0x60, 0x18, 0x0D, 0x83, 0x00,
  0xC0, 0x4C, 0x18, 0x06, 0x06, 0x60, 0xC0, 0x70, 0x23, 0x06, 0x03, 0x83,
  0x18, 0x10, 0x2C, 0x30, 0xC0, 0xC6, 0x33, 0x06, 0x03, 0xE1, 0xF0, 0x30,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x20,
  0x00, 0x1F, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x16, 0x00, 0x01, 0xB0,
  0x00, 0x08, 0x80, 0x00, 0xC4, 0x00, 0x04, 0x20, 0x00, 0x61, 0x00, 0x02,
  0x08, 0x00, 0x30, 0x60, 0x01, 0x03, 0x00, 0x18, 0x18, 0x00, 0x80, 0xC0,
  0x0C, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x04, 0x03, 0xFF,
  0xE0, 0x30, 0x01, 0x01, 0x80, 0x08, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x0C,
  0x00, 0x18, 0x60, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x33, 0x00, 0x01,
  0x98, 0x00, 0x0D, 0x80, 0x00, 0x3C, 0x00, 0x01, 0x01, 0xFF, 0xC0, 0x08,
  0x07, 0x80, 0xC0, 0x0E, 0x06, 0x00, 0x30, 0x30, 0x00, 0x81, 0x80, 0x04,
  0x08, 0x00, 0x20, 0xC0, 0x01, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x00,
  0x0C, 0x18, 0x00, 0x60, 0xC0, 0x0E, 0x06, 0x01, 0xC0, 0x3F, 0xF8, 0x01,
  0x00, 0xF0, 0x18, 0x01, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00,
  0xC1, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x20,
  0x00, 0x61, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x07, 0x06, 0x00, 0x70,
  0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0,
  0x0E, 0x00, 0x80, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x60, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x02, 0x03, 0xC0, 0x0C, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0x30, 0x00,
  0xC0, 0x60, 0x01, 0x80, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06,
  0x0C, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61,
  0x80, 0x00, 0xC3, 0x00, 0x01, 0x84, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30,
  0x00, 0x08, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x00, 0x01, 0x86, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x20, 0x00, 0x60, 0x40, 0x01,
  0x81, 0x80, 0x06, 0x03, 0x00, 0x38, 0x06, 0x01, 0xE0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFE, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFE, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0xF8, 0x03, 0x80, 0x38, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x07,
  0xF9, 0x80, 0x1F, 0xF3, 0x00, 0x00, 0x66, 0x00, 0x00, 0x8C, 0x00, 0x03,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x21,
  0x80, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x03, 0x00, 0x04, 0x07,
  0x00, 0x08, 0x07, 0x80, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x10,
  0x10, 0x00, 0x18, 0x08, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x02,
  0x03, 0x00, 0x01, 0x01, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00,
  0x60, 0x60, 0x00, 0x20, 0x3F, 0xFF, 0xF0, 0x10, 0x00, 0x18, 0x18, 0x00,
  0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x02, 0x03, 0x00, 0x03, 0x01, 0x00,
  0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x20, 0x20,
  0x00, 0x30, 0x10, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x04, 0x06,
  0x00, 0x02, 0x02, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0x01, 0xFC, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x07, 0xF0,
  0x01, 0xE0, 0x00, 0x01, 0x80, 0x07, 0x01, 0x00, 0x0C, 0x03, 0x00, 0x18,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x02, 0x00, 0xC0, 0x02, 0x01, 0x80,
  0x06, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x0D, 0xE0, 0x00,
  0x0B, 0x20, 0x00, 0x1E, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x10, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00,
  0x30, 0x04, 0x00, 0x20, 0x06, 0x00, 0x20, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x60, 0x03, 0x00, 0x60, 0x01, 0x00, 0x40, 0x01, 0x80, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xB0, 0x3C,
  0x00, 0x03, 0x40, 0x48, 0x00, 0x04, 0x80, 0x90, 0x00, 0x1B, 0x03, 0x20,
  0x00, 0x66, 0x06, 0x60, 0x00, 0xCC, 0x0C, 0xC0, 0x03, 0x10, 0x11, 0x80,
  0x06, 0x60, 0x63, 0x00, 0x18, 0xC0, 0xC6, 0x00, 0x31, 0x81, 0x84, 0x00,
  0xC3, 0x03, 0x08, 0x01, 0x04, 0x04, 0x10, 0x06, 0x18, 0x18, 0x30, 0x08,
  0x30, 0x30, 0x60, 0x30, 0x60, 0x60, 0xC0, 0xC0, 0x80, 0x81, 0x81, 0x81,
  0x01, 0x03, 0x06, 0x06, 0x06, 0x02, 0x0C, 0x0C, 0x0C, 0x04, 0x30, 0x18,
  0x18, 0x08, 0x60, 0x20, 0x20, 0x19, 0x80, 0x40, 0x40, 0x32, 0x01, 0x81,
  0x80, 0x6C, 0x03, 0x03, 0x00, 0xD0, 0x06, 0x06, 0x01, 0xE0, 0x08, 0x08,
  0x01, 0x80, 0x30, 0x30, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x20, 0x3C, 0x00, 0x18, 0x0F, 0x00, 0x06, 0x03, 0x40, 0x01,
  0x80, 0x98, 0x00, 0x60, 0x26, 0x00, 0x10, 0x18, 0x80, 0x0C, 0x06, 0x30,
  0x03, 0x01, 0x8C, 0x00, 0xC0, 0x41, 0x00, 0x20, 0x30, 0x60, 0x08, 0x0C,
  0x18, 0x06, 0x03, 0x02, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x20, 0x30, 0x10,
  0x18, 0x04, 0x0C, 0x06, 0x01, 0x83, 0x01, 0x80, 0x60, 0xC0, 0x40, 0x08,
  0x30, 0x10, 0x03, 0x08, 0x0C, 0x00, 0xC6, 0x03, 0x00, 0x11, 0x80, 0xC0,
  0x06, 0x60, 0x20, 0x01, 0x98, 0x08, 0x00, 0x24, 0x06, 0x00, 0x0F, 0x01,
  0x80, 0x03, 0xC0, 0x60, 0x00, 0x70, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x06,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0x01, 0xC0, 0x1C, 0x00,
  0xC0, 0x60, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x01, 0x0C, 0x00, 0x03,
  0x18, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x05, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0xD8, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x31, 0x80, 0x00, 0xC1, 0x00, 0x01, 0x83, 0x00, 0x06, 0x07, 0x00, 0x18,
  0x07, 0x00, 0x60, 0x07, 0x83, 0x80, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x08, 0x0F, 0x00, 0xC0, 0x1C, 0x06, 0x00, 0x60, 0x30, 0x01, 0x01, 0x80,
  0x0C, 0x08, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0x81,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x02, 0x06, 0x00, 0x30, 0x30, 0x03,
  0x01, 0x00, 0x70, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xC0, 0x07, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x60, 0x00, 0xC1, 0x80, 0x01,
  0x83, 0x00, 0x01, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x98, 0x00, 0x03, 0x30, 0x00,
  0x06, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xC1, 0x00, 0x01,
  0x83, 0x00, 0x06, 0x07, 0x00, 0x18, 0x07, 0x00, 0x60, 0x07, 0x83, 0x80,
  0x03, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x08, 0x0F, 0x00, 0xC0, 0x1C, 0x06, 0x00, 0x60, 0x30,
  0x01, 0x01, 0x80, 0x0C, 0x08, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18,
  0x30, 0x00, 0x81, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x06, 0x06, 0x00,
  0x70, 0x30, 0x07, 0x01, 0x03, 0xE0, 0x1F, 0xFC, 0x00, 0xC0, 0xC0, 0x06,
  0x02, 0x00, 0x30, 0x18, 0x01, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0xC0, 0x20, 0x06, 0x01, 0x00, 0x10, 0x18, 0x00, 0xC0, 0xC0,
  0x06, 0x06, 0x00, 0x30, 0x20, 0x00, 0xC3, 0x00, 0x06, 0x00, 0x00, 0x1F,
  0x80, 0x0F, 0xFF, 0x01, 0xC0, 0x30, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x08, 0x00,
  0xE0, 0xF0, 0x3C, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x0C, 0x00,
  0x06, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x06, 0x18, 0x00, 0x04, 0x18, 0x00,
  0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x30, 0x00,
  0x08, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x20, 0x00,
  0x10, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x40, 0x00,
  0x30, 0x40, 0x00, 0x20, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x80, 0xC0, 0x01,
  0x80, 0x60, 0x03, 0x00, 0x70, 0x06, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0xF8,
  0x00, 0xC0, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00, 0x64, 0x00, 0x0C, 0x40,
  0x00, 0xC4, 0x00, 0x18, 0x40, 0x01, 0x84, 0x00, 0x30, 0x60, 0x03, 0x06,
  0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x03, 0x00, 0x20, 0x30, 0x02, 0x06, 0x00, 0x20, 0x60,
  0x02, 0x0C, 0x00, 0x20, 0xC0, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x10,
  0x00, 0x33, 0x00, 0x03, 0x20, 0x00, 0x36, 0x00, 0x03, 0x40, 0x00, 0x3C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x1A, 0x00, 0x1C, 0x00, 0x34, 0x00, 0x28, 0x00, 0x48, 0x00,
  0xD0, 0x01, 0x98, 0x01, 0xB0, 0x03, 0x30, 0x02, 0x60, 0x0C, 0x60, 0x0C,
  0xC0, 0x18, 0xC0, 0x11, 0x80, 0x61, 0x80, 0x63, 0x00, 0xC3, 0x00, 0x86,
  0x01, 0x06, 0x03, 0x0C, 0x06, 0x0C, 0x06, 0x18, 0x0C, 0x18, 0x18, 0x30,
  0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x40, 0xC1, 0x80, 0xC1, 0x81, 0x83,
  0x01, 0x82, 0x03, 0x04, 0x03, 0x0C, 0x06, 0x18, 0x06, 0x10, 0x0C, 0x20,
  0x0C, 0x60, 0x18, 0xC0, 0x18, 0xC0, 0x31, 0x80, 0x33, 0x00, 0x66, 0x00,
  0x66, 0x00, 0xCC, 0x00, 0xC8, 0x01, 0x90, 0x01, 0xB0, 0x03, 0x60, 0x03,
  0x40, 0x02, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x01, 0x80,
  0x20, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x80, 0x02, 0x00, 0xC0,
  0x01, 0x00, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x10, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x06, 0x20, 0x00, 0x01, 0x30, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x19, 0x00, 0x00, 0x08, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x08, 0x00, 0x04, 0x06, 0x00, 0x06, 0x03, 0x00, 0x06,
  0x01, 0x80, 0x06, 0x00, 0x40, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x03,
  0x00, 0x04, 0x01, 0x00, 0x03, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xF0,
  0x00, 0x64, 0x00, 0x19, 0x80, 0x0C, 0x60, 0x06, 0x18, 0x01, 0x82, 0x00,
  0xC0, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x03, 0x02, 0x00, 0x41, 0x80,
  0x18, 0xC0, 0x06, 0x30, 0x01, 0x98, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0xC0, 0x81,
  0x03, 0x06, 0x0C, 0x08, 0x10, 0x20, 0x60, 0xC1, 0x81, 0x02, 0x04, 0x0C,
  0x18, 0x30, 0x20, 0x40, 0x81, 0x83, 0x06, 0x0C, 0x08, 0x10, 0x30, 0x60,
  0xC1, 0x80, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x01, 0xA0, 0x00, 0xCC, 0x00, 0x23, 0x00, 0x18, 0x40, 0x0C, 0x18,
  0x03, 0x06, 0x01, 0x80, 0x80, 0x40, 0x30, 0x30, 0x0C, 0x18, 0x01, 0x06,
  0x00, 0x63, 0x00, 0x19, 0x80, 0x02, 0x60, 0x00, 0xF0, 0x00, 0x30, 0x7F,
  0xFF, 0xFF, 0xFC, 0xC3, 0x18, 0x61, 0x0C, 0x20, 0x00, 0x70, 0x20, 0x3F,
  0x88, 0x1C, 0x19, 0x06, 0x01, 0x21, 0xC0, 0x1C, 0x30, 0x03, 0x8C, 0x00,
  0x61, 0x80, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x00, 0x06, 0x60, 0x00,
  0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x10, 0xC0, 0x06,
  0x18, 0x00, 0xC3, 0x00, 0x38, 0x60, 0x0F, 0x0C, 0x01, 0x40, 0xC0, 0xC8,
  0x1C, 0x31, 0x01, 0xFC, 0x60, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC3, 0xC0, 0x11, 0xFE, 0x06, 0x60, 0xE0, 0xD8, 0x0C,
  0x1E, 0x00, 0xC2, 0x80, 0x18, 0x60, 0x03, 0x1C, 0x00, 0x63, 0x00, 0x0C,
  0x60, 0x01, 0x8C, 0x00, 0x31, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x11,
  0x80, 0x06, 0x20, 0x00, 0xC4, 0x00, 0x11, 0x80, 0x06, 0x30, 0x00, 0xC7,
  0x00, 0x30, 0xA0, 0x0C, 0x36, 0x03, 0x86, 0x61, 0xC0, 0x87, 0xF0, 0x00,
  0x00, 0x7C, 0x01, 0xFF, 0x07, 0x01, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x38, 0x30, 0x1F, 0xF0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x03, 0xC3, 0x00, 0x7F, 0x18, 0x0E, 0x0C, 0xC0, 0xC0, 0x14, 0x0C, 0x00,
  0xA0, 0x60, 0x07, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x00, 0x04, 0x18,
  0x00, 0x60, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x0C,
  0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x38, 0x30, 0x01, 0x81, 0x80,
  0x1C, 0x0C, 0x01, 0xA0, 0x60, 0x0B, 0x01, 0x80, 0xD8, 0x0E, 0x1C, 0x80,
  0x3F, 0x84, 0x00, 0x00, 0x70, 0x01, 0xFE, 0x07, 0x06, 0x0E, 0x03, 0x0C,
  0x03, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x60, 0x06, 0x60, 0x0C, 0x60,
  0x38, 0x7F, 0xE0, 0xFF, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x38, 0x1F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFC, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0xC0, 0x70, 0x66, 0x06, 0x00, 0xA0,
  0x70, 0x05, 0x03, 0x00, 0x38, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x18, 0x00,
  0x20, 0xC0, 0x03, 0x04, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18,
  0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0xC1, 0x80, 0x0C,
  0x0C, 0x00, 0xE0, 0x60, 0x0F, 0x03, 0x00, 0x58, 0x0C, 0x06, 0xC0, 0x70,
  0xE4, 0x01, 0xFC, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0xE0, 0x70, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x87, 0x80, 0x47, 0xF8, 0x13, 0x07,
  0x0D, 0x80, 0xC3, 0xC0, 0x10, 0xA0, 0x04, 0x30, 0x01, 0x1C, 0x00, 0xC6,
  0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x10, 0x00, 0x8C, 0x00, 0x63, 0x00,
  0x18, 0xC0, 0x06, 0x20, 0x01, 0x88, 0x00, 0x46, 0x00, 0x31, 0x80, 0x0C,
  0x60, 0x03, 0x10, 0x00, 0x8C, 0x00, 0x23, 0x00, 0x18, 0xC0, 0x06, 0x00,
  0x01, 0x01, 0xC0, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x02, 0x02, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x07, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xF8, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x1C, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x01, 0x80, 0xC0, 0xC0,
  0x20, 0x60, 0x18, 0x30, 0x06, 0x18, 0x01, 0x8C, 0x00, 0x46, 0x00, 0x13,
  0x80, 0x0D, 0xB0, 0x03, 0xCC, 0x00, 0xE1, 0x00, 0x30, 0x60, 0x08, 0x18,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x06, 0x0C, 0x01, 0x83,
  0x00, 0x20, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x10,
  0x08, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18,
  0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C,
  0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x11,
  0xFC, 0x1F, 0xC0, 0xCC, 0x39, 0xC1, 0x83, 0x40, 0x64, 0x06, 0x0E, 0x00,
  0xA0, 0x08, 0x38, 0x03, 0x80, 0x30, 0xC0, 0x0C, 0x00, 0x87, 0x00, 0x30,
  0x02, 0x18, 0x01, 0x80, 0x18, 0x60, 0x06, 0x00, 0x61, 0x80, 0x18, 0x01,
  0x84, 0x00, 0x40, 0x04, 0x30, 0x01, 0x00, 0x10, 0xC0, 0x0C, 0x00, 0xC3,
  0x00, 0x30, 0x03, 0x08, 0x00, 0xC0, 0x0C, 0x20, 0x02, 0x00, 0x21, 0x80,
  0x18, 0x00, 0x86, 0x00, 0x60, 0x06, 0x18, 0x01, 0x80, 0x18, 0x40, 0x04,
  0x00, 0x63, 0x00, 0x10, 0x01, 0x0C, 0x00, 0xC0, 0x0C, 0x30, 0x03, 0x00,
  0x30, 0x00, 0x1E, 0x01, 0x1F, 0xE0, 0xCC, 0x1C, 0x36, 0x03, 0x0F, 0x00,
  0x42, 0x80, 0x10, 0xC0, 0x04, 0x70, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31,
  0x80, 0x0C, 0x40, 0x02, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0x80,
  0x06, 0x20, 0x01, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x40, 0x02,
  0x30, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x18, 0x00, 0x78, 0x00, 0x7F, 0x80,
  0x70, 0x70, 0x38, 0x06, 0x1C, 0x01, 0x86, 0x00, 0x23, 0x00, 0x0C, 0xC0,
  0x03, 0x60, 0x00, 0xD8, 0x00, 0x34, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03, 0x30, 0x00, 0xCC,
  0x00, 0x23, 0x00, 0x18, 0x60, 0x0C, 0x18, 0x06, 0x03, 0x87, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0x80, 0x08, 0xFF, 0x00, 0x4C, 0x1C, 0x06, 0xC0, 0x60,
  0x3C, 0x01, 0x81, 0x40, 0x0C, 0x0E, 0x00, 0x60, 0xE0, 0x03, 0x06, 0x00,
  0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x08, 0x00, 0x30, 0xC0, 0x01, 0x86,
  0x00, 0x08, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x08, 0x00, 0x30, 0xC0, 0x03,
  0x06, 0x00, 0x18, 0x38, 0x01, 0x81, 0x40, 0x18, 0x1B, 0x01, 0xC0, 0xCC,
  0x38, 0x06, 0x3F, 0x80, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F, 0x8C,
  0x1C, 0x19, 0x86, 0x01, 0xA1, 0xC0, 0x14, 0x30, 0x03, 0x8C, 0x00, 0x31,
  0x80, 0x06, 0x60, 0x00, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x60, 0x00, 0xCC,
  0x00, 0x19, 0x80, 0x02, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x07, 0x18,
  0x00, 0xC3, 0x00, 0x38, 0x60, 0x0F, 0x0C, 0x01, 0x60, 0xC0, 0x6C, 0x1C,
  0x39, 0x01, 0xFC, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x08, 0xFC, 0x13, 0x00, 0x6C, 0x00,
  0xF0, 0x01, 0x40, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x00, 0xF8, 0x03, 0xFF, 0x0E, 0x03, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x80, 0x30, 0xE0, 0x60, 0x7F,
  0xC0, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x1F, 0xFC, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10,
  0x03, 0x00, 0x61, 0x07, 0xE0, 0x18, 0x00, 0x46, 0x00, 0x31, 0x80, 0x0C,
  0x60, 0x03, 0x10, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x20,
  0x01, 0x88, 0x00, 0x46, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x10, 0x00,
  0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x8C, 0x01, 0xC3,
  0x00, 0xD0, 0xC0, 0x64, 0x18, 0x33, 0x03, 0xF8, 0xC0, 0xC0, 0x03, 0xC0,
  0x03, 0x40, 0x06, 0x40, 0x06, 0x40, 0x0C, 0x60, 0x08, 0x60, 0x18, 0x60,
  0x10, 0x60, 0x30, 0x60, 0x20, 0x60, 0x60, 0x60, 0x40, 0x20, 0xC0, 0x21,
  0x80, 0x21, 0x80, 0x23, 0x00, 0x33, 0x00, 0x36, 0x00, 0x36, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x80, 0x18, 0x01, 0xC0, 0x0C,
  0x01, 0xA0, 0x0E, 0x00, 0xD0, 0x05, 0x00, 0xC8, 0x06, 0x80, 0x64, 0x02,
  0x40, 0x22, 0x03, 0x20, 0x31, 0x01, 0x10, 0x10, 0x81, 0x8C, 0x18, 0x40,
  0x86, 0x0C, 0x20, 0xC3, 0x0C, 0x18, 0x61, 0x86, 0x0C, 0x60, 0xC2, 0x06,
  0x30, 0x63, 0x03, 0x30, 0x31, 0x01, 0x98, 0x19, 0x80, 0xC8, 0x0C, 0x80,
  0x6C, 0x06, 0xC0, 0x34, 0x01, 0x60, 0x1E, 0x00, 0xA0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x38, 0x18, 0x03,
  0x00, 0x40, 0x10, 0x03, 0x01, 0x80, 0x18, 0x18, 0x00, 0x41, 0x80, 0x03,
  0x18, 0x00, 0x18, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x05, 0x00, 0x00, 0x6C, 0x00, 0x06, 0x60, 0x00, 0x61,
  0x00, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x01, 0x00, 0x30, 0x0C, 0x03,
  0x00, 0x60, 0x10, 0x01, 0x83, 0x80, 0x0C, 0x00, 0x00, 0x80, 0x03, 0x00,
  0x80, 0x06, 0x00, 0xC0, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x30, 0x00, 0x40, 0x20, 0x00,
  0x40, 0x60, 0x00, 0x40, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x61, 0x80, 0x00,
  0x61, 0x80, 0x00, 0x63, 0x00, 0x00, 0x63, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x38, 0x01, 0xF0, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x1F,
  0xE0, 0x1C, 0x1E, 0x0E, 0x01, 0xFE, 0x00, 0x0C, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 31, 10, 1, -31 },
  { 36, 10, 11, 14, 5, -31 },
  { 50, 23, 31, 23, 1, -31 },
  { 140, 19, 36, 21, 1, -33 },
  { 226, 25, 33, 30, 3, -32 },
  { 330, 22, 32, 25, 1, -32 },
  { 418, 4, 11, 8, 5, -31 },
  { 424, 13, 38, 11, 1, -31 },
  { 486, 13, 38, 11, -3, -31 },
  { 548, 16, 16, 20, 5, -33 },
  { 580, 18, 21, 22, 3, -26 },
  { 628, 6, 11, 8, -2, -5 },
  { 637, 10, 2, 13, 1, -13 },
  { 640, 3, 3, 9, 1, -3 },
  { 642, 19, 31, 14, -2, -31 },
  { 716, 18, 32, 21, 2, -32 },
  { 788, 10, 31, 21, 6, -31 },
  { 827, 20, 32, 21, 0, -32 },
  { 907, 20, 32, 21, 0, -32 },
  { 987, 20, 32, 21, 0, -32 },
  { 1067, 20, 31, 21, 1, -31 },
  { 1145, 19, 32, 21, 2, -32 },
  { 1221, 18, 31, 21, 4, -31 },
  { 1291, 20, 32, 21, 1, -32 },
  { 1371, 19, 32, 21, 1, -32 },
  { 1447, 7, 24, 9, 1, -24 },
  { 1468, 10, 30, 9, -2, -24 },
  { 1506, 18, 20, 22, 3, -26 },
  { 1551, 18, 11, 22, 3, -21 },
  { 1576, 18, 20, 22, 3, -26 },
  { 1621, 15, 32, 15, 2, -32 },
  { 1681, 29, 35, 32, 2, -31 },
  { 1808, 21, 32, 21, -3, -32 },
  { 1892, 21, 31, 23, 1, -31 },
  { 1974, 22, 32, 22, 3, -32 },
  { 2062, 23, 31, 26, 1, -31 },
  { 2152, 21, 31, 20, 1, -31 },
  { 2234, 21, 31, 19, 1, -31 },
  { 2316, 23, 32, 27, 3, -32 },
  { 2408, 25, 31, 26, 1, -31 },
  { 2505, 14, 31, 11, -1, -31 },
  { 2560, 17, 39, 9, -7, -31 },
  { 2643, 24, 31, 21, 1, -31 },
  { 2736, 14, 31, 19, 1, -31 },
  { 2791, 31, 31, 32, 1, -31 },
  { 2912, 26, 31, 27, 1, -31 },
  { 3013, 23, 32, 27, 3, -32 },
  { 3105, 21, 31, 21, 1, -31 },
  { 3187, 23, 39, 27, 3, -32 },
  { 3300, 21, 31, 22, 1, -31 },
  { 3382, 20, 32, 20, 0, -32 },
  { 3462, 18, 31, 19, 4, -31 },
  { 3532, 24, 31, 26, 3, -31 },
  { 3625, 20, 31, 21, 4, -31 },
  { 3703, 31, 31, 33, 5, -31 },
  { 3824, 25, 31, 19, -3, -31 },
  { 3921, 18, 31, 19, 4, -31 },
  { 3991, 23, 31, 20, -1, -31 },
  { 4081, 17, 38, 13, -1, -31 },
  { 4162, 7, 31, 14, 4, -31 },
  { 4190, 16, 38, 13, -3, -31 },
  { 4266, 18, 18, 22, 2, -32 },
  { 4307, 15, 2, 15, -4, 4 },
  { 4311, 5, 7, 10, 6, -34 },
  { 4316, 19, 24, 22, 2, -24 },
  { 4373, 19, 33, 22, 1, -33 },
  { 4452, 16, 24, 17, 2, -24 },
  { 4500, 21, 33, 22, 2, -33 },
  { 4587, 16, 24, 19, 2, -24 },
  { 4635, 23, 45, 11, -6, -34 },
  { 4765, 21, 35, 22, 0, -24 },
  { 4857, 18, 33, 22, 1, -33 },
  { 4932, 9, 32, 9, 1, -32 },
  { 4968, 16, 43, 9, -6, -32 },
  { 5054, 18, 33, 18, 1, -33 },
  { 5129, 9, 33, 9, 1, -33 },
  { 5167, 30, 24, 33, 1, -24 },
  { 5257, 18, 24, 22, 1, -24 },
  { 5311, 18, 24, 22, 2, -24 },
  { 5365, 21, 34, 22, -1, -24 },
  { 5455, 19, 34, 22, 2, -24 },
  { 5536, 15, 24, 14, 1, -24 },
  { 5581, 16, 24, 16, 0, -24 },
  { 5629, 11, 29, 12, 2, -29 },
  { 5669, 18, 23, 22, 2, -23 },
  { 5721, 16, 23, 16, 2, -23 },
  { 5767, 25, 23, 26, 3, -23 },
  { 5839, 21, 23, 18, -2, -23 },
  { 5900, 24, 34, 17, -5, -23 },
  { 6002, 18, 23, 16, -1, -23 },
  { 6054, 16, 38, 14, 1, -31 },
  { 6130, 2, 44, 21, 10, -33 },
  { 6141, 15, 38, 14, -2, -31 },
  { 6213, 18, 5, 22, 3, -18 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC44PT7B_H_
