#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC12PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x90, 0x80, 0x76, 0xD0, 0x14, 0x28, 0x93, 0xD2, 0x85,
  0x35, 0x28, 0x50, 0x10, 0xF5, 0x14, 0x30, 0xA2, 0xAE, 0x61, 0x00, 0x65,
  0x4A, 0xA5, 0x6B, 0xBD, 0x4C, 0xA9, 0x9C, 0x18, 0x92, 0x8E, 0x21, 0x58,
  0xE2, 0xF4, 0xF0, 0x12, 0x44, 0x48, 0x88, 0x88, 0x40, 0x21, 0x11, 0x11,
  0x22, 0x24, 0x80, 0x27, 0x4C, 0xA0, 0x21, 0x3E, 0x42, 0x10, 0x58, 0xE0,
  0x80, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0x80, 0x32, 0x63, 0x18, 0xCA,
  0x52, 0xE0, 0x75, 0x5A, 0x80, 0x38, 0x42, 0x10, 0x88, 0x88, 0xF0, 0x38,
  0x10, 0x42, 0x30, 0x20, 0x82, 0xF0, 0x08, 0x46, 0x54, 0xA7, 0xE2, 0x10,
  0x3C, 0x84, 0x10, 0x78, 0x20, 0x82, 0xF0, 0x3A, 0x21, 0x4D, 0x4A, 0x52,
  0xE0, 0xF8, 0x44, 0x22, 0x11, 0x08, 0x80, 0x18, 0x94, 0x4A, 0x31, 0x28,
  0xA2, 0x70, 0x39, 0x14, 0x51, 0x48, 0xE0, 0x84, 0xE0, 0x40, 0x20, 0x20,
  0x00, 0x94, 0x1B, 0x20, 0x83, 0x80, 0xF8, 0x3E, 0x83, 0x06, 0x6C, 0x00,
  0xE1, 0x12, 0x48, 0x80, 0x80, 0x1C, 0xC6, 0x0D, 0xFA, 0xB9, 0x72, 0xDA,
  0x80, 0xF0, 0x08, 0x21, 0x45, 0x24, 0xF4, 0x51, 0x84, 0x38, 0x94, 0x51,
  0x79, 0x14, 0x62, 0xF0, 0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x70, 0x38,
  0x49, 0x0A, 0x14, 0x28, 0x51, 0x44, 0xF0, 0x3C, 0x84, 0x10, 0x79, 0x04,
  0x20, 0xF0, 0x3C, 0x84, 0x10, 0x79, 0x04, 0x20, 0x80, 0x3D, 0x08, 0x20,
  0x9A, 0x18, 0xA2, 0x78, 0x22, 0x45, 0x0A, 0x17, 0xC8, 0x91, 0x42, 0x84,
  0x32, 0x24, 0x44, 0x44, 0xC0, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x30,
  0x22, 0x49, 0x22, 0x86, 0x0A, 0x14, 0x44, 0x88, 0x22, 0x44, 0x44, 0x48,
  0xF0, 0x20, 0x90, 0x58, 0x4A, 0x65, 0x32, 0xA9, 0x55, 0x32, 0x92, 0x00,
  0x22, 0x45, 0x4A, 0x95, 0x29, 0x93, 0x42, 0x84, 0x39, 0x18, 0x61, 0x86,
  0x18, 0x62, 0xF0, 0x38, 0x94, 0x51, 0x49, 0xC4, 0x20, 0x80, 0x39, 0x18,
  0x61, 0x86, 0x18, 0x62, 0xD0, 0x81, 0x00, 0x38, 0x94, 0x51, 0x49, 0xC5,
  0x22, 0x88, 0x3D, 0x04, 0x10, 0x20, 0x40, 0x82, 0xF0, 0xF9, 0x08, 0x84,
  0x21, 0x08, 0x80, 0x45, 0x18, 0x61, 0x86, 0x28, 0xA2, 0xF0, 0x86, 0x28,
  0xA4, 0x92, 0x8A, 0x30, 0x40, 0x88, 0xC4, 0x66, 0x53, 0x2A, 0xA5, 0x53,
  0x31, 0x88, 0x88, 0x00, 0x22, 0x44, 0x50, 0xC1, 0x02, 0x0A, 0x24, 0x88,
  0x8C, 0x65, 0x46, 0x21, 0x08, 0x80, 0x3C, 0x10, 0x84, 0x10, 0x84, 0x20,
  0xF0, 0x32, 0x44, 0x44, 0x48, 0x88, 0xC0, 0xAA, 0x55, 0x40, 0x38, 0x44,
  0x21, 0x08, 0x44, 0x21, 0x30, 0x10, 0x42, 0x92, 0xC4, 0xF0, 0xC0, 0x7D,
  0x28, 0xA2, 0x89, 0xC0, 0x20, 0x85, 0x99, 0x45, 0x14, 0xA2, 0xF0, 0xF8,
  0x88, 0x8E, 0x04, 0x11, 0x5B, 0x46, 0x28, 0xA2, 0x70, 0xF9, 0xE8, 0x8E,
  0x0E, 0x10, 0x60, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x86, 0x00, 0x7D,
  0x18, 0xA2, 0x89, 0xC0, 0x84, 0xE0, 0x21, 0x14, 0xD4, 0xA5, 0x31, 0x88,
  0x20, 0x24, 0x94, 0x80, 0x08, 0x00, 0x21, 0x08, 0x44, 0x21, 0x09, 0x80,
  0x21, 0x10, 0x95, 0x31, 0x92, 0x90, 0x25, 0x24, 0x94, 0x80, 0x7F, 0x49,
  0x49, 0x49, 0x89, 0x91, 0x7A, 0x52, 0x98, 0xC4, 0xF9, 0x99, 0x9E, 0x7D,
  0x14, 0x52, 0x8B, 0xC8, 0x20, 0x80, 0x7D, 0x18, 0xA2, 0x89, 0xC0, 0x84,
  0x10, 0x74, 0x44, 0x88, 0x74, 0x61, 0x1E, 0x27, 0x44, 0x48, 0x8C, 0x8C,
  0xA5, 0x29, 0x70, 0x9A, 0xAC, 0xC8, 0xA7, 0x4B, 0x56, 0xC9, 0x12, 0x00,
  0x4A, 0x88, 0xC9, 0x48, 0x24, 0xA2, 0x8C, 0x30, 0x82, 0x10, 0x80, 0x78,
  0x88, 0x88, 0x70, 0x19, 0x08, 0x42, 0x61, 0x08, 0x42, 0x10, 0xFF, 0xF0,
  0x20, 0x84, 0x21, 0x0C, 0x84, 0x21, 0x30, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 4, 4, 1, -9 },
  { 7, 7, 9, 6, 0, -9 },
  { 15, 6, 10, 6, 0, -9 },
  { 23, 7, 9, 8, 1, -9 },
  { 31, 6, 9, 7, 0, -9 },
  { 38, 1, 4, 2, 1, -9 },
  { 39, 4, 11, 3, 0, -9 },
  { 45, 4, 11, 3, -1, -9 },
  { 51, 5, 4, 6, 1, -9 },
  { 54, 5, 6, 6, 1, -7 },
  { 58, 2, 3, 2, -1, -1 },
  { 59, 3, 1, 4, 0, -4 },
  { 60, 1, 1, 2, 0, -1 },
  { 61, 6, 9, 4, -1, -9 },
  { 68, 5, 9, 6, 1, -9 },
  { 74, 2, 9, 6, 2, -9 },
  { 77, 5, 9, 6, 0, -9 },
  { 83, 6, 9, 6, 0, -9 },
  { 90, 5, 9, 6, 0, -9 },
  { 96, 6, 9, 6, 0, -9 },
  { 103, 5, 9, 6, 1, -9 },
  { 109, 5, 9, 6, 1, -9 },
  { 115, 6, 9, 6, 0, -9 },
  { 122, 6, 9, 6, 0, -9 },
  { 129, 2, 6, 2, 0, -6 },
  { 131, 3, 8, 2, -1, -6 },
  { 134, 5, 5, 6, 1, -7 },
  { 138, 5, 3, 6, 1, -6 },
  { 140, 5, 5, 6, 1, -7 },
  { 144, 4, 9, 4, 1, -9 },
  { 149, 7, 10, 9, 1, -9 },
  { 158, 6, 9, 6, -1, -9 },
  { 165, 6, 9, 6, 0, -9 },
  { 172, 6, 9, 6, 1, -9 },
  { 179, 7, 9, 7, 0, -9 },
  { 187, 6, 9, 6, 0, -9 },
  { 194, 6, 9, 5, 0, -9 },
  { 201, 6, 9, 7, 1, -9 },
  { 208, 7, 9, 7, 0, -9 },
  { 216, 4, 9, 3, 0, -9 },
  { 221, 5, 11, 3, -2, -9 },
  { 228, 7, 9, 6, 0, -9 },
  { 236, 4, 9, 5, 0, -9 },
  { 241, 9, 9, 9, 0, -9 },
  { 252, 7, 9, 7, 0, -9 },
  { 260, 6, 9, 7, 1, -9 },
  { 267, 6, 9, 6, 0, -9 },
  { 274, 6, 11, 7, 1, -9 },
  { 283, 6, 9, 6, 0, -9 },
  { 290, 6, 9, 5, 0, -9 },
  { 297, 5, 9, 5, 1, -9 },
  { 303, 6, 9, 7, 1, -9 },
  { 310, 6, 9, 6, 1, -9 },
  { 317, 9, 9, 9, 1, -9 },
  { 328, 7, 9, 5, -1, -9 },
  { 336, 5, 9, 5, 1, -9 },
  { 342, 6, 9, 5, 0, -9 },
  { 349, 4, 11, 3, 0, -9 },
  { 355, 2, 9, 4, 1, -9 },
  { 358, 5, 11, 3, -1, -9 },
  { 365, 6, 5, 6, 0, -9 },
  { 369, 4, 1, 4, -1, 1 },
  { 370, 1, 2, 3, 2, -9 },
  { 371, 6, 6, 6, 0, -6 },
  { 376, 6, 9, 6, 0, -9 },
  { 383, 4, 6, 5, 1, -6 },
  { 386, 6, 9, 6, 0, -9 },
  { 393, 4, 6, 5, 1, -6 },
  { 396, 7, 12, 3, -2, -9 },
  { 407, 6, 9, 6, 0, -6 },
  { 414, 5, 9, 6, 0, -9 },
  { 420, 3, 9, 2, 0, -9 },
  { 424, 5, 12, 2, -2, -9 },
  { 432, 5, 9, 5, 0, -9 },
  { 438, 3, 9, 2, 0, -9 },
  { 442, 8, 6, 9, 0, -6 },
  { 448, 5, 6, 6, 0, -6 },
  { 452, 4, 6, 6, 1, -6 },
  { 455, 6, 9, 6, 0, -6 },
  { 462, 6, 9, 6, 0, -6 },
  { 469, 4, 6, 4, 0, -6 },
  { 472, 4, 6, 4, 0, -6 },
  { 475, 4, 8, 3, 0, -8 },
  { 479, 5, 6, 6, 1, -6 },
  { 483, 4, 6, 4, 1, -6 },
  { 486, 7, 6, 7, 1, -6 },
  { 492, 5, 6, 5, 0, -6 },
  { 496, 6, 9, 5, -1, -6 },
  { 503, 5, 6, 4, 0, -6 },
  { 507, 5, 11, 4, 0, -9 },
  { 514, 1, 12, 6, 2, -9 },
  { 516, 5, 11, 4, -1, -9 },
  { 523, 5, 1, 6, 1, -5 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC12PT7B_H_
