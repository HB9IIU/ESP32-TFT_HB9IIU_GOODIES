#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC62PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x00, 0xE0,
  0x00, 0x38, 0x1C, 0xE0, 0x63, 0x03, 0x8C, 0x0E, 0x30, 0x31, 0xC0, 0xC6,
  0x03, 0x18, 0x1C, 0x60, 0x61, 0x81, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0x43,
  0x03, 0x08, 0x0C, 0x20, 0x30, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x01, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xF6, 0x7F, 0x00, 0xF0,
  0xC0, 0xC0, 0x38, 0x18, 0x00, 0x0E, 0x03, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x70, 0x18, 0x00, 0x0E, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C,
  0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x3C, 0x30, 0x00, 0x03, 0xCC, 0x00, 0x00, 0x3D, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x37, 0x80, 0x00, 0x06, 0x78, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x18, 0x38,
  0x00, 0x02, 0x07, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x60, 0x38, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x01, 0xC0, 0x80, 0x60,
  0xF0, 0x1E, 0x0C, 0x78, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x40, 0x1F, 0xE0, 0x00, 0x18, 0x03, 0x87, 0x00,
  0x03, 0x00, 0x70, 0x30, 0x00, 0x70, 0x0E, 0x03, 0x00, 0x06, 0x00, 0xC0,
  0x38, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x38, 0x03, 0x00, 0x30, 0x03, 0x80,
  0x60, 0x03, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x03, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x18, 0x00, 0x60, 0x03, 0x03, 0x80, 0x06, 0x00, 0x70, 0x30, 0x00,
  0x60, 0x06, 0x06, 0x00, 0x0E, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0x06, 0x0C,
  0x1F, 0x8E, 0x00, 0xE1, 0x83, 0xFC, 0xE0, 0x0C, 0x38, 0x70, 0xEE, 0x01,
  0xC3, 0x0C, 0x06, 0x60, 0x18, 0x61, 0xC0, 0x66, 0x03, 0x8E, 0x18, 0x06,
  0x70, 0x70, 0xC3, 0x00, 0x73, 0x8E, 0x18, 0x30, 0x07, 0x3F, 0xC3, 0x86,
  0x00, 0x70, 0xF0, 0x30, 0x60, 0x06, 0x00, 0x07, 0x06, 0x00, 0x60, 0x00,
  0x60, 0xE0, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x01, 0xC0, 0xC0, 0x06,
  0x00, 0x18, 0x0C, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x0C, 0x00, 0x70, 0x1C,
  0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x01, 0x80, 0x30,
  0x07, 0x00, 0x1C, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x0C, 0x00, 0x0C,
  0x0E, 0x01, 0xC0, 0x00, 0xF3, 0xC0, 0x38, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x00, 0x30, 0x03, 0x80, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x07, 0x81, 0xC0, 0x07, 0x0F,
  0x00, 0xC0, 0x06, 0x0C, 0x00, 0xE0, 0x0E, 0x1C, 0x00, 0x60, 0x0C, 0x38,
  0x00, 0x70, 0x1C, 0x30, 0x00, 0x30, 0x18, 0x70, 0x00, 0x38, 0x38, 0x60,
  0x00, 0x1C, 0x30, 0x60, 0x00, 0x0C, 0x60, 0x60, 0x00, 0x0E, 0xE0, 0xE0,
  0x00, 0x07, 0xC0, 0xE0, 0x00, 0x07, 0x80, 0x60, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x07, 0x80, 0x60, 0x00, 0x1D, 0x80, 0x70, 0x00, 0x39, 0xC0, 0x38,
  0x00, 0x70, 0xE0, 0x3C, 0x01, 0xE0, 0xE0, 0x1F, 0xFF, 0xC0, 0x70, 0x07,
  0xFF, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x39, 0xCC, 0x63, 0x39, 0x8C,
  0x63, 0x31, 0x8C, 0x62, 0x10, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x18, 0x06, 0x00, 0x7C, 0x0C,
  0x00, 0x1E, 0x18, 0x00, 0x0E, 0x20, 0x04, 0x07, 0x43, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x62, 0x00, 0x01, 0x86, 0x00,
  0x06, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0xE0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x81, 0xC0, 0xC0,
  0xE0, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x03, 0x03, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xF7, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xE1, 0xE0, 0x01, 0xE0,
  0x1C, 0x00, 0xE0, 0x03, 0x00, 0x30, 0x00, 0xE0, 0x1C, 0x00, 0x18, 0x0E,
  0x00, 0x06, 0x03, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x1C, 0x60, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x06, 0x30, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x07, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x30,
  0x38, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x80, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xF0, 0x0F, 0x80,
  0xF6, 0x07, 0x98, 0x38, 0xE3, 0xC3, 0x9C, 0x0C, 0xE0, 0x31, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xC0,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x04, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x02, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xE1, 0xF0,
  0x00, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x20, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x08, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x04, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x3C,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x1C,
  0x18, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x18, 0x00, 0x06, 0x03, 0x80,
  0x00, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0x30, 0x00, 0x30,
  0x03, 0x00, 0x06, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x06, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x0C,
  0x06, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x02, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x80, 0x00,
  0xF0, 0x0E, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0x83, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0xFF, 0x80, 0x1C, 0x7F, 0xF8, 0x03,
  0x1C, 0x07, 0x80, 0x66, 0x00, 0x38, 0x1D, 0x80, 0x03, 0x03, 0xE0, 0x00,
  0x70, 0x78, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x30,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x1C, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x38, 0x70, 0x00, 0x06, 0x0E, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x30,
  0x18, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0x30, 0x00, 0x60, 0x07, 0x00,
  0x3C, 0x00, 0x70, 0x0F, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xF8,
  0x7C, 0x00, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x01, 0x80, 0x01, 0xC0,
  0x70, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x70, 0x00,
  0x0C, 0x0E, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x1C, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x3C, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x8E, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x78, 0x00, 0xE0, 0x1C, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x1C, 0x30,
  0x00, 0x03, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x0F, 0x00, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xE3,
  0xE0, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x00, 0x60, 0x38,
  0x00, 0x1C, 0x0C, 0x00, 0x07, 0x07, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30,
  0xE0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x71, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x03, 0xC7,
  0x00, 0x01, 0xE0, 0xC0, 0x00, 0xF8, 0x38, 0x00, 0x76, 0x07, 0x00, 0x3B,
  0x80, 0xF0, 0x3C, 0xC0, 0x1F, 0xFC, 0x30, 0x01, 0xFC, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x08, 0x01, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x70,
  0x3C, 0x0F, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0x87, 0xC0, 0xC0, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x06, 0x00, 0x03, 0xC0, 0x03, 0x0E, 0x00,
  0x1F, 0xFC, 0x03, 0x0C, 0x00, 0x7C, 0x3C, 0x03, 0x18, 0x00, 0xE0, 0x1C,
  0x03, 0x18, 0x01, 0xC0, 0x18, 0x03, 0x38, 0x03, 0x80, 0x18, 0x03, 0x30,
  0x03, 0x00, 0x18, 0x03, 0x30, 0x06, 0x00, 0x38, 0x03, 0x70, 0x0E, 0x00,
  0x30, 0x03, 0x60, 0x0C, 0x00, 0x30, 0x03, 0x60, 0x1C, 0x00, 0x30, 0x03,
  0x60, 0x18, 0x00, 0x70, 0x07, 0xE0, 0x18, 0x00, 0x60, 0x06, 0xC0, 0x38,
  0x00, 0x60, 0x06, 0xC0, 0x38, 0x00, 0xE0, 0x0E, 0xC0, 0x30, 0x00, 0xC0,
  0x0C, 0xC0, 0x30, 0x00, 0xC0, 0x0C, 0xC0, 0x30, 0x01, 0xC0, 0x1C, 0xC0,
  0x30, 0x01, 0xC0, 0x18, 0xC0, 0x30, 0x03, 0xC0, 0x38, 0xC0, 0x38, 0x06,
  0xC0, 0x70, 0xC0, 0x18, 0x0E, 0xC0, 0xE0, 0xC0, 0x1C, 0x1C, 0xE1, 0xC0,
  0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x30, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0x70, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x30, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x60, 0x0C,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x18, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x78, 0x01,
  0xC0, 0x1F, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0xF0, 0x18, 0x00, 0x07, 0x80, 0x60, 0x00, 0x7C, 0x03, 0x80, 0x0F,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x78, 0x00,
  0x60, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x60, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x07, 0x01, 0x80, 0x00, 0x07, 0x01, 0x80, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x03, 0x03, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x60, 0x01, 0xF8, 0x00, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x1F,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x10, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x7F, 0xF8, 0xE0, 0x00, 0x7F, 0xFC, 0x70, 0x00, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00,
  0xC0, 0x07, 0x00, 0x00, 0x60, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x38, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x30, 0x07, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x38, 0x03,
  0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x18, 0x03, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x01, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0xC1, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x30, 0x00, 0x07, 0x00, 0x18, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0x67, 0xE0, 0x00,
  0x00, 0x37, 0x30, 0x00, 0x00, 0x3B, 0x1C, 0x00, 0x00, 0x1F, 0x0E, 0x00,
  0x00, 0x0F, 0x03, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xC0, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x36, 0x00, 0xD8, 0x00, 0x00, 0x07,
  0xE0, 0x0D, 0x80, 0x00, 0x00, 0x6E, 0x00, 0xDC, 0x00, 0x00, 0x0E, 0xC0,
  0x0D, 0xC0, 0x00, 0x00, 0xCC, 0x01, 0xCC, 0x00, 0x00, 0x1C, 0xC0, 0x1C,
  0xC0, 0x00, 0x01, 0x9C, 0x01, 0x8C, 0x00, 0x00, 0x39, 0x80, 0x18, 0xC0,
  0x00, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x00, 0x71, 0x80, 0x38, 0xC0, 0x00,
  0x0E, 0x38, 0x03, 0x8E, 0x00, 0x00, 0xC3, 0x80, 0x30, 0xE0, 0x00, 0x1C,
  0x30, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x30, 0x60, 0x00, 0x38, 0x30,
  0x07, 0x06, 0x00, 0x03, 0x07, 0x00, 0x60, 0x60, 0x00, 0x70, 0x70, 0x06,
  0x06, 0x00, 0x06, 0x06, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x60, 0x0E, 0x07,
  0x00, 0x0C, 0x06, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x0C, 0x03, 0x00,
  0x38, 0x0E, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x70,
  0x0C, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0xE0, 0x1C,
  0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x81, 0xC0, 0x18, 0x01,
  0x80, 0x38, 0x18, 0x01, 0x80, 0x38, 0x01, 0x83, 0x80, 0x38, 0x03, 0x80,
  0x18, 0x30, 0x03, 0x80, 0x30, 0x01, 0x87, 0x00, 0x30, 0x03, 0x00, 0x18,
  0xE0, 0x03, 0x00, 0x70, 0x01, 0x8C, 0x00, 0x30, 0x07, 0x00, 0x19, 0xC0,
  0x07, 0x00, 0x60, 0x01, 0x98, 0x00, 0x70, 0x06, 0x00, 0x1F, 0x80, 0x06,
  0x00, 0x60, 0x00, 0xF0, 0x00, 0x60, 0x0E, 0x00, 0x0F, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x06, 0x00, 0x78, 0x00, 0x00,
  0x60, 0x0F, 0x80, 0x00, 0x06, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x0D, 0xC0,
  0x00, 0x0E, 0x00, 0xCC, 0x00, 0x00, 0xC0, 0x0C, 0xC0, 0x00, 0x0C, 0x01,
  0xCE, 0x00, 0x01, 0xC0, 0x1C, 0x60, 0x00, 0x1C, 0x01, 0x86, 0x00, 0x01,
  0x80, 0x18, 0x70, 0x00, 0x18, 0x01, 0x83, 0x00, 0x01, 0x80, 0x38, 0x30,
  0x00, 0x38, 0x03, 0x83, 0x80, 0x03, 0x80, 0x30, 0x18, 0x00, 0x30, 0x03,
  0x01, 0x80, 0x03, 0x00, 0x30, 0x1C, 0x00, 0x30, 0x07, 0x01, 0xC0, 0x07,
  0x00, 0x60, 0x0C, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0x60, 0x0E, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x0C,
  0x00, 0x70, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x0C, 0x00, 0x38, 0x0C,
  0x01, 0xC0, 0x03, 0x81, 0xC0, 0x1C, 0x00, 0x18, 0x1C, 0x01, 0x80, 0x01,
  0xC1, 0x80, 0x18, 0x00, 0x1C, 0x18, 0x01, 0x80, 0x00, 0xC1, 0x80, 0x38,
  0x00, 0x0E, 0x38, 0x03, 0x80, 0x00, 0xE3, 0x80, 0x30, 0x00, 0x06, 0x30,
  0x03, 0x00, 0x00, 0x73, 0x00, 0x70, 0x00, 0x07, 0x30, 0x07, 0x00, 0x00,
  0x37, 0x00, 0x60, 0x00, 0x03, 0xF0, 0x06, 0x00, 0x00, 0x3E, 0x00, 0x60,
  0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x03, 0x00,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x18,
  0x01, 0xF0, 0x01, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x38, 0x03, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30,
  0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x70, 0x18,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x30,
  0x0E, 0x00, 0x03, 0x80, 0x60, 0x00, 0x38, 0x03, 0x00, 0x07, 0x80, 0x38,
  0x00, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38,
  0x03, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x18, 0x70,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x18, 0x01, 0xF0, 0x01, 0xC0, 0x03,
  0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x03, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x18, 0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x70, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0x60, 0x0E, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x38, 0x01, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x01,
  0x80, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x70, 0x07, 0x00, 0x01, 0x80,
  0x38, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x00, 0x01, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x04, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x7C, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00,
  0x30, 0x1C, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x18, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x38, 0x06,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x06, 0x00, 0x70, 0x00,
  0xE0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x30, 0x03, 0x80, 0x03, 0x00, 0x30, 0x00, 0x30, 0x07, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x1C, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xEC, 0x00, 0x01,
  0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x60,
  0x00, 0x18, 0xC0, 0x00, 0x36, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x60, 0x00,
  0x38, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x60, 0x00, 0x70,
  0xC0, 0x00, 0xC6, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x60, 0x00, 0xE0, 0xC0,
  0x01, 0x86, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x60, 0x01, 0xC0, 0xC0, 0x03,
  0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x80, 0xC0, 0x07, 0x07,
  0x00, 0x38, 0x0C, 0x00, 0x60, 0x70, 0x03, 0x00, 0xC0, 0x0E, 0x07, 0x00,
  0x70, 0x0C, 0x00, 0xC0, 0x70, 0x06, 0x00, 0xC0, 0x1C, 0x07, 0x00, 0xE0,
  0x0C, 0x01, 0x80, 0x70, 0x0C, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x0E,
  0x03, 0x00, 0x30, 0x1C, 0x00, 0xE0, 0x30, 0x03, 0x01, 0x80, 0x0E, 0x07,
  0x00, 0x30, 0x38, 0x00, 0xE0, 0x60, 0x03, 0x03, 0x00, 0x0E, 0x0E, 0x00,
  0x30, 0x70, 0x00, 0xE0, 0xC0, 0x03, 0x06, 0x00, 0x0E, 0x1C, 0x00, 0x30,
  0x60, 0x00, 0xE1, 0x80, 0x03, 0x0E, 0x00, 0x0E, 0x18, 0x00, 0x30, 0xC0,
  0x00, 0xE3, 0x00, 0x03, 0x1C, 0x00, 0x0E, 0x30, 0x00, 0x31, 0x80, 0x00,
  0x67, 0x00, 0x03, 0x38, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x00, 0x6E,
  0x00, 0x03, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00,
  0x03, 0x60, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x30, 0x00, 0x06, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x18, 0x60, 0x00, 0x0E,
  0x18, 0x00, 0x07, 0x06, 0x00, 0x01, 0x81, 0xC0, 0x00, 0xE0, 0x30, 0x00,
  0x70, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x06, 0x00, 0xE0, 0x01, 0x80, 0x30, 0x00, 0x60, 0x1C, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0xE0,
  0x00, 0x0E, 0x30, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x38, 0x18, 0x00, 0x06, 0x03, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x30, 0x06, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x1C, 0x00, 0x38, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x38,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x33, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0xC1, 0xC1, 0x83, 0x83, 0x03, 0x06,
  0x06, 0x00, 0x3F, 0xE0, 0xC0, 0x1F, 0xFC, 0x30, 0x1E, 0x03, 0x8C, 0x0F,
  0x00, 0x66, 0x07, 0x80, 0x0D, 0x81, 0xC0, 0x03, 0x60, 0xE0, 0x00, 0x78,
  0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x70, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x07,
  0x0C, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x78, 0x30, 0x00,
  0x1E, 0x0C, 0x00, 0x0F, 0x03, 0x80, 0x06, 0xC0, 0xE0, 0x03, 0xB0, 0x1C,
  0x01, 0xCC, 0x07, 0x80, 0xE3, 0x00, 0xFF, 0xF1, 0x80, 0x1F, 0xF0, 0x60,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x7F, 0x80, 0x0C, 0x3F, 0xF8, 0x01, 0x8E,
  0x03, 0x80, 0x33, 0x80, 0x38, 0x0E, 0xC0, 0x03, 0x01, 0xB0, 0x00, 0x70,
  0x36, 0x00, 0x06, 0x07, 0x80, 0x00, 0xC1, 0xE0, 0x00, 0x18, 0x3C, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x38, 0x60, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x18, 0x60,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0F, 0x80,
  0x01, 0x81, 0xB0, 0x00, 0x70, 0x33, 0x00, 0x1C, 0x06, 0x70, 0x0F, 0x00,
  0xC7, 0xFF, 0xC0, 0x30, 0x3F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0x00, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x18, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x80, 0x03, 0xFE, 0x0E, 0x00, 0x1F, 0xFC, 0x30, 0x01, 0xF0, 0x38, 0xC0,
  0x0F, 0x00, 0x33, 0x00, 0x78, 0x00, 0x5C, 0x01, 0xC0, 0x01, 0xE0, 0x0E,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x03, 0x80, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x3C, 0x03, 0x00, 0x00, 0xF0, 0x0C, 0x00, 0x07, 0x80, 0x30, 0x00,
  0x1E, 0x00, 0xC0, 0x00, 0xD8, 0x03, 0x80, 0x07, 0x60, 0x0E, 0x00, 0x39,
  0x80, 0x1C, 0x01, 0xCC, 0x00, 0x78, 0x0E, 0x30, 0x00, 0xFF, 0xF0, 0xC0,
  0x00, 0xFF, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0xE0, 0x0F, 0x03, 0x80, 0x70, 0x07, 0x03, 0x80, 0x0C, 0x1C, 0x00,
  0x30, 0xE0, 0x00, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x0C, 0x60, 0x00, 0x73,
  0x80, 0x01, 0x8C, 0x00, 0x0E, 0x70, 0x00, 0x71, 0x80, 0x07, 0x86, 0x00,
  0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x1C, 0x07, 0xF7, 0xF0,
  0x07, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x10,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x87, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x18, 0x00, 0xFF, 0xE1, 0x80, 0x1E, 0x03,
  0x8C, 0x01, 0xE0, 0x06, 0x60, 0x1E, 0x00, 0x13, 0x00, 0xE0, 0x00, 0xF8,
  0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x30, 0x18, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x07, 0x07, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x01, 0x81, 0x80, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x70, 0x18, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x3C, 0x06, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x1E, 0x01, 0x80, 0x00, 0xF0,
  0x0C, 0x00, 0x0D, 0x80, 0x70, 0x00, 0xEC, 0x03, 0x80, 0x0E, 0xE0, 0x0E,
  0x00, 0xE6, 0x00, 0x78, 0x0E, 0x30, 0x01, 0xFF, 0xE1, 0x80, 0x07, 0xFC,
  0x1C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x78, 0x00, 0x7C, 0x1F, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x1F, 0xE0, 0x06, 0x1F, 0xFE,
  0x01, 0x8E, 0x03, 0x80, 0x66, 0x00, 0x70, 0x3B, 0x00, 0x1C, 0x0D, 0x80,
  0x03, 0x03, 0xC0, 0x00, 0xC0, 0xF0, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x1E,
  0x00, 0x03, 0x07, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x18,
  0x38, 0x00, 0x06, 0x0E, 0x00, 0x01, 0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x38, 0x30, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x07, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x70, 0x60, 0x00, 0x1C, 0x18, 0x00, 0x06, 0x0E, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x03,
  0x07, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x18, 0x00,
  0x06, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x20, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x02, 0x3C, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x06,
  0x00, 0x0E, 0x01, 0x80, 0x07, 0x00, 0x60, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x03, 0x00, 0x70, 0x00, 0xC0, 0x38, 0x00, 0x70, 0x1C,
  0x00, 0x1C, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x01, 0x83, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x38, 0x60, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x1F, 0x00, 0x00,
  0xCD, 0xC0, 0x00, 0x36, 0x30, 0x00, 0x1F, 0x0E, 0x00, 0x07, 0x81, 0x80,
  0x01, 0xC0, 0x60, 0x00, 0x60, 0x1C, 0x00, 0x18, 0x03, 0x00, 0x0E, 0x00,
  0xE0, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x1C,
  0x00, 0x30, 0x07, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x80, 0x60, 0x00, 0x60,
  0x18, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x00,
  0x01, 0x83, 0xFC, 0x01, 0xFE, 0x00, 0x61, 0xFF, 0x81, 0xFF, 0xC0, 0x19,
  0xE0, 0x70, 0xE0, 0x38, 0x06, 0xE0, 0x0C, 0x70, 0x07, 0x03, 0x30, 0x03,
  0xB8, 0x01, 0xC0, 0xD8, 0x00, 0xEC, 0x00, 0x30, 0x3C, 0x00, 0x1E, 0x00,
  0x0C, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x03, 0x80, 0x03, 0xC0, 0x00, 0xC1,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x00, 0x01, 0x83, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x30, 0x00, 0x18, 0x00, 0x0E,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC1, 0xC0,
  0x00, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC1, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0x06, 0x00, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x01, 0x81, 0xFE, 0x00, 0x61, 0xFF,
  0xE0, 0x18, 0xE0, 0x38, 0x06, 0x60, 0x07, 0x03, 0x30, 0x01, 0xC0, 0xD8,
  0x00, 0x30, 0x3C, 0x00, 0x0C, 0x0F, 0x00, 0x03, 0x07, 0x80, 0x00, 0xC1,
  0xE0, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x06, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x0C, 0x00,
  0x03, 0x83, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x18,
  0x00, 0x07, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x18,
  0x38, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x30, 0x70, 0x00, 0x0C, 0x18, 0x00, 0x07, 0x06, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x60, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x7C, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x78, 0x00, 0x70, 0x38, 0x00,
  0x38, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x9C, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x70,
  0x00, 0x01, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x39, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x1C,
  0x60, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x0E,
  0x03, 0x80, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x3F, 0xC0, 0x00, 0xC3, 0xFF,
  0x80, 0x03, 0x1C, 0x07, 0x00, 0x0C, 0xE0, 0x0E, 0x00, 0x67, 0x00, 0x18,
  0x01, 0xB8, 0x00, 0x70, 0x06, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x0C, 0x03, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x30, 0x1C, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x03, 0x01, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0x60, 0x0F, 0x80, 0x03, 0x80, 0x33, 0x00, 0x1C, 0x00, 0xCE, 0x01,
  0xE0, 0x03, 0x1F, 0xFF, 0x00, 0x1C, 0x1F, 0xF0, 0x00, 0x70, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x60, 0x0F, 0xFE, 0x18, 0x07, 0xC0, 0xE3,
  0x01, 0xE0, 0x06, 0x60, 0x78, 0x00, 0xCC, 0x0E, 0x00, 0x0F, 0x83, 0x80,
  0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x87, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x0E, 0x18, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x38, 0x60, 0x00, 0x07, 0x0C, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x38, 0x30, 0x00, 0x07, 0x06, 0x00, 0x01, 0xE0, 0xC0,
  0x00, 0x78, 0x18, 0x00, 0x0F, 0x03, 0x00, 0x03, 0xE0, 0x70, 0x00, 0xEC,
  0x0E, 0x00, 0x3B, 0x80, 0xE0, 0x0E, 0x60, 0x1E, 0x03, 0x8C, 0x01, 0xFF,
  0xE1, 0x80, 0x1F, 0xF0, 0x70, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x01, 0x83, 0xF8, 0x0C,
  0x3F, 0xC0, 0x63, 0x80, 0x03, 0x30, 0x00, 0x33, 0x00, 0x01, 0xB0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0x3C, 0x01, 0xC0, 0xE0, 0x01, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC2, 0x00, 0x0E, 0x0E, 0x00, 0x78,
  0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x1F, 0xFF, 0x3F, 0xFF, 0x43, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x06, 0x0C, 0x00,
  0x03, 0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x1C,
  0x00, 0x03, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0x60, 0x00, 0x18,
  0x38, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x30, 0x70, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x06, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x70, 0x60, 0x00, 0x18, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x78, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x0F,
  0x03, 0x00, 0x06, 0xC0, 0xC0, 0x03, 0x30, 0x38, 0x01, 0xDC, 0x07, 0x01,
  0xE6, 0x01, 0xFF, 0xE1, 0x80, 0x1F, 0xF0, 0x60, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x73, 0x00, 0x00, 0xC6,
  0x00, 0x03, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x30, 0x60,
  0x00, 0xE0, 0xC0, 0x01, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0C, 0x07, 0x00,
  0x38, 0x06, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x0E,
  0x00, 0x60, 0x38, 0x00, 0xC0, 0x60, 0x01, 0x81, 0xC0, 0x03, 0x03, 0x00,
  0x07, 0x0E, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0x70, 0x00, 0x18, 0xC0, 0x00,
  0x33, 0x80, 0x00, 0x66, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xB0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0x60, 0x00, 0xF0, 0x00, 0xEC, 0x00, 0x36, 0x00, 0x19, 0x80, 0x06, 0xC0,
  0x07, 0x30, 0x01, 0xD8, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x0E,
  0x60, 0x07, 0x18, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x71, 0x80, 0x38, 0x60,
  0x0C, 0x30, 0x06, 0x0C, 0x01, 0x86, 0x01, 0xC1, 0x80, 0x60, 0xC0, 0x30,
  0x30, 0x0C, 0x18, 0x06, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70,
  0x30, 0x18, 0x18, 0x0E, 0x0E, 0x03, 0x03, 0x01, 0xC1, 0x80, 0x60, 0xE0,
  0x18, 0x70, 0x0C, 0x18, 0x03, 0x0C, 0x01, 0x87, 0x00, 0x63, 0x80, 0x38,
  0xC0, 0x0C, 0x60, 0x07, 0x38, 0x01, 0x8C, 0x00, 0xE6, 0x00, 0x33, 0x00,
  0x1D, 0xC0, 0x06, 0x60, 0x03, 0xB0, 0x00, 0xDC, 0x00, 0x76, 0x00, 0x1B,
  0x00, 0x07, 0x80, 0x03, 0x60, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xC0, 0x0E,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x70, 0x00, 0x70, 0x06,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x18, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x0C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x30, 0x03, 0x80, 0x03, 0x80, 0x30, 0x00, 0x18,
  0x07, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x06, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x78, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0x00, 0x7C, 0x0E, 0x80, 0x07,
  0xFF, 0x20, 0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 13, 44, 13, 1, -44 },
  { 73, 14, 16, 19, 7, -44 },
  { 101, 33, 44, 33, 1, -44 },
  { 283, 27, 51, 30, 2, -47 },
  { 456, 36, 46, 42, 4, -45 },
  { 663, 32, 46, 35, 1, -45 },
  { 847, 5, 16, 11, 7, -44 },
  { 857, 18, 54, 15, 2, -44 },
  { 979, 17, 54, 15, -4, -44 },
  { 1094, 23, 23, 28, 7, -47 },
  { 1161, 26, 29, 32, 4, -36 },
  { 1256, 9, 15, 12, -3, -7 },
  { 1273, 14, 2, 18, 2, -18 },
  { 1277, 4, 4, 12, 1, -4 },
  { 1279, 27, 44, 19, -3, -44 },
  { 1428, 26, 46, 30, 3, -45 },
  { 1578, 14, 44, 30, 9, -44 },
  { 1655, 28, 45, 30, 0, -45 },
  { 1813, 29, 46, 30, 0, -45 },
  { 1980, 28, 45, 30, 0, -45 },
  { 2138, 28, 45, 30, 1, -44 },
  { 2296, 27, 46, 30, 3, -45 },
  { 2452, 26, 44, 30, 5, -44 },
  { 2595, 27, 46, 30, 2, -45 },
  { 2751, 26, 46, 30, 2, -45 },
  { 2901, 10, 33, 12, 1, -33 },
  { 2943, 14, 41, 12, -3, -33 },
  { 3015, 26, 27, 32, 4, -36 },
  { 3103, 26, 15, 32, 4, -29 },
  { 3152, 26, 27, 32, 4, -36 },
  { 3240, 20, 45, 22, 3, -45 },
  { 3353, 40, 50, 45, 3, -44 },
  { 3603, 30, 44, 29, -4, -44 },
  { 3768, 30, 44, 32, 2, -44 },
  { 3933, 31, 46, 31, 4, -45 },
  { 4112, 32, 44, 36, 2, -44 },
  { 4288, 29, 44, 29, 2, -44 },
  { 4448, 29, 44, 26, 2, -44 },
  { 4608, 33, 46, 37, 4, -45 },
  { 4798, 35, 44, 37, 2, -44 },
  { 4991, 20, 44, 16, -1, -44 },
  { 5101, 24, 55, 13, -10, -44 },
  { 5266, 33, 44, 30, 2, -44 },
  { 5448, 19, 44, 26, 2, -44 },
  { 5553, 44, 44, 46, 2, -44 },
  { 5795, 36, 44, 37, 2, -44 },
  { 5993, 33, 46, 39, 4, -45 },
  { 6183, 29, 44, 30, 2, -44 },
  { 6343, 33, 56, 39, 4, -45 },
  { 6574, 29, 44, 31, 2, -44 },
  { 6734, 29, 46, 28, 0, -45 },
  { 6901, 25, 44, 26, 6, -44 },
  { 7039, 34, 45, 37, 4, -44 },
  { 7231, 28, 44, 29, 6, -44 },
  { 7385, 44, 44, 47, 7, -44 },
  { 7627, 35, 44, 27, -4, -44 },
  { 7820, 26, 44, 26, 6, -44 },
  { 7963, 32, 44, 28, -1, -44 },
  { 8139, 23, 54, 18, -1, -44 },
  { 8295, 10, 44, 20, 6, -44 },
  { 8350, 23, 54, 18, -4, -44 },
  { 8506, 27, 25, 31, 2, -44 },
  { 8591, 21, 2, 21, -5, 6 },
  { 8597, 7, 9, 14, 9, -47 },
  { 8605, 26, 34, 30, 3, -33 },
  { 8716, 27, 48, 31, 1, -47 },
  { 8878, 22, 34, 24, 3, -33 },
  { 8972, 30, 48, 31, 3, -47 },
  { 9152, 22, 34, 27, 3, -33 },
  { 9246, 32, 62, 15, -8, -47 },
  { 9494, 29, 48, 31, 1, -33 },
  { 9668, 26, 47, 30, 1, -47 },
  { 9821, 12, 45, 12, 1, -45 },
  { 9889, 22, 60, 12, -8, -45 },
  { 10054, 26, 47, 25, 1, -47 },
  { 10207, 13, 47, 12, 1, -47 },
  { 10284, 42, 33, 46, 1, -33 },
  { 10458, 26, 33, 30, 1, -33 },
  { 10566, 25, 34, 31, 3, -33 },
  { 10673, 30, 47, 31, -2, -33 },
  { 10850, 27, 48, 31, 3, -33 },
  { 11012, 21, 33, 20, 1, -33 },
  { 11099, 22, 34, 23, 0, -33 },
  { 11193, 16, 42, 17, 2, -41 },
  { 11277, 26, 34, 30, 3, -33 },
  { 11388, 23, 33, 23, 3, -33 },
  { 11483, 35, 33, 37, 4, -33 },
  { 11628, 28, 33, 25, -2, -33 },
  { 11744, 34, 48, 23, -7, -33 },
  { 11948, 24, 33, 23, -1, -33 },
  { 12047, 22, 54, 20, 2, -44 },
  { 12196, 3, 62, 29, 14, -47 },
  { 12220, 22, 54, 20, -3, -44 },
  { 12369, 26, 6, 32, 4, -25 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC62PT7B_H_
