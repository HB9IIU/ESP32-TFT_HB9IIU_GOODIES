#ifndef _ROBOTOCONDENSED_THIN58PT7B_H_
#define _ROBOTOCONDENSED_THIN58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin58pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x00, 0x00, 0x00, 0x17, 0xE0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x00, 0x10, 0x04, 0x00, 0x02, 0x00, 0x80,
  0x00, 0xC0, 0x10, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60,
  0x18, 0x00, 0x08, 0x02, 0x00, 0x01, 0x00, 0x40, 0x00, 0x20, 0x08, 0x00,
  0x0C, 0x01, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x80, 0x20, 0x00, 0x10, 0x04, 0x00, 0x06, 0x00, 0x80, 0x00,
  0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x40, 0x10,
  0x00, 0x08, 0x02, 0x00, 0x01, 0x00, 0x40, 0x00, 0x60, 0x18, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x20, 0x0C, 0x00, 0x04, 0x01, 0x00,
  0x00, 0x80, 0x20, 0x0F, 0xFF, 0xFF, 0xF8, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x18, 0x06, 0x00, 0x02, 0x00, 0x80, 0x00, 0x40, 0x10, 0x00,
  0x08, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x00, 0x40, 0x00, 0x20, 0x08, 0x00, 0x04, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xF0, 0x01, 0xC0, 0x70, 0x0C, 0x00,
  0xE0, 0x60, 0x01, 0x81, 0x00, 0x03, 0x0C, 0x00, 0x04, 0x30, 0x00, 0x18,
  0x80, 0x00, 0x62, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x08, 0x80,
  0x00, 0x22, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x34, 0x00, 0x00, 0xD0,
  0x00, 0x02, 0x60, 0x00, 0x08, 0x80, 0x00, 0x63, 0x00, 0x01, 0x06, 0x00,
  0x0C, 0x0C, 0x00, 0x60, 0x1C, 0x07, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x01, 0x01, 0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x08, 0x03, 0x00,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x60, 0x04, 0x00, 0x80, 0xC0, 0x08, 0x03,
  0x01, 0x80, 0x10, 0x0C, 0x03, 0x00, 0x20, 0x18, 0x06, 0x00, 0x40, 0x60,
  0x0C, 0x00, 0x80, 0x80, 0x18, 0x01, 0x03, 0x00, 0x10, 0x06, 0x04, 0x00,
  0x30, 0x08, 0x18, 0x00, 0x20, 0x30, 0x20, 0x00, 0x70, 0xC0, 0xC0, 0x00,
  0x3F, 0x01, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x03, 0xF0, 0x00, 0x0C, 0x0C, 0x30, 0x00, 0x30, 0x30, 0x30, 0x00,
  0x40, 0xC0, 0x30, 0x01, 0x81, 0x00, 0x60, 0x02, 0x02, 0x00, 0x40, 0x0C,
  0x0C, 0x00, 0x80, 0x10, 0x18, 0x01, 0x00, 0x60, 0x30, 0x02, 0x00, 0x80,
  0x60, 0x04, 0x03, 0x00, 0xC0, 0x08, 0x04, 0x01, 0x80, 0x10, 0x18, 0x01,
  0x00, 0x20, 0x20, 0x02, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x38, 0x70, 0x00, 0x18,
  0x06, 0x00, 0x04, 0x01, 0x80, 0x03, 0x00, 0x20, 0x00, 0x80, 0x0C, 0x00,
  0x20, 0x03, 0x00, 0x08, 0x00, 0xC0, 0x02, 0x00, 0x30, 0x00, 0x80, 0x08,
  0x00, 0x20, 0x06, 0x00, 0x0C, 0x01, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x40,
  0x60, 0x00, 0x18, 0x30, 0x00, 0x02, 0x18, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x98, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x30, 0x40, 0x00, 0x18, 0x18, 0x01, 0x8C, 0x03,
  0x00, 0x62, 0x00, 0x60, 0x19, 0x80, 0x08, 0x06, 0x40, 0x03, 0x01, 0x90,
  0x00, 0x60, 0x4C, 0x00, 0x0C, 0x13, 0x00, 0x01, 0x0C, 0xC0, 0x00, 0x62,
  0x30, 0x00, 0x0D, 0x8C, 0x00, 0x01, 0xE1, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x1C, 0x18, 0x00, 0x05, 0x83, 0x00, 0x02, 0x30, 0x60, 0x03, 0x04, 0x0E,
  0x03, 0x81, 0x80, 0xFF, 0x80, 0x30, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xEA,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x03,
  0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18,
  0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10,
  0x06, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x40, 0x08, 0x02, 0xF0, 0x10, 0x3C, 0x7C, 0x21,
  0xE0, 0x1E, 0x5E, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0D, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x43, 0x00, 0x01, 0x83, 0x00, 0x06, 0x03, 0x00,
  0x18, 0x06, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x06, 0x01, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x33, 0x33, 0x33, 0x32, 0x64, 0xC8, 0xFF, 0xE0, 0x5F,
  0xA0, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x03, 0x81, 0xC0, 0x38, 0x07, 0x01, 0x80, 0x08, 0x18, 0x00, 0x60, 0x80,
  0x01, 0x8C, 0x00, 0x0C, 0x40, 0x00, 0x26, 0x00, 0x01, 0xB0, 0x00, 0x0D,
  0x80, 0x00, 0x68, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00,
  0x02, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x28, 0x00, 0x01, 0x40,
  0x00, 0x0A, 0x00, 0x00, 0x58, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01,
  0x90, 0x00, 0x08, 0xC0, 0x00, 0xC2, 0x00, 0x06, 0x18, 0x00, 0x60, 0x60,
  0x02, 0x03, 0x80, 0x30, 0x0E, 0x07, 0x00, 0x1F, 0xE0, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x1C, 0x1E, 0x8E, 0x17, 0x03, 0x80, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x0F, 0xF8, 0x00, 0x70, 0x38, 0x03, 0x00, 0x30, 0x18, 0x00, 0x60, 0xC0,
  0x01, 0x82, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x40, 0x00, 0x11, 0x00, 0x00,
  0x4C, 0x00, 0x01, 0x30, 0x00, 0x04, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x70,
  0x38, 0x03, 0x00, 0x30, 0x18, 0x00, 0x60, 0xC0, 0x00, 0xC2, 0x00, 0x03,
  0x18, 0x00, 0x04, 0x60, 0x00, 0x19, 0x00, 0x00, 0x64, 0x00, 0x01, 0x90,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x98, 0x00, 0x02, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x41, 0x80, 0x03, 0x03, 0x00, 0x18, 0x07, 0x01, 0xC0, 0x07, 0xFC,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x16, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x02, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x01, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x80, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0x40, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x10, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x08, 0x00,
  0x30, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x1F, 0xFF, 0xF1, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x1F, 0x80, 0x6F, 0xBE, 0x07, 0x80, 0x30, 0x60, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x40, 0x00, 0x26, 0x00, 0x06, 0x20, 0x00, 0x63, 0x00, 0x0C,
  0x18, 0x01, 0x80, 0xE0, 0x70, 0x03, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x0F,
  0x80, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x03,
  0xF0, 0x18, 0xFF, 0xE0, 0x8E, 0x01, 0x84, 0xC0, 0x06, 0x2C, 0x00, 0x19,
  0x40, 0x00, 0x4C, 0x00, 0x03, 0x60, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x12, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x43, 0x00, 0x06, 0x0C,
  0x00, 0x60, 0x30, 0x06, 0x00, 0xE0, 0x60, 0x03, 0xFE, 0x00, 0x01, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x70, 0x38, 0x03, 0x00, 0x30, 0x18, 0x00,
  0x60, 0xC0, 0x00, 0xC2, 0x00, 0x01, 0x18, 0x00, 0x06, 0x60, 0x00, 0x19,
  0x80, 0x00, 0x24, 0x00, 0x00, 0x90, 0x00, 0x02, 0x40, 0x00, 0x09, 0x80,
  0x00, 0x26, 0x00, 0x01, 0x88, 0x00, 0x06, 0x30, 0x00, 0x30, 0x40, 0x00,
  0xC1, 0x80, 0x06, 0x03, 0x80, 0x70, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x70, 0x38, 0x07, 0x00, 0x38, 0x30, 0x00, 0x30, 0x80, 0x00, 0x66, 0x00,
  0x01, 0x90, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xD0,
  0x00, 0x03, 0x60, 0x00, 0x09, 0x80, 0x00, 0x63, 0x00, 0x03, 0x06, 0x00,
  0x18, 0x0F, 0x01, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x1F, 0xF0, 0x01, 0xC0, 0xE0, 0x18, 0x03, 0x81, 0x80, 0x06, 0x18,
  0x00, 0x30, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x12, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x02,
  0x80, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x1C, 0x80, 0x00, 0xA6, 0x00,
  0x0D, 0x18, 0x00, 0xC8, 0x60, 0x1C, 0x41, 0xF7, 0x82, 0x03, 0xF0, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x2F,
  0xC0, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x31, 0x8C, 0x62, 0x11, 0x8C, 0xC6,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x20, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x07, 0x07, 0x06, 0x00, 0xC6,
  0x00, 0x23, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x03, 0x80,
  0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00,
  0x08, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x08,
  0x00, 0x1F, 0x80, 0x06, 0x18, 0x00, 0x7F, 0xC0, 0x06, 0x18, 0x00, 0xE0,
  0x60, 0x02, 0x30, 0x01, 0x80, 0x30, 0x02, 0x30, 0x01, 0x00, 0x30, 0x03,
  0x20, 0x03, 0x00, 0x30, 0x03, 0x20, 0x02, 0x00, 0x30, 0x03, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x60, 0x04, 0x00, 0x30, 0x01, 0x60, 0x0C, 0x00, 0x20,
  0x01, 0x40, 0x0C, 0x00, 0x20, 0x01, 0x40, 0x08, 0x00, 0x20, 0x01, 0x40,
  0x08, 0x00, 0x20, 0x01, 0x40, 0x08, 0x00, 0x20, 0x03, 0x40, 0x18, 0x00,
  0x20, 0x03, 0x40, 0x18, 0x00, 0x20, 0x03, 0x40, 0x18, 0x00, 0x20, 0x03,
  0x40, 0x18, 0x00, 0x60, 0x03, 0x40, 0x18, 0x00, 0x60, 0x02, 0x40, 0x18,
  0x00, 0x60, 0x02, 0x40, 0x18, 0x00, 0x60, 0x06, 0x40, 0x08, 0x00, 0xE0,
  0x06, 0x60, 0x08, 0x00, 0xE0, 0x04, 0x60, 0x08, 0x01, 0xA0, 0x0C, 0x60,
  0x0C, 0x01, 0x20, 0x08, 0x20, 0x04, 0x02, 0x30, 0x18, 0x20, 0x07, 0x0E,
  0x18, 0x70, 0x30, 0x03, 0xF8, 0x0F, 0xC0, 0x30, 0x00, 0x40, 0x02, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x98, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00, 0x60, 0x20, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x0C, 0x01, 0x00, 0x00, 0xC0, 0x10, 0x00,
  0x08, 0x01, 0x80, 0x01, 0x80, 0x08, 0x00, 0x18, 0x00, 0x80, 0x01, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x04, 0x00, 0x20, 0x00, 0x60,
  0x02, 0x00, 0x06, 0x00, 0x60, 0x00, 0x20, 0x06, 0x00, 0x03, 0x00, 0x40,
  0x00, 0x30, 0x0F, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x18, 0x08, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x08, 0x18, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x02, 0x60, 0x00, 0x00, 0x24, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30,
  0xFF, 0xFC, 0x01, 0x80, 0x7E, 0x03, 0x00, 0x07, 0x06, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x04, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x13, 0x00, 0x00, 0x26, 0x00, 0x00, 0x4C, 0x00,
  0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x08, 0xC0, 0x00,
  0x31, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x06, 0x00, 0xF8, 0x0F, 0xFF, 0xF8,
  0x18, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x05, 0x80,
  0x00, 0x0B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x98, 0x00,
  0x06, 0x30, 0x00, 0x18, 0x60, 0x07, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x40, 0x00, 0x06, 0x60,
  0x00, 0x01, 0x30, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x02, 0x80,
  0x00, 0x03, 0x40, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x10,
  0x0C, 0x00, 0x30, 0x03, 0x80, 0x70, 0x00, 0x7F, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0xC0, 0x1F, 0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x00,
  0x70, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0, 0x01, 0xC0, 0xC0, 0x3F,
  0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF,
  0xFF, 0xE3, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x03, 0x01, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x08,
  0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0x20, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x24, 0x00, 0x00, 0x13, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x03, 0x80, 0x78, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0x60, 0x00, 0xC6, 0x00, 0x08,
  0x30, 0x03, 0x81, 0xC0, 0x70, 0x07, 0xFC, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0,
  0x01, 0x80, 0x60, 0x01, 0x80, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C,
  0x01, 0x80, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xF0, 0x00,
  0x0C, 0xCC, 0x00, 0x06, 0x43, 0x00, 0x03, 0x40, 0x80, 0x01, 0xE0, 0x60,
  0x00, 0xE0, 0x18, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80,
  0x01, 0x80, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xBE, 0x00, 0x00, 0x00, 0x5D, 0x00, 0x00, 0x00, 0x6E, 0x80,
  0x00, 0x00, 0x27, 0x60, 0x00, 0x00, 0x33, 0x90, 0x00, 0x00, 0x19, 0xCC,
  0x00, 0x00, 0x08, 0xE6, 0x00, 0x00, 0x0C, 0x71, 0x00, 0x00, 0x04, 0x38,
  0xC0, 0x00, 0x02, 0x1C, 0x60, 0x00, 0x03, 0x0E, 0x10, 0x00, 0x01, 0x07,
  0x0C, 0x00, 0x01, 0x83, 0x82, 0x00, 0x00, 0xC1, 0xC1, 0x00, 0x00, 0x40,
  0xE0, 0xC0, 0x00, 0x60, 0x70, 0x20, 0x00, 0x30, 0x38, 0x18, 0x00, 0x10,
  0x1C, 0x0C, 0x00, 0x18, 0x0E, 0x02, 0x00, 0x08, 0x07, 0x01, 0x80, 0x04,
  0x03, 0x80, 0x40, 0x06, 0x01, 0xC0, 0x20, 0x02, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x70, 0x04, 0x01, 0x80, 0x38, 0x03, 0x00, 0x80, 0x1C, 0x01, 0x80,
  0xC0, 0x0E, 0x00, 0x40, 0x40, 0x07, 0x00, 0x30, 0x20, 0x03, 0x80, 0x08,
  0x30, 0x01, 0xC0, 0x04, 0x10, 0x00, 0xE0, 0x03, 0x18, 0x00, 0x70, 0x00,
  0x8C, 0x00, 0x38, 0x00, 0x44, 0x00, 0x1C, 0x00, 0x36, 0x00, 0x0E, 0x00,
  0x0B, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xD8, 0x00, 0x00, 0xF6, 0x00, 0x00, 0x3C,
  0xC0, 0x00, 0x0F, 0x10, 0x00, 0x03, 0xC6, 0x00, 0x00, 0xF0, 0x80, 0x00,
  0x3C, 0x30, 0x00, 0x0F, 0x06, 0x00, 0x03, 0xC1, 0x80, 0x00, 0xF0, 0x30,
  0x00, 0x3C, 0x04, 0x00, 0x0F, 0x01, 0x80, 0x03, 0xC0, 0x30, 0x00, 0xF0,
  0x0C, 0x00, 0x3C, 0x01, 0x80, 0x0F, 0x00, 0x20, 0x03, 0xC0, 0x0C, 0x00,
  0xF0, 0x01, 0x00, 0x3C, 0x00, 0x60, 0x0F, 0x00, 0x0C, 0x03, 0xC0, 0x03,
  0x00, 0xF0, 0x00, 0x60, 0x3C, 0x00, 0x08, 0x0F, 0x00, 0x03, 0x03, 0xC0,
  0x00, 0x60, 0xF0, 0x00, 0x18, 0x3C, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x43,
  0xC0, 0x00, 0x18, 0xF0, 0x00, 0x02, 0x3C, 0x00, 0x00, 0xCF, 0x00, 0x00,
  0x1B, 0xC0, 0x00, 0x06, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x38, 0x07, 0x00, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x30, 0x80, 0x00, 0x04, 0x60, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x90, 0x00, 0x00, 0x66, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x04, 0x30, 0x00, 0x03, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x60, 0x03, 0x80, 0x70, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x80, 0x00, 0xFF, 0xFE, 0x01, 0x80, 0x1F, 0x83, 0x00, 0x03, 0x86, 0x00,
  0x01, 0x8C, 0x00, 0x01, 0x98, 0x00, 0x01, 0x30, 0x00, 0x03, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x02,
  0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x26, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0x18, 0x00, 0x1C, 0x30, 0x03, 0xF0, 0x7F, 0xFF, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x38, 0x07, 0x00, 0x38, 0x00,
  0x60, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x04, 0x60, 0x00, 0x01, 0x90, 0x00, 0x00, 0x64, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x90,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x18, 0x80, 0x00, 0x04, 0x30, 0x00, 0x03,
  0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x70, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0xFF, 0xFE, 0x00, 0xC0, 0x0F,
  0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x07,
  0xC0, 0xFF, 0xFF, 0x00, 0xC0, 0x02, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0xE0, 0x01, 0xC0, 0x3C, 0x01, 0x80, 0x07, 0x01, 0x80,
  0x00, 0xC1, 0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x04, 0x40,
  0x00, 0x03, 0x20, 0x00, 0x01, 0x90, 0x00, 0x00, 0x48, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x31, 0x80, 0x00, 0x30, 0x60, 0x00, 0x38,
  0x18, 0x00, 0x38, 0x07, 0x80, 0x70, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x02, 0x40, 0x00, 0x06, 0x60, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x38,
  0x00, 0x18, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x63, 0x00, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x08, 0x08, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x00,
  0x40, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x20, 0x02, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x01, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x80, 0x00, 0x80, 0x08, 0x00, 0x08,
  0x01, 0x80, 0x00, 0xC0, 0x10, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x40, 0x30,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x60, 0x20, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x98, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xB0, 0x00, 0x03, 0x00, 0x00,
  0x24, 0x00, 0x01, 0xC0, 0x00, 0x19, 0x00, 0x00, 0x78, 0x00, 0x06, 0x60,
  0x00, 0x16, 0x00, 0x01, 0x98, 0x00, 0x04, 0x80, 0x00, 0x46, 0x00, 0x03,
  0x20, 0x00, 0x10, 0x80, 0x00, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x23, 0x00,
  0x03, 0x0C, 0x00, 0x08, 0x40, 0x00, 0x83, 0x00, 0x06, 0x10, 0x00, 0x20,
  0x40, 0x01, 0x06, 0x00, 0x18, 0x10, 0x00, 0x41, 0x80, 0x06, 0x06, 0x00,
  0x10, 0x20, 0x01, 0x81, 0x80, 0x0C, 0x08, 0x00, 0x40, 0x20, 0x02, 0x03,
  0x00, 0x30, 0x08, 0x00, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x10, 0x03,
  0x00, 0xC0, 0x18, 0x04, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x04,
  0x01, 0x00, 0x60, 0x18, 0x01, 0x80, 0xC0, 0x08, 0x06, 0x00, 0x60, 0x30,
  0x02, 0x01, 0x00, 0x18, 0x08, 0x00, 0xC0, 0x40, 0x02, 0x02, 0x00, 0x30,
  0x30, 0x00, 0x81, 0x80, 0x04, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x03, 0x00,
  0x0C, 0x10, 0x00, 0x60, 0x80, 0x01, 0x04, 0x00, 0x18, 0x20, 0x00, 0x43,
  0x00, 0x02, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x20, 0x00,
  0x31, 0x00, 0x01, 0x88, 0x00, 0x0C, 0x40, 0x00, 0x26, 0x00, 0x01, 0x30,
  0x00, 0x09, 0x80, 0x00, 0x4C, 0x00, 0x03, 0x40, 0x00, 0x1B, 0x00, 0x00,
  0xD0, 0x00, 0x06, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x10, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0xC0, 0x10, 0x00, 0x08, 0x06, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x02, 0x60, 0x00, 0x00, 0x68, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x18, 0x02, 0x00, 0x02, 0x00, 0x60, 0x00, 0xC0, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x20, 0x00, 0x18,
  0x0C, 0x00, 0x01, 0x01, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x08, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x30, 0x04, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x02, 0x00, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x00, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x00, 0x80,
  0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x30, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x10, 0x80, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7F, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x03, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0xFF, 0x01, 0x00, 0x07, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x6C, 0x00,
  0x88, 0x01, 0x10, 0x06, 0x30, 0x08, 0x20, 0x10, 0x40, 0x60, 0xC0, 0x80,
  0x81, 0x01, 0x86, 0x03, 0x08, 0x02, 0x10, 0x06, 0x60, 0x0C, 0x80, 0x09,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x20, 0xFF, 0xFF, 0xF0, 0xE0, 0x60, 0x30,
  0x18, 0x18, 0x0C, 0x06, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0E, 0x03,
  0x81, 0x80, 0x0C, 0x30, 0x00, 0x46, 0x00, 0x06, 0x60, 0x00, 0x24, 0x00,
  0x02, 0x40, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x1F, 0xFE, 0x0F, 0xFF, 0xE1,
  0xC0, 0x02, 0x30, 0x00, 0x26, 0x00, 0x02, 0x40, 0x00, 0x2C, 0x00, 0x02,
  0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x06, 0x80, 0x00,
  0x6C, 0x00, 0x0A, 0x40, 0x01, 0xA6, 0x00, 0x33, 0x38, 0x1E, 0x31, 0xFF,
  0x83, 0x01, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x7F, 0xC0, 0x8C, 0x07, 0x09, 0x80, 0x18, 0xA0, 0x00, 0x8E, 0x00,
  0x0C, 0xC0, 0x00, 0x4C, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x02, 0x80,
  0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00,
  0x68, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0xE0, 0x00, 0x8B, 0x00,
  0x18, 0x9C, 0x07, 0x08, 0x7F, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x0E, 0x03, 0x81, 0x80, 0x0C, 0x30, 0x00, 0x62, 0x00, 0x06,
  0x60, 0x00, 0x24, 0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x40, 0x00, 0x14,
  0x00, 0x03, 0x60, 0x00, 0x32, 0x00, 0x02, 0x30, 0x00, 0x61, 0x80, 0x0C,
  0x0E, 0x03, 0x80, 0x3F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x20, 0x10, 0x3F, 0xE1, 0x0E, 0x03, 0x11, 0x80, 0x09,
  0x10, 0x00, 0x53, 0x00, 0x07, 0x20, 0x00, 0x36, 0x00, 0x01, 0x60, 0x00,
  0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x14,
  0x00, 0x01, 0x60, 0x00, 0x16, 0x00, 0x01, 0x20, 0x00, 0x33, 0x00, 0x03,
  0x18, 0x00, 0x71, 0x80, 0x0D, 0x0E, 0x03, 0x90, 0x3F, 0xE1, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0E, 0x03, 0x81, 0xC0, 0x0C, 0x30,
  0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0x34, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x21, 0xC0, 0x06, 0x07, 0x01, 0xC0, 0x3F, 0xF0, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x01, 0xFC, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x3F, 0xFE, 0x7F, 0xFC, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0x0E, 0x03, 0x11, 0x80, 0x19, 0x10,
  0x00, 0x53, 0x00, 0x07, 0x20, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x14,
  0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00,
  0x01, 0x60, 0x00, 0x16, 0x00, 0x01, 0x20, 0x00, 0x33, 0x00, 0x03, 0x18,
  0x00, 0x51, 0x80, 0x0D, 0x0E, 0x03, 0x90, 0x3F, 0xE1, 0x00, 0x60, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x33, 0x00, 0x02, 0x18, 0x00, 0x60, 0xC0, 0x0C, 0x07, 0xCF,
  0x80, 0x1F, 0xE0, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x02, 0x01, 0x07, 0xFC,
  0x21, 0x81, 0xC4, 0x60, 0x0C, 0x98, 0x01, 0x96, 0x00, 0x1A, 0x80, 0x03,
  0x70, 0x00, 0x2C, 0x00, 0x05, 0x80, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x02,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x7D, 0x80, 0x00, 0x00, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92,
  0x49, 0x24, 0x92, 0x48, 0x00, 0xC0, 0x70, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x0C, 0xDE, 0x1E, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x03, 0x20, 0x00, 0xC4,
  0x00, 0x38, 0x80, 0x06, 0x10, 0x01, 0x82, 0x00, 0x60, 0x40, 0x18, 0x08,
  0x06, 0x01, 0x01, 0x80, 0x20, 0x60, 0x04, 0x18, 0x00, 0x82, 0x00, 0x10,
  0x80, 0x02, 0x30, 0x00, 0x4F, 0x00, 0x0B, 0x30, 0x01, 0xC2, 0x00, 0x30,
  0x60, 0x04, 0x06, 0x00, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x00, 0xC0, 0x40,
  0x0C, 0x08, 0x01, 0x81, 0x00, 0x18, 0x20, 0x01, 0x84, 0x00, 0x10, 0x80,
  0x03, 0x10, 0x00, 0x32, 0x00, 0x02, 0x40, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x0F, 0xF0, 0x07, 0xFC,
  0x31, 0xC0, 0xE0, 0x60, 0x71, 0x98, 0x01, 0x0E, 0x00, 0xCC, 0x80, 0x0C,
  0x40, 0x03, 0x6C, 0x00, 0x26, 0x00, 0x1B, 0xC0, 0x01, 0xE0, 0x00, 0x5C,
  0x00, 0x06, 0x00, 0x02, 0xE0, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x01, 0x80,
  0x00, 0xF0, 0x00, 0x08, 0x00, 0x07, 0x80, 0x00, 0x40, 0x00, 0x3C, 0x00,
  0x02, 0x00, 0x01, 0xE0, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x00, 0x80, 0x00,
  0x78, 0x00, 0x04, 0x00, 0x03, 0xC0, 0x00, 0x20, 0x00, 0x1E, 0x00, 0x01,
  0x00, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x07, 0x80, 0x00, 0x40, 0x00, 0x3C,
  0x00, 0x02, 0x00, 0x01, 0xE0, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x00, 0x80,
  0x00, 0x78, 0x00, 0x04, 0x00, 0x03, 0xC0, 0x00, 0x20, 0x00, 0x1E, 0x00,
  0x01, 0x00, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x07, 0x80, 0x00, 0x40, 0x00,
  0x3C, 0x00, 0x02, 0x00, 0x01, 0xE0, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x00,
  0x80, 0x00, 0x78, 0x00, 0x04, 0x00, 0x03, 0x00, 0x20, 0x10, 0x7F, 0xC2,
  0x18, 0x1C, 0x46, 0x00, 0xC9, 0x80, 0x19, 0x60, 0x01, 0xA8, 0x00, 0x37,
  0x00, 0x02, 0xC0, 0x00, 0x58, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x28,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x70, 0x38, 0x03, 0x00, 0x30, 0x18, 0x00,
  0x60, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x18, 0x00, 0x06, 0x60, 0x00, 0x19,
  0x00, 0x00, 0x24, 0x00, 0x00, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x90, 0x00, 0x02, 0x60, 0x00, 0x19, 0x80, 0x00, 0x63, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x30, 0x03, 0x00, 0x70, 0x38,
  0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x7F, 0xC0, 0x8C,
  0x07, 0x09, 0x00, 0x18, 0xA0, 0x00, 0x8E, 0x00, 0x0C, 0xC0, 0x00, 0x4C,
  0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x68, 0x00, 0x06, 0xC0,
  0x00, 0x4C, 0x00, 0x0C, 0xE0, 0x00, 0x8B, 0x00, 0x18, 0x9C, 0x07, 0x08,
  0x7F, 0xC0, 0x80, 0x40, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE1, 0x0E, 0x03, 0x11, 0x80, 0x19, 0x18, 0x00, 0x53, 0x00, 0x07, 0x20,
  0x00, 0x36, 0x00, 0x01, 0x60, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x14,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x60, 0x00, 0x16, 0x00,
  0x01, 0x20, 0x00, 0x33, 0x00, 0x03, 0x10, 0x00, 0x71, 0x80, 0x0D, 0x0E,
  0x03, 0x90, 0x3F, 0xE1, 0x00, 0x60, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x50,
  0xFE, 0x30, 0x4C, 0x0B, 0x01, 0x40, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x70,
  0x1C, 0x18, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x00, 0x90, 0x00, 0x12, 0x00,
  0x03, 0x40, 0x00, 0x68, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xA0, 0x00,
  0x26, 0x00, 0x0C, 0x60, 0x03, 0x07, 0x01, 0xC0, 0x3F, 0xF0, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xC1, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0xE0, 0x04, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00,
  0x0A, 0x00, 0x01, 0x60, 0x00, 0x6C, 0x00, 0x0C, 0x80, 0x03, 0x98, 0x00,
  0x51, 0x80, 0x32, 0x38, 0x0C, 0x41, 0xFF, 0x08, 0x06, 0x00, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x04, 0x80, 0x00, 0x66, 0x00, 0x03, 0x30,
  0x00, 0x10, 0x80, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x40, 0x80, 0x06,
  0x06, 0x00, 0x30, 0x30, 0x01, 0x00, 0x80, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x03, 0x00, 0x30, 0x10, 0x00, 0x80, 0x80,
  0x04, 0x0C, 0x00, 0x30, 0x40, 0x00, 0x82, 0x00, 0x04, 0x30, 0x00, 0x31,
  0x00, 0x01, 0x88, 0x00, 0x04, 0xC0, 0x00, 0x34, 0x00, 0x01, 0xA0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x90, 0x00, 0x30, 0x00, 0x66, 0x00, 0x0C, 0x00, 0x19, 0x80, 0x07, 0x80,
  0x06, 0x20, 0x01, 0xE0, 0x01, 0x88, 0x00, 0x48, 0x00, 0x43, 0x00, 0x13,
  0x00, 0x30, 0xC0, 0x0C, 0xC0, 0x0C, 0x10, 0x03, 0x30, 0x03, 0x04, 0x00,
  0x84, 0x00, 0x81, 0x80, 0x61, 0x80, 0x60, 0x60, 0x18, 0x60, 0x18, 0x08,
  0x04, 0x18, 0x06, 0x02, 0x01, 0x02, 0x01, 0x00, 0xC0, 0xC0, 0xC0, 0xC0,
  0x30, 0x30, 0x30, 0x30, 0x0C, 0x08, 0x04, 0x0C, 0x01, 0x02, 0x01, 0x02,
  0x00, 0x61, 0x80, 0x61, 0x80, 0x18, 0x60, 0x18, 0x60, 0x06, 0x10, 0x02,
  0x18, 0x00, 0x84, 0x00, 0xC4, 0x00, 0x33, 0x00, 0x33, 0x00, 0x0C, 0x80,
  0x04, 0xC0, 0x03, 0x20, 0x01, 0x30, 0x00, 0x58, 0x00, 0x68, 0x00, 0x16,
  0x00, 0x1A, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x33, 0x00,
  0x01, 0x0C, 0x00, 0x18, 0x60, 0x01, 0x81, 0x80, 0x0C, 0x04, 0x00, 0xC0,
  0x30, 0x04, 0x00, 0xC0, 0x60, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0x43,
  0x00, 0x03, 0x10, 0x00, 0x0D, 0x80, 0x00, 0x68, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x06, 0xC0, 0x00, 0x62, 0x00, 0x02, 0x18,
  0x00, 0x30, 0x40, 0x01, 0x03, 0x00, 0x18, 0x0C, 0x01, 0x80, 0x60, 0x08,
  0x01, 0x80, 0xC0, 0x04, 0x04, 0x00, 0x30, 0x60, 0x00, 0xC6, 0x00, 0x06,
  0x30, 0x00, 0x1B, 0x00, 0x00, 0x60, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x04, 0x80, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x10, 0x80, 0x00,
  0x86, 0x00, 0x0C, 0x30, 0x00, 0x40, 0x80, 0x02, 0x06, 0x00, 0x30, 0x30,
  0x01, 0x80, 0x80, 0x08, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x80, 0x20,
  0x06, 0x03, 0x00, 0x30, 0x18, 0x00, 0x80, 0x80, 0x06, 0x0C, 0x00, 0x30,
  0x60, 0x00, 0x82, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x00, 0x88, 0x00,
  0x06, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xA0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x02, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x04, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x3C, 0x00, 0xF0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x13, 0x03, 0x00, 0x05, 0x80, 0x60, 0x01, 0x40, 0x0C, 0x00, 0xD0, 0x01,
  0x80, 0x2C, 0x00, 0x38, 0x1B, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_Thin58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 42, 11, 4, -41 },
  { 17, 8, 12, 15, 4, -44 },
  { 29, 27, 41, 28, 2, -41 },
  { 168, 22, 53, 28, 3, -47 },
  { 314, 31, 43, 38, 3, -42 },
  { 481, 26, 43, 31, 3, -42 },
  { 621, 2, 12, 10, 4, -44 },
  { 624, 11, 59, 16, 4, -46 },
  { 706, 11, 59, 16, 1, -46 },
  { 788, 23, 22, 24, 1, -41 },
  { 852, 24, 29, 29, 2, -33 },
  { 939, 4, 12, 11, 3, -4 },
  { 945, 11, 1, 16, 2, -19 },
  { 947, 3, 4, 13, 4, -3 },
  { 949, 16, 45, 20, 2, -41 },
  { 1039, 21, 43, 28, 4, -42 },
  { 1152, 11, 41, 28, 5, -41 },
  { 1209, 22, 42, 28, 3, -42 },
  { 1325, 22, 43, 28, 3, -42 },
  { 1444, 25, 41, 28, 2, -41 },
  { 1573, 20, 42, 28, 5, -41 },
  { 1678, 21, 42, 28, 4, -41 },
  { 1789, 23, 41, 28, 2, -41 },
  { 1907, 22, 43, 28, 3, -42 },
  { 2026, 21, 42, 28, 3, -42 },
  { 2137, 3, 31, 10, 4, -30 },
  { 2149, 5, 38, 10, 2, -30 },
  { 2173, 21, 23, 26, 2, -30 },
  { 2234, 20, 12, 28, 4, -25 },
  { 2264, 20, 22, 26, 3, -30 },
  { 2319, 17, 43, 23, 3, -42 },
  { 2411, 40, 53, 47, 3, -40 },
  { 2676, 28, 41, 31, 1, -41 },
  { 2820, 23, 41, 31, 5, -41 },
  { 2938, 25, 43, 33, 4, -42 },
  { 3073, 24, 41, 33, 5, -41 },
  { 3196, 22, 41, 29, 5, -41 },
  { 3309, 22, 41, 29, 5, -41 },
  { 3422, 25, 43, 35, 5, -42 },
  { 3557, 25, 41, 36, 5, -41 },
  { 3686, 2, 41, 14, 6, -41 },
  { 3697, 20, 42, 28, 3, -41 },
  { 3802, 25, 41, 32, 5, -41 },
  { 3931, 20, 41, 27, 5, -41 },
  { 4034, 33, 41, 43, 5, -41 },
  { 4204, 26, 41, 36, 5, -41 },
  { 4338, 26, 43, 34, 4, -42 },
  { 4478, 23, 41, 31, 5, -41 },
  { 4596, 26, 50, 34, 4, -42 },
  { 4759, 24, 41, 33, 5, -41 },
  { 4882, 25, 43, 30, 3, -42 },
  { 5017, 27, 41, 30, 2, -41 },
  { 5156, 24, 42, 34, 5, -41 },
  { 5282, 28, 41, 31, 1, -41 },
  { 5426, 42, 41, 46, 2, -41 },
  { 5642, 27, 41, 31, 2, -41 },
  { 5781, 28, 41, 30, 1, -41 },
  { 5925, 25, 41, 31, 3, -41 },
  { 6054, 7, 56, 12, 5, -47 },
  { 6103, 16, 45, 20, 2, -41 },
  { 6193, 7, 56, 12, 0, -47 },
  { 6242, 15, 21, 22, 3, -41 },
  { 6282, 20, 1, 21, 1, 0 },
  { 6285, 8, 8, 15, 4, -44 },
  { 6293, 20, 33, 27, 3, -32 },
  { 6376, 20, 45, 28, 5, -44 },
  { 6489, 20, 33, 26, 3, -32 },
  { 6572, 20, 45, 28, 3, -44 },
  { 6685, 20, 33, 26, 3, -32 },
  { 6768, 15, 45, 17, 2, -45 },
  { 6853, 20, 44, 28, 3, -32 },
  { 6963, 19, 44, 28, 5, -44 },
  { 7068, 3, 42, 11, 4, -42 },
  { 7084, 10, 54, 12, -3, -42 },
  { 7152, 19, 44, 24, 5, -44 },
  { 7257, 1, 44, 11, 5, -44 },
  { 7263, 37, 32, 45, 4, -32 },
  { 7411, 19, 32, 28, 5, -32 },
  { 7487, 22, 33, 28, 3, -32 },
  { 7578, 20, 44, 28, 5, -32 },
  { 7688, 20, 44, 28, 3, -32 },
  { 7798, 11, 32, 18, 5, -32 },
  { 7842, 19, 33, 26, 3, -32 },
  { 7921, 13, 40, 17, 1, -39 },
  { 7986, 19, 32, 28, 4, -31 },
  { 8062, 21, 31, 25, 2, -31 },
  { 8144, 34, 31, 38, 2, -31 },
  { 8276, 21, 31, 25, 2, -31 },
  { 8358, 21, 43, 25, 2, -31 },
  { 8471, 20, 31, 25, 3, -31 },
  { 8549, 14, 58, 17, 2, -45 },
  { 8651, 2, 49, 12, 5, -41 },
  { 8664, 14, 58, 17, 1, -45 },
  { 8766, 26, 9, 35, 4, -22 },
};

const GFXfont RobotoCondensed_Thin58pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin58pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin58pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _ROBOTOCONDENSED_THIN58PT7B_H_
