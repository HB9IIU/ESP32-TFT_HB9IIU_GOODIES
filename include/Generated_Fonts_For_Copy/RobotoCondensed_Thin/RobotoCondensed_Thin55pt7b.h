#ifndef _ROBOTOCONDENSED_THIN55PT7B_H_
#define _ROBOTOCONDENSED_THIN55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin55pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60,
  0x00, 0x00, 0x01, 0xB0, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x06, 0x18, 0x00, 0x30, 0x08, 0x00, 0x10, 0x04, 0x00, 0x08, 0x06, 0x00,
  0x04, 0x03, 0x00, 0x02, 0x01, 0x80, 0x03, 0x00, 0x80, 0x01, 0x80, 0x40,
  0x00, 0x80, 0x20, 0x00, 0x40, 0x30, 0x00, 0x20, 0x18, 0x00, 0x10, 0x0C,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0C, 0x02, 0x00, 0x06, 0x01, 0x00, 0x02, 0x00,
  0x80, 0x01, 0x00, 0xC0, 0x00, 0x80, 0x60, 0x00, 0x40, 0x30, 0x00, 0x60,
  0x10, 0x00, 0x30, 0x08, 0x00, 0x10, 0x04, 0x00, 0x08, 0x06, 0x00, 0x04,
  0x03, 0x00, 0x02, 0x01, 0x80, 0x03, 0x00, 0x80, 0x01, 0x80, 0x40, 0x00,
  0xC0, 0x20, 0x1F, 0xFF, 0xFF, 0xC0, 0x20, 0x18, 0x00, 0x10, 0x0C, 0x00,
  0x08, 0x04, 0x00, 0x0C, 0x02, 0x00, 0x06, 0x01, 0x00, 0x02, 0x00, 0x80,
  0x01, 0x00, 0xC0, 0x00, 0x80, 0x60, 0x00, 0x40, 0x30, 0x00, 0x60, 0x10,
  0x00, 0x30, 0x08, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x03, 0xFE, 0x00, 0x60, 0x38,
  0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x00, 0x62, 0x00, 0x02, 0x20, 0x00,
  0x36, 0x00, 0x03, 0x60, 0x00, 0x16, 0x00, 0x01, 0x60, 0x00, 0x16, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x14, 0x00, 0x01, 0x40, 0x00, 0x36, 0x00, 0x03, 0x20, 0x00, 0x23, 0x00,
  0x06, 0x18, 0x00, 0xC0, 0xE0, 0x38, 0x03, 0xFE, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18,
  0x08, 0x00, 0x00, 0x40, 0x30, 0x00, 0x03, 0x00, 0x40, 0x08, 0x0C, 0x01,
  0x00, 0x20, 0x20, 0x04, 0x01, 0x80, 0x80, 0x18, 0x04, 0x02, 0x00, 0x60,
  0x30, 0x08, 0x01, 0x81, 0x80, 0x20, 0x04, 0x04, 0x00, 0xC0, 0x10, 0x30,
  0x03, 0x00, 0x40, 0x80, 0x04, 0x03, 0x06, 0x00, 0x18, 0x08, 0x10, 0x00,
  0x30, 0x60, 0xC0, 0x00, 0x7E, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x01, 0x03, 0xF8, 0x00, 0x0C, 0x18, 0x30, 0x00, 0x60,
  0x40, 0x40, 0x01, 0x02, 0x01, 0x80, 0x0C, 0x08, 0x02, 0x00, 0x20, 0x60,
  0x0C, 0x01, 0x81, 0x80, 0x30, 0x04, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x03,
  0x00, 0x80, 0x60, 0x0C, 0x06, 0x01, 0x80, 0x30, 0x10, 0x06, 0x00, 0xC0,
  0xC0, 0x08, 0x02, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x40, 0x40, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x80, 0x60, 0x00, 0xC0,
  0x10, 0x00, 0x40, 0x08, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0x80, 0x06, 0x00, 0x40, 0x01, 0x00, 0x60, 0x00,
  0x80, 0x60, 0x00, 0x60, 0x60, 0x00, 0x10, 0x20, 0x00, 0x0C, 0x60, 0x00,
  0x02, 0x60, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x63, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x20, 0x20,
  0x04, 0x30, 0x08, 0x02, 0x30, 0x06, 0x01, 0x10, 0x01, 0x80, 0x88, 0x00,
  0x60, 0x4C, 0x00, 0x10, 0x66, 0x00, 0x0C, 0x33, 0x00, 0x03, 0x11, 0x80,
  0x00, 0x98, 0xC0, 0x00, 0x28, 0x60, 0x00, 0x1C, 0x10, 0x00, 0x06, 0x0C,
  0x00, 0x05, 0x03, 0x00, 0x04, 0x41, 0xC0, 0x0C, 0x30, 0x70, 0x1C, 0x0C,
  0x0F, 0xFC, 0x02, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x40, 0x20,
  0x10, 0x0C, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40,
  0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x60,
  0x18, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x80, 0x10, 0x02,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x80, 0x20, 0x08,
  0x03, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x18, 0x04, 0x03, 0xF8, 0x20, 0xF0, 0xF1, 0x1C, 0x00,
  0xFF, 0x80, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x6C, 0x00, 0x06, 0x30,
  0x00, 0x20, 0xC0, 0x03, 0x03, 0x00, 0x30, 0x18, 0x03, 0x00, 0x60, 0x18,
  0x01, 0x80, 0x80, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x11, 0x11, 0x11, 0x33, 0x26, 0x40, 0xFF,
  0xE0, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xC0, 0x06, 0x07, 0x00, 0xC0,
  0x18, 0x18, 0x00, 0x81, 0x00, 0x0C, 0x30, 0x00, 0x42, 0x00, 0x06, 0x60,
  0x00, 0x26, 0x00, 0x02, 0x40, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x40, 0x00, 0x14, 0x00, 0x03, 0x40, 0x00, 0x36, 0x00, 0x03, 0x60,
  0x00, 0x22, 0x00, 0x06, 0x30, 0x00, 0x61, 0x00, 0x0C, 0x18, 0x00, 0x80,
  0xC0, 0x18, 0x06, 0x07, 0x00, 0x3F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x3C, 0x3D, 0x9C, 0x3E, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0x81, 0xC0,
  0x30, 0x03, 0x03, 0x00, 0x0C, 0x10, 0x00, 0x61, 0x80, 0x01, 0x88, 0x00,
  0x0C, 0x40, 0x00, 0x66, 0x00, 0x01, 0x30, 0x00, 0x09, 0x80, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x20, 0x00, 0x3F, 0xE0, 0x0E, 0x03, 0x01, 0x80, 0x18, 0x30,
  0x00, 0xC2, 0x00, 0x06, 0x60, 0x00, 0x64, 0x00, 0x02, 0x40, 0x00, 0x34,
  0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x80, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x60, 0x00, 0x36, 0x00, 0x02, 0x30, 0x00, 0x61, 0x80, 0x0C,
  0x0E, 0x03, 0x80, 0x3F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x98, 0x00, 0x03, 0x30, 0x00, 0x04, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x21,
  0x80, 0x00, 0xC3, 0x00, 0x03, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x20, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x00, 0xC0, 0x06, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x00, 0x18, 0x06,
  0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80,
  0x03, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x3F, 0xFF, 0xE6, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0xFC,
  0x02, 0x79, 0xE0, 0x70, 0x06, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x02, 0xC0, 0x00, 0x48, 0x00, 0x19, 0x80, 0x02,
  0x10, 0x00, 0xC3, 0x00, 0x30, 0x38, 0x0C, 0x01, 0xFF, 0x00, 0x02, 0x00,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x03, 0xF0, 0x08, 0x79, 0xE0, 0x4E, 0x01, 0x82, 0xC0, 0x06, 0x34,
  0x00, 0x19, 0xC0, 0x00, 0x4E, 0x00, 0x03, 0x60, 0x00, 0x0B, 0x00, 0x00,
  0x58, 0x00, 0x02, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x34, 0x00, 0x01, 0xA0, 0x00, 0x09, 0x00, 0x00, 0x4C, 0x00, 0x06,
  0x20, 0x00, 0x31, 0x80, 0x01, 0x0C, 0x00, 0x18, 0x30, 0x01, 0x80, 0xC0,
  0x18, 0x03, 0x81, 0x80, 0x07, 0xF8, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x1F, 0xF0, 0x03, 0x81, 0xC0, 0x30, 0x03, 0x03, 0x00, 0x0C, 0x18, 0x00,
  0x31, 0x80, 0x00, 0x8C, 0x00, 0x06, 0x40, 0x00, 0x32, 0x00, 0x00, 0x90,
  0x00, 0x04, 0x80, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x19, 0x80, 0x00,
  0x84, 0x00, 0x04, 0x30, 0x00, 0x40, 0xC0, 0x06, 0x03, 0x00, 0x60, 0x0F,
  0x3C, 0x00, 0x3F, 0xC0, 0x07, 0x03, 0x80, 0x60, 0x03, 0x06, 0x00, 0x0C,
  0x60, 0x00, 0x22, 0x00, 0x01, 0xB0, 0x00, 0x05, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xD0, 0x00, 0x04, 0xC0, 0x00, 0x63, 0x00, 0x06, 0x1C, 0x00,
  0x60, 0x38, 0x0E, 0x00, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x0E, 0x07, 0x01, 0x80, 0x18, 0x10, 0x00, 0xC3, 0x00, 0x0C,
  0x60, 0x00, 0x66, 0x00, 0x06, 0x40, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x60,
  0x00, 0x76, 0x00, 0x05, 0x30, 0x00, 0xD1, 0x80, 0x19, 0x0C, 0x03, 0x10,
  0x79, 0xE3, 0x01, 0xF8, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x67, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x33, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x84, 0x23, 0x18, 0xC6,
  0x62, 0x10, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x18, 0x18, 0x20,
  0x0C, 0x60, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x20, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x01, 0x06, 0x00, 0x0F, 0x80, 0x04,
  0x18, 0x00, 0xF7, 0x80, 0x18, 0xC0, 0x06, 0x03, 0x00, 0x23, 0x00, 0x30,
  0x04, 0x00, 0x88, 0x00, 0x80, 0x10, 0x02, 0x20, 0x06, 0x00, 0x40, 0x09,
  0x80, 0x10, 0x01, 0x00, 0x36, 0x00, 0xC0, 0x04, 0x00, 0xD0, 0x02, 0x00,
  0x10, 0x03, 0x40, 0x08, 0x00, 0xC0, 0x0D, 0x00, 0x60, 0x03, 0x00, 0x34,
  0x01, 0x80, 0x0C, 0x00, 0xF0, 0x04, 0x00, 0x30, 0x03, 0xC0, 0x10, 0x00,
  0xC0, 0x0F, 0x00, 0x40, 0x03, 0x00, 0x3C, 0x01, 0x00, 0x08, 0x00, 0xF0,
  0x04, 0x00, 0x20, 0x02, 0xC0, 0x10, 0x00, 0x80, 0x0B, 0x00, 0x40, 0x02,
  0x00, 0x24, 0x01, 0x00, 0x18, 0x01, 0x90, 0x04, 0x00, 0x60, 0x06, 0x40,
  0x10, 0x01, 0x80, 0x11, 0x00, 0x60, 0x0A, 0x00, 0xC6, 0x01, 0x80, 0x6C,
  0x02, 0x18, 0x03, 0x01, 0x10, 0x18, 0x20, 0x04, 0x18, 0x60, 0xC0, 0xC0,
  0x1F, 0xC0, 0xFE, 0x03, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x22, 0x00, 0x00, 0x04, 0x40,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x20, 0x80, 0x00, 0x04, 0x10, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x20, 0x20, 0x00, 0x04, 0x04, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x20, 0x08, 0x00, 0x04, 0x01, 0x00, 0x01, 0x80, 0x30, 0x00, 0x30,
  0x06, 0x00, 0x04, 0x00, 0x40, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x01, 0x80, 0x02, 0x00, 0x30, 0x00, 0x60, 0x04, 0x00,
  0x04, 0x00, 0x80, 0x00, 0x80, 0x3F, 0xFF, 0xF8, 0x04, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x20, 0x30, 0x00, 0x06, 0x04, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x08, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x80, 0x00, 0x02, 0x30,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x18, 0xFF, 0xF8, 0x04, 0x00, 0xF0, 0x20, 0x00, 0xE1, 0x00, 0x01, 0x88,
  0x00, 0x04, 0x40, 0x00, 0x32, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00,
  0x34, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0x68, 0x00, 0x03, 0x40,
  0x00, 0x12, 0x00, 0x01, 0x90, 0x00, 0x08, 0x80, 0x00, 0xC4, 0x00, 0x0C,
  0x20, 0x07, 0x81, 0xFF, 0xFC, 0x08, 0x00, 0x38, 0x40, 0x00, 0x62, 0x00,
  0x01, 0x90, 0x00, 0x06, 0x80, 0x00, 0x14, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0xC8,
  0x00, 0x0C, 0x40, 0x07, 0xC3, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x20, 0x00, 0x04, 0x60, 0x00, 0x06, 0x40, 0x00, 0x02, 0x40,
  0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x30, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x30, 0x07, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xFF,
  0xF8, 0x01, 0x00, 0x3E, 0x02, 0x00, 0x06, 0x04, 0x00, 0x06, 0x08, 0x00,
  0x06, 0x10, 0x00, 0x06, 0x20, 0x00, 0x06, 0x40, 0x00, 0x04, 0x80, 0x00,
  0x0D, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50, 0x00,
  0x00, 0xA0, 0x00, 0x03, 0x40, 0x00, 0x04, 0x80, 0x00, 0x19, 0x00, 0x00,
  0x62, 0x00, 0x01, 0x84, 0x00, 0x07, 0x08, 0x00, 0x18, 0x10, 0x07, 0xE0,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0xFF, 0x88, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1C, 0x03, 0x80, 0x60, 0x01,
  0x81, 0x80, 0x01, 0x86, 0x00, 0x01, 0x98, 0x00, 0x01, 0x20, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x40, 0x00, 0x02,
  0xC0, 0x00, 0x04, 0x80, 0x00, 0x09, 0x80, 0x00, 0x11, 0x80, 0x00, 0xE1,
  0x80, 0x03, 0x81, 0xC0, 0x3C, 0x00, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0,
  0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x66,
  0x00, 0x06, 0x20, 0x00, 0x43, 0x00, 0x0C, 0x18, 0x01, 0x80, 0xE0, 0x70,
  0x07, 0xFC, 0x00, 0x04, 0x00, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x18, 0x80,
  0x00, 0x30, 0x80, 0x00, 0x60, 0x80, 0x00, 0x60, 0x80, 0x00, 0xC0, 0x80,
  0x01, 0x80, 0x80, 0x03, 0x00, 0x80, 0x06, 0x00, 0x80, 0x0C, 0x00, 0x80,
  0x0C, 0x00, 0x80, 0x18, 0x00, 0x80, 0x30, 0x00, 0x80, 0x60, 0x00, 0x80,
  0xC0, 0x00, 0x81, 0x80, 0x00, 0x81, 0x00, 0x00, 0x83, 0x00, 0x00, 0x87,
  0x00, 0x00, 0x8D, 0x80, 0x00, 0x98, 0xC0, 0x00, 0xB0, 0x60, 0x00, 0xE0,
  0x20, 0x00, 0xC0, 0x30, 0x00, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x80,
  0x04, 0x00, 0x80, 0x06, 0x00, 0x80, 0x03, 0x00, 0x80, 0x01, 0x80, 0x80,
  0x00, 0x80, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x60, 0x80, 0x00, 0x30, 0x80,
  0x00, 0x30, 0x80, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x04, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3D, 0x00, 0x00, 0x00, 0x5B, 0x00, 0x00,
  0x01, 0xB2, 0x00, 0x00, 0x02, 0x64, 0x00, 0x00, 0x04, 0xCC, 0x00, 0x00,
  0x19, 0x88, 0x00, 0x00, 0x23, 0x18, 0x00, 0x00, 0x46, 0x30, 0x00, 0x01,
  0x8C, 0x20, 0x00, 0x02, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x40, 0x00, 0x10,
  0x60, 0x80, 0x00, 0x20, 0xC1, 0x80, 0x00, 0xC1, 0x81, 0x00, 0x01, 0x03,
  0x02, 0x00, 0x02, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x04, 0x00, 0x10, 0x18,
  0x0C, 0x00, 0x60, 0x30, 0x08, 0x00, 0xC0, 0x60, 0x10, 0x01, 0x00, 0xC0,
  0x30, 0x06, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x00,
  0xC0, 0x60, 0x0C, 0x00, 0x80, 0x80, 0x18, 0x01, 0x03, 0x00, 0x30, 0x03,
  0x06, 0x00, 0x60, 0x02, 0x08, 0x00, 0xC0, 0x06, 0x30, 0x01, 0x80, 0x04,
  0x40, 0x03, 0x00, 0x08, 0x80, 0x06, 0x00, 0x1B, 0x00, 0x0C, 0x00, 0x14,
  0x00, 0x18, 0x00, 0x28, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x80, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xC8, 0x00, 0x01, 0xCC,
  0x00, 0x01, 0xC4, 0x00, 0x01, 0xC6, 0x00, 0x01, 0xC3, 0x00, 0x01, 0xC1,
  0x00, 0x01, 0xC1, 0x80, 0x01, 0xC0, 0x80, 0x01, 0xC0, 0xC0, 0x01, 0xC0,
  0x60, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0x10, 0x01, 0xC0,
  0x18, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x06, 0x01, 0xC0,
  0x02, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x01, 0x01, 0xC0, 0x01, 0x81, 0xC0,
  0x00, 0xC1, 0xC0, 0x00, 0xC1, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x21, 0xC0,
  0x00, 0x31, 0xC0, 0x00, 0x11, 0xC0, 0x00, 0x19, 0xC0, 0x00, 0x0D, 0xC0,
  0x00, 0x05, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x60, 0x00, 0x06, 0x40,
  0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40,
  0x00, 0x02, 0x60, 0x00, 0x06, 0x20, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0xFF, 0xFC, 0x04, 0x00, 0x7C, 0x20, 0x00, 0x71, 0x00, 0x00,
  0xC8, 0x00, 0x03, 0x40, 0x00, 0x1A, 0x00, 0x00, 0x50, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0xC8, 0x00, 0x1C, 0x40, 0x0F, 0xC3,
  0xFF, 0xF0, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x60, 0x00, 0x06, 0x40, 0x00, 0x02,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x02,
  0x60, 0x00, 0x06, 0x20, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x10, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0xFF, 0xFC, 0x01, 0x00, 0x1F, 0x02,
  0x00, 0x03, 0x04, 0x00, 0x03, 0x08, 0x00, 0x03, 0x10, 0x00, 0x02, 0x20,
  0x00, 0x06, 0x40, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x48, 0x00, 0x00, 0x90, 0x00, 0x01, 0x20, 0x00,
  0x02, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x11, 0x00, 0x00, 0x62, 0x00, 0x01,
  0x84, 0x00, 0x06, 0x08, 0x00, 0x78, 0x1F, 0xFF, 0x80, 0x20, 0x01, 0x00,
  0x40, 0x03, 0x00, 0x80, 0x02, 0x01, 0x00, 0x06, 0x02, 0x00, 0x06, 0x04,
  0x00, 0x0C, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x20, 0x00, 0x18, 0x40,
  0x00, 0x30, 0x80, 0x00, 0x31, 0x00, 0x00, 0x22, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x48, 0x00, 0x00, 0xD0, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x3C, 0x03, 0x80, 0xE0, 0x01, 0x83, 0x00,
  0x01, 0x84, 0x00, 0x01, 0x18, 0x00, 0x03, 0x20, 0x00, 0x02, 0x40, 0x00,
  0x04, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0D, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x63, 0x00, 0x01, 0x83, 0x80, 0x06,
  0x03, 0xC0, 0x38, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x26, 0x00, 0x01, 0x8C,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0x38, 0x07, 0x00, 0x3F, 0xF0, 0x00, 0x08,
  0x00, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x09, 0x80, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x08, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x08, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x08, 0x04, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x60, 0x08, 0x00, 0x08,
  0x01, 0x00, 0x01, 0x00, 0x30, 0x00, 0x60, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x10, 0x01, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x04, 0x01, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x01, 0x00, 0x00, 0x20, 0x20, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x20, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1A, 0x00, 0x01, 0x40, 0x00, 0x34, 0x00, 0x02, 0xC0,
  0x00, 0x4C, 0x00, 0x0C, 0x80, 0x00, 0x98, 0x00, 0x19, 0x00, 0x03, 0x10,
  0x00, 0x22, 0x00, 0x06, 0x20, 0x00, 0x46, 0x00, 0x08, 0x60, 0x01, 0x84,
  0x00, 0x10, 0xC0, 0x03, 0x08, 0x00, 0x60, 0x80, 0x04, 0x10, 0x00, 0xC1,
  0x00, 0x08, 0x30, 0x01, 0x83, 0x00, 0x30, 0x20, 0x02, 0x06, 0x00, 0x60,
  0x40, 0x04, 0x0C, 0x00, 0x80, 0x80, 0x18, 0x08, 0x01, 0x01, 0x80, 0x30,
  0x10, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x10,
  0x04, 0x03, 0x00, 0x40, 0x20, 0x0C, 0x06, 0x00, 0x80, 0xC0, 0x08, 0x08,
  0x01, 0x81, 0x80, 0x10, 0x10, 0x03, 0x02, 0x00, 0x20, 0x60, 0x06, 0x04,
  0x00, 0x60, 0xC0, 0x04, 0x18, 0x00, 0x41, 0x80, 0x08, 0x20, 0x00, 0x82,
  0x00, 0x18, 0x40, 0x01, 0x84, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x23,
  0x00, 0x02, 0x30, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0xC8, 0x00, 0x08,
  0x80, 0x01, 0x90, 0x00, 0x1B, 0x00, 0x01, 0x60, 0x00, 0x16, 0x00, 0x02,
  0x80, 0x00, 0x2C, 0x00, 0x05, 0x00, 0x00, 0x50, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x01, 0x30, 0x00, 0x01, 0x88, 0x00, 0x00, 0x86, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x60, 0x08, 0x00,
  0x20, 0x06, 0x00, 0x30, 0x01, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x30,
  0x18, 0x00, 0x08, 0x08, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x04, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x40, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x88, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x40, 0x40, 0x00, 0x60, 0x30,
  0x00, 0x20, 0x08, 0x00, 0x30, 0x06, 0x00, 0x30, 0x01, 0x80, 0x10, 0x00,
  0xC0, 0x18, 0x00, 0x30, 0x08, 0x00, 0x08, 0x0C, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0x86, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x32, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x18, 0x80, 0x00, 0x02,
  0x18, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x10, 0x30, 0x00, 0x06, 0x02, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x30, 0x04, 0x00, 0x04, 0x00, 0xC0, 0x01, 0x80,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x10, 0x01, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x20, 0x08, 0x00, 0x06, 0x03, 0x00, 0x00, 0x40, 0x40, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x82, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x10,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xFE, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFC, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0xFE, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x3F, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x78, 0x01, 0x20,
  0x04, 0x80, 0x33, 0x00, 0xC4, 0x02, 0x10, 0x18, 0x60, 0x61, 0x81, 0x02,
  0x0C, 0x0C, 0x30, 0x30, 0x80, 0x46, 0x01, 0x98, 0x06, 0x40, 0x0B, 0x00,
  0x3C, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0xC0, 0xC0, 0xC0, 0x81, 0x81,
  0x81, 0x80, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x70, 0x1C, 0x18, 0x00, 0xC2,
  0x00, 0x08, 0xC0, 0x01, 0x90, 0x00, 0x16, 0x00, 0x02, 0xC0, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0xFF, 0xF0, 0x7C, 0x02, 0x38, 0x00, 0x4C, 0x00, 0x09, 0x00, 0x01, 0x60,
  0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x06, 0x80,
  0x00, 0xD0, 0x00, 0x3B, 0x00, 0x0D, 0x30, 0x03, 0x23, 0x01, 0xC6, 0x3F,
  0xE0, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x3F, 0xC1, 0x98,
  0x0E, 0x36, 0x00, 0x67, 0x80, 0x04, 0xE0, 0x00, 0xDC, 0x00, 0x0B, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x2E, 0x00, 0x0D, 0xC0, 0x01, 0x36, 0x00,
  0x66, 0x60, 0x38, 0xC7, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x30, 0x1C, 0x0C, 0x00, 0xC3, 0x00, 0x08, 0xC0, 0x01, 0x90, 0x00,
  0x12, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x70, 0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x4C, 0x00, 0x08, 0xC0, 0x03,
  0x0C, 0x00, 0xC0, 0xC0, 0x70, 0x0F, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x7F, 0xC2, 0x18, 0x0E, 0x46, 0x00, 0x69, 0x80, 0x05,
  0x20, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x05, 0x80, 0x00, 0xB0, 0x00, 0x32,
  0x00, 0x06, 0x60, 0x01, 0xC6, 0x00, 0x68, 0x60, 0x39, 0x07, 0xFC, 0x20,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0x03, 0x80, 0xC0, 0x0C,
  0x18, 0x00, 0x63, 0x00, 0x06, 0x20, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00,
  0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x20, 0xC0, 0x06,
  0x07, 0x01, 0xC0, 0x1F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x03, 0xFF, 0xC0, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x84, 0x30, 0x18, 0x8C, 0x00, 0x93, 0x00, 0x0A, 0x40, 0x01,
  0xD8, 0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x28, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x02,
  0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x60, 0x00, 0x64, 0x00, 0x0C,
  0xC0, 0x03, 0x8C, 0x00, 0xD0, 0xC0, 0x72, 0x0F, 0xF8, 0x40, 0x10, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x32,
  0x00, 0x04, 0x60, 0x01, 0x87, 0x00, 0x60, 0x3C, 0x78, 0x01, 0xFC, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x80, 0xC1, 0xFE, 0x31, 0x81, 0xCC, 0xC0, 0x1B, 0x60, 0x02,
  0xD0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x40, 0xDF, 0x00, 0x00,
  0x00, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92,
  0x00, 0x80, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04,
  0x03, 0x33, 0x87, 0x80, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01, 0xB0, 0x00, 0xCC,
  0x00, 0x63, 0x00, 0x30, 0xC0, 0x08, 0x30, 0x06, 0x0C, 0x03, 0x03, 0x01,
  0x80, 0xC0, 0xC0, 0x30, 0x60, 0x0C, 0x30, 0x03, 0x18, 0x00, 0xCC, 0x00,
  0x36, 0x80, 0x0D, 0x30, 0x03, 0x86, 0x00, 0xC0, 0x80, 0x30, 0x30, 0x0C,
  0x06, 0x03, 0x00, 0x80, 0xC0, 0x30, 0x30, 0x06, 0x0C, 0x00, 0xC3, 0x00,
  0x10, 0xC0, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x7F, 0x80, 0x3F, 0xC3, 0x18, 0x1C, 0x1C, 0x0C, 0x66, 0x00, 0xC6, 0x00,
  0xCD, 0x80, 0x19, 0x80, 0x0D, 0xE0, 0x01, 0x20, 0x01, 0xB8, 0x00, 0x38,
  0x00, 0x17, 0x00, 0x07, 0x00, 0x02, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00,
  0x08, 0x00, 0x0F, 0x00, 0x01, 0x00, 0x01, 0xE0, 0x00, 0x20, 0x00, 0x3C,
  0x00, 0x04, 0x00, 0x07, 0x80, 0x00, 0x80, 0x00, 0xF0, 0x00, 0x10, 0x00,
  0x1E, 0x00, 0x02, 0x00, 0x03, 0xC0, 0x00, 0x40, 0x00, 0x78, 0x00, 0x08,
  0x00, 0x0F, 0x00, 0x01, 0x00, 0x01, 0xE0, 0x00, 0x20, 0x00, 0x3C, 0x00,
  0x04, 0x00, 0x07, 0x80, 0x00, 0x80, 0x00, 0xF0, 0x00, 0x10, 0x00, 0x1E,
  0x00, 0x02, 0x00, 0x03, 0xC0, 0x00, 0x40, 0x00, 0x78, 0x00, 0x08, 0x00,
  0x0F, 0x00, 0x01, 0x00, 0x01, 0xE0, 0x00, 0x20, 0x00, 0x3C, 0x00, 0x04,
  0x00, 0x07, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x30, 0x7F, 0x8C,
  0x60, 0x73, 0x30, 0x06, 0xD8, 0x00, 0xB4, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x10, 0x00, 0x20, 0x00, 0x3F, 0xE0, 0x0E, 0x03, 0x01, 0x80,
  0x18, 0x30, 0x00, 0xC3, 0x00, 0x06, 0x60, 0x00, 0x26, 0x00, 0x03, 0x40,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00,
  0x36, 0x00, 0x03, 0x60, 0x00, 0x23, 0x00, 0x06, 0x10, 0x00, 0xC1, 0x80,
  0x18, 0x0E, 0x03, 0x00, 0x3F, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x7F, 0x83, 0x30, 0x1C, 0x6C, 0x00, 0xCF, 0x00, 0x09, 0xC0, 0x01, 0xB0,
  0x00, 0x16, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x5C, 0x00, 0x1B, 0x80,
  0x02, 0x6C, 0x00, 0xCC, 0xC0, 0x71, 0x8F, 0xF8, 0x30, 0x18, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x84, 0x30, 0x1C, 0x8C, 0x00, 0xD3, 0x00, 0x0A, 0x40,
  0x00, 0xD8, 0x00, 0x1B, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x02, 0x80, 0x00, 0x50, 0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x24, 0x00,
  0x0C, 0xC0, 0x03, 0x8C, 0x00, 0xD0, 0xC0, 0x72, 0x0F, 0xF8, 0x40, 0x10,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x18, 0x7F, 0x38, 0x64, 0x0D, 0x01, 0xE0, 0x38, 0x07, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x03,
  0x80, 0xE0, 0xC0, 0x0C, 0x60, 0x01, 0x90, 0x00, 0x2C, 0x00, 0x0B, 0x00,
  0x02, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x24, 0x00, 0x19, 0x80, 0x0C, 0x38, 0x06,
  0x03, 0xFF, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0xFF, 0xF0, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x1F, 0x00, 0x30, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x14, 0x00, 0x0D, 0x00,
  0x03, 0x60, 0x01, 0xC8, 0x00, 0x53, 0x00, 0x34, 0x60, 0x39, 0x0F, 0xF8,
  0x40, 0x20, 0x00, 0x40, 0x00, 0x1A, 0x00, 0x00, 0x98, 0x00, 0x04, 0x40,
  0x00, 0x62, 0x00, 0x02, 0x18, 0x00, 0x10, 0x40, 0x01, 0x82, 0x00, 0x08,
  0x18, 0x00, 0x40, 0x40, 0x06, 0x02, 0x00, 0x20, 0x18, 0x01, 0x00, 0x40,
  0x18, 0x02, 0x00, 0x80, 0x18, 0x04, 0x00, 0x40, 0x60, 0x02, 0x02, 0x00,
  0x18, 0x10, 0x00, 0x41, 0x80, 0x02, 0x08, 0x00, 0x18, 0x40, 0x00, 0x46,
  0x00, 0x02, 0x20, 0x00, 0x19, 0x00, 0x00, 0x58, 0x00, 0x02, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x40, 0x01, 0x80, 0x02, 0x60, 0x01, 0x80, 0x02, 0x60, 0x03, 0xC0, 0x06,
  0x60, 0x03, 0x40, 0x06, 0x20, 0x02, 0x40, 0x04, 0x30, 0x02, 0x60, 0x04,
  0x30, 0x06, 0x60, 0x0C, 0x30, 0x06, 0x60, 0x0C, 0x10, 0x04, 0x20, 0x08,
  0x18, 0x0C, 0x30, 0x08, 0x18, 0x0C, 0x30, 0x18, 0x18, 0x08, 0x10, 0x18,
  0x08, 0x08, 0x10, 0x10, 0x0C, 0x18, 0x18, 0x10, 0x0C, 0x18, 0x18, 0x30,
  0x0C, 0x10, 0x08, 0x30, 0x04, 0x10, 0x08, 0x20, 0x06, 0x30, 0x0C, 0x20,
  0x06, 0x20, 0x04, 0x60, 0x06, 0x20, 0x04, 0x60, 0x02, 0x60, 0x06, 0x40,
  0x02, 0x60, 0x06, 0x40, 0x03, 0x40, 0x02, 0xC0, 0x03, 0x40, 0x02, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x66, 0x00, 0x0C, 0x20, 0x00, 0xC3,
  0x00, 0x18, 0x18, 0x01, 0x00, 0x80, 0x30, 0x0C, 0x06, 0x00, 0x40, 0x60,
  0x06, 0x0C, 0x00, 0x30, 0x80, 0x01, 0x18, 0x00, 0x19, 0x00, 0x00, 0xA0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xB0, 0x00, 0x11,
  0x80, 0x03, 0x08, 0x00, 0x20, 0xC0, 0x06, 0x04, 0x00, 0xC0, 0x60, 0x08,
  0x03, 0x01, 0x80, 0x10, 0x30, 0x01, 0x83, 0x00, 0x08, 0x60, 0x00, 0xC4,
  0x00, 0x06, 0xC0, 0x00, 0x20, 0x40, 0x00, 0x1A, 0x00, 0x00, 0xD8, 0x00,
  0x04, 0x40, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x10, 0x40, 0x01, 0x83,
  0x00, 0x0C, 0x18, 0x00, 0x40, 0x40, 0x06, 0x03, 0x00, 0x30, 0x18, 0x01,
  0x00, 0x40, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x04, 0x00, 0x40, 0x60, 0x03,
  0x03, 0x00, 0x08, 0x10, 0x00, 0x41, 0x80, 0x03, 0x0C, 0x00, 0x08, 0x40,
  0x00, 0x46, 0x00, 0x03, 0x30, 0x00, 0x09, 0x00, 0x00, 0x58, 0x00, 0x03,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60,
  0x0F, 0x00, 0x38, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x06, 0x00, 0x1E, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x70, 0x02, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x48, 0x18,
  0x00, 0x6C, 0x03, 0x00, 0x34, 0x00, 0x80, 0x16, 0x00, 0x20, 0x1B, 0x00,
  0x0C, 0x09, 0x80, 0x03, 0x9C, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_Thin55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 40, 10, 4, -39 },
  { 16, 7, 11, 14, 4, -41 },
  { 26, 25, 39, 27, 2, -39 },
  { 148, 20, 51, 27, 3, -45 },
  { 276, 30, 41, 36, 3, -40 },
  { 430, 25, 41, 29, 3, -40 },
  { 559, 1, 11, 9, 4, -41 },
  { 561, 10, 57, 15, 4, -44 },
  { 633, 10, 57, 15, 1, -44 },
  { 705, 21, 21, 23, 1, -39 },
  { 761, 23, 29, 27, 2, -32 },
  { 845, 4, 11, 10, 2, -4 },
  { 851, 11, 1, 15, 2, -18 },
  { 853, 3, 3, 12, 4, -2 },
  { 855, 16, 42, 19, 1, -39 },
  { 939, 20, 41, 27, 3, -40 },
  { 1042, 11, 39, 27, 5, -39 },
  { 1096, 21, 40, 27, 3, -40 },
  { 1201, 20, 41, 27, 3, -40 },
  { 1304, 23, 39, 27, 2, -39 },
  { 1417, 19, 40, 27, 5, -39 },
  { 1512, 21, 40, 27, 3, -39 },
  { 1617, 22, 39, 27, 2, -39 },
  { 1725, 21, 41, 27, 3, -40 },
  { 1833, 20, 40, 27, 3, -40 },
  { 1933, 4, 29, 10, 3, -28 },
  { 1948, 5, 35, 9, 2, -28 },
  { 1970, 19, 22, 25, 2, -29 },
  { 2023, 19, 12, 27, 4, -24 },
  { 2052, 19, 22, 25, 3, -29 },
  { 2105, 16, 41, 21, 3, -40 },
  { 2187, 38, 50, 44, 3, -38 },
  { 2425, 27, 39, 29, 1, -39 },
  { 2557, 21, 39, 29, 5, -39 },
  { 2660, 24, 41, 31, 4, -40 },
  { 2783, 23, 39, 32, 5, -39 },
  { 2896, 20, 39, 28, 5, -39 },
  { 2994, 21, 39, 28, 5, -39 },
  { 3097, 23, 41, 33, 5, -40 },
  { 3215, 24, 39, 34, 5, -39 },
  { 3332, 1, 39, 13, 6, -39 },
  { 3337, 20, 40, 27, 2, -39 },
  { 3437, 24, 39, 31, 5, -39 },
  { 3554, 18, 39, 25, 5, -39 },
  { 3642, 31, 39, 41, 5, -39 },
  { 3794, 24, 39, 34, 5, -39 },
  { 3911, 24, 41, 32, 4, -40 },
  { 4034, 21, 39, 29, 5, -39 },
  { 4137, 24, 47, 32, 4, -40 },
  { 4278, 23, 39, 31, 5, -39 },
  { 4391, 23, 41, 29, 3, -40 },
  { 4509, 25, 39, 29, 2, -39 },
  { 4631, 22, 40, 32, 5, -39 },
  { 4741, 27, 39, 29, 1, -39 },
  { 4873, 39, 39, 43, 2, -39 },
  { 5064, 25, 39, 29, 2, -39 },
  { 5186, 27, 39, 29, 1, -39 },
  { 5318, 23, 39, 29, 3, -39 },
  { 5431, 6, 53, 11, 5, -45 },
  { 5471, 15, 42, 19, 2, -39 },
  { 5550, 7, 53, 11, 0, -45 },
  { 5597, 14, 20, 20, 3, -39 },
  { 5632, 20, 1, 20, 0, 0 },
  { 5635, 7, 7, 15, 4, -41 },
  { 5642, 19, 31, 26, 3, -30 },
  { 5716, 19, 42, 27, 4, -41 },
  { 5816, 19, 31, 25, 3, -30 },
  { 5890, 19, 42, 27, 3, -41 },
  { 5990, 20, 31, 25, 2, -30 },
  { 6068, 14, 42, 16, 2, -42 },
  { 6142, 19, 41, 27, 3, -30 },
  { 6240, 18, 41, 27, 4, -41 },
  { 6333, 3, 40, 11, 4, -40 },
  { 6348, 10, 51, 11, -3, -40 },
  { 6412, 18, 41, 23, 4, -41 },
  { 6505, 1, 41, 11, 5, -41 },
  { 6511, 35, 30, 43, 4, -30 },
  { 6643, 18, 30, 27, 4, -30 },
  { 6711, 20, 31, 27, 3, -30 },
  { 6789, 19, 41, 27, 4, -30 },
  { 6887, 19, 41, 27, 3, -30 },
  { 6985, 11, 30, 17, 4, -30 },
  { 7027, 18, 31, 24, 3, -30 },
  { 7097, 13, 38, 16, 1, -37 },
  { 7159, 18, 30, 27, 4, -29 },
  { 7227, 21, 29, 23, 1, -29 },
  { 7304, 32, 29, 36, 2, -29 },
  { 7420, 20, 29, 23, 2, -29 },
  { 7493, 21, 40, 23, 1, -29 },
  { 7598, 20, 29, 23, 2, -29 },
  { 7671, 14, 55, 16, 2, -43 },
  { 7768, 1, 46, 11, 5, -39 },
  { 7774, 13, 55, 16, 1, -43 },
  { 7864, 25, 9, 33, 4, -21 },
};

const GFXfont RobotoCondensed_Thin55pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin55pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin55pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _ROBOTOCONDENSED_THIN55PT7B_H_
