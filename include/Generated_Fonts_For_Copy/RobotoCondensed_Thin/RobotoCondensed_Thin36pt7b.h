#ifndef _ROBOTOCONDENSED_THIN36PT7B_H_
#define _ROBOTOCONDENSED_THIN36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xE0, 0xC0, 0x99, 0x99, 0x99, 0x90, 0x01, 0x04, 0x00,
  0x82, 0x00, 0x41, 0x00, 0x40, 0x80, 0x20, 0x40, 0x10, 0x40, 0x08, 0x20,
  0xFF, 0xFF, 0x02, 0x08, 0x01, 0x04, 0x01, 0x02, 0x00, 0x82, 0x00, 0x41,
  0x00, 0x20, 0x80, 0x10, 0x40, 0x08, 0x20, 0x08, 0x10, 0x04, 0x08, 0x3F,
  0xFF, 0xC1, 0x04, 0x00, 0x82, 0x00, 0x41, 0x00, 0x20, 0x80, 0x20, 0x40,
  0x10, 0x40, 0x08, 0x20, 0x00, 0x01, 0x00, 0x08, 0x00, 0x40, 0x1F, 0x81,
  0x06, 0x10, 0x09, 0x00, 0x48, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x40, 0x0A, 0x00, 0x48,
  0x04, 0x20, 0x40, 0xFC, 0x00, 0x80, 0x04, 0x00, 0x20, 0x3C, 0x00, 0x08,
  0x40, 0x01, 0x04, 0x00, 0x40, 0x81, 0x08, 0x10, 0x21, 0x02, 0x08, 0x20,
  0x41, 0x04, 0x08, 0x40, 0x81, 0x08, 0x08, 0x22, 0x01, 0x08, 0x40, 0x1E,
  0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0xE0, 0x04, 0x62, 0x01,
  0x08, 0x20, 0x22, 0x04, 0x08, 0x40, 0x81, 0x08, 0x10, 0x41, 0x02, 0x08,
  0x20, 0x42, 0x04, 0x08, 0x00, 0x41, 0x00, 0x0C, 0x40, 0x00, 0xF0, 0x07,
  0x80, 0x18, 0x40, 0x10, 0x60, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x40, 0x20, 0x40, 0x10, 0x80, 0x11, 0x00, 0x0A, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x12, 0x00, 0x21, 0x00, 0x41, 0x82, 0x40, 0x82, 0x80, 0x42, 0x80,
  0x22, 0x80, 0x22, 0x80, 0x14, 0x80, 0x0C, 0x40, 0x0C, 0x40, 0x14, 0x30,
  0x62, 0x0F, 0x81, 0x57, 0xA8, 0x04, 0x20, 0x84, 0x20, 0x82, 0x10, 0x41,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x10, 0x41, 0x02, 0x08, 0x20, 0x40, 0x82, 0x04, 0x81, 0x04, 0x08,
  0x20, 0x41, 0x02, 0x08, 0x20, 0x81, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x21, 0x04, 0x20, 0x84, 0x10,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x03, 0x08, 0x63,
  0xAE, 0x01, 0xC0, 0x05, 0x00, 0x16, 0x00, 0x88, 0x04, 0x10, 0x30, 0x20,
  0x80, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x01, 0xFF, 0xFC, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x55, 0x68, 0xFE, 0xB0, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x02, 0x00, 0x0F, 0x80, 0x82, 0x08, 0x08, 0x40, 0x24,
  0x01, 0x20, 0x05, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x80, 0x14, 0x00, 0xA0, 0x08, 0x80, 0x44, 0x04, 0x10, 0x40, 0x7C, 0x00,
  0x02, 0x3D, 0x8C, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0F,
  0x80, 0x41, 0x82, 0x02, 0x10, 0x04, 0x40, 0x12, 0x00, 0x48, 0x00, 0xA0,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x01, 0xFF, 0xF0, 0x0F, 0x80, 0x83,
  0x08, 0x04, 0x80, 0x24, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x0C, 0x00, 0xC0, 0x78, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x05, 0x00, 0x24, 0x02,
  0x10, 0x20, 0x7E, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x02, 0x80, 0x05, 0x00,
  0x12, 0x00, 0x24, 0x00, 0x88, 0x01, 0x10, 0x04, 0x20, 0x08, 0x40, 0x20,
  0x80, 0xC1, 0x01, 0x02, 0x04, 0x04, 0x08, 0x08, 0x20, 0x10, 0x40, 0x21,
  0x00, 0x43, 0xFF, 0xF8, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x3F, 0xF1, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x17, 0xE0, 0xC0,
  0x84, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03,
  0x00, 0x18, 0x01, 0x40, 0x09, 0x00, 0x4C, 0x04, 0x30, 0x60, 0x7C, 0x00,
  0x01, 0xE0, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x3E, 0x26, 0x19, 0x40, 0x2C, 0x01, 0xE0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x14, 0x00, 0xA0, 0x05,
  0x80, 0x44, 0x02, 0x18, 0x60, 0x3C, 0x00, 0xFF, 0xFC, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x0F, 0x80, 0xC1, 0x82, 0x01, 0x10, 0x04,
  0x40, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x40, 0x09, 0x00, 0x42, 0x01,
  0x04, 0x18, 0x0F, 0x80, 0x41, 0x86, 0x01, 0x10, 0x02, 0x80, 0x0A, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x24, 0x00, 0x90, 0x04, 0x30,
  0x20, 0x3F, 0x00, 0x0F, 0x80, 0x83, 0x08, 0x08, 0x80, 0x24, 0x01, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xA0, 0x0C, 0x80, 0xA6, 0x09, 0x0F, 0x88, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x01, 0x80, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x24, 0x92, 0xB0,
  0x00, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x00, 0x1E, 0x18, 0x64, 0x0A,
  0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xE0, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x80, 0x01, 0x80, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x10,
  0x40, 0x00, 0x08, 0x40, 0x3C, 0x02, 0x20, 0x21, 0x81, 0x20, 0x20, 0x40,
  0x90, 0x10, 0x20, 0x48, 0x10, 0x10, 0x14, 0x08, 0x08, 0x0C, 0x08, 0x04,
  0x06, 0x04, 0x02, 0x03, 0x02, 0x01, 0x01, 0x81, 0x00, 0x80, 0xC0, 0x80,
  0x40, 0x60, 0x40, 0x20, 0x50, 0x20, 0x20, 0x28, 0x10, 0x10, 0x14, 0x08,
  0x14, 0x11, 0x04, 0x0A, 0x08, 0x81, 0x09, 0x88, 0x40, 0x78, 0x78, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x80, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x24, 0x00,
  0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x04, 0x10, 0x02, 0x08, 0x01, 0x04,
  0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x40, 0x10, 0x20, 0x08, 0x10,
  0x04, 0x1F, 0xFF, 0x08, 0x00, 0x84, 0x00, 0x42, 0x00, 0x22, 0x00, 0x09,
  0x00, 0x04, 0x80, 0x02, 0x80, 0x00, 0xC0, 0x00, 0x40, 0xFF, 0x82, 0x01,
  0x88, 0x01, 0x20, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80,
  0x0A, 0x00, 0x28, 0x01, 0x20, 0x08, 0xFF, 0xC2, 0x00, 0xC8, 0x00, 0xA0,
  0x02, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xA0, 0x02, 0x80, 0x33, 0xFF, 0x00, 0x07, 0xE0, 0x30, 0x20, 0x80,
  0x22, 0x00, 0x2C, 0x00, 0x50, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x28, 0x00,
  0x90, 0x01, 0x10, 0x04, 0x18, 0x10, 0x1F, 0xC0, 0xFF, 0x81, 0x00, 0xC2,
  0x00, 0x64, 0x00, 0x48, 0x00, 0x50, 0x00, 0xA0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x50,
  0x00, 0xA0, 0x02, 0x40, 0x0C, 0x80, 0x61, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xF2, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0xFF, 0xF2, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x18, 0x18, 0x20, 0x04, 0x60,
  0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40,
  0x01, 0x20, 0x01, 0x30, 0x06, 0x18, 0x0C, 0x07, 0xF0, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x24, 0x02, 0x20, 0xC1, 0xF0, 0x80, 0x04, 0x80, 0x0C,
  0x80, 0x08, 0x80, 0x10, 0x80, 0x20, 0x80, 0x40, 0x80, 0xC0, 0x81, 0x80,
  0x81, 0x00, 0x82, 0x00, 0x84, 0x00, 0x88, 0x00, 0x94, 0x00, 0xB6, 0x00,
  0xA2, 0x00, 0xC1, 0x00, 0x80, 0x80, 0x80, 0xC0, 0x80, 0x40, 0x80, 0x20,
  0x80, 0x10, 0x80, 0x10, 0x80, 0x08, 0x80, 0x04, 0x80, 0x06, 0x80, 0x02,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE8, 0x00, 0x0B, 0x40,
  0x00, 0x5A, 0x00, 0x02, 0xC8, 0x00, 0x26, 0x40, 0x01, 0x32, 0x00, 0x09,
  0x88, 0x00, 0x8C, 0x40, 0x04, 0x62, 0x00, 0x43, 0x08, 0x02, 0x18, 0x40,
  0x10, 0xC2, 0x01, 0x06, 0x08, 0x08, 0x30, 0x40, 0x41, 0x81, 0x04, 0x0C,
  0x08, 0x20, 0x60, 0x41, 0x03, 0x01, 0x10, 0x18, 0x08, 0x80, 0xC0, 0x48,
  0x06, 0x01, 0x40, 0x30, 0x0A, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40,
  0xC0, 0x01, 0xC0, 0x01, 0xA0, 0x01, 0xA0, 0x01, 0x90, 0x01, 0x90, 0x01,
  0x88, 0x01, 0x8C, 0x01, 0x84, 0x01, 0x82, 0x01, 0x82, 0x01, 0x81, 0x01,
  0x81, 0x01, 0x80, 0x81, 0x80, 0x41, 0x80, 0x41, 0x80, 0x21, 0x80, 0x21,
  0x80, 0x11, 0x80, 0x11, 0x80, 0x09, 0x80, 0x05, 0x80, 0x05, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x01, 0x03, 0xE0, 0x06, 0x0C, 0x04, 0x01, 0x04, 0x00,
  0x44, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x48, 0x00, 0x24, 0x00,
  0x12, 0x00, 0x08, 0x80, 0x08, 0x20, 0x08, 0x0C, 0x08, 0x01, 0xF0, 0x00,
  0xFF, 0xC2, 0x00, 0xC8, 0x01, 0xA0, 0x02, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x02, 0x80, 0x0A, 0x00,
  0xCF, 0xFC, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00, 0x03, 0xE0,
  0x06, 0x0C, 0x04, 0x01, 0x04, 0x00, 0x44, 0x00, 0x12, 0x00, 0x09, 0x00,
  0x04, 0x80, 0x02, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x50, 0x00, 0x48, 0x00, 0x24, 0x00, 0x12, 0x00, 0x08, 0x80, 0x08, 0x20,
  0x08, 0x0C, 0x08, 0x03, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0xFF, 0xC1, 0x00, 0x62, 0x00, 0x24, 0x00, 0x48,
  0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00,
  0x14, 0x00, 0x48, 0x00, 0x90, 0x06, 0x3F, 0xF0, 0x40, 0x20, 0x80, 0x41,
  0x00, 0x42, 0x00, 0x84, 0x00, 0x88, 0x01, 0x10, 0x01, 0x20, 0x03, 0x40,
  0x02, 0x80, 0x07, 0x00, 0x04, 0x0F, 0xE0, 0x20, 0x20, 0x80, 0x22, 0x00,
  0x24, 0x00, 0x50, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x50, 0x01,
  0x90, 0x06, 0x18, 0x18, 0x0F, 0xC0, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x28, 0x00, 0x90, 0x01, 0x10, 0x04, 0x10,
  0x10, 0x1F, 0xC0, 0x80, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x48, 0x00, 0x24,
  0x00, 0x11, 0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20, 0x04, 0x08, 0x02,
  0x04, 0x01, 0x02, 0x00, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x08,
  0x20, 0x04, 0x10, 0x02, 0x08, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00,
  0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0x40, 0x00, 0x80,
  0x04, 0x00, 0x50, 0x03, 0x00, 0x14, 0x00, 0xC0, 0x05, 0x00, 0x28, 0x02,
  0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x22, 0x01, 0x20, 0x08, 0x80, 0x44,
  0x04, 0x20, 0x21, 0x01, 0x08, 0x08, 0x40, 0x41, 0x02, 0x10, 0x10, 0x40,
  0x82, 0x04, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x20,
  0x21, 0x01, 0x08, 0x08, 0x80, 0x44, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04,
  0x40, 0x12, 0x00, 0x90, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x50,
  0x02, 0x80, 0x14, 0x00, 0x60, 0x02, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x01, 0x20, 0x01, 0x88, 0x00, 0x86, 0x00, 0x81, 0x00, 0x40, 0x40,
  0x40, 0x20, 0x20, 0x08, 0x20, 0x04, 0x30, 0x01, 0x10, 0x00, 0x50, 0x00,
  0x28, 0x00, 0x08, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x04, 0x40, 0x02, 0x20,
  0x02, 0x08, 0x01, 0x04, 0x01, 0x01, 0x01, 0x00, 0x40, 0x80, 0x20, 0x80,
  0x08, 0x40, 0x04, 0x40, 0x01, 0x60, 0x00, 0xC0, 0x80, 0x00, 0xA0, 0x00,
  0x90, 0x00, 0x44, 0x00, 0x42, 0x00, 0x20, 0x80, 0x20, 0x40, 0x10, 0x10,
  0x10, 0x08, 0x08, 0x02, 0x08, 0x01, 0x04, 0x00, 0x44, 0x00, 0x22, 0x00,
  0x0A, 0x00, 0x05, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x01, 0xFF, 0xFC, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x80, 0x10,
  0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0xF8, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x0F, 0xC0, 0x08, 0x04, 0x05, 0x02, 0x81,
  0x21, 0x10, 0x88, 0x42, 0x41, 0x20, 0x90, 0x30, 0x18, 0x08, 0xFF, 0xF8,
  0x84, 0x42, 0x10, 0x0F, 0x83, 0x06, 0x40, 0x24, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x01, 0x1F, 0xF3, 0x01, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x54, 0x09, 0x3F, 0x10, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x8F, 0x8B, 0x04, 0xC0,
  0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0xC0, 0x2A, 0x04, 0x8F,
  0x80, 0x0F, 0x83, 0x04, 0x40, 0x24, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x14,
  0x01, 0x40, 0x23, 0x06, 0x0F, 0x80, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x0F, 0x89, 0x82, 0x58, 0x0A,
  0x80, 0x34, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x05, 0x00, 0x28, 0x03, 0x60, 0x29, 0x83,
  0x43, 0xE2, 0x0F, 0x81, 0x83, 0x18, 0x08, 0x80, 0x28, 0x01, 0x40, 0x0A,
  0x00, 0x30, 0x01, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x11, 0x81, 0x03, 0xF0, 0x07, 0x86, 0x02,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0xFF, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x00, 0x0F, 0x89, 0x82, 0x58, 0x0A, 0x80, 0x34, 0x01,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x05, 0x00, 0x28, 0x03, 0x60, 0x29, 0x83, 0x43, 0xE2, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x4C, 0x02, 0x30, 0x60, 0x7C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x8F,
  0x89, 0x04, 0xA0, 0x2C, 0x02, 0xC0, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0xC1, 0xFF, 0xFF, 0xC0, 0x04, 0x10, 0x00, 0x00,
  0x00, 0x01, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0xC2, 0xF0, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x68, 0x0C,
  0x80, 0x88, 0x10, 0x82, 0x08, 0x40, 0x88, 0x09, 0x00, 0xB0, 0x0C, 0x80,
  0x8C, 0x08, 0x40, 0x82, 0x08, 0x10, 0x81, 0x08, 0x08, 0x80, 0x48, 0x06,
  0x80, 0x20, 0xFF, 0xFF, 0xFF, 0xE0, 0x8F, 0x81, 0xF2, 0x41, 0x18, 0x2A,
  0x02, 0x80, 0xF0, 0x0A, 0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x18, 0x01,
  0x00, 0x60, 0x04, 0x01, 0x80, 0x10, 0x06, 0x00, 0x40, 0x18, 0x01, 0x00,
  0x60, 0x04, 0x01, 0x80, 0x10, 0x06, 0x00, 0x40, 0x18, 0x01, 0x00, 0x60,
  0x04, 0x01, 0x80, 0x10, 0x06, 0x00, 0x40, 0x18, 0x01, 0x00, 0x40, 0x8F,
  0x89, 0x04, 0xA0, 0x2C, 0x02, 0xC0, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x0F, 0x80, 0x83, 0x08, 0x04, 0x80, 0x24, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x05, 0x00, 0x28, 0x02, 0x20, 0x10, 0x83, 0x03, 0xE0, 0x8F,
  0x8B, 0x04, 0xC0, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0xC0,
  0x2A, 0x04, 0x8F, 0x88, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x0F, 0x89, 0x82, 0x58, 0x0A, 0x80, 0x34, 0x01, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x05, 0x00, 0x28, 0x03, 0x60, 0x29, 0x83, 0x43, 0xE2, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x8F, 0x62, 0x86,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x00, 0x1F, 0x86, 0x04, 0x40, 0x28, 0x02, 0x80, 0x28, 0x00, 0x40,
  0x02, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x20, 0x01, 0x80,
  0x18, 0x02, 0x40, 0x26, 0x04, 0x1F, 0x80, 0x10, 0x10, 0x10, 0x10, 0x10,
  0xFE, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x18, 0x0F, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x40, 0x56, 0x09, 0x1F, 0x10,
  0x80, 0x0C, 0x00, 0x50, 0x02, 0x80, 0x24, 0x01, 0x10, 0x08, 0x80, 0x84,
  0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x10, 0x80, 0x88, 0x04, 0x40, 0x12,
  0x00, 0xA0, 0x05, 0x00, 0x18, 0x00, 0x80, 0x80, 0x40, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x28, 0x0A, 0x02, 0x40, 0xA0, 0x24, 0x09, 0x02, 0x40, 0x90,
  0x44, 0x11, 0x04, 0x21, 0x08, 0x42, 0x10, 0x84, 0x22, 0x08, 0xC2, 0x20,
  0x88, 0x12, 0x04, 0x81, 0x20, 0x48, 0x14, 0x05, 0x01, 0x40, 0x50, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x08, 0x03, 0x00, 0x40, 0x1A, 0x00, 0x88, 0x08,
  0x20, 0x41, 0x04, 0x04, 0x40, 0x22, 0x00, 0xA0, 0x03, 0x00, 0x10, 0x01,
  0x40, 0x0B, 0x00, 0x88, 0x0C, 0x20, 0x41, 0x04, 0x04, 0x20, 0x32, 0x00,
  0xB0, 0x02, 0x80, 0x0C, 0x00, 0x50, 0x02, 0x80, 0x22, 0x01, 0x10, 0x08,
  0x80, 0x82, 0x04, 0x10, 0x20, 0x82, 0x02, 0x10, 0x10, 0x80, 0x88, 0x02,
  0x40, 0x12, 0x00, 0xA0, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x03, 0x80, 0x00, 0xFF, 0xE0, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00,
  0xFF, 0xF0, 0x00, 0x81, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x10, 0x30, 0x06,
  0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x08, 0x04, 0x03, 0x00, 0xC0, 0x10, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0,
  0x10, 0x04, 0x03, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x60, 0x40, 0x40, 0x20,
  0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x08, 0x08, 0x18, 0x00, 0x3C, 0x01, 0x42, 0x01, 0x81, 0x01, 0x80, 0x82,
  0x80, 0x42, 0x80, 0x3C,
};

const GFXglyph RobotoCondensed_Thin36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 1, 26, 7, 3, -26 },
  { 5, 4, 7, 9, 3, -27 },
  { 9, 17, 26, 18, 1, -26 },
  { 65, 13, 32, 17, 2, -29 },
  { 117, 19, 26, 23, 2, -26 },
  { 179, 16, 26, 19, 2, -26 },
  { 231, 2, 7, 6, 2, -27 },
  { 233, 6, 37, 10, 3, -29 },
  { 261, 6, 37, 10, 1, -29 },
  { 289, 14, 14, 15, 1, -26 },
  { 314, 15, 19, 18, 1, -21 },
  { 350, 2, 7, 7, 2, -3 },
  { 352, 7, 1, 10, 1, -12 },
  { 353, 2, 2, 8, 3, -2 },
  { 354, 10, 28, 12, 1, -26 },
  { 389, 13, 26, 17, 2, -26 },
  { 432, 7, 26, 17, 3, -26 },
  { 455, 14, 26, 17, 2, -26 },
  { 501, 13, 26, 17, 2, -26 },
  { 544, 15, 26, 17, 2, -26 },
  { 593, 13, 26, 17, 3, -26 },
  { 636, 13, 26, 17, 2, -26 },
  { 679, 14, 26, 17, 1, -26 },
  { 725, 14, 26, 17, 2, -26 },
  { 771, 13, 26, 17, 2, -26 },
  { 814, 2, 19, 6, 2, -19 },
  { 819, 3, 23, 6, 1, -19 },
  { 828, 12, 14, 16, 2, -19 },
  { 849, 12, 8, 18, 3, -16 },
  { 861, 13, 14, 16, 2, -19 },
  { 884, 10, 26, 14, 2, -26 },
  { 917, 25, 33, 29, 2, -25 },
  { 1021, 17, 26, 19, 1, -26 },
  { 1077, 14, 26, 19, 3, -26 },
  { 1123, 15, 26, 20, 3, -26 },
  { 1172, 15, 26, 21, 3, -26 },
  { 1221, 14, 26, 18, 3, -26 },
  { 1267, 14, 26, 18, 3, -26 },
  { 1313, 16, 26, 22, 3, -26 },
  { 1365, 16, 26, 22, 3, -26 },
  { 1417, 1, 26, 9, 4, -26 },
  { 1421, 12, 26, 17, 2, -26 },
  { 1460, 16, 26, 20, 3, -26 },
  { 1512, 12, 26, 16, 3, -26 },
  { 1551, 21, 26, 27, 3, -26 },
  { 1620, 16, 26, 22, 3, -26 },
  { 1672, 17, 26, 21, 2, -26 },
  { 1728, 14, 26, 19, 3, -26 },
  { 1774, 17, 31, 21, 2, -26 },
  { 1840, 15, 26, 21, 3, -26 },
  { 1889, 15, 26, 19, 2, -26 },
  { 1938, 17, 26, 19, 1, -26 },
  { 1994, 15, 26, 21, 3, -26 },
  { 2043, 17, 26, 19, 1, -26 },
  { 2099, 26, 26, 28, 1, -26 },
  { 2184, 17, 26, 19, 1, -26 },
  { 2240, 17, 26, 19, 1, -26 },
  { 2296, 15, 26, 19, 2, -26 },
  { 2345, 4, 34, 7, 3, -29 },
  { 2362, 10, 28, 12, 1, -26 },
  { 2397, 5, 34, 7, 0, -29 },
  { 2419, 9, 13, 13, 2, -26 },
  { 2434, 13, 1, 13, 0, 0 },
  { 2436, 4, 5, 10, 3, -27 },
  { 2439, 12, 19, 17, 2, -19 },
  { 2468, 12, 27, 17, 3, -27 },
  { 2509, 12, 19, 16, 2, -19 },
  { 2538, 13, 27, 17, 2, -27 },
  { 2582, 13, 19, 16, 2, -19 },
  { 2613, 9, 27, 10, 1, -27 },
  { 2644, 13, 26, 17, 2, -19 },
  { 2687, 12, 27, 17, 3, -27 },
  { 2728, 1, 26, 7, 3, -26 },
  { 2732, 6, 33, 7, -2, -26 },
  { 2757, 12, 27, 15, 3, -27 },
  { 2798, 1, 27, 7, 3, -27 },
  { 2802, 22, 19, 28, 3, -19 },
  { 2855, 12, 19, 17, 3, -19 },
  { 2884, 13, 19, 17, 2, -19 },
  { 2915, 12, 26, 17, 3, -19 },
  { 2954, 13, 26, 17, 2, -19 },
  { 2997, 7, 19, 11, 3, -19 },
  { 3014, 12, 19, 16, 2, -19 },
  { 3043, 8, 24, 10, 1, -24 },
  { 3067, 12, 19, 17, 3, -19 },
  { 3096, 13, 19, 15, 1, -19 },
  { 3127, 20, 19, 24, 2, -19 },
  { 3175, 13, 19, 15, 1, -19 },
  { 3206, 13, 26, 15, 1, -19 },
  { 3249, 12, 19, 15, 2, -19 },
  { 3278, 9, 36, 11, 1, -28 },
  { 3319, 1, 31, 7, 3, -26 },
  { 3323, 9, 36, 11, 0, -28 },
  { 3364, 16, 6, 22, 3, -14 },
};

const GFXfont RobotoCondensed_Thin36pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin36pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin36pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOCONDENSED_THIN36PT7B_H_
