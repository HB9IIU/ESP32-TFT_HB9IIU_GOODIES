#ifndef _ROBOTOCONDENSED_THIN29PT7B_H_
#define _ROBOTOCONDENSED_THIN29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0x18, 0x99, 0x99, 0x99, 0x04, 0x20, 0x21, 0x01, 0x08,
  0x08, 0x40, 0x42, 0x04, 0x11, 0xFF, 0xE1, 0x08, 0x08, 0x40, 0x42, 0x02,
  0x10, 0x10, 0x81, 0x08, 0x08, 0x43, 0xFF, 0xC2, 0x10, 0x10, 0x80, 0x84,
  0x04, 0x20, 0x42, 0x02, 0x10, 0x00, 0x04, 0x01, 0x00, 0x40, 0x7C, 0x20,
  0x90, 0x18, 0x06, 0x01, 0x80, 0x60, 0x04, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x60, 0x16, 0x08, 0x7C,
  0x04, 0x01, 0x00, 0x40, 0x70, 0x01, 0x10, 0x02, 0x10, 0x04, 0x20, 0x88,
  0x42, 0x10, 0x84, 0x21, 0x10, 0x42, 0x20, 0x88, 0x80, 0xE2, 0x00, 0x04,
  0x00, 0x11, 0xC0, 0x24, 0x20, 0x88, 0x41, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x20, 0x84, 0x41, 0x08, 0x02, 0x10, 0x03, 0xC0, 0x1E, 0x01, 0x08, 0x08,
  0x40, 0x81, 0x04, 0x10, 0x20, 0x80, 0x88, 0x04, 0x80, 0x18, 0x00, 0x80,
  0x0A, 0x00, 0x88, 0x04, 0x41, 0x41, 0x0A, 0x04, 0x50, 0x12, 0x80, 0xA4,
  0x03, 0x20, 0x18, 0x83, 0x23, 0xE1, 0x00, 0xFC, 0x08, 0x44, 0x42, 0x21,
  0x08, 0x44, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x21, 0x08, 0x41,
  0x08, 0x20, 0x84, 0x84, 0x10, 0x42, 0x10, 0x42, 0x10, 0x82, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x11, 0x08, 0x42, 0x21, 0x08, 0x88, 0x40, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x21, 0x62, 0x61, 0xF8, 0x06, 0x00, 0x90, 0x08, 0x81,
  0x08, 0x20, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x0F, 0xFF, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x55, 0x60, 0xFC, 0x30, 0x01, 0x02, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x80, 0x80, 0x80, 0x1E, 0x08, 0x44, 0x0A, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x14, 0x08, 0x84, 0x1E, 0x00, 0x04, 0xFC, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x3E, 0x08, 0x22, 0x02, 0x40, 0x28, 0x05, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x01, 0x00, 0x20, 0x0F, 0xFE, 0x0F, 0x06, 0x18, 0x81, 0x20, 0x14, 0x02,
  0x80, 0x40, 0x08, 0x01, 0x00, 0x40, 0x10, 0x3C, 0x00, 0x60, 0x02, 0x00,
  0x40, 0x0C, 0x01, 0x40, 0x28, 0x05, 0x00, 0x98, 0x20, 0xF8, 0x00, 0x80,
  0x08, 0x01, 0x40, 0x24, 0x02, 0x40, 0x44, 0x04, 0x40, 0x84, 0x08, 0x41,
  0x04, 0x10, 0x42, 0x04, 0x40, 0x44, 0x04, 0xFF, 0xF0, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x3F, 0xC4, 0x00, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x5F, 0x0C, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x0C, 0x01, 0x40, 0x28, 0x09, 0x01, 0x10, 0x41, 0xF0, 0x07,
  0x06, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x7C, 0xA0, 0xB0, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x08, 0x82,
  0x1F, 0x00, 0xFF, 0xE0, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x0F, 0x03, 0x0C, 0x20, 0x44,
  0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x20, 0x43, 0x0C, 0x0F, 0x03,
  0x0C, 0x40, 0x24, 0x02, 0x80, 0x18, 0x01, 0x80, 0x14, 0x02, 0x40, 0x22,
  0x04, 0x1F, 0x80, 0x0F, 0x06, 0x10, 0x81, 0x20, 0x14, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x28, 0x05, 0x00, 0xA0, 0x32, 0x0A, 0x3E, 0x40, 0x08,
  0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x81, 0xE0, 0x40, 0x03, 0x10, 0x00,
  0x00, 0x05, 0x56, 0x00, 0x40, 0x60, 0x60, 0x60, 0x60, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x18, 0x18,
  0x18, 0x18, 0x08, 0x00, 0x1E, 0x10, 0x90, 0x30, 0x18, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x01, 0x00, 0x80, 0x80, 0x80, 0x40, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x80, 0x01, 0xFC, 0x00, 0x60, 0x30, 0x08, 0x00, 0x81,
  0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x02, 0x40, 0xF0, 0x24, 0x10, 0x82,
  0x81, 0x04, 0x28, 0x20, 0x81, 0x82, 0x08, 0x18, 0x40, 0x81, 0x84, 0x08,
  0x18, 0x40, 0x81, 0x84, 0x08, 0x28, 0x40, 0x82, 0x84, 0x08, 0x28, 0x41,
  0x84, 0x82, 0x24, 0x44, 0x1C, 0x78, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x3F, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x50, 0x01, 0x40, 0x04, 0x80, 0x22, 0x00, 0x88, 0x02, 0x10, 0x10,
  0x40, 0x41, 0x01, 0x04, 0x04, 0x08, 0x20, 0x20, 0x80, 0x83, 0xFF, 0x10,
  0x04, 0x40, 0x11, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x04, 0xFE, 0x10,
  0x32, 0x02, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x90, 0x33,
  0xF8, 0x40, 0xC8, 0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0x40, 0x4F, 0xF0, 0x0F, 0x81, 0x83, 0x10, 0x08, 0x80, 0x28, 0x01, 0x40,
  0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x12, 0x00, 0x90, 0x08, 0x60, 0xC0,
  0xF8, 0x00, 0xFE, 0x08, 0x18, 0x80, 0x48, 0x02, 0x80, 0x28, 0x02, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x18, 0xFE, 0x00, 0xFF, 0xE0,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFA,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x0F, 0xFA, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0x81, 0x08, 0x04, 0x80, 0x14, 0x00,
  0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xF8,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x40, 0x0A, 0x00, 0x48, 0x02, 0x20,
  0x60, 0xFC, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xFF, 0xF8, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0xFF,
  0xFF, 0xF8, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x60,
  0x14, 0x04, 0x82, 0x1F, 0x00, 0x80, 0x28, 0x04, 0x80, 0x88, 0x08, 0x81,
  0x08, 0x20, 0x84, 0x08, 0x80, 0x90, 0x09, 0x00, 0xA8, 0x0C, 0x80, 0x84,
  0x08, 0x20, 0x82, 0x08, 0x10, 0x80, 0x88, 0x04, 0x80, 0x48, 0x02, 0x80,
  0x10, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0F,
  0xF8, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x05, 0xA0,
  0x05, 0xA0, 0x09, 0x90, 0x09, 0x90, 0x09, 0x90, 0x11, 0x88, 0x11, 0x88,
  0x11, 0x88, 0x21, 0x84, 0x21, 0x84, 0x21, 0x84, 0x41, 0x82, 0x41, 0x82,
  0x81, 0x82, 0x81, 0x81, 0x81, 0x81, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C,
  0x01, 0xA0, 0x19, 0x01, 0x90, 0x18, 0x81, 0x88, 0x18, 0x41, 0x84, 0x18,
  0x21, 0x81, 0x18, 0x11, 0x80, 0x98, 0x09, 0x80, 0x58, 0x03, 0x80, 0x38,
  0x01, 0x80, 0x10, 0x0F, 0x81, 0x83, 0x10, 0x04, 0x80, 0x28, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0A, 0x00, 0x90, 0x04, 0x60, 0xC0,
  0xF8, 0x00, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0A, 0x02, 0x7F, 0x88, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x0F, 0x81, 0x83, 0x10, 0x04,
  0x80, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0A, 0x00,
  0x90, 0x04, 0x60, 0xC0, 0xFC, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0xFF, 0x08, 0x08, 0x80, 0x48, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02,
  0x80, 0x28, 0x04, 0x80, 0x8F, 0xF0, 0x82, 0x08, 0x10, 0x81, 0x08, 0x08,
  0x80, 0x48, 0x04, 0x80, 0x28, 0x02, 0x80, 0x10, 0x0F, 0xC1, 0x81, 0x08,
  0x04, 0x80, 0x24, 0x00, 0xA0, 0x05, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0x00, 0x08, 0x00, 0x30, 0x01, 0x80, 0x0A,
  0x00, 0x50, 0x04, 0x60, 0x40, 0xFC, 0x00, 0xFF, 0xF8, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x14, 0x01, 0x40, 0x13, 0x06,
  0x0F, 0x80, 0x80, 0x06, 0x00, 0x28, 0x00, 0x90, 0x02, 0x40, 0x11, 0x00,
  0x42, 0x01, 0x08, 0x08, 0x20, 0x20, 0x40, 0x81, 0x04, 0x04, 0x10, 0x10,
  0x40, 0x21, 0x00, 0x88, 0x02, 0x20, 0x04, 0x80, 0x14, 0x00, 0x50, 0x00,
  0xC0, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x60, 0x14, 0x04, 0x80,
  0xA0, 0x24, 0x05, 0x01, 0x20, 0x48, 0x09, 0x02, 0x20, 0x84, 0x11, 0x04,
  0x20, 0x88, 0x21, 0x08, 0x41, 0x08, 0x41, 0x08, 0x42, 0x08, 0x81, 0x10,
  0x44, 0x09, 0x02, 0x20, 0x48, 0x09, 0x02, 0x40, 0x50, 0x0A, 0x02, 0x80,
  0x60, 0x14, 0x03, 0x00, 0x60, 0x18, 0x02, 0x00, 0x40, 0x10, 0x00, 0x80,
  0x0A, 0x00, 0x88, 0x04, 0x40, 0x41, 0x02, 0x08, 0x20, 0x22, 0x01, 0x10,
  0x05, 0x00, 0x18, 0x00, 0x80, 0x0A, 0x00, 0x50, 0x04, 0x40, 0x21, 0x02,
  0x08, 0x20, 0x21, 0x01, 0x10, 0x04, 0x80, 0x18, 0x00, 0x80, 0x80, 0x0A,
  0x00, 0x24, 0x01, 0x10, 0x04, 0x20, 0x20, 0x80, 0x81, 0x04, 0x04, 0x10,
  0x08, 0x80, 0x22, 0x00, 0x50, 0x01, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x7F,
  0xF0, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x0F, 0xFF, 0x80, 0xF8, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F,
  0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x10,
  0x08, 0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0x01, 0xF1,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x1F, 0x08, 0x18, 0x14, 0x14, 0x24, 0x22, 0x42, 0x42, 0x41, 0x81, 0xFF,
  0xC0, 0x84, 0x22, 0x1F, 0x04, 0x11, 0x01, 0x20, 0x20, 0x04, 0x00, 0x80,
  0x10, 0xFE, 0x20, 0x48, 0x0A, 0x01, 0x40, 0x28, 0x04, 0x81, 0x90, 0x51,
  0xF1, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x09, 0xF2, 0x82, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x07, 0x01, 0xA0, 0xA7, 0xC0, 0x1F, 0x04, 0x11, 0x01, 0x20, 0x14, 0x03,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x14, 0x02, 0x80,
  0x88, 0x20, 0xF8, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x13, 0xE5,
  0x05, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x03, 0x41, 0x4F, 0x90, 0x1F, 0x04, 0x11, 0x01, 0x20,
  0x18, 0x03, 0x00, 0x7F, 0xFC, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x10, 0xFC, 0x0E, 0x20, 0x81, 0x02, 0x04, 0x3F, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x00, 0x3E, 0x50, 0x58, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x34, 0x14, 0xF9, 0x00, 0x40, 0x10,
  0x04, 0x02, 0x41, 0x8F, 0x80, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x09, 0xF2, 0x82, 0xC0, 0xB0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x30, 0x0A, 0xAA,
  0xAA, 0xAA, 0xA0, 0x00, 0xC0, 0x00, 0x00, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x85, 0xC0, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x0A, 0x04, 0x82, 0x21, 0x08, 0x82, 0x20,
  0x90, 0x2C, 0x0C, 0x82, 0x20, 0x84, 0x20, 0x88, 0x22, 0x04, 0x80, 0xA0,
  0x20, 0xFF, 0xFF, 0xFC, 0x9F, 0x0F, 0x28, 0x24, 0x2C, 0x0A, 0x07, 0x01,
  0x01, 0x80, 0x40, 0x60, 0x10, 0x18, 0x04, 0x06, 0x01, 0x01, 0x80, 0x40,
  0x60, 0x10, 0x18, 0x04, 0x06, 0x01, 0x01, 0x80, 0x40, 0x60, 0x10, 0x18,
  0x04, 0x06, 0x01, 0x01, 0x9F, 0x28, 0x2C, 0x0B, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x1E, 0x18, 0x64, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x50, 0x26, 0x18, 0x78, 0x9F, 0x28, 0x2C, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x70, 0x1A, 0x0A, 0x7C, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00,
  0x3E, 0x50, 0x58, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x34, 0x14, 0xF9, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x9E, 0x8C, 0x30, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x3E, 0x60, 0xA0, 0x30, 0x18, 0x04, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x80, 0x20, 0x18, 0x0C, 0x07, 0x04, 0x7C, 0x20, 0x82,
  0x3F, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81,
  0xC0, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x34, 0x14, 0xF9, 0x80, 0x50, 0x0A,
  0x01, 0x20, 0x24, 0x08, 0x81, 0x08, 0x21, 0x08, 0x21, 0x02, 0x20, 0x48,
  0x09, 0x00, 0xA0, 0x18, 0x03, 0x00, 0x20, 0x80, 0x80, 0xC0, 0x40, 0x50,
  0x50, 0x48, 0x28, 0x24, 0x14, 0x12, 0x0A, 0x08, 0x88, 0x88, 0x44, 0x44,
  0x22, 0x22, 0x11, 0x11, 0x05, 0x05, 0x02, 0x82, 0x81, 0x41, 0x40, 0xA0,
  0xA0, 0x20, 0x20, 0x10, 0x10, 0x80, 0x50, 0x22, 0x08, 0x84, 0x11, 0x04,
  0x80, 0xC0, 0x10, 0x0C, 0x02, 0x81, 0x20, 0x84, 0x21, 0x10, 0x24, 0x06,
  0x01, 0x80, 0x30, 0x0A, 0x01, 0x20, 0x24, 0x08, 0x81, 0x08, 0x21, 0x08,
  0x21, 0x02, 0x20, 0x48, 0x09, 0x00, 0xA0, 0x18, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x01, 0xC0, 0x00, 0x7F, 0xC0, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x10, 0x04, 0x03, 0xFF, 0x02, 0x08, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x04, 0x30, 0x10, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x20, 0x20, 0x20, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x40,
  0x40, 0x81, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x80, 0x82,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x0C, 0x00,
  0x38, 0x0A, 0x20, 0x60, 0x83, 0x02, 0x18, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_Thin29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 21, 5, 2, -21 },
  { 4, 4, 6, 7, 2, -22 },
  { 7, 13, 21, 14, 1, -21 },
  { 42, 10, 27, 14, 2, -24 },
  { 76, 15, 21, 19, 2, -21 },
  { 116, 13, 21, 16, 2, -21 },
  { 151, 1, 6, 5, 2, -22 },
  { 152, 5, 30, 8, 2, -23 },
  { 171, 5, 30, 8, 1, -23 },
  { 190, 12, 11, 12, 0, -21 },
  { 207, 12, 15, 14, 1, -17 },
  { 230, 2, 6, 5, 1, -2 },
  { 232, 6, 1, 8, 1, -10 },
  { 233, 2, 2, 6, 2, -2 },
  { 234, 8, 23, 10, 1, -21 },
  { 257, 10, 21, 14, 2, -21 },
  { 284, 6, 21, 14, 2, -21 },
  { 300, 11, 21, 14, 2, -21 },
  { 329, 11, 21, 14, 1, -21 },
  { 358, 12, 21, 14, 1, -21 },
  { 390, 11, 21, 14, 2, -21 },
  { 419, 10, 21, 14, 2, -21 },
  { 446, 11, 21, 14, 1, -21 },
  { 475, 12, 21, 14, 1, -21 },
  { 507, 11, 21, 14, 1, -21 },
  { 536, 1, 16, 5, 2, -16 },
  { 538, 2, 20, 5, 1, -16 },
  { 543, 10, 11, 13, 1, -15 },
  { 557, 10, 7, 14, 2, -13 },
  { 566, 10, 11, 13, 2, -15 },
  { 580, 9, 21, 11, 1, -21 },
  { 604, 20, 26, 23, 2, -20 },
  { 669, 14, 21, 15, 1, -21 },
  { 706, 11, 21, 15, 3, -21 },
  { 735, 13, 21, 16, 2, -21 },
  { 770, 12, 21, 17, 3, -21 },
  { 802, 10, 21, 15, 3, -21 },
  { 829, 10, 21, 15, 3, -21 },
  { 856, 13, 21, 17, 2, -21 },
  { 891, 12, 21, 18, 3, -21 },
  { 923, 1, 21, 7, 3, -21 },
  { 926, 10, 21, 14, 1, -21 },
  { 953, 12, 21, 16, 3, -21 },
  { 985, 9, 21, 13, 3, -21 },
  { 1009, 16, 21, 22, 3, -21 },
  { 1051, 12, 21, 18, 3, -21 },
  { 1083, 13, 21, 17, 2, -21 },
  { 1118, 11, 21, 15, 3, -21 },
  { 1147, 13, 25, 17, 2, -21 },
  { 1188, 12, 21, 17, 3, -21 },
  { 1220, 13, 21, 15, 1, -21 },
  { 1255, 13, 21, 15, 1, -21 },
  { 1290, 12, 21, 17, 2, -21 },
  { 1322, 14, 21, 15, 1, -21 },
  { 1359, 21, 21, 23, 1, -21 },
  { 1415, 13, 21, 15, 1, -21 },
  { 1450, 14, 21, 15, 1, -21 },
  { 1487, 13, 21, 15, 1, -21 },
  { 1522, 4, 28, 6, 2, -24 },
  { 1536, 8, 23, 10, 1, -21 },
  { 1559, 4, 28, 6, 0, -24 },
  { 1573, 8, 10, 11, 1, -21 },
  { 1583, 10, 1, 11, 0, 0 },
  { 1585, 4, 4, 8, 2, -22 },
  { 1587, 11, 16, 14, 1, -16 },
  { 1609, 10, 22, 14, 2, -22 },
  { 1637, 11, 16, 13, 1, -16 },
  { 1659, 10, 22, 14, 2, -22 },
  { 1687, 11, 16, 13, 1, -16 },
  { 1709, 7, 22, 8, 1, -22 },
  { 1729, 10, 22, 14, 2, -16 },
  { 1757, 10, 22, 14, 2, -22 },
  { 1785, 2, 22, 6, 2, -22 },
  { 1791, 5, 28, 6, -1, -22 },
  { 1809, 10, 22, 12, 2, -22 },
  { 1837, 1, 22, 6, 2, -22 },
  { 1840, 18, 16, 23, 2, -16 },
  { 1876, 10, 16, 14, 2, -16 },
  { 1896, 10, 16, 14, 2, -16 },
  { 1916, 10, 22, 14, 2, -16 },
  { 1944, 10, 22, 14, 2, -16 },
  { 1972, 6, 16, 9, 2, -16 },
  { 1984, 9, 16, 13, 2, -16 },
  { 2002, 6, 19, 8, 1, -19 },
  { 2017, 10, 16, 14, 2, -16 },
  { 2037, 11, 16, 12, 1, -16 },
  { 2059, 17, 16, 19, 1, -16 },
  { 2093, 10, 16, 12, 1, -16 },
  { 2113, 11, 22, 12, 1, -16 },
  { 2144, 10, 16, 12, 1, -16 },
  { 2164, 7, 29, 8, 1, -23 },
  { 2190, 1, 25, 6, 2, -21 },
  { 2194, 7, 29, 8, 0, -23 },
  { 2220, 13, 5, 18, 2, -11 },
};

const GFXfont RobotoCondensed_Thin29pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin29pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin29pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOCONDENSED_THIN29PT7B_H_
