#ifndef _ROBOTOCONDENSED_THIN26PT7B_H_
#define _ROBOTOCONDENSED_THIN26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0x20, 0xB6, 0xDA, 0x04, 0x40, 0x84, 0x08, 0x40, 0x84,
  0x08, 0x87, 0xFF, 0x08, 0x81, 0x08, 0x10, 0x81, 0x08, 0x10, 0x81, 0x10,
  0x11, 0x0F, 0xFE, 0x21, 0x02, 0x10, 0x21, 0x02, 0x20, 0x22, 0x00, 0x08,
  0x04, 0x0F, 0x88, 0x28, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x20, 0x08, 0x03,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x28, 0x23, 0xE0, 0x40,
  0x20, 0x38, 0x01, 0x10, 0x08, 0x40, 0x21, 0x08, 0x82, 0x22, 0x11, 0x08,
  0x44, 0x11, 0x20, 0x39, 0x00, 0x04, 0x00, 0x23, 0x80, 0x91, 0x04, 0x44,
  0x12, 0x10, 0x88, 0x42, 0x21, 0x10, 0x44, 0x01, 0x10, 0x03, 0x80, 0x0E,
  0x01, 0x10, 0x21, 0x02, 0x10, 0x21, 0x02, 0x10, 0x22, 0x01, 0x40, 0x08,
  0x01, 0x80, 0x24, 0x04, 0x21, 0x41, 0x18, 0x12, 0x80, 0xA8, 0x04, 0x40,
  0x42, 0x0A, 0x1F, 0x10, 0xF8, 0x08, 0x88, 0x44, 0x21, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x04, 0x21, 0x04, 0x20, 0x82, 0x88, 0x44,
  0x22, 0x21, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x22, 0x24, 0x48, 0x80,
  0x04, 0x00, 0x80, 0x10, 0x22, 0x23, 0x58, 0x1C, 0x02, 0x80, 0x88, 0x11,
  0x04, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x55, 0x80, 0xF8, 0x80,
  0x02, 0x04, 0x10, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x08, 0x20, 0x40, 0x82, 0x04, 0x08, 0x00, 0x3C, 0x21, 0x20, 0x50, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x81, 0x21, 0x0F, 0x00, 0x0B, 0xE2, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x1E, 0x08, 0x44, 0x09, 0x02, 0x80, 0x40,
  0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x07, 0xFC, 0x1F, 0x08, 0x24, 0x09, 0x01, 0x40, 0x40,
  0x10, 0x04, 0x02, 0x01, 0x83, 0x80, 0x18, 0x01, 0x00, 0x40, 0x18, 0x06,
  0x01, 0x40, 0x48, 0x21, 0xF0, 0x01, 0x00, 0x20, 0x0C, 0x02, 0x80, 0x50,
  0x12, 0x02, 0x40, 0x88, 0x11, 0x04, 0x20, 0x84, 0x20, 0x84, 0x11, 0xFF,
  0xC0, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x7F, 0xA0, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0xFC, 0x41, 0x00, 0x40, 0x20, 0x10, 0x08, 0x06,
  0x03, 0x01, 0x40, 0xA0, 0x8F, 0x80, 0x0E, 0x08, 0x08, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x7C, 0xC1, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x81, 0x20, 0x8F, 0x80, 0xFF, 0xC0, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x01, 0x00, 0x1F, 0x08, 0x24, 0x09, 0x01, 0x40, 0x50, 0x14,
  0x05, 0x02, 0x20, 0x87, 0xC2, 0x19, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x40, 0x58, 0x21, 0xF0, 0x1E, 0x08, 0x44, 0x09, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x50, 0x14, 0x0C, 0x85, 0x1E, 0x40, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x83, 0xC0, 0x80, 0x08, 0x40, 0x00, 0x01, 0x56, 0x00, 0x81,
  0x81, 0x03, 0x06, 0x04, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0xC0, 0x10, 0x06, 0x00, 0xC0,
  0x10, 0x04, 0x04, 0x0C, 0x18, 0x10, 0x30, 0x00, 0x3C, 0x42, 0x41, 0x81,
  0x81, 0x01, 0x01, 0x01, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x03, 0xF0, 0x06, 0x06, 0x04, 0x00, 0x84, 0x00, 0x24,
  0x00, 0x12, 0x0F, 0x06, 0x08, 0x43, 0x04, 0x21, 0x84, 0x10, 0xC2, 0x08,
  0x62, 0x04, 0x31, 0x02, 0x18, 0x81, 0x0C, 0x41, 0x06, 0x20, 0x83, 0x10,
  0x41, 0x84, 0x51, 0x41, 0xC7, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x40, 0x0F, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0xA0,
  0x09, 0x00, 0x90, 0x11, 0x01, 0x08, 0x10, 0x82, 0x08, 0x20, 0x42, 0x04,
  0x3F, 0xC4, 0x02, 0x40, 0x24, 0x02, 0x80, 0x28, 0x01, 0x80, 0x10, 0xFE,
  0x20, 0x68, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0x80, 0xBF, 0xC8,
  0x1A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x2F, 0xF0, 0x1F,
  0x04, 0x19, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x44, 0x18,
  0x7C, 0x00, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x02,
  0x80, 0x50, 0x13, 0xFC, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x3F, 0xE8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x0F, 0xFC, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x3F, 0xE8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x00, 0x1F, 0x84, 0x09, 0x00, 0xA0, 0x18, 0x03,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x0F, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0A, 0x01, 0x40, 0x24, 0x0C, 0x7E, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0xFF, 0xFF, 0xE0, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0xA0,
  0x8F, 0x80, 0x80, 0x28, 0x04, 0x80, 0x88, 0x10, 0x82, 0x08, 0x40, 0x84,
  0x08, 0x80, 0x90, 0x0A, 0x80, 0xC8, 0x08, 0x40, 0x82, 0x08, 0x10, 0x81,
  0x08, 0x08, 0x80, 0x48, 0x02, 0x80, 0x20, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x3F, 0xE0, 0x80, 0x03, 0x80, 0x07, 0x00, 0x1D, 0x00,
  0x3A, 0x00, 0xB4, 0x01, 0x64, 0x02, 0xC8, 0x09, 0x90, 0x13, 0x10, 0x26,
  0x20, 0x8C, 0x21, 0x18, 0x44, 0x30, 0x88, 0x60, 0x90, 0xC1, 0x41, 0x82,
  0x83, 0x03, 0x06, 0x04, 0x08, 0x80, 0x1C, 0x01, 0xA0, 0x1A, 0x01, 0x90,
  0x19, 0x01, 0x88, 0x18, 0x81, 0x84, 0x18, 0x21, 0x82, 0x18, 0x11, 0x81,
  0x18, 0x09, 0x80, 0x98, 0x05, 0x80, 0x38, 0x03, 0x80, 0x10, 0x1F, 0x04,
  0x19, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x44, 0x18, 0x7C,
  0x00, 0xFF, 0x20, 0x28, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x2F, 0xF2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x00, 0x1F, 0x04, 0x19, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x40,
  0x44, 0x18, 0x7C, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0x10, 0x12, 0x01,
  0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x02, 0x80, 0x50, 0x13, 0xFC, 0x41,
  0x08, 0x11, 0x02, 0x20, 0x24, 0x02, 0x80, 0x50, 0x06, 0x00, 0x80, 0x1F,
  0x84, 0x09, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x10, 0x01, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x24, 0x08,
  0x7E, 0x00, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x44, 0x18, 0x7C, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x42, 0x04, 0x20, 0x42,
  0x08, 0x10, 0x81, 0x08, 0x11, 0x00, 0x90, 0x09, 0x00, 0xA0, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x80, 0x40, 0x30, 0x18, 0x0A, 0x03, 0x01, 0x20, 0x50,
  0x24, 0x0A, 0x04, 0x82, 0x41, 0x10, 0x48, 0x22, 0x08, 0x84, 0x21, 0x10,
  0x84, 0x42, 0x10, 0x88, 0x44, 0x11, 0x04, 0x81, 0x20, 0x90, 0x28, 0x12,
  0x05, 0x02, 0x80, 0xA0, 0x30, 0x14, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x10,
  0x00, 0x80, 0x24, 0x02, 0x40, 0x42, 0x04, 0x10, 0x81, 0x08, 0x09, 0x00,
  0xA0, 0x06, 0x00, 0x40, 0x06, 0x00, 0x90, 0x11, 0x01, 0x08, 0x20, 0x82,
  0x04, 0x40, 0x24, 0x02, 0x80, 0x10, 0x80, 0x18, 0x02, 0x40, 0x24, 0x04,
  0x20, 0x42, 0x08, 0x10, 0x81, 0x10, 0x09, 0x00, 0xA0, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x7F,
  0xE0, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x03,
  0xFF, 0x80, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0xE0,
  0x81, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0x81,
  0x02, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0xE4, 0x92, 0x49, 0x24, 0x92,
  0x49, 0x24, 0x92, 0x49, 0xE0, 0x10, 0x30, 0xA1, 0x42, 0x48, 0x90, 0xA1,
  0x82, 0xFF, 0x80, 0x88, 0x80, 0x1E, 0x30, 0x90, 0x30, 0x10, 0x08, 0x04,
  0xFE, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x14, 0x39, 0xE4, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0xF9, 0x82, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x57, 0xC0, 0x1E, 0x30, 0x90, 0x30,
  0x18, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x28, 0x12, 0x08, 0xF8,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0xF2, 0x85, 0x81, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xD0, 0xE7, 0x90, 0x1F,
  0x08, 0x24, 0x0A, 0x01, 0x80, 0x7F, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x87, 0xC0, 0x1C, 0x82, 0x08, 0x20, 0x8F, 0xC8, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3C, 0xA1, 0x60, 0x70,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x34, 0x39, 0xE4,
  0x02, 0x01, 0x01, 0x20, 0x8F, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x79, 0x42, 0xC1, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x10, 0x87, 0xFF, 0xE0, 0x10, 0x00, 0x01, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x2E, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x05, 0x04, 0x84, 0x44, 0x24, 0x14, 0x0E, 0x04, 0x82,
  0x21, 0x10, 0x84, 0x41, 0x20, 0x50, 0x20, 0xFF, 0xFF, 0xF0, 0x9E, 0x3E,
  0xA1, 0x41, 0xC1, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81,
  0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81,
  0x80, 0x81, 0x9E, 0x50, 0xB0, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x1F, 0x08, 0x24, 0x09, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x05, 0x02, 0x20, 0x87, 0xC0,
  0xBE, 0x60, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x1C, 0x15, 0xF2, 0x01, 0x00, 0x80, 0x40, 0x20, 0x00, 0x3C, 0xA1,
  0x60, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x14,
  0x39, 0xE4, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0xBE, 0x31, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x40, 0x3E, 0x20, 0x90, 0x30, 0x14, 0x01, 0x00,
  0x70, 0x04, 0x01, 0x00, 0x60, 0x30, 0x14, 0x11, 0xF0, 0x21, 0x09, 0xF2,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x18, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x34, 0x29, 0xE4,
  0x80, 0xC0, 0x60, 0x28, 0x24, 0x12, 0x08, 0x88, 0x44, 0x22, 0x0A, 0x05,
  0x02, 0x80, 0x80, 0x40, 0x81, 0x03, 0x02, 0x05, 0x0A, 0x12, 0x14, 0x24,
  0x28, 0x48, 0x50, 0x89, 0x12, 0x12, 0x24, 0x24, 0x48, 0x50, 0x50, 0x60,
  0xA0, 0xC1, 0x81, 0x83, 0x02, 0x02, 0x00, 0x80, 0xA0, 0x90, 0x44, 0x41,
  0x40, 0xA0, 0x20, 0x10, 0x14, 0x11, 0x08, 0x88, 0x24, 0x14, 0x04, 0x80,
  0xC0, 0x60, 0x28, 0x24, 0x12, 0x08, 0x88, 0x44, 0x22, 0x0A, 0x05, 0x02,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x38, 0x00, 0x7F, 0x80, 0x80,
  0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x07,
  0xFC, 0x04, 0x21, 0x04, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0xC1, 0x02,
  0x08, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x08, 0x10, 0xFF, 0xFF, 0xFC,
  0xC0, 0x40, 0x80, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0x61,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x10, 0x21, 0x80, 0x78,
  0x18, 0x41, 0x82, 0x28, 0x1C,
};

const GFXglyph RobotoCondensed_Thin26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 19, 5, 2, -19 },
  { 4, 3, 5, 7, 2, -20 },
  { 6, 12, 19, 13, 1, -19 },
  { 35, 9, 23, 13, 2, -21 },
  { 61, 14, 19, 17, 1, -19 },
  { 95, 12, 19, 14, 1, -19 },
  { 124, 1, 5, 4, 2, -20 },
  { 125, 5, 27, 7, 2, -21 },
  { 142, 4, 27, 7, 1, -21 },
  { 156, 11, 10, 11, 0, -19 },
  { 170, 11, 13, 13, 1, -15 },
  { 188, 2, 5, 5, 1, -2 },
  { 190, 5, 1, 7, 1, -9 },
  { 191, 1, 1, 6, 2, -1 },
  { 192, 7, 21, 9, 1, -19 },
  { 211, 9, 19, 13, 2, -19 },
  { 233, 5, 19, 13, 2, -19 },
  { 245, 10, 19, 13, 1, -19 },
  { 269, 10, 19, 13, 1, -19 },
  { 293, 11, 19, 13, 1, -19 },
  { 320, 9, 19, 13, 2, -19 },
  { 342, 9, 19, 13, 2, -19 },
  { 364, 10, 19, 13, 1, -19 },
  { 388, 10, 19, 13, 1, -19 },
  { 412, 10, 19, 13, 1, -19 },
  { 436, 1, 13, 5, 2, -13 },
  { 438, 2, 16, 4, 1, -13 },
  { 442, 9, 11, 12, 1, -14 },
  { 455, 9, 7, 13, 2, -12 },
  { 463, 9, 11, 12, 1, -14 },
  { 476, 8, 19, 10, 1, -19 },
  { 495, 17, 24, 21, 2, -18 },
  { 546, 12, 19, 14, 1, -19 },
  { 575, 10, 19, 14, 2, -19 },
  { 599, 11, 19, 15, 2, -19 },
  { 626, 11, 19, 15, 2, -19 },
  { 653, 10, 19, 13, 2, -19 },
  { 677, 10, 19, 13, 2, -19 },
  { 701, 11, 19, 16, 2, -19 },
  { 728, 12, 19, 16, 2, -19 },
  { 757, 1, 19, 6, 3, -19 },
  { 760, 9, 19, 13, 1, -19 },
  { 782, 12, 19, 14, 2, -19 },
  { 811, 9, 19, 12, 2, -19 },
  { 833, 15, 19, 19, 2, -19 },
  { 869, 12, 19, 16, 2, -19 },
  { 898, 11, 19, 15, 2, -19 },
  { 925, 10, 19, 14, 2, -19 },
  { 949, 11, 22, 15, 2, -19 },
  { 980, 11, 19, 15, 2, -19 },
  { 1007, 11, 19, 14, 1, -19 },
  { 1034, 12, 19, 14, 1, -19 },
  { 1063, 11, 19, 15, 2, -19 },
  { 1090, 12, 19, 14, 1, -19 },
  { 1119, 19, 19, 20, 1, -19 },
  { 1165, 12, 19, 14, 1, -19 },
  { 1194, 12, 19, 14, 1, -19 },
  { 1223, 11, 19, 14, 1, -19 },
  { 1250, 3, 25, 5, 2, -21 },
  { 1260, 7, 21, 9, 1, -19 },
  { 1279, 3, 25, 5, 0, -21 },
  { 1289, 7, 9, 10, 1, -19 },
  { 1297, 9, 1, 10, 0, 0 },
  { 1299, 3, 3, 7, 2, -19 },
  { 1301, 9, 14, 12, 1, -14 },
  { 1317, 9, 20, 13, 2, -20 },
  { 1340, 9, 14, 12, 1, -14 },
  { 1356, 9, 20, 13, 2, -20 },
  { 1379, 10, 14, 12, 1, -14 },
  { 1397, 6, 20, 7, 1, -20 },
  { 1412, 9, 19, 13, 2, -14 },
  { 1434, 9, 20, 13, 2, -20 },
  { 1457, 1, 19, 5, 2, -19 },
  { 1460, 4, 24, 5, -1, -19 },
  { 1472, 9, 20, 11, 2, -20 },
  { 1495, 1, 20, 5, 2, -20 },
  { 1498, 16, 14, 20, 2, -14 },
  { 1526, 9, 14, 13, 2, -14 },
  { 1542, 10, 14, 13, 1, -14 },
  { 1560, 9, 19, 13, 2, -14 },
  { 1582, 9, 19, 13, 2, -14 },
  { 1604, 5, 14, 8, 2, -14 },
  { 1613, 9, 14, 11, 1, -14 },
  { 1629, 5, 17, 7, 1, -17 },
  { 1640, 9, 14, 13, 2, -14 },
  { 1656, 9, 14, 11, 1, -14 },
  { 1672, 15, 14, 17, 1, -14 },
  { 1699, 9, 14, 11, 1, -14 },
  { 1715, 9, 19, 11, 1, -14 },
  { 1737, 9, 14, 11, 1, -14 },
  { 1753, 6, 26, 8, 1, -20 },
  { 1773, 1, 22, 5, 2, -19 },
  { 1776, 7, 26, 8, 0, -20 },
  { 1799, 12, 4, 16, 2, -10 },
};

const GFXfont RobotoCondensed_Thin26pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin26pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin26pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOCONDENSED_THIN26PT7B_H_
