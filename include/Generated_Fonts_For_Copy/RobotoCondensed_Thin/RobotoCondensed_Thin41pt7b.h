#ifndef _ROBOTOCONDENSED_THIN41PT7B_H_
#define _ROBOTOCONDENSED_THIN41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin41pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x80, 0x03, 0xC0, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x00, 0x81, 0x00, 0x10, 0x20, 0x02, 0x04, 0x00, 0x40, 0x80,
  0x10, 0x10, 0x02, 0x04, 0x00, 0x40, 0x80, 0x08, 0x10, 0x3F, 0xFF, 0xE0,
  0x20, 0x40, 0x0C, 0x08, 0x01, 0x03, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00,
  0x81, 0x00, 0x10, 0x20, 0x02, 0x04, 0x00, 0x80, 0x80, 0x10, 0x20, 0x02,
  0x04, 0x0F, 0xFF, 0xFC, 0x08, 0x10, 0x01, 0x02, 0x00, 0x60, 0x40, 0x08,
  0x10, 0x01, 0x02, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x81, 0x00, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x7E, 0x01, 0x83, 0x04, 0x03,
  0x10, 0x02, 0x20, 0x06, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x2C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x05,
  0x00, 0x0A, 0x00, 0x14, 0x00, 0x24, 0x00, 0xCC, 0x03, 0x0E, 0x0C, 0x07,
  0xE0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x1E, 0x00, 0x00,
  0x84, 0x00, 0x04, 0x08, 0x00, 0x10, 0x20, 0x00, 0x80, 0x80, 0x82, 0x01,
  0x02, 0x08, 0x04, 0x10, 0x20, 0x10, 0x40, 0x80, 0x42, 0x02, 0x02, 0x08,
  0x04, 0x08, 0x40, 0x10, 0x23, 0x00, 0x21, 0x08, 0x00, 0x78, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x3C, 0x00, 0x21, 0x18, 0x01, 0x08, 0x20, 0x04,
  0x20, 0x40, 0x21, 0x01, 0x01, 0x84, 0x04, 0x04, 0x10, 0x10, 0x20, 0x40,
  0x40, 0x81, 0x01, 0x04, 0x04, 0x04, 0x10, 0x08, 0x10, 0x00, 0x20, 0xC0,
  0x00, 0x46, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0x84, 0x00, 0x20, 0x40,
  0x08, 0x08, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x04, 0x00, 0x80, 0x80,
  0x10, 0x30, 0x03, 0x0C, 0x00, 0x23, 0x00, 0x06, 0xC0, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x02, 0x40, 0x00, 0x8C, 0x00, 0x30, 0x80, 0x44, 0x08, 0x09,
  0x00, 0x81, 0x20, 0x18, 0x4C, 0x01, 0x09, 0x00, 0x11, 0x20, 0x01, 0x46,
  0x00, 0x38, 0x40, 0x02, 0x08, 0x00, 0xA0, 0x80, 0x32, 0x0C, 0x18, 0x60,
  0x7E, 0x04, 0xFF, 0x02, 0x0C, 0x10, 0x41, 0x82, 0x04, 0x10, 0x20, 0xC1,
  0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x06, 0x04, 0x08, 0x10, 0x30, 0x20, 0x40, 0xC0, 0x81, 0x81,
  0x01, 0x03, 0x02, 0x80, 0x81, 0x81, 0x01, 0x02, 0x02, 0x04, 0x08, 0x08,
  0x10, 0x20, 0x40, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x60, 0x81, 0x02, 0x08, 0x10, 0x20, 0x81, 0x04,
  0x18, 0x20, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x81, 0x02, 0xE1, 0x0E, 0x1D, 0x70, 0x03, 0x80, 0x03, 0x80, 0x02,
  0xC0, 0x04, 0x60, 0x0C, 0x20, 0x18, 0x10, 0x10, 0x18, 0x30, 0x08, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xE0, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x24, 0x96, 0xB4, 0xFF,
  0xF0, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x07, 0xC0, 0x18, 0x60, 0x40, 0x21, 0x00, 0x62, 0x00, 0x48, 0x00,
  0x90, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x05, 0x00,
  0x0A, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x02, 0x20, 0x04,
  0x40, 0x18, 0x40, 0x20, 0x61, 0x80, 0x7E, 0x00, 0x03, 0x0D, 0x31, 0xC1,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x07, 0xC0, 0x18, 0x30, 0x30, 0x08, 0x20, 0x0C, 0x40, 0x04, 0x40,
  0x04, 0x40, 0x04, 0x80, 0x06, 0x80, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0x07,
  0xE0, 0x38, 0x60, 0xC0, 0x21, 0x00, 0x24, 0x00, 0x48, 0x00, 0x50, 0x00,
  0xA0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x40, 0x08,
  0xC0, 0x30, 0xE0, 0xC0, 0x7E, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0A,
  0x00, 0x0D, 0x00, 0x04, 0x80, 0x04, 0x40, 0x02, 0x20, 0x02, 0x10, 0x01,
  0x08, 0x01, 0x04, 0x01, 0x82, 0x00, 0x81, 0x00, 0xC0, 0x80, 0x40, 0x40,
  0x40, 0x20, 0x20, 0x10, 0x20, 0x08, 0x30, 0x04, 0x10, 0x02, 0x18, 0x01,
  0x0F, 0xFF, 0xF8, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x3F, 0xFE, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x3E, 0x05, 0x83, 0x0C, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x38,
  0x00, 0x50, 0x00, 0xA0, 0x02, 0x40, 0x04, 0x40, 0x08, 0xC0, 0x20, 0xC1,
  0x80, 0x7E, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x1F, 0x04,
  0xC1, 0x8A, 0x01, 0x98, 0x01, 0x20, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xA0, 0x01, 0x40, 0x02,
  0x40, 0x0C, 0xC0, 0x10, 0x80, 0x40, 0xC1, 0x80, 0x7C, 0x00, 0xFF, 0xFF,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x07, 0xE0, 0x18, 0x38,
  0x30, 0x0C, 0x20, 0x04, 0x40, 0x06, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x30, 0x08, 0x18, 0x30,
  0x07, 0xE0, 0x18, 0x18, 0x20, 0x0C, 0x40, 0x06, 0x40, 0x02, 0x80, 0x03,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02,
  0x20, 0x04, 0x18, 0x18, 0x07, 0xE0, 0x07, 0xC0, 0x30, 0x60, 0x40, 0x61,
  0x00, 0x66, 0x00, 0x48, 0x00, 0xD0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x50, 0x00, 0xA0, 0x03,
  0x20, 0x0A, 0x60, 0x34, 0x60, 0xC8, 0x3E, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x6C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xB6, 0xD2, 0xD0, 0x00, 0x04, 0x00, 0x60, 0x06, 0x00, 0x70,
  0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x00, 0x0F, 0x83, 0x0C, 0x60, 0x24,
  0x02, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x04, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x08, 0x06, 0x00, 0x00,
  0x20, 0x20, 0x00, 0x01, 0x83, 0x00, 0x00, 0x04, 0x10, 0x07, 0xC0, 0x21,
  0x80, 0x63, 0x00, 0x88, 0x04, 0x04, 0x04, 0x40, 0x40, 0x20, 0x26, 0x02,
  0x01, 0x01, 0x20, 0x20, 0x08, 0x09, 0x01, 0x00, 0x40, 0x48, 0x08, 0x06,
  0x02, 0x40, 0xC0, 0x20, 0x12, 0x04, 0x01, 0x00, 0x90, 0x20, 0x08, 0x04,
  0x81, 0x00, 0x40, 0x24, 0x08, 0x02, 0x01, 0x20, 0x40, 0x10, 0x09, 0x02,
  0x00, 0x80, 0x48, 0x10, 0x0C, 0x04, 0x40, 0x40, 0x60, 0x22, 0x02, 0x05,
  0x82, 0x10, 0x08, 0x44, 0x20, 0x40, 0x3C, 0x1E, 0x02, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xA0, 0x00, 0x09, 0x00, 0x00, 0x90, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00,
  0x10, 0x80, 0x03, 0x08, 0x00, 0x20, 0x80, 0x02, 0x04, 0x00, 0x20, 0x40,
  0x04, 0x04, 0x00, 0x40, 0x20, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01,
  0x00, 0x80, 0x10, 0x10, 0x01, 0x01, 0xFF, 0xF8, 0x10, 0x00, 0x82, 0x00,
  0x08, 0x20, 0x00, 0x42, 0x00, 0x04, 0x60, 0x00, 0x44, 0x00, 0x06, 0x40,
  0x00, 0x2C, 0x00, 0x02, 0x80, 0x00, 0x30, 0xFF, 0xC0, 0x80, 0x30, 0x80,
  0x18, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x30, 0xFF,
  0xE0, 0x80, 0x18, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80,
  0x0C, 0x80, 0x18, 0xFF, 0xE0, 0x03, 0xF0, 0x03, 0x03, 0x01, 0x00, 0x20,
  0x80, 0x04, 0x40, 0x01, 0x90, 0x00, 0x2C, 0x00, 0x0A, 0x00, 0x02, 0x80,
  0x00, 0xE0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x60,
  0x00, 0x88, 0x00, 0x41, 0x00, 0x20, 0x30, 0x30, 0x03, 0xF0, 0x00, 0xFF,
  0xC0, 0x40, 0x18, 0x20, 0x02, 0x10, 0x00, 0x88, 0x00, 0x24, 0x00, 0x1A,
  0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05,
  0x00, 0x06, 0x80, 0x02, 0x40, 0x02, 0x20, 0x02, 0x10, 0x06, 0x0F, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x3F, 0xFE, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x3F, 0xFE,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x00, 0x03, 0xF8, 0x03, 0x81, 0x81, 0x80, 0x10, 0xC0, 0x02,
  0x20, 0x00, 0x90, 0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x3F, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x40, 0x00, 0x50, 0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0x20, 0x00, 0x4C,
  0x00, 0x11, 0x80, 0x18, 0x38, 0x1C, 0x03, 0xF8, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x09, 0x00,
  0x26, 0x01, 0x0C, 0x18, 0x0F, 0xC0, 0x80, 0x01, 0x40, 0x01, 0x20, 0x01,
  0x10, 0x01, 0x08, 0x01, 0x84, 0x01, 0x82, 0x01, 0x81, 0x00, 0x80, 0x80,
  0x80, 0x40, 0x80, 0x20, 0xC0, 0x10, 0xC0, 0x08, 0xC0, 0x04, 0x60, 0x02,
  0x58, 0x01, 0x44, 0x00, 0xC1, 0x00, 0x40, 0xC0, 0x20, 0x30, 0x10, 0x08,
  0x08, 0x02, 0x04, 0x01, 0x82, 0x00, 0x41, 0x00, 0x10, 0x80, 0x04, 0x40,
  0x03, 0x20, 0x00, 0x90, 0x00, 0x28, 0x00, 0x08, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFF, 0x80, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x2F, 0x00, 0x00, 0x5A, 0x00, 0x00, 0xB4, 0x00,
  0x02, 0x64, 0x00, 0x04, 0xC8, 0x00, 0x09, 0x90, 0x00, 0x23, 0x10, 0x00,
  0x46, 0x20, 0x01, 0x8C, 0x40, 0x02, 0x18, 0x40, 0x04, 0x30, 0x80, 0x10,
  0x60, 0x80, 0x20, 0xC1, 0x00, 0x41, 0x82, 0x01, 0x03, 0x02, 0x02, 0x06,
  0x04, 0x04, 0x0C, 0x08, 0x10, 0x18, 0x08, 0x20, 0x30, 0x10, 0x80, 0x60,
  0x21, 0x00, 0xC0, 0x22, 0x01, 0x80, 0x48, 0x03, 0x00, 0x50, 0x06, 0x00,
  0xA0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x00, 0x20, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x80, 0x01, 0xA0, 0x00, 0x64, 0x00, 0x19, 0x80, 0x06,
  0x20, 0x01, 0x84, 0x00, 0x61, 0x00, 0x18, 0x20, 0x06, 0x0C, 0x01, 0x81,
  0x00, 0x60, 0x20, 0x18, 0x08, 0x06, 0x01, 0x01, 0x80, 0x60, 0x60, 0x08,
  0x18, 0x03, 0x06, 0x00, 0x41, 0x80, 0x08, 0x60, 0x02, 0x18, 0x00, 0x46,
  0x00, 0x19, 0x80, 0x02, 0x60, 0x00, 0x58, 0x00, 0x16, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x03, 0xF0, 0x03, 0x03, 0x01, 0x00, 0x20, 0x80, 0x04, 0x40,
  0x00, 0x90, 0x00, 0x28, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0D, 0x00, 0x02, 0x40, 0x00, 0x88, 0x00,
  0x41, 0x00, 0x20, 0x30, 0x30, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x80, 0x38,
  0x80, 0x0C, 0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x03,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04,
  0x80, 0x0C, 0x80, 0x38, 0xFF, 0xE0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x03, 0x03, 0x01, 0x00,
  0x20, 0x80, 0x04, 0x40, 0x00, 0x90, 0x00, 0x28, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0D, 0x00, 0x02,
  0x40, 0x00, 0x88, 0x00, 0x41, 0x00, 0x20, 0x30, 0x30, 0x03, 0xFC, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0xFF,
  0xE0, 0x40, 0x1C, 0x20, 0x03, 0x10, 0x00, 0x88, 0x00, 0x24, 0x00, 0x12,
  0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0xD0, 0x00,
  0x48, 0x00, 0x24, 0x00, 0x22, 0x00, 0x31, 0x00, 0x30, 0xFF, 0xE0, 0x40,
  0x30, 0x20, 0x08, 0x10, 0x06, 0x08, 0x01, 0x04, 0x00, 0x42, 0x00, 0x21,
  0x00, 0x08, 0x80, 0x04, 0x40, 0x01, 0x20, 0x00, 0xD0, 0x00, 0x28, 0x00,
  0x18, 0x03, 0xF0, 0x07, 0x03, 0x03, 0x00, 0x20, 0x80, 0x04, 0x40, 0x01,
  0x90, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x80, 0x00,
  0xA0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x02, 0x40, 0x00, 0x98, 0x00, 0x63,
  0x00, 0x30, 0x30, 0x38, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0x90, 0x00, 0x8C,
  0x00, 0x81, 0x81, 0x80, 0x3F, 0x00, 0x80, 0x00, 0x3C, 0x00, 0x02, 0x40,
  0x00, 0x24, 0x00, 0x06, 0x60, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0xC2,
  0x00, 0x08, 0x10, 0x00, 0x81, 0x00, 0x08, 0x10, 0x01, 0x00, 0x80, 0x10,
  0x08, 0x01, 0x00, 0x80, 0x20, 0x04, 0x02, 0x00, 0x40, 0x20, 0x04, 0x04,
  0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x20, 0x80, 0x03, 0x08, 0x00, 0x10,
  0x80, 0x01, 0x10, 0x00, 0x19, 0x00, 0x00, 0x90, 0x00, 0x0B, 0x00, 0x00,
  0xA0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x40, 0x03, 0x00, 0x05, 0x00,
  0x0C, 0x00, 0x24, 0x00, 0x30, 0x00, 0x90, 0x00, 0xA0, 0x02, 0x60, 0x04,
  0x80, 0x08, 0x80, 0x12, 0x00, 0x62, 0x00, 0x48, 0x01, 0x08, 0x01, 0x10,
  0x04, 0x20, 0x08, 0x40, 0x10, 0x40, 0x21, 0x00, 0x41, 0x00, 0x84, 0x02,
  0x04, 0x02, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x80, 0x80,
  0x81, 0x02, 0x06, 0x02, 0x04, 0x04, 0x10, 0x08, 0x20, 0x10, 0x40, 0x30,
  0x80, 0x41, 0x00, 0x42, 0x01, 0x0C, 0x01, 0x18, 0x02, 0x20, 0x04, 0x40,
  0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x24, 0x00, 0xC8, 0x00, 0xB0, 0x01,
  0x40, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x40, 0x00, 0x64, 0x00,
  0x08, 0x80, 0x02, 0x08, 0x00, 0x41, 0x80, 0x10, 0x10, 0x06, 0x01, 0x00,
  0x80, 0x20, 0x20, 0x02, 0x04, 0x00, 0x61, 0x00, 0x04, 0x60, 0x00, 0x48,
  0x00, 0x0A, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0x90,
  0x00, 0x22, 0x00, 0x04, 0x20, 0x01, 0x06, 0x00, 0x60, 0x40, 0x08, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x08, 0x10, 0x01, 0x86, 0x00, 0x10, 0x80, 0x01,
  0x20, 0x00, 0x24, 0x00, 0x02, 0xC0, 0x00, 0x24, 0x00, 0x06, 0x60, 0x00,
  0x42, 0x00, 0x0C, 0x30, 0x00, 0x81, 0x00, 0x18, 0x18, 0x01, 0x00, 0x80,
  0x30, 0x0C, 0x02, 0x00, 0x40, 0x60, 0x06, 0x04, 0x00, 0x20, 0xC0, 0x03,
  0x08, 0x00, 0x11, 0x80, 0x01, 0x90, 0x00, 0x0B, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x43,
  0xE0, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x01, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x87, 0xE0, 0x04, 0x01, 0x80, 0x28, 0x05, 0x01, 0x20, 0x22, 0x04, 0x41,
  0x08, 0x20, 0x84, 0x11, 0x83, 0x20, 0x24, 0x05, 0x80, 0xE0, 0x08, 0xFF,
  0xFE, 0xC3, 0x08, 0x21, 0x80, 0x0F, 0xC0, 0x60, 0xC2, 0x00, 0x90, 0x02,
  0x40, 0x07, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0xFF,
  0xCE, 0x01, 0x60, 0x05, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x01, 0xD0, 0x0D, 0x60, 0x64, 0x7E, 0x10, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x1F, 0x09, 0x83, 0x28, 0x06, 0xC0, 0x0B, 0x00, 0x38, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0xF0, 0x02, 0xA0, 0x1A, 0x60,
  0xC8, 0x7C, 0x00, 0x07, 0xC0, 0x60, 0xC2, 0x01, 0x90, 0x02, 0x40, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00,
  0x48, 0x02, 0x18, 0x30, 0x1F, 0x00, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x0F,
  0x84, 0x60, 0xC9, 0x80, 0x52, 0x00, 0xA8, 0x00, 0xD0, 0x01, 0xA0, 0x01,
  0x40, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x19, 0x00, 0x33, 0x00,
  0xA3, 0x06, 0x41, 0xF0, 0x80, 0x07, 0xE0, 0x30, 0x60, 0xC0, 0x23, 0x00,
  0x64, 0x00, 0x58, 0x00, 0xA0, 0x01, 0x40, 0x01, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x21, 0x81, 0x80, 0xFC, 0x00, 0x03,
  0xE0, 0xC0, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x1F,
  0xF8, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x07, 0xC2, 0x30, 0x64, 0xC0, 0x29,
  0x00, 0x54, 0x00, 0x68, 0x00, 0xD0, 0x00, 0xA0, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x50, 0x00, 0xA0, 0x01,
  0x40, 0x02, 0x80, 0x0C, 0x80, 0x19, 0x80, 0x51, 0x83, 0x20, 0xF8, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x80, 0x11, 0x80, 0x41, 0x81,
  0x00, 0xFC, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x1F, 0x08, 0x83, 0x24, 0x04,
  0xA0, 0x0A, 0x80, 0x2C, 0x00, 0xB0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08,
  0x10, 0x20, 0x9E, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x68, 0x03, 0x20,
  0x18, 0x80, 0x42, 0x02, 0x08, 0x10, 0x20, 0x80, 0x84, 0x02, 0x20, 0x09,
  0x80, 0x2F, 0x00, 0xE4, 0x03, 0x08, 0x08, 0x30, 0x20, 0x40, 0x80, 0x82,
  0x03, 0x08, 0x04, 0x20, 0x08, 0x80, 0x12, 0x00, 0x68, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x87, 0xC0, 0x7E, 0x22, 0x0C,
  0x30, 0xC9, 0x01, 0x10, 0x1A, 0x80, 0x28, 0x02, 0xC0, 0x0E, 0x00, 0xF0,
  0x03, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x87, 0xC2, 0x20, 0xC9, 0x01,
  0x28, 0x02, 0xA0, 0x0B, 0x00, 0x2C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x07, 0xE0,
  0x18, 0x30, 0x30, 0x08, 0x20, 0x04, 0x40, 0x06, 0x40, 0x02, 0x40, 0x02,
  0xC0, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x06, 0x20, 0x04,
  0x30, 0x08, 0x18, 0x30, 0x07, 0xE0, 0x87, 0xC2, 0x60, 0xCA, 0x01, 0xB0,
  0x02, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0xA8, 0x06, 0x98, 0x32, 0x1F, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00, 0x07,
  0xC2, 0x30, 0x64, 0xC0, 0x29, 0x00, 0x74, 0x00, 0x68, 0x00, 0xD0, 0x00,
  0xA0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x0C, 0x80, 0x19, 0x80,
  0x51, 0x83, 0x20, 0xF8, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x87, 0x4C, 0x2C, 0x14,
  0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x0F, 0xC0, 0xC0,
  0xC6, 0x01, 0x10, 0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x80, 0x0E, 0x00, 0x24, 0x00, 0x98, 0x06, 0x30, 0x30, 0x3F, 0x00,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x83, 0xFE, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x08, 0x04, 0x03, 0x00, 0xF0, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x0D, 0x00, 0x34, 0x01, 0x58, 0x0D, 0x30, 0x64, 0x3E, 0x10, 0x80,
  0x02, 0x80, 0x05, 0x00, 0x1A, 0x00, 0x22, 0x00, 0x44, 0x01, 0x88, 0x02,
  0x08, 0x04, 0x10, 0x18, 0x20, 0x20, 0x60, 0x40, 0x40, 0x80, 0x82, 0x01,
  0x84, 0x01, 0x08, 0x02, 0x20, 0x06, 0x40, 0x04, 0x80, 0x0A, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x07, 0x00,
  0xA0, 0x1A, 0x01, 0x40, 0x24, 0x02, 0x80, 0x48, 0x0D, 0x00, 0x90, 0x11,
  0x03, 0x10, 0x22, 0x04, 0x20, 0x44, 0x08, 0x41, 0x08, 0x10, 0x82, 0x08,
  0x60, 0x84, 0x10, 0x81, 0x08, 0x21, 0x02, 0x20, 0x62, 0x04, 0x40, 0x4C,
  0x04, 0x80, 0x90, 0x09, 0x01, 0x20, 0x14, 0x01, 0x40, 0x28, 0x02, 0x80,
  0x70, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x40,
  0x08, 0x80, 0x20, 0x80, 0xC1, 0x81, 0x01, 0x04, 0x01, 0x08, 0x02, 0x20,
  0x02, 0xC0, 0x07, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x28, 0x00, 0xC8, 0x01,
  0x18, 0x04, 0x10, 0x08, 0x10, 0x20, 0x20, 0xC0, 0x21, 0x00, 0x64, 0x00,
  0x48, 0x00, 0xC0, 0x80, 0x02, 0x80, 0x05, 0x00, 0x1A, 0x00, 0x22, 0x00,
  0x44, 0x01, 0x88, 0x02, 0x08, 0x04, 0x10, 0x18, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x80, 0x82, 0x00, 0x84, 0x01, 0x08, 0x02, 0x20, 0x02, 0x40, 0x04,
  0x80, 0x0A, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x0E, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x04, 0x01, 0x01, 0x80, 0xC0, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20,
  0x06, 0x00, 0xC0, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x00, 0x1E, 0x00, 0x64, 0x60, 0x09, 0x02, 0x01, 0x20,
  0x20, 0x28, 0x02, 0x0D, 0x00, 0x21, 0x20, 0x03, 0xC0,
};

const GFXglyph RobotoCondensed_Thin41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 29, 8, 3, -29 },
  { 9, 5, 8, 11, 3, -31 },
  { 14, 19, 29, 20, 1, -29 },
  { 83, 15, 37, 20, 2, -33 },
  { 153, 22, 29, 27, 2, -29 },
  { 233, 19, 29, 22, 2, -29 },
  { 302, 1, 8, 7, 3, -31 },
  { 303, 7, 41, 11, 3, -32 },
  { 339, 7, 41, 11, 1, -32 },
  { 375, 16, 16, 17, 1, -29 },
  { 407, 17, 21, 20, 2, -24 },
  { 452, 3, 8, 8, 2, -3 },
  { 455, 8, 1, 11, 1, -14 },
  { 456, 2, 2, 9, 3, -2 },
  { 457, 12, 32, 14, 1, -29 },
  { 505, 15, 29, 20, 2, -29 },
  { 560, 8, 29, 20, 4, -29 },
  { 589, 16, 29, 20, 2, -29 },
  { 647, 15, 29, 20, 2, -29 },
  { 702, 17, 29, 20, 2, -29 },
  { 764, 15, 29, 20, 3, -29 },
  { 819, 15, 29, 20, 3, -29 },
  { 874, 16, 29, 20, 2, -29 },
  { 932, 16, 29, 20, 2, -29 },
  { 990, 15, 29, 20, 2, -29 },
  { 1045, 2, 21, 7, 3, -21 },
  { 1051, 3, 26, 7, 2, -21 },
  { 1061, 14, 16, 19, 2, -21 },
  { 1089, 14, 9, 20, 3, -18 },
  { 1105, 15, 16, 19, 2, -21 },
  { 1135, 12, 29, 16, 2, -29 },
  { 1179, 29, 37, 33, 2, -28 },
  { 1314, 20, 29, 22, 1, -29 },
  { 1387, 16, 29, 22, 4, -29 },
  { 1445, 18, 29, 23, 3, -29 },
  { 1511, 17, 29, 24, 4, -29 },
  { 1573, 15, 29, 21, 4, -29 },
  { 1628, 15, 29, 21, 4, -29 },
  { 1683, 18, 29, 25, 3, -29 },
  { 1749, 17, 29, 25, 4, -29 },
  { 1811, 1, 29, 10, 4, -29 },
  { 1815, 14, 29, 20, 2, -29 },
  { 1866, 17, 29, 23, 4, -29 },
  { 1928, 13, 29, 19, 4, -29 },
  { 1976, 23, 29, 31, 4, -29 },
  { 2060, 18, 29, 25, 4, -29 },
  { 2126, 18, 29, 24, 3, -29 },
  { 2192, 16, 29, 22, 4, -29 },
  { 2250, 18, 34, 24, 3, -29 },
  { 2327, 17, 29, 23, 4, -29 },
  { 2389, 18, 29, 21, 2, -29 },
  { 2455, 19, 29, 22, 1, -29 },
  { 2524, 17, 29, 24, 3, -29 },
  { 2586, 20, 29, 22, 1, -29 },
  { 2659, 30, 29, 32, 1, -29 },
  { 2768, 19, 29, 22, 1, -29 },
  { 2837, 20, 29, 22, 1, -29 },
  { 2910, 18, 29, 22, 2, -29 },
  { 2976, 5, 39, 8, 3, -33 },
  { 3001, 12, 32, 14, 1, -29 },
  { 3049, 5, 39, 8, 0, -33 },
  { 3074, 11, 15, 15, 2, -29 },
  { 3095, 15, 1, 15, 0, 0 },
  { 3097, 5, 5, 11, 3, -30 },
  { 3101, 14, 22, 19, 2, -22 },
  { 3140, 14, 31, 20, 3, -31 },
  { 3195, 14, 22, 18, 2, -22 },
  { 3234, 15, 31, 20, 2, -31 },
  { 3293, 15, 22, 19, 2, -22 },
  { 3335, 11, 31, 12, 1, -31 },
  { 3378, 15, 30, 20, 2, -22 },
  { 3435, 14, 31, 20, 3, -31 },
  { 3490, 2, 30, 8, 3, -30 },
  { 3498, 7, 38, 8, -2, -30 },
  { 3532, 14, 31, 17, 3, -31 },
  { 3587, 2, 31, 8, 3, -31 },
  { 3595, 26, 22, 32, 3, -22 },
  { 3667, 14, 22, 20, 3, -22 },
  { 3706, 16, 22, 20, 2, -22 },
  { 3750, 14, 30, 20, 3, -22 },
  { 3803, 15, 30, 20, 2, -22 },
  { 3860, 9, 22, 12, 3, -22 },
  { 3885, 14, 22, 18, 2, -22 },
  { 3924, 9, 28, 12, 1, -28 },
  { 3956, 14, 22, 20, 3, -22 },
  { 3995, 15, 22, 17, 1, -22 },
  { 4037, 23, 22, 27, 2, -22 },
  { 4101, 15, 22, 17, 1, -22 },
  { 4143, 15, 30, 17, 1, -22 },
  { 4200, 14, 22, 17, 2, -22 },
  { 4239, 10, 41, 12, 2, -32 },
  { 4291, 1, 34, 8, 4, -29 },
  { 4296, 10, 41, 12, 0, -32 },
  { 4348, 19, 7, 25, 3, -16 },
};

const GFXfont RobotoCondensed_Thin41pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin41pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin41pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _ROBOTOCONDENSED_THIN41PT7B_H_
