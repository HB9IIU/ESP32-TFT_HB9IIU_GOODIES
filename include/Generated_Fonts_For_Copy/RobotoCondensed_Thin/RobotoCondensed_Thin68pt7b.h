#ifndef _ROBOTOCONDENSED_THIN68PT7B_H_
#define _ROBOTOCONDENSED_THIN68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin68pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x40, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0C,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x40, 0x00, 0x04, 0x00, 0x40,
  0x00, 0x04, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x80,
  0x00, 0x08, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x18, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x10, 0x01, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x30, 0x02, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x60, 0x04, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x40, 0x0C, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x18, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x10, 0x00, 0x01, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x20, 0x00, 0x02, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF,
  0xC0, 0x03, 0x80, 0x70, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x03, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x61, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x40,
  0x00, 0x06, 0x60, 0x00, 0x01, 0x30, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x8E, 0x00, 0x01, 0x83, 0x80, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x07, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x0C, 0x00, 0x60,
  0x01, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x80,
  0x02, 0x00, 0x60, 0x08, 0x00, 0x20, 0x0C, 0x00, 0x80, 0x02, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x30, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x60, 0x00, 0x60,
  0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x1F, 0xF0, 0x08, 0x00,
  0x00, 0xFE, 0x01, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x03, 0xF0, 0x00, 0x01, 0x80, 0xFF,
  0x80, 0x00, 0x18, 0x1C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x60, 0x00, 0x30,
  0x30, 0x02, 0x00, 0x06, 0x03, 0x00, 0x30, 0x00, 0x60, 0x60, 0x03, 0x00,
  0x0C, 0x06, 0x00, 0x10, 0x00, 0x80, 0x60, 0x01, 0x00, 0x18, 0x06, 0x00,
  0x10, 0x01, 0x00, 0x60, 0x01, 0x00, 0x30, 0x06, 0x00, 0x10, 0x06, 0x00,
  0x60, 0x01, 0x00, 0x60, 0x06, 0x00, 0x10, 0x0C, 0x00, 0x60, 0x01, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x18, 0x00, 0x20, 0x03, 0x00, 0x80, 0x03, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x03,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x30, 0x00, 0x40,
  0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x30, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x18,
  0xC0, 0x0C, 0x00, 0x63, 0x00, 0x38, 0x01, 0x98, 0x00, 0x60, 0x06, 0x60,
  0x00, 0xC0, 0x13, 0x00, 0x01, 0x80, 0x4C, 0x00, 0x07, 0x03, 0x30, 0x00,
  0x0C, 0x0C, 0xC0, 0x00, 0x18, 0x33, 0x00, 0x00, 0x31, 0x8C, 0x00, 0x00,
  0xE6, 0x30, 0x00, 0x01, 0xB0, 0xC0, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xF0, 0x30, 0x00, 0x06, 0x60,
  0xE0, 0x00, 0x70, 0xC1, 0xC0, 0x03, 0x83, 0x83, 0xC0, 0x38, 0x06, 0x03,
  0xFF, 0xC0, 0x0C, 0x00, 0xF0, 0x00, 0x00, 0x6D, 0xB6, 0xDB, 0x69, 0x2D,
  0x80, 0x00, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x06, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x5C, 0x00,
  0x80, 0x39, 0xF0, 0x10, 0x3E, 0x07, 0xC2, 0x1E, 0x00, 0x1E, 0x5F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x0C, 0x07, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x06, 0x00, 0x0E, 0x00, 0x80, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x31, 0x8C, 0xCE, 0x20, 0xFF,
  0xFF, 0xFF, 0xF0, 0x6F, 0xF6, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x03,
  0x80, 0xE0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x60, 0x00, 0x08, 0x30, 0x00,
  0x06, 0x10, 0x00, 0x03, 0x18, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x05, 0x80, 0x00, 0x02, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0,
  0x00, 0x06, 0x20, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x83,
  0x00, 0x01, 0x81, 0xC0, 0x01, 0x80, 0x60, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x07, 0x03, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x08,
  0x03, 0xC0, 0x7A, 0x0F, 0x13, 0xC0, 0xF8, 0x07, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x78,
  0x1E, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x18, 0x06, 0x00, 0x07, 0x03,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x10, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x02, 0x30, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x1C, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x0E,
  0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x30, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x62, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0x98, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x04, 0x18, 0x00, 0x03, 0x03, 0x00,
  0x01, 0x80, 0x70, 0x00, 0xC0, 0x0F, 0x01, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0x60, 0x80, 0x00, 0x0C, 0x08,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x18, 0x08, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x30, 0x08, 0x00, 0x06, 0x00, 0x80, 0x00, 0x60, 0x08, 0x00, 0x0C, 0x00,
  0x80, 0x00, 0xC0, 0x08, 0x00, 0x18, 0x00, 0x80, 0x03, 0x80, 0x08, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x08, 0x00, 0x60, 0x00, 0x80, 0x0C, 0x00,
  0x08, 0x00, 0xC0, 0x00, 0x80, 0x18, 0x00, 0x08, 0x03, 0x80, 0x00, 0x80,
  0x30, 0x00, 0x08, 0x06, 0x00, 0x00, 0x80, 0x60, 0x00, 0x08, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0xFE, 0x00,
  0x67, 0xFF, 0x80, 0x6E, 0x01, 0xE0, 0x78, 0x00, 0x70, 0x60, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x18, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x07, 0x01, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x1F, 0xC0, 0x10, 0x3F, 0xF8, 0x08, 0x70, 0x0E, 0x04, 0x60, 0x01, 0x86,
  0x60, 0x00, 0x63, 0x60, 0x00, 0x19, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x03,
  0x70, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x30,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x80, 0x01, 0x80,
  0xE0, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x02, 0x10, 0x00, 0x00, 0x42, 0x00, 0x00, 0x08,
  0x40, 0x00, 0x01, 0x08, 0x00, 0x00, 0x21, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x06,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x01, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30,
  0x38, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0x1E, 0x03, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xC0, 0x01,
  0xE0, 0x78, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0xC0, 0x00, 0xE0,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x01,
  0x30, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x05, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x60, 0x00, 0x07, 0xB0,
  0x00, 0x03, 0xCC, 0x00, 0x03, 0x66, 0x00, 0x01, 0xB1, 0x80, 0x01, 0x98,
  0x60, 0x03, 0x88, 0x1C, 0x03, 0x84, 0x07, 0xFF, 0x06, 0x00, 0xFE, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x6F, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xF6, 0x33, 0xDE, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x63, 0x18, 0xC6, 0x33, 0x98, 0xC6, 0x63, 0x31,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xE0, 0x0E, 0x03, 0x81, 0xC0, 0x1C,
  0x38, 0x00, 0xC3, 0x00, 0x06, 0x60, 0x00, 0x26, 0x00, 0x03, 0x40, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x38, 0x00, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0xFC, 0x00, 0x06, 0x0C,
  0x00, 0x07, 0xFE, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x0E, 0x00, 0x08, 0x30,
  0x00, 0x70, 0x06, 0x00, 0x18, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x31, 0x80,
  0x03, 0x00, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xCC, 0x00,
  0x10, 0x00, 0x60, 0x01, 0x98, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x30, 0x00,
  0x80, 0x01, 0x80, 0x02, 0x60, 0x03, 0x00, 0x03, 0x00, 0x04, 0x80, 0x06,
  0x00, 0x06, 0x00, 0x09, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x16, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x2C, 0x00, 0x60, 0x00, 0x30, 0x00, 0x58, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0xB0, 0x01, 0x80, 0x00, 0x80, 0x01, 0x60, 0x03, 0x00,
  0x01, 0x00, 0x02, 0xC0, 0x06, 0x00, 0x02, 0x00, 0x0D, 0x80, 0x0C, 0x00,
  0x0C, 0x00, 0x1B, 0x00, 0x10, 0x00, 0x18, 0x00, 0x36, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x6C, 0x00, 0x40, 0x00, 0x60, 0x00, 0xD8, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x30, 0x01, 0x80, 0x03, 0x80, 0x06, 0x20, 0x03, 0x00, 0x07,
  0x00, 0x0C, 0x40, 0x06, 0x00, 0x0E, 0x00, 0x10, 0xC0, 0x0C, 0x00, 0x3C,
  0x00, 0x61, 0x80, 0x0C, 0x00, 0xC8, 0x00, 0x83, 0x00, 0x18, 0x01, 0x18,
  0x03, 0x06, 0x00, 0x18, 0x06, 0x30, 0x0C, 0x06, 0x00, 0x38, 0x38, 0x38,
  0x70, 0x0C, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x18, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0xC0, 0x02, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x80, 0x03, 0x00, 0x01, 0x80, 0x01, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x00, 0x80,
  0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x40,
  0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x13,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x13, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x0E, 0x30, 0x00, 0x0F, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x0E,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x0E, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x78,
  0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x0E, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x18, 0x00,
  0x38, 0x1C, 0x00, 0x70, 0x07, 0x01, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x3E,
  0x00, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x18, 0x01, 0xC0, 0x00, 0xC0,
  0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x0F, 0x00, 0x00,
  0x18, 0x6C, 0x00, 0x00, 0xC6, 0x30, 0x00, 0x06, 0x61, 0xC0, 0x00, 0x36,
  0x06, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x60, 0x03,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0,
  0x06, 0x00, 0x07, 0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x0C,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFD, 0x00, 0x00, 0x00,
  0x03, 0x7B, 0x00, 0x00, 0x00, 0x06, 0xF6, 0x00, 0x00, 0x00, 0x09, 0xE4,
  0x00, 0x00, 0x00, 0x33, 0xCC, 0x00, 0x00, 0x00, 0x67, 0x98, 0x00, 0x00,
  0x00, 0x8F, 0x18, 0x00, 0x00, 0x03, 0x1E, 0x30, 0x00, 0x00, 0x06, 0x3C,
  0x20, 0x00, 0x00, 0x18, 0x78, 0x60, 0x00, 0x00, 0x30, 0xF0, 0xC0, 0x00,
  0x00, 0x41, 0xE0, 0x80, 0x00, 0x01, 0x83, 0xC1, 0x80, 0x00, 0x03, 0x07,
  0x83, 0x00, 0x00, 0x04, 0x0F, 0x03, 0x00, 0x00, 0x18, 0x1E, 0x06, 0x00,
  0x00, 0x30, 0x3C, 0x0C, 0x00, 0x00, 0xC0, 0x78, 0x0C, 0x00, 0x01, 0x80,
  0xF0, 0x18, 0x00, 0x02, 0x01, 0xE0, 0x10, 0x00, 0x0C, 0x03, 0xC0, 0x30,
  0x00, 0x18, 0x07, 0x80, 0x60, 0x00, 0x20, 0x0F, 0x00, 0x40, 0x00, 0xC0,
  0x1E, 0x00, 0xC0, 0x01, 0x80, 0x3C, 0x01, 0x80, 0x06, 0x00, 0x78, 0x01,
  0x80, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x18, 0x01, 0xE0, 0x02, 0x00, 0x60,
  0x03, 0xC0, 0x06, 0x00, 0xC0, 0x07, 0x80, 0x0C, 0x01, 0x00, 0x0F, 0x00,
  0x08, 0x06, 0x00, 0x1E, 0x00, 0x18, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x10,
  0x00, 0x78, 0x00, 0x30, 0x60, 0x00, 0xF0, 0x00, 0x60, 0xC0, 0x01, 0xE0,
  0x00, 0x43, 0x00, 0x03, 0xC0, 0x00, 0xC6, 0x00, 0x07, 0x80, 0x01, 0x88,
  0x00, 0x0F, 0x00, 0x01, 0x30, 0x00, 0x1E, 0x00, 0x03, 0x60, 0x00, 0x3C,
  0x00, 0x06, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xD8, 0x00,
  0x00, 0x0F, 0x60, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x00, 0xF3, 0x00, 0x00,
  0x03, 0xC6, 0x00, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x3C, 0x30, 0x00, 0x00,
  0xF0, 0x60, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x0F, 0x03, 0x00, 0x00, 0x3C,
  0x06, 0x00, 0x00, 0xF0, 0x18, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x0F, 0x00,
  0xC0, 0x00, 0x3C, 0x01, 0x80, 0x00, 0xF0, 0x06, 0x00, 0x03, 0xC0, 0x0C,
  0x00, 0x0F, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x60, 0x00, 0xF0, 0x00, 0xC0,
  0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x3C, 0x00, 0x0C, 0x00,
  0xF0, 0x00, 0x30, 0x03, 0xC0, 0x00, 0x60, 0x0F, 0x00, 0x01, 0x80, 0x3C,
  0x00, 0x03, 0x00, 0xF0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x18, 0x0F, 0x00,
  0x00, 0x30, 0x3C, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x01, 0x83, 0xC0, 0x00,
  0x06, 0x0F, 0x00, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0x18, 0xF0, 0x00, 0x00,
  0x63, 0xC0, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x03, 0x3C, 0x00, 0x00, 0x06,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x78, 0x07, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0C, 0x00, 0x03,
  0xC3, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x0E,
  0x30, 0x00, 0x0F, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1E,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x06, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x78, 0x07, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0xC0, 0x00, 0x3C, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18,
  0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x78, 0x07, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x60, 0x1E, 0x00, 0x0E, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xF0,
  0x07, 0xC0, 0x3C, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x08,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x04,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x02,
  0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0xC0, 0x02, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x31, 0x80, 0x00, 0x19, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00, 0x04,
  0x30, 0x00, 0x02, 0x30, 0x00, 0x06, 0x08, 0x00, 0x03, 0x08, 0x00, 0x03,
  0x06, 0x00, 0x01, 0x84, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x41, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x40, 0x00,
  0x60, 0x30, 0x00, 0x30, 0x20, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x02, 0x00,
  0x0C, 0x01, 0x00, 0x06, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x02, 0x00, 0xC0,
  0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x01, 0x00, 0x30, 0x01, 0x80, 0x10,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x40, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x30, 0x00,
  0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x18, 0x00, 0x30, 0x08, 0x00,
  0x30, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x06, 0x00,
  0x04, 0x02, 0x00, 0x06, 0x03, 0x00, 0x03, 0x03, 0x00, 0x01, 0x01, 0x00,
  0x01, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x20, 0x40, 0x00, 0x30, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x20,
  0x00, 0x0C, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x18,
  0x00, 0x01, 0x0C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x26, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x09, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0xE0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x0C, 0x38, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xD0, 0x00, 0x1B, 0x00, 0x02, 0x60,
  0x00, 0xC4, 0x00, 0x18, 0xC0, 0x02, 0x18, 0x00, 0xC1, 0x80, 0x18, 0x30,
  0x02, 0x06, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x00, 0x80, 0xC0, 0x18,
  0x18, 0x03, 0x06, 0x00, 0x20, 0xC0, 0x06, 0x18, 0x00, 0xC6, 0x00, 0x08,
  0xC0, 0x01, 0x98, 0x00, 0x36, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0x38,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x20, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0x00, 0x06,
  0x1C, 0x00, 0x06, 0x38, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x1A,
  0x60, 0x00, 0x12, 0x70, 0x00, 0x72, 0x38, 0x00, 0xE3, 0x1E, 0x03, 0x83,
  0x0F, 0xFF, 0x03, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x3E, 0x00, 0xC1, 0xFF, 0xC0, 0xC7, 0x80, 0xE0, 0xCE, 0x00, 0x30,
  0xD8, 0x00, 0x18, 0xD0, 0x00, 0x0C, 0xF0, 0x00, 0x0C, 0xE0, 0x00, 0x04,
  0xE0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x04, 0xE0, 0x00, 0x0C,
  0xF0, 0x00, 0x1C, 0xD8, 0x00, 0x18, 0xCC, 0x00, 0x30, 0xC7, 0x80, 0xE0,
  0xC1, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0x80, 0xF0, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x20, 0x00, 0x03,
  0x30, 0x00, 0x02, 0x30, 0x00, 0x06, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x0E, 0x00, 0x18, 0x07, 0x80, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x7C, 0x03, 0x03, 0xFF, 0x83,
  0x07, 0x01, 0xE3, 0x0C, 0x00, 0x73, 0x18, 0x00, 0x1B, 0x30, 0x00, 0x1B,
  0x30, 0x00, 0x0F, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x03,
  0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x07, 0x30, 0x00, 0x07, 0x30, 0x00, 0x0F, 0x18, 0x00, 0x1B,
  0x0C, 0x00, 0x33, 0x07, 0x01, 0xE3, 0x03, 0xFF, 0x83, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0xC0, 0x07,
  0x00, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x16, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x02, 0x06, 0x00, 0x03, 0x01, 0xC0,
  0x03, 0x00, 0x78, 0x07, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x3F, 0xC0, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0xFF, 0xFE, 0x7F,
  0xFF, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x04, 0x1C, 0x07, 0x88, 0x60,
  0x03, 0x91, 0x80, 0x01, 0xA6, 0x00, 0x03, 0x4C, 0x00, 0x03, 0xB0, 0x00,
  0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x58, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00,
  0x0E, 0x30, 0x00, 0x34, 0x30, 0x00, 0xC8, 0x38, 0x0F, 0x10, 0x3F, 0xF8,
  0x20, 0x0F, 0x80, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x66,
  0x00, 0x01, 0x86, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x07, 0x00, 0x70, 0x07,
  0xFF, 0xC0, 0x01, 0xFC, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x07, 0x80,
  0x60, 0x7F, 0xE0, 0xC1, 0xC0, 0xE1, 0x8E, 0x00, 0x63, 0x18, 0x00, 0x66,
  0x60, 0x00, 0xCD, 0x80, 0x00, 0xDA, 0x00, 0x01, 0xBC, 0x00, 0x03, 0x70,
  0x00, 0x02, 0xE0, 0x00, 0x05, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x5F, 0xF0, 0x00, 0x00,
  0x00, 0x1B, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6C, 0x00, 0x40, 0x1C, 0x03, 0x80, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x18, 0x06, 0x3F, 0x87, 0xC0, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xC3, 0x00,
  0x03, 0x86, 0x00, 0x0E, 0x0C, 0x00, 0x38, 0x18, 0x00, 0xE0, 0x30, 0x01,
  0x80, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x60, 0x03, 0x01, 0x80,
  0x06, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x60, 0x00, 0x31, 0xC0, 0x00,
  0x67, 0xC0, 0x00, 0xCD, 0x80, 0x01, 0xB1, 0x80, 0x03, 0xC1, 0x80, 0x07,
  0x03, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0E, 0x06, 0x00,
  0x0C, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x18, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0x0E, 0x03,
  0x80, 0xF0, 0x3C, 0x63, 0x00, 0x18, 0x38, 0x01, 0x8C, 0xC0, 0x01, 0x8C,
  0x00, 0x19, 0x90, 0x00, 0x33, 0x80, 0x01, 0xB6, 0x00, 0x02, 0x60, 0x00,
  0x37, 0x80, 0x00, 0x78, 0x00, 0x06, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x40, 0x00, 0x07, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x20, 0x00,
  0x03, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x78, 0x00, 0x00, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x10, 0x00, 0x01, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x40, 0x00, 0x07, 0x80, 0x00, 0x08, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x20, 0x00, 0x03, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x10, 0x00, 0x01,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x40, 0x00, 0x07, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x20, 0x00, 0x03, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x78, 0x00, 0x00, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x10, 0x00, 0x01, 0xE0, 0x00, 0x02, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x1E, 0x01, 0x81, 0xFF, 0x83,
  0x07, 0x03, 0x86, 0x38, 0x01, 0x8C, 0x60, 0x01, 0x99, 0x80, 0x03, 0x36,
  0x00, 0x03, 0x68, 0x00, 0x06, 0xF0, 0x00, 0x0D, 0xC0, 0x00, 0x0B, 0x80,
  0x00, 0x17, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xE0, 0x3C, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01,
  0x90, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x0E, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0xF0, 0x1E, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xC1, 0xFF, 0xC0, 0xC7, 0x00,
  0xE0, 0xCE, 0x00, 0x30, 0xD8, 0x00, 0x18, 0xD0, 0x00, 0x0C, 0xF0, 0x00,
  0x0C, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xE0, 0x00,
  0x04, 0xE0, 0x00, 0x0C, 0xF0, 0x00, 0x0C, 0xD8, 0x00, 0x18, 0xCC, 0x00,
  0x30, 0xC7, 0x80, 0xE0, 0xC1, 0xFF, 0xC0, 0xC0, 0x7E, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x04, 0x1C, 0x07, 0x88, 0x60, 0x03,
  0x91, 0x80, 0x03, 0xA6, 0x00, 0x03, 0x4C, 0x00, 0x03, 0xB0, 0x00, 0x03,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x58, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x0E,
  0x30, 0x00, 0x34, 0x30, 0x00, 0xC8, 0x38, 0x0F, 0x10, 0x3F, 0xF8, 0x20,
  0x0F, 0x80, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x3F, 0x07, 0xFC, 0x38, 0x31, 0x80, 0xCC,
  0x03, 0x60, 0x0D, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x1F, 0xFE, 0x01, 0xE0, 0x3C, 0x0E, 0x00, 0x18, 0x60, 0x00, 0x31, 0x80,
  0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x0B, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0xC3, 0x80, 0x06, 0x07, 0x80, 0x70,
  0x07, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x03, 0xFF, 0xF7, 0xFF, 0xE0, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1F, 0xC0, 0x0F, 0x00, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x76, 0x00, 0x00, 0xEC, 0x00,
  0x01, 0xD8, 0x00, 0x07, 0x98, 0x00, 0x1B, 0x38, 0x00, 0x76, 0x38, 0x01,
  0xCC, 0x38, 0x0F, 0x18, 0x3F, 0xF8, 0x30, 0x0F, 0x80, 0x00, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x10,
  0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x01, 0x00, 0x03, 0x00,
  0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x10, 0x00, 0x40, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C,
  0x00, 0x10, 0x04, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x01, 0x01,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x0C,
  0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x10, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x19, 0x00, 0x00, 0xE0, 0x00, 0x33, 0x00, 0x01, 0xC0, 0x00, 0x66, 0x00,
  0x06, 0x80, 0x00, 0xCC, 0x00, 0x0D, 0x80, 0x03, 0x18, 0x00, 0x13, 0x00,
  0x06, 0x18, 0x00, 0x66, 0x00, 0x0C, 0x30, 0x00, 0xC4, 0x00, 0x18, 0x60,
  0x01, 0x8C, 0x00, 0x60, 0xC0, 0x02, 0x18, 0x00, 0xC0, 0xC0, 0x0C, 0x30,
  0x01, 0x81, 0x80, 0x18, 0x30, 0x03, 0x03, 0x00, 0x30, 0x60, 0x0C, 0x06,
  0x00, 0x40, 0xC0, 0x18, 0x06, 0x01, 0x81, 0x80, 0x30, 0x0C, 0x03, 0x01,
  0x80, 0x60, 0x18, 0x04, 0x03, 0x01, 0x80, 0x30, 0x18, 0x06, 0x03, 0x00,
  0x30, 0x30, 0x04, 0x06, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x00, 0xC0, 0x80,
  0x18, 0x30, 0x01, 0x83, 0x00, 0x30, 0x60, 0x01, 0x86, 0x00, 0x20, 0xC0,
  0x03, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x10, 0x00, 0xC6, 0x00, 0x0C, 0x60,
  0x00, 0x8C, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x19, 0x00, 0x03, 0x30,
  0x00, 0x32, 0x00, 0x06, 0x40, 0x00, 0x6C, 0x00, 0x05, 0x80, 0x00, 0x58,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x01, 0x81,
  0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x03, 0x00, 0x60, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x18, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x02, 0x60, 0x00, 0x03, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0x83, 0x00, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0xC0, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x70, 0x00, 0x60,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x18, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0xC0,
  0x00, 0x18, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0,
  0x18, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x06,
  0x00, 0x06, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x02, 0x30, 0x00, 0x01,
  0x98, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0C,
  0xE0, 0x70, 0x00, 0x19, 0x80, 0x70, 0x00, 0x36, 0x00, 0x70, 0x00, 0x4C,
  0x00, 0x70, 0x01, 0xB0, 0x00, 0x70, 0x03, 0x60, 0x00, 0x70, 0x0C, 0xC0,
  0x00, 0x70, 0x31, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
};

const GFXglyph RobotoCondensed_Thin68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 49, 13, 5, -48 },
  { 20, 9, 14, 18, 5, -51 },
  { 36, 32, 48, 33, 2, -48 },
  { 228, 25, 62, 33, 4, -55 },
  { 422, 36, 50, 44, 4, -49 },
  { 647, 30, 50, 36, 4, -49 },
  { 835, 3, 14, 11, 4, -51 },
  { 841, 12, 70, 19, 5, -54 },
  { 946, 13, 70, 19, 1, -54 },
  { 1060, 27, 26, 28, 1, -48 },
  { 1148, 28, 36, 34, 3, -41 },
  { 1274, 5, 14, 13, 3, -5 },
  { 1283, 14, 2, 18, 2, -23 },
  { 1287, 4, 4, 15, 5, -3 },
  { 1289, 19, 52, 23, 2, -48 },
  { 1413, 25, 50, 33, 4, -49 },
  { 1570, 13, 48, 33, 6, -48 },
  { 1648, 26, 49, 33, 4, -49 },
  { 1808, 26, 50, 33, 3, -49 },
  { 1971, 28, 48, 33, 3, -48 },
  { 2139, 24, 49, 33, 6, -48 },
  { 2286, 25, 49, 33, 4, -48 },
  { 2440, 26, 48, 33, 3, -48 },
  { 2596, 27, 50, 33, 3, -49 },
  { 2765, 25, 49, 33, 4, -49 },
  { 2919, 4, 36, 12, 4, -35 },
  { 2937, 5, 44, 12, 3, -35 },
  { 2965, 24, 27, 31, 3, -36 },
  { 3046, 23, 16, 33, 5, -30 },
  { 3092, 23, 27, 31, 4, -36 },
  { 3170, 20, 50, 27, 3, -49 },
  { 3295, 47, 62, 55, 4, -47 },
  { 3660, 32, 48, 36, 2, -48 },
  { 3852, 26, 48, 36, 6, -48 },
  { 4008, 29, 50, 39, 5, -49 },
  { 4190, 28, 48, 39, 6, -48 },
  { 4358, 25, 48, 34, 6, -48 },
  { 4508, 26, 48, 34, 6, -48 },
  { 4664, 29, 50, 41, 6, -49 },
  { 4846, 30, 48, 42, 6, -48 },
  { 5026, 2, 48, 16, 7, -48 },
  { 5038, 24, 49, 33, 3, -48 },
  { 5185, 29, 48, 38, 6, -48 },
  { 5359, 23, 48, 31, 6, -48 },
  { 5497, 39, 48, 51, 6, -48 },
  { 5731, 30, 48, 42, 6, -48 },
  { 5911, 30, 50, 40, 5, -49 },
  { 6099, 26, 48, 36, 6, -48 },
  { 6255, 30, 58, 40, 5, -49 },
  { 6473, 28, 48, 39, 6, -48 },
  { 6641, 29, 50, 35, 3, -49 },
  { 6823, 32, 48, 36, 2, -48 },
  { 7015, 28, 49, 40, 6, -48 },
  { 7187, 32, 48, 36, 2, -48 },
  { 7379, 49, 48, 53, 2, -48 },
  { 7673, 32, 48, 36, 2, -48 },
  { 7865, 32, 48, 36, 2, -48 },
  { 8057, 29, 48, 36, 3, -48 },
  { 8231, 8, 65, 14, 6, -55 },
  { 8296, 19, 52, 23, 2, -48 },
  { 8420, 9, 65, 14, 0, -55 },
  { 8494, 19, 24, 25, 3, -48 },
  { 8551, 24, 2, 25, 1, 0 },
  { 8557, 9, 9, 18, 5, -51 },
  { 8568, 24, 38, 32, 3, -37 },
  { 8682, 24, 52, 33, 5, -51 },
  { 8838, 24, 38, 31, 3, -37 },
  { 8952, 24, 52, 33, 4, -51 },
  { 9108, 25, 38, 31, 3, -37 },
  { 9227, 17, 52, 20, 2, -52 },
  { 9338, 23, 51, 33, 4, -37 },
  { 9485, 23, 51, 33, 5, -51 },
  { 9632, 3, 50, 13, 5, -50 },
  { 9651, 11, 64, 14, -3, -50 },
  { 9739, 23, 51, 29, 5, -51 },
  { 9886, 2, 51, 13, 6, -51 },
  { 9899, 43, 37, 53, 5, -37 },
  { 10098, 23, 37, 33, 5, -37 },
  { 10205, 25, 38, 33, 4, -37 },
  { 10324, 24, 51, 33, 5, -37 },
  { 10477, 23, 51, 33, 4, -37 },
  { 10624, 14, 37, 21, 5, -37 },
  { 10689, 22, 38, 30, 4, -37 },
  { 10794, 15, 47, 20, 2, -46 },
  { 10883, 23, 37, 33, 5, -36 },
  { 10990, 25, 36, 29, 2, -36 },
  { 11103, 39, 36, 45, 3, -36 },
  { 11279, 25, 36, 29, 2, -36 },
  { 11392, 25, 50, 29, 2, -36 },
  { 11549, 24, 36, 29, 3, -36 },
  { 11657, 16, 68, 20, 3, -53 },
  { 11793, 2, 57, 14, 6, -48 },
  { 11808, 16, 68, 20, 1, -53 },
  { 11944, 31, 11, 41, 5, -26 },
};

const GFXfont RobotoCondensed_Thin68pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin68pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin68pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _ROBOTOCONDENSED_THIN68PT7B_H_
