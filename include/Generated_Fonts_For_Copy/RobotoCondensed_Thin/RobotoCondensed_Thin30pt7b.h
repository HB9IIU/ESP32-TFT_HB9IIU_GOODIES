#ifndef _ROBOTOCONDENSED_THIN30PT7B_H_
#define _ROBOTOCONDENSED_THIN30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin30pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0x00, 0xA0, 0x99, 0x99, 0x99, 0x04, 0x10,
  0x10, 0x40, 0x42, 0x01, 0x08, 0x04, 0x20, 0x10, 0x87, 0xFF, 0xC2, 0x08,
  0x08, 0x40, 0x21, 0x00, 0x84, 0x02, 0x10, 0x08, 0x40, 0x21, 0x01, 0x04,
  0x3F, 0xFE, 0x10, 0x80, 0x42, 0x01, 0x08, 0x04, 0x20, 0x20, 0x80, 0x82,
  0x00, 0x04, 0x00, 0x80, 0x10, 0x0F, 0x82, 0x08, 0x80, 0x90, 0x14, 0x01,
  0x80, 0x30, 0x01, 0x00, 0x20, 0x02, 0x00, 0x38, 0x00, 0xC0, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x50, 0x13, 0x04, 0x1F, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x78, 0x00, 0x84, 0x00, 0x84, 0x00, 0x82, 0x10,
  0x82, 0x10, 0x82, 0x20, 0x82, 0x20, 0x84, 0x40, 0x84, 0x40, 0x78, 0x80,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x1C, 0x02, 0x22, 0x04, 0x41, 0x04, 0x41,
  0x08, 0x41, 0x08, 0x41, 0x10, 0x41, 0x10, 0x41, 0x00, 0x22, 0x00, 0x1C,
  0x1E, 0x01, 0x08, 0x08, 0x20, 0x81, 0x04, 0x08, 0x20, 0x40, 0x84, 0x04,
  0x40, 0x14, 0x00, 0xC0, 0x06, 0x00, 0x48, 0x04, 0x40, 0xC1, 0x0A, 0x04,
  0x50, 0x12, 0x80, 0x94, 0x03, 0x20, 0x09, 0x00, 0xC4, 0x09, 0x1F, 0x84,
  0xFC, 0x04, 0x21, 0x04, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x81, 0x04, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20,
  0x40, 0x84, 0x10, 0x42, 0x10, 0x42, 0x10, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x42, 0x11, 0x08, 0x44, 0x42, 0x00, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x42, 0x31, 0xAC, 0x07, 0x00, 0x50, 0x09, 0x00, 0x88,
  0x10, 0x42, 0x06, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x1F, 0xFF, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x24, 0xA5, 0x00, 0xFC, 0x30, 0x01, 0x01, 0x02,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x1E, 0x04, 0x31,
  0x02, 0x20, 0x28, 0x05, 0x00, 0xA0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x50, 0x09, 0x01, 0x20,
  0x42, 0x18, 0x3C, 0x00, 0x0C, 0xDC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x1E, 0x0C, 0x31,
  0x02, 0x40, 0x28, 0x05, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x04, 0x01, 0xFF, 0xC0, 0x1F, 0x04, 0x11, 0x01, 0x40, 0x28, 0x05, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x40, 0x30, 0x78, 0x00, 0xC0, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x30, 0x06, 0x01, 0x60, 0x26, 0x08, 0x3E, 0x00, 0x00,
  0x40, 0x06, 0x00, 0x50, 0x02, 0x80, 0x24, 0x01, 0x20, 0x11, 0x00, 0x88,
  0x08, 0x40, 0x42, 0x04, 0x10, 0x40, 0x82, 0x04, 0x20, 0x21, 0x01, 0x1F,
  0xFF, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x7F,
  0xD0, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xBE, 0x30, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02,
  0x41, 0x0F, 0x80, 0x07, 0x81, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20,
  0x04, 0x00, 0x9F, 0x14, 0x13, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x05, 0x01, 0x20, 0x22, 0x08, 0x3E, 0x00, 0xFF, 0xF0,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x1F, 0x0C, 0x11, 0x01, 0x40,
  0x28, 0x03, 0x00, 0x60, 0x0C, 0x02, 0x40, 0x44, 0x10, 0x7C, 0x10, 0xC4,
  0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x26, 0x08,
  0x3E, 0x00, 0x1E, 0x04, 0x31, 0x02, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x34, 0x0A, 0xC2, 0x47, 0x90, 0x02,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20, 0x78, 0x00, 0x30, 0x00, 0x00,
  0x0A, 0x4C, 0x00, 0x00, 0x00, 0x00, 0x12, 0x49, 0x40, 0x00, 0x20, 0x18,
  0x0C, 0x06, 0x03, 0x00, 0x80, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x10, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x0C, 0x0C, 0x0C, 0x04, 0x06,
  0x02, 0x00, 0x1E, 0x10, 0x90, 0x30, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x40, 0x01, 0xFC, 0x00, 0x20, 0x30, 0x0C, 0x00, 0x81, 0x80,
  0x04, 0x10, 0x00, 0x22, 0x00, 0x02, 0x40, 0x78, 0x14, 0x08, 0x41, 0x41,
  0x04, 0x18, 0x20, 0x41, 0x82, 0x04, 0x18, 0x20, 0x41, 0x82, 0x04, 0x18,
  0x40, 0x41, 0x84, 0x04, 0x18, 0x40, 0x81, 0x84, 0x08, 0x18, 0x40, 0x81,
  0x82, 0x14, 0x28, 0x21, 0x44, 0x81, 0xE3, 0x84, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x3F,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00,
  0x88, 0x02, 0x10, 0x08, 0x40, 0x41, 0x01, 0x02, 0x04, 0x08, 0x20, 0x20,
  0x80, 0x43, 0xFF, 0x08, 0x04, 0x40, 0x09, 0x00, 0x24, 0x00, 0xA0, 0x02,
  0x80, 0x06, 0x00, 0x10, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x28, 0x03, 0x00,
  0x60, 0x0C, 0x02, 0x80, 0x50, 0x13, 0xFC, 0x40, 0x48, 0x05, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x28, 0x0D, 0xFE, 0x00, 0x0F,
  0xC0, 0x81, 0x08, 0x04, 0x80, 0x24, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x0A, 0x00, 0x50, 0x04, 0x40, 0x21, 0x02, 0x07, 0xC0, 0xFF,
  0x08, 0x08, 0x80, 0x48, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x28, 0x04, 0x80, 0x8F, 0xF0, 0xFF, 0xF0, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0xFF, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x03, 0xFF, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x00, 0x0F, 0xC0,
  0x40, 0xC2, 0x01, 0x10, 0x02, 0x40, 0x09, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x81, 0xFE, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00, 0x48, 0x03, 0x10, 0x10, 0x3F,
  0x80, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFF, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0xFF, 0xFF, 0xFC, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x80, 0x30, 0x05, 0x01, 0x20, 0x22, 0x08, 0x3E, 0x00, 0x80,
  0x34, 0x01, 0x20, 0x11, 0x01, 0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0x80,
  0x88, 0x04, 0x80, 0x2C, 0x01, 0x90, 0x0C, 0x40, 0x41, 0x02, 0x08, 0x10,
  0x20, 0x80, 0x84, 0x04, 0x20, 0x11, 0x00, 0x48, 0x01, 0x40, 0x08, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x3F, 0xF0, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x5A,
  0x00, 0x2D, 0x00, 0x26, 0x80, 0x13, 0x20, 0x09, 0x90, 0x08, 0xC8, 0x04,
  0x62, 0x02, 0x31, 0x02, 0x18, 0x81, 0x0C, 0x20, 0x86, 0x10, 0x83, 0x08,
  0x41, 0x82, 0x20, 0xC1, 0x20, 0x60, 0x50, 0x30, 0x30, 0x18, 0x18, 0x0C,
  0x04, 0x04, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x40, 0x1A, 0x00, 0xC8, 0x06,
  0x40, 0x31, 0x01, 0x88, 0x0C, 0x20, 0x60, 0x83, 0x04, 0x18, 0x10, 0xC0,
  0x86, 0x02, 0x30, 0x11, 0x80, 0x4C, 0x02, 0x60, 0x0B, 0x00, 0x38, 0x01,
  0xC0, 0x04, 0x0F, 0xC0, 0xC0, 0x82, 0x01, 0x10, 0x02, 0x80, 0x0A, 0x00,
  0x28, 0x00, 0xA0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x02, 0x80, 0x0A, 0x00, 0x24, 0x00, 0x88,
  0x04, 0x30, 0x20, 0x3F, 0x00, 0xFF, 0x10, 0x1A, 0x01, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x40, 0x6F, 0xF1, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x00,
  0x0F, 0xC0, 0xC0, 0x82, 0x01, 0x10, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00,
  0xA0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x02, 0x80, 0x0A, 0x00, 0x24, 0x00, 0x88, 0x04, 0x30,
  0x20, 0x3F, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0xFF, 0x08,
  0x0C, 0x80, 0x48, 0x02, 0x80, 0x28, 0x02, 0x80, 0x18, 0x02, 0x80, 0x28,
  0x02, 0x80, 0x48, 0x0C, 0xFF, 0x08, 0x10, 0x81, 0x08, 0x08, 0x80, 0x88,
  0x04, 0x80, 0x48, 0x02, 0x80, 0x18, 0x01, 0x0F, 0xC0, 0x81, 0x08, 0x04,
  0x80, 0x14, 0x00, 0xA0, 0x05, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00,
  0x50, 0x02, 0x80, 0x23, 0x03, 0x07, 0xE0, 0xFF, 0xFC, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x24, 0x02, 0x60, 0x41, 0xF0, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x90, 0x02, 0x40, 0x09, 0x00, 0x22, 0x01, 0x08, 0x04, 0x20, 0x10, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x21, 0x00, 0x84, 0x02, 0x20, 0x04,
  0x80, 0x12, 0x00, 0x48, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x80, 0x20,
  0x06, 0x00, 0xC0, 0x24, 0x03, 0x00, 0x90, 0x14, 0x02, 0x40, 0x50, 0x09,
  0x01, 0x20, 0x44, 0x04, 0x81, 0x08, 0x22, 0x04, 0x20, 0x88, 0x10, 0x82,
  0x10, 0x42, 0x08, 0x42, 0x08, 0x41, 0x08, 0x11, 0x04, 0x20, 0x44, 0x08,
  0x81, 0x10, 0x24, 0x04, 0x80, 0x90, 0x0A, 0x02, 0x40, 0x28, 0x05, 0x00,
  0xA0, 0x14, 0x03, 0x00, 0x60, 0x04, 0x01, 0x80, 0x10, 0x02, 0x00, 0x80,
  0x09, 0x00, 0x22, 0x01, 0x08, 0x04, 0x10, 0x20, 0x41, 0x00, 0x84, 0x02,
  0x20, 0x04, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x05, 0x00, 0x12, 0x00,
  0x84, 0x02, 0x10, 0x10, 0x20, 0x80, 0x82, 0x01, 0x10, 0x04, 0x40, 0x0A,
  0x00, 0x10, 0x80, 0x06, 0x00, 0x24, 0x00, 0x90, 0x04, 0x20, 0x10, 0x80,
  0x81, 0x02, 0x04, 0x10, 0x08, 0x40, 0x22, 0x00, 0x48, 0x01, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x7F, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x7F, 0xFC, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x80, 0x80, 0x40, 0x40,
  0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04,
  0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0xF1, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x08,
  0x0C, 0x05, 0x02, 0x82, 0x41, 0x10, 0x88, 0x84, 0x41, 0x20, 0xA0, 0x40,
  0xFF, 0xE0, 0xC4, 0x21, 0x1F, 0x04, 0x19, 0x01, 0x20, 0x14, 0x02, 0x00,
  0x40, 0x08, 0xFF, 0x20, 0x28, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x80, 0xD0,
  0x69, 0xF1, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0xF8, 0xA0, 0x98, 0x0A, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x2C, 0x05, 0x41, 0x27, 0xC0, 0x1F, 0x04,
  0x19, 0x01, 0x20, 0x14, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x20, 0x14, 0x02, 0x80, 0x48, 0x10, 0xFC, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0xF9, 0x41, 0xD0, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x40, 0x50, 0x33,
  0xF4, 0x0F, 0x86, 0x09, 0x00, 0xA0, 0x14, 0x03, 0x00, 0x7F, 0xFC, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x0C, 0x10, 0x7C, 0x0F,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0xFE, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x3E, 0x50,
  0x74, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x50, 0x14, 0x1C, 0xF9, 0x00, 0x40, 0x10, 0x04, 0x01, 0x60,
  0x87, 0xC0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x3C,
  0x90, 0xA8, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x30, 0x0A, 0xAA, 0xAA, 0xAA,
  0xA0, 0x00, 0xC0, 0x00, 0x00, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x85, 0xC0, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x02, 0x81, 0x20, 0x88, 0x22, 0x10, 0x88, 0x24,
  0x0B, 0x03, 0x20, 0x84, 0x21, 0x08, 0x22, 0x04, 0x81, 0x20, 0x28, 0x04,
  0xFF, 0xFF, 0xFE, 0x8F, 0x0F, 0x96, 0x12, 0x0A, 0x81, 0x80, 0xE0, 0x30,
  0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40,
  0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80,
  0x60, 0x10, 0x0C, 0x02, 0x01, 0x8F, 0x24, 0x2A, 0x07, 0x01, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x1F, 0x04, 0x11, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x04, 0x80, 0x88, 0x20, 0xF8, 0x9F,
  0x14, 0x13, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x05, 0x80, 0xA8, 0x24, 0xF8, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x00, 0x3E, 0x50, 0x74, 0x0E, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x14,
  0x0C, 0xFD, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x9E, 0x8C,
  0x30, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x3E, 0x20,
  0xA0, 0x30, 0x18, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x20, 0x18,
  0x0C, 0x05, 0x04, 0x7C, 0x20, 0x82, 0x08, 0xFC, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x81, 0x07, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50,
  0x36, 0x1C, 0x79, 0x80, 0x30, 0x05, 0x01, 0x20, 0x24, 0x04, 0x81, 0x08,
  0x21, 0x04, 0x21, 0x02, 0x20, 0x44, 0x09, 0x00, 0xA0, 0x14, 0x01, 0x00,
  0x20, 0x80, 0x80, 0xA0, 0x60, 0x50, 0x30, 0x28, 0x28, 0x14, 0x14, 0x11,
  0x09, 0x08, 0x84, 0x84, 0x44, 0x42, 0x22, 0x12, 0x09, 0x09, 0x04, 0x84,
  0x82, 0x82, 0x41, 0x40, 0xC0, 0xA0, 0x60, 0x20, 0x30, 0x10, 0x08, 0x80,
  0x48, 0x08, 0x82, 0x10, 0x81, 0x10, 0x24, 0x02, 0x80, 0x20, 0x0C, 0x01,
  0x40, 0x44, 0x08, 0x82, 0x08, 0x81, 0x10, 0x14, 0x01, 0x80, 0x30, 0x05,
  0x01, 0x20, 0x24, 0x04, 0x41, 0x08, 0x21, 0x04, 0x11, 0x02, 0x20, 0x44,
  0x05, 0x00, 0xA0, 0x14, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x01, 0xC0, 0x00, 0x7F, 0xC0, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10,
  0x07, 0xFF, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x20, 0xC0, 0x20, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x02, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x04, 0x03, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x20, 0xC0, 0x38, 0x05, 0x18, 0x18, 0x30, 0xA0, 0x62, 0x80,
  0x70,
};

const GFXglyph RobotoCondensed_Thin30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 22, 6, 2, -22 },
  { 7, 4, 6, 8, 2, -23 },
  { 10, 14, 22, 15, 1, -22 },
  { 49, 11, 28, 15, 2, -25 },
  { 88, 16, 22, 20, 2, -22 },
  { 132, 13, 22, 16, 2, -22 },
  { 168, 1, 6, 5, 2, -23 },
  { 169, 6, 31, 8, 2, -24 },
  { 193, 5, 31, 8, 1, -24 },
  { 213, 12, 12, 13, 0, -22 },
  { 231, 13, 15, 15, 1, -18 },
  { 256, 3, 6, 6, 1, -2 },
  { 259, 6, 1, 8, 1, -10 },
  { 260, 2, 2, 6, 2, -2 },
  { 261, 8, 24, 10, 1, -22 },
  { 285, 11, 22, 15, 2, -22 },
  { 316, 6, 22, 15, 3, -22 },
  { 333, 11, 22, 15, 2, -22 },
  { 364, 11, 22, 15, 2, -22 },
  { 395, 13, 22, 15, 1, -22 },
  { 431, 10, 22, 15, 3, -22 },
  { 459, 11, 22, 15, 2, -22 },
  { 490, 12, 22, 15, 1, -22 },
  { 523, 11, 22, 15, 2, -22 },
  { 554, 11, 22, 15, 2, -22 },
  { 585, 2, 16, 5, 2, -16 },
  { 589, 3, 20, 5, 1, -16 },
  { 597, 11, 12, 14, 1, -16 },
  { 614, 10, 7, 15, 2, -13 },
  { 623, 10, 12, 14, 2, -16 },
  { 638, 9, 22, 12, 1, -22 },
  { 663, 20, 28, 24, 2, -21 },
  { 733, 14, 22, 16, 1, -22 },
  { 772, 11, 22, 16, 3, -22 },
  { 803, 13, 22, 17, 2, -22 },
  { 839, 12, 22, 17, 3, -22 },
  { 872, 11, 22, 15, 3, -22 },
  { 903, 11, 22, 15, 3, -22 },
  { 934, 14, 22, 18, 2, -22 },
  { 973, 13, 22, 18, 3, -22 },
  { 1009, 1, 22, 7, 3, -22 },
  { 1012, 11, 22, 15, 1, -22 },
  { 1043, 13, 22, 17, 3, -22 },
  { 1079, 10, 22, 14, 3, -22 },
  { 1107, 17, 22, 22, 3, -22 },
  { 1154, 13, 22, 19, 3, -22 },
  { 1190, 14, 22, 18, 2, -22 },
  { 1229, 11, 22, 16, 3, -22 },
  { 1260, 14, 26, 18, 2, -22 },
  { 1306, 12, 22, 17, 3, -22 },
  { 1339, 13, 22, 16, 1, -22 },
  { 1375, 14, 22, 16, 1, -22 },
  { 1414, 12, 22, 17, 3, -22 },
  { 1447, 14, 22, 16, 1, -22 },
  { 1486, 22, 22, 24, 1, -22 },
  { 1547, 14, 22, 16, 1, -22 },
  { 1586, 14, 22, 16, 1, -22 },
  { 1625, 13, 22, 16, 1, -22 },
  { 1661, 4, 29, 6, 2, -24 },
  { 1676, 8, 24, 10, 1, -22 },
  { 1700, 4, 29, 6, 0, -24 },
  { 1715, 9, 11, 11, 1, -22 },
  { 1728, 11, 1, 11, 0, 0 },
  { 1730, 4, 4, 8, 2, -23 },
  { 1732, 11, 16, 14, 1, -16 },
  { 1754, 11, 23, 15, 2, -23 },
  { 1786, 11, 16, 13, 1, -16 },
  { 1808, 10, 23, 15, 2, -23 },
  { 1837, 11, 16, 14, 1, -16 },
  { 1859, 8, 23, 9, 1, -23 },
  { 1882, 10, 22, 15, 2, -16 },
  { 1910, 10, 23, 14, 2, -23 },
  { 1939, 2, 22, 6, 2, -22 },
  { 1945, 5, 28, 6, -1, -22 },
  { 1963, 10, 23, 13, 2, -23 },
  { 1992, 1, 23, 6, 2, -23 },
  { 1995, 19, 16, 23, 2, -16 },
  { 2033, 10, 16, 15, 2, -16 },
  { 2053, 11, 16, 15, 2, -16 },
  { 2075, 11, 22, 15, 2, -16 },
  { 2106, 10, 22, 15, 2, -16 },
  { 2134, 6, 16, 9, 2, -16 },
  { 2146, 9, 16, 13, 2, -16 },
  { 2164, 6, 20, 9, 1, -20 },
  { 2179, 10, 16, 15, 2, -16 },
  { 2199, 11, 16, 13, 1, -16 },
  { 2221, 17, 16, 20, 1, -16 },
  { 2255, 11, 16, 13, 1, -16 },
  { 2277, 11, 22, 13, 1, -16 },
  { 2308, 11, 16, 13, 1, -16 },
  { 2330, 8, 29, 9, 1, -23 },
  { 2359, 1, 26, 6, 3, -22 },
  { 2363, 8, 29, 9, 0, -23 },
  { 2392, 14, 5, 18, 2, -11 },
};

const GFXfont RobotoCondensed_Thin30pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin30pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin30pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _ROBOTOCONDENSED_THIN30PT7B_H_
