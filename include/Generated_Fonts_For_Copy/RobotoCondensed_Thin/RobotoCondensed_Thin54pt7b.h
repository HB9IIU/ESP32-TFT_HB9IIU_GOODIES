#ifndef _ROBOTOCONDENSED_THIN54PT7B_H_
#define _ROBOTOCONDENSED_THIN54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin54pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0x87, 0x0E, 0x18, 0x00, 0x20, 0x18,
  0x00, 0x10, 0x0C, 0x00, 0x08, 0x04, 0x00, 0x0C, 0x02, 0x00, 0x06, 0x01,
  0x00, 0x03, 0x00, 0x80, 0x01, 0x00, 0xC0, 0x00, 0x80, 0x60, 0x00, 0x40,
  0x20, 0x00, 0x20, 0x10, 0x00, 0x30, 0x08, 0x0F, 0xFF, 0xFF, 0xF0, 0x08,
  0x06, 0x00, 0x04, 0x03, 0x00, 0x02, 0x01, 0x80, 0x01, 0x00, 0x80, 0x01,
  0x80, 0x40, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x10, 0x00, 0x20, 0x18, 0x00,
  0x10, 0x0C, 0x00, 0x08, 0x04, 0x00, 0x04, 0x02, 0x00, 0x06, 0x01, 0x00,
  0x03, 0x00, 0x80, 0x01, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x40, 0x20,
  0x00, 0x20, 0x10, 0x00, 0x30, 0x08, 0x00, 0x18, 0x04, 0x00, 0x08, 0x06,
  0x00, 0x04, 0x03, 0x00, 0x02, 0x01, 0x80, 0x01, 0x00, 0x80, 0x01, 0x80,
  0x40, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x10, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x03,
  0xFE, 0x00, 0xE0, 0x30, 0x18, 0x01, 0x81, 0x00, 0x0C, 0x30, 0x00, 0x62,
  0x00, 0x06, 0x60, 0x00, 0x26, 0x00, 0x02, 0x60, 0x00, 0x36, 0x00, 0x03,
  0x60, 0x00, 0x36, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x22, 0x00, 0x06,
  0x30, 0x00, 0x61, 0x80, 0x0C, 0x0E, 0x03, 0x80, 0x3F, 0xE0, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x04, 0x02, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00,
  0x40, 0x18, 0x10, 0x02, 0x00, 0x80, 0x80, 0x10, 0x0C, 0x04, 0x00, 0x80,
  0xC0, 0x20, 0x04, 0x04, 0x01, 0x00, 0x20, 0x60, 0x0C, 0x01, 0x02, 0x00,
  0x60, 0x18, 0x30, 0x01, 0x00, 0xC1, 0x00, 0x0C, 0x0C, 0x18, 0x00, 0x30,
  0xC0, 0x80, 0x00, 0xFC, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x3F,
  0x00, 0x01, 0x03, 0x0C, 0x00, 0x18, 0x30, 0x30, 0x00, 0x81, 0x00, 0x80,
  0x0C, 0x18, 0x06, 0x00, 0x40, 0x80, 0x10, 0x06, 0x04, 0x00, 0x80, 0x20,
  0x20, 0x04, 0x03, 0x01, 0x00, 0x20, 0x10, 0x08, 0x01, 0x01, 0x80, 0x40,
  0x08, 0x08, 0x02, 0x00, 0x40, 0xC0, 0x18, 0x06, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x06, 0x00, 0x0C,
  0x02, 0x00, 0x0C, 0x03, 0x00, 0x08, 0x01, 0x00, 0x18, 0x01, 0x00, 0x18,
  0x01, 0x00, 0x18, 0x01, 0x00, 0x18, 0x01, 0x00, 0x18, 0x03, 0x00, 0x08,
  0x02, 0x00, 0x08, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x06,
  0x30, 0x00, 0x02, 0x40, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x06,
  0xC0, 0x00, 0x04, 0x40, 0x00, 0x08, 0x60, 0x00, 0x10, 0x30, 0x02, 0x30,
  0x18, 0x02, 0x60, 0x08, 0x02, 0x60, 0x0C, 0x06, 0x40, 0x06, 0x06, 0xC0,
  0x03, 0x04, 0xC0, 0x01, 0x04, 0x80, 0x01, 0x8C, 0x80, 0x00, 0xC8, 0xC0,
  0x00, 0x78, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x30, 0x60, 0x00, 0x78, 0x20,
  0x00, 0xCC, 0x30, 0x01, 0x84, 0x1C, 0x07, 0x02, 0x07, 0xFC, 0x03, 0x00,
  0x40, 0x00, 0xFF, 0xE0, 0x00, 0x80, 0x20, 0x10, 0x08, 0x06, 0x01, 0x00,
  0xC0, 0x20, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x03,
  0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x10,
  0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80,
  0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x40,
  0x10, 0x08, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x18, 0x04, 0x07, 0xF0, 0x20, 0xF0, 0xF1, 0x1C,
  0x00, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x6C, 0x00, 0x06,
  0x30, 0x00, 0x20, 0x80, 0x03, 0x06, 0x00, 0x30, 0x18, 0x03, 0x00, 0x60,
  0x18, 0x01, 0x81, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x11, 0x11, 0x11,
  0x33, 0x66, 0x40, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x06, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x01,
  0x83, 0x00, 0x0C, 0x20, 0x00, 0x42, 0x00, 0x06, 0x60, 0x00, 0x64, 0x00,
  0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00,
  0x34, 0x00, 0x02, 0x40, 0x00, 0x26, 0x00, 0x06, 0x20, 0x00, 0x62, 0x00,
  0x04, 0x30, 0x00, 0xC1, 0x80, 0x18, 0x0C, 0x03, 0x00, 0x60, 0x70, 0x03,
  0xFC, 0x00, 0x04, 0x00, 0x00, 0x40, 0xF0, 0xE4, 0xE1, 0xE0, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0x81, 0xC0,
  0x30, 0x03, 0x03, 0x00, 0x08, 0x10, 0x00, 0x61, 0x80, 0x01, 0x08, 0x00,
  0x08, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x0E, 0x03, 0x01, 0x80, 0x18, 0x30, 0x00, 0xC2,
  0x00, 0x04, 0x60, 0x00, 0x64, 0x00, 0x02, 0x40, 0x00, 0x2C, 0x00, 0x02,
  0xC0, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x3E, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x02,
  0x60, 0x00, 0x63, 0x00, 0x04, 0x18, 0x00, 0x80, 0xE0, 0x30, 0x03, 0xFE,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x68, 0x00, 0x00, 0x90, 0x00, 0x03, 0x20, 0x00,
  0x04, 0x40, 0x00, 0x10, 0x80, 0x00, 0x61, 0x00, 0x00, 0x82, 0x00, 0x03,
  0x04, 0x00, 0x04, 0x08, 0x00, 0x18, 0x10, 0x00, 0x20, 0x20, 0x00, 0xC0,
  0x40, 0x03, 0x00, 0x80, 0x04, 0x01, 0x00, 0x18, 0x02, 0x00, 0x20, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x00, 0x10, 0x06, 0x00, 0x20, 0x18, 0x00, 0x40,
  0x30, 0x00, 0x80, 0xC0, 0x01, 0x01, 0x00, 0x02, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xFF, 0xC8, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x3F, 0x01, 0x38, 0xF0, 0x70, 0x06, 0x18, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x90, 0x00, 0x26, 0x00, 0x18,
  0xC0, 0x0C, 0x1C, 0x06, 0x01, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x0F, 0xC0, 0x43, 0xCF, 0x04, 0xC0,
  0x18, 0x58, 0x00, 0xCD, 0x00, 0x04, 0xE0, 0x00, 0x6E, 0x00, 0x02, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x03,
  0x60, 0x00, 0x36, 0x00, 0x02, 0x20, 0x00, 0x63, 0x00, 0x04, 0x18, 0x00,
  0xC0, 0xC0, 0x18, 0x07, 0x03, 0x00, 0x1F, 0xE0, 0x00, 0x20, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0x81, 0xC0, 0x30,
  0x03, 0x03, 0x00, 0x0C, 0x10, 0x00, 0x31, 0x80, 0x01, 0x88, 0x00, 0x04,
  0x40, 0x00, 0x22, 0x00, 0x01, 0x90, 0x00, 0x0C, 0x80, 0x00, 0x64, 0x00,
  0x02, 0x20, 0x00, 0x11, 0x80, 0x01, 0x86, 0x00, 0x08, 0x10, 0x00, 0xC0,
  0x60, 0x1C, 0x01, 0xE7, 0x80, 0x07, 0xF8, 0x00, 0xE0, 0x70, 0x0C, 0x00,
  0xC0, 0xC0, 0x03, 0x0C, 0x00, 0x0C, 0x40, 0x00, 0x36, 0x00, 0x01, 0xA0,
  0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x0E, 0x00, 0x00,
  0x50, 0x00, 0x02, 0xC0, 0x00, 0x16, 0x00, 0x01, 0x98, 0x00, 0x08, 0x40,
  0x00, 0xC3, 0x80, 0x0C, 0x0E, 0x01, 0xC0, 0x1F, 0xF8, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x3F, 0xC0, 0x0E, 0x07, 0x01, 0x80, 0x38, 0x30, 0x01,
  0x82, 0x00, 0x0C, 0x60, 0x00, 0x44, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00,
  0x02, 0x80, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34,
  0x00, 0x07, 0x60, 0x00, 0x72, 0x00, 0x0B, 0x30, 0x01, 0xB1, 0x80, 0x73,
  0x0F, 0x1C, 0x20, 0x3F, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0xE4, 0x37, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x33, 0x33, 0x33, 0x26, 0x4C, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x02, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x38, 0x18, 0x20, 0x0C, 0x60, 0x04,
  0xC0, 0x06, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x7C, 0x00, 0x61, 0x00, 0x0E, 0x70, 0x01, 0x18, 0x00,
  0xC0, 0xC0, 0x08, 0xC0, 0x0C, 0x03, 0x00, 0x44, 0x00, 0xC0, 0x18, 0x03,
  0x60, 0x04, 0x00, 0xC0, 0x1B, 0x00, 0x60, 0x06, 0x00, 0x50, 0x02, 0x00,
  0x20, 0x02, 0x80, 0x30, 0x01, 0x00, 0x14, 0x01, 0x80, 0x08, 0x00, 0xA0,
  0x08, 0x00, 0x40, 0x07, 0x00, 0x40, 0x02, 0x00, 0x38, 0x02, 0x00, 0x10,
  0x01, 0xC0, 0x30, 0x00, 0x80, 0x0E, 0x01, 0x80, 0x04, 0x00, 0xF0, 0x0C,
  0x00, 0x20, 0x07, 0x80, 0x60, 0x03, 0x00, 0x3C, 0x03, 0x00, 0x18, 0x01,
  0x60, 0x18, 0x00, 0xC0, 0x09, 0x00, 0xC0, 0x06, 0x00, 0xC8, 0x02, 0x00,
  0x70, 0x04, 0x40, 0x10, 0x02, 0x80, 0x22, 0x00, 0xC0, 0x24, 0x03, 0x18,
  0x02, 0x03, 0x30, 0x30, 0xC0, 0x18, 0x30, 0xC3, 0x02, 0x00, 0x7F, 0x03,
  0xF0, 0x18, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x03, 0x10, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x18, 0x20, 0x00, 0x04, 0x08, 0x00, 0x01, 0x03, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x20, 0x10, 0x00, 0x08, 0x06, 0x00, 0x06, 0x00,
  0x80, 0x01, 0x80, 0x20, 0x00, 0x40, 0x0C, 0x00, 0x30, 0x01, 0x00, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x80, 0x02, 0x00, 0x60, 0x00, 0x80,
  0x10, 0x00, 0x30, 0x04, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x00, 0xFF, 0xFF,
  0xE0, 0x20, 0x00, 0x18, 0x18, 0x00, 0x02, 0x04, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x04, 0x20, 0x00, 0x01, 0x88, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x09, 0x80, 0x00, 0x02, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x10, 0xFF, 0xF8, 0x04, 0x00, 0xF0, 0x20, 0x00, 0xE1, 0x00, 0x01, 0x88,
  0x00, 0x04, 0x40, 0x00, 0x32, 0x00, 0x01, 0x90, 0x00, 0x04, 0x80, 0x00,
  0x24, 0x00, 0x01, 0x20, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x02, 0x40,
  0x00, 0x32, 0x00, 0x01, 0x10, 0x00, 0x18, 0x80, 0x01, 0x84, 0x00, 0xF0,
  0x3F, 0xFF, 0x81, 0x00, 0x07, 0x08, 0x00, 0x0C, 0x40, 0x00, 0x32, 0x00,
  0x00, 0x90, 0x00, 0x06, 0x80, 0x00, 0x14, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x50, 0x00,
  0x02, 0x80, 0x00, 0x34, 0x00, 0x01, 0x20, 0x00, 0x19, 0x00, 0x03, 0x88,
  0x00, 0xF0, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1C,
  0x03, 0x80, 0x60, 0x01, 0x81, 0x80, 0x01, 0x86, 0x00, 0x01, 0x08, 0x00,
  0x03, 0x30, 0x00, 0x02, 0x40, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x50, 0x00, 0x01, 0xA0, 0x00,
  0x03, 0x60, 0x00, 0x04, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x20, 0xC0, 0x00,
  0xC0, 0xC0, 0x03, 0x00, 0xE0, 0x1C, 0x00, 0x7F, 0xE0, 0x00, 0x08, 0x00,
  0xFF, 0xF8, 0x02, 0x00, 0x78, 0x08, 0x00, 0x38, 0x20, 0x00, 0x30, 0x80,
  0x00, 0x62, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x20, 0x00, 0x06, 0x80, 0x00,
  0x0A, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x28, 0x00,
  0x01, 0xA0, 0x00, 0x04, 0x80, 0x00, 0x32, 0x00, 0x01, 0x88, 0x00, 0x0C,
  0x20, 0x00, 0xE0, 0x80, 0x3E, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xC8, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xC8, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF,
  0xC0, 0x03, 0x80, 0x70, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x10, 0x00,
  0x04, 0x30, 0x00, 0x06, 0x20, 0x00, 0x02, 0x60, 0x00, 0x02, 0x40, 0x00,
  0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00,
  0x01, 0x60, 0x00, 0x01, 0x60, 0x00, 0x01, 0x20, 0x00, 0x01, 0x30, 0x00,
  0x01, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x1C, 0x03, 0x80,
  0x78, 0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x02, 0x80,
  0x00, 0x50, 0x00, 0x1A, 0x00, 0x03, 0x60, 0x00, 0x44, 0x00, 0x18, 0xC0,
  0x02, 0x0C, 0x00, 0xC0, 0xC0, 0x70, 0x0F, 0xF8, 0x00, 0x10, 0x00, 0x80,
  0x00, 0x19, 0x00, 0x00, 0x32, 0x00, 0x00, 0xC4, 0x00, 0x03, 0x08, 0x00,
  0x0C, 0x10, 0x00, 0x30, 0x20, 0x00, 0xC0, 0x40, 0x01, 0x80, 0x80, 0x06,
  0x01, 0x00, 0x18, 0x02, 0x00, 0x60, 0x04, 0x01, 0x80, 0x08, 0x06, 0x00,
  0x10, 0x08, 0x00, 0x20, 0x30, 0x00, 0x40, 0xC0, 0x00, 0x83, 0x00, 0x01,
  0x0E, 0x00, 0x02, 0x36, 0x00, 0x04, 0xC4, 0x00, 0x0B, 0x0C, 0x00, 0x14,
  0x0C, 0x00, 0x30, 0x0C, 0x00, 0x40, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x18, 0x02, 0x00, 0x10, 0x04, 0x00, 0x30, 0x08, 0x00, 0x30, 0x10, 0x00,
  0x30, 0x20, 0x00, 0x20, 0x40, 0x00, 0x60, 0x80, 0x00, 0x61, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x44, 0x00, 0x00, 0xC8, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x3F, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE8, 0x00, 0x00, 0x05, 0xB0, 0x00, 0x00, 0x16, 0xC0, 0x00,
  0x00, 0xD9, 0x00, 0x00, 0x02, 0x66, 0x00, 0x00, 0x09, 0x88, 0x00, 0x00,
  0x66, 0x20, 0x00, 0x01, 0x18, 0xC0, 0x00, 0x0C, 0x61, 0x00, 0x00, 0x31,
  0x86, 0x00, 0x00, 0x86, 0x18, 0x00, 0x06, 0x18, 0x20, 0x00, 0x10, 0x60,
  0xC0, 0x00, 0x41, 0x81, 0x00, 0x03, 0x06, 0x04, 0x00, 0x08, 0x18, 0x18,
  0x00, 0x20, 0x60, 0x20, 0x01, 0x81, 0x80, 0x80, 0x04, 0x06, 0x03, 0x00,
  0x30, 0x18, 0x04, 0x00, 0x80, 0x60, 0x18, 0x02, 0x01, 0x80, 0x20, 0x18,
  0x06, 0x00, 0x80, 0x40, 0x18, 0x03, 0x01, 0x00, 0x60, 0x04, 0x0C, 0x01,
  0x80, 0x10, 0x20, 0x06, 0x00, 0x61, 0x80, 0x18, 0x00, 0x84, 0x00, 0x60,
  0x03, 0x10, 0x01, 0x80, 0x04, 0xC0, 0x06, 0x00, 0x12, 0x00, 0x18, 0x00,
  0x68, 0x00, 0x60, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xA0,
  0x00, 0x03, 0xB0, 0x00, 0x03, 0x98, 0x00, 0x03, 0x88, 0x00, 0x03, 0x8C,
  0x00, 0x03, 0x84, 0x00, 0x03, 0x86, 0x00, 0x03, 0x83, 0x00, 0x03, 0x81,
  0x00, 0x03, 0x81, 0x80, 0x03, 0x80, 0x80, 0x03, 0x80, 0xC0, 0x03, 0x80,
  0x60, 0x03, 0x80, 0x60, 0x03, 0x80, 0x30, 0x03, 0x80, 0x10, 0x03, 0x80,
  0x18, 0x03, 0x80, 0x08, 0x03, 0x80, 0x0C, 0x03, 0x80, 0x06, 0x03, 0x80,
  0x02, 0x03, 0x80, 0x03, 0x03, 0x80, 0x01, 0x03, 0x80, 0x01, 0x83, 0x80,
  0x00, 0xC3, 0x80, 0x00, 0x43, 0x80, 0x00, 0x63, 0x80, 0x00, 0x23, 0x80,
  0x00, 0x33, 0x80, 0x00, 0x1B, 0x80, 0x00, 0x1B, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x04, 0x40, 0x00, 0x06, 0x40, 0x00, 0x06, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x06, 0x60, 0x00, 0x06, 0x20,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x07,
  0x00, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xFF, 0xFC, 0x04, 0x00,
  0x78, 0x20, 0x00, 0x71, 0x00, 0x00, 0x88, 0x00, 0x06, 0x40, 0x00, 0x1A,
  0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x50,
  0x00, 0x02, 0x80, 0x00, 0x34, 0x00, 0x03, 0x20, 0x00, 0x19, 0x00, 0x03,
  0x88, 0x01, 0xF0, 0x7F, 0xFE, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0x18, 0x30, 0x00, 0x08, 0x60, 0x00, 0x04, 0x40, 0x00, 0x06,
  0x40, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0xFF, 0xFC, 0x02, 0x00, 0x3C, 0x08,
  0x00, 0x1C, 0x20, 0x00, 0x18, 0x80, 0x00, 0x22, 0x00, 0x00, 0xC8, 0x00,
  0x01, 0x20, 0x00, 0x06, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x28, 0x00, 0x00,
  0xA0, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x68, 0x00, 0x01, 0xA0,
  0x00, 0x04, 0x80, 0x00, 0x32, 0x00, 0x00, 0x88, 0x00, 0x06, 0x20, 0x00,
  0x30, 0x80, 0x0F, 0x03, 0xFF, 0xF0, 0x08, 0x00, 0x40, 0x20, 0x01, 0x80,
  0x80, 0x02, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x10, 0x20, 0x00, 0x60, 0x80,
  0x00, 0x82, 0x00, 0x03, 0x08, 0x00, 0x04, 0x20, 0x00, 0x18, 0x80, 0x00,
  0x32, 0x00, 0x00, 0xC8, 0x00, 0x01, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x10, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x38, 0x07, 0x00,
  0xC0, 0x03, 0x83, 0x00, 0x01, 0x04, 0x00, 0x03, 0x18, 0x00, 0x02, 0x20,
  0x00, 0x06, 0x40, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x04, 0x80, 0x00, 0x19, 0x80, 0x00, 0x31, 0x80, 0x00, 0xC1, 0x80,
  0x03, 0x01, 0xE0, 0x1C, 0x00, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x02, 0x40, 0x00, 0x19, 0x80, 0x00, 0x43, 0x00, 0x03, 0x0E, 0x00, 0x18,
  0x0E, 0x01, 0xC0, 0x1F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x36, 0x00, 0x00, 0x09, 0x80, 0x00, 0x02, 0x20, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x10, 0x40, 0x00, 0x0C, 0x10,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x80, 0x80, 0x00, 0x60, 0x20, 0x00, 0x18,
  0x0C, 0x00, 0x04, 0x01, 0x00, 0x03, 0x00, 0x40, 0x00, 0xC0, 0x18, 0x00,
  0x20, 0x02, 0x00, 0x18, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x00, 0x04,
  0x00, 0x40, 0x01, 0x00, 0x30, 0x00, 0x60, 0x08, 0x00, 0x18, 0x02, 0x00,
  0x02, 0x01, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x30, 0x10, 0x00, 0x04, 0x0C,
  0x00, 0x01, 0x02, 0x00, 0x00, 0x60, 0x80, 0x00, 0x08, 0x60, 0x00, 0x02,
  0x10, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x13, 0x00, 0x00, 0x04, 0x80, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x05, 0x80, 0x00, 0x60, 0x00, 0x0B, 0x00,
  0x00, 0xE0, 0x00, 0x12, 0x00, 0x01, 0x40, 0x00, 0x64, 0x00, 0x06, 0x80,
  0x00, 0xCC, 0x00, 0x09, 0x00, 0x01, 0x18, 0x00, 0x13, 0x00, 0x02, 0x10,
  0x00, 0x22, 0x00, 0x0C, 0x20, 0x00, 0xC4, 0x00, 0x18, 0x60, 0x01, 0x08,
  0x00, 0x20, 0xC0, 0x02, 0x18, 0x00, 0x41, 0x80, 0x04, 0x10, 0x01, 0x81,
  0x00, 0x18, 0x20, 0x03, 0x02, 0x00, 0x20, 0x60, 0x06, 0x06, 0x00, 0x40,
  0xC0, 0x08, 0x0C, 0x01, 0x80, 0x80, 0x10, 0x08, 0x03, 0x01, 0x00, 0x60,
  0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x00, 0x60, 0x30,
  0x04, 0x02, 0x00, 0x40, 0x60, 0x08, 0x0C, 0x00, 0x80, 0x80, 0x18, 0x18,
  0x01, 0x81, 0x00, 0x30, 0x20, 0x03, 0x06, 0x00, 0x20, 0x40, 0x06, 0x0C,
  0x00, 0x41, 0x80, 0x04, 0x10, 0x00, 0xC3, 0x00, 0x08, 0x20, 0x01, 0x86,
  0x00, 0x18, 0xC0, 0x01, 0x08, 0x00, 0x31, 0x80, 0x02, 0x10, 0x00, 0x22,
  0x00, 0x06, 0x60, 0x00, 0x44, 0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x09,
  0x00, 0x01, 0xB0, 0x00, 0x12, 0x00, 0x01, 0x40, 0x00, 0x3C, 0x00, 0x02,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x03, 0x30, 0x00,
  0x01, 0x08, 0x00, 0x01, 0x86, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0xC0, 0x30, 0x00, 0x40, 0x08, 0x00, 0x60, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x10, 0x00, 0x08, 0x18, 0x00,
  0x06, 0x08, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x40,
  0x00, 0x01, 0x30, 0x00, 0x01, 0x88, 0x00, 0x01, 0x86, 0x00, 0x00, 0x81,
  0x80, 0x00, 0xC0, 0x40, 0x00, 0x40, 0x30, 0x00, 0x60, 0x08, 0x00, 0x60,
  0x06, 0x00, 0x20, 0x01, 0x80, 0x30, 0x00, 0x40, 0x10, 0x00, 0x30, 0x18,
  0x00, 0x08, 0x18, 0x00, 0x06, 0x08, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x04, 0x10, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x60, 0x30, 0x00, 0x10, 0x04, 0x00, 0x0C, 0x01,
  0x80, 0x02, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x01, 0x00, 0x30,
  0x00, 0x60, 0x08, 0x00, 0x08, 0x06, 0x00, 0x03, 0x01, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x18, 0x60, 0x00, 0x02, 0x10, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0xF0, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x06, 0xFE, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1F,
  0xF0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x16, 0x00, 0x24, 0x00, 0xC8,
  0x01, 0x18, 0x02, 0x10, 0x0C, 0x20, 0x10, 0x60, 0x60, 0x40, 0xC0, 0xC1,
  0x01, 0x86, 0x01, 0x0C, 0x03, 0x10, 0x06, 0x60, 0x04, 0xC0, 0x0D, 0x00,
  0x18, 0xFF, 0xFF, 0xF0, 0xC0, 0xC0, 0xC1, 0x81, 0x81, 0x81, 0x00, 0x00,
  0x40, 0x01, 0xFF, 0x01, 0xC0, 0x60, 0xC0, 0x04, 0x60, 0x01, 0x90, 0x00,
  0x24, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x3F, 0xFC, 0x3E, 0x03, 0x38,
  0x00, 0xD8, 0x00, 0x34, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x3D,
  0x80, 0x19, 0x30, 0x18, 0x47, 0xFC, 0x10, 0x30, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x7F, 0xC1, 0x98, 0x0C, 0x36, 0x00, 0xC7, 0x80, 0x0C, 0xE0,
  0x00, 0xD8, 0x00, 0x1B, 0x00, 0x01, 0x60, 0x00, 0x2C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x6E, 0x00,
  0x09, 0xC0, 0x03, 0x34, 0x00, 0xC6, 0x60, 0x30, 0xC7, 0xFC, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x70, 0x1C, 0x18, 0x00, 0xC2, 0x00,
  0x08, 0xC0, 0x01, 0x90, 0x00, 0x16, 0x00, 0x02, 0xC0, 0x00, 0x50, 0x00,
  0x0E, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0xF0, 0x00, 0x16, 0x00, 0x02, 0x40, 0x00,
  0x4C, 0x00, 0x18, 0x80, 0x02, 0x18, 0x00, 0xC1, 0xC0, 0x70, 0x0F, 0xF8,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x20, 0x30, 0x7F, 0xC6, 0x18, 0x0C,
  0xC6, 0x00, 0xD9, 0x80, 0x0F, 0x20, 0x00, 0xEC, 0x00, 0x0D, 0x00, 0x01,
  0xA0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x0D,
  0x00, 0x01, 0xB0, 0x00, 0x32, 0x00, 0x06, 0x60, 0x01, 0xC6, 0x00, 0x58,
  0x60, 0x33, 0x07, 0xFC, 0x60, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x06, 0x03, 0x80, 0xC0, 0x1C, 0x18, 0x00, 0xC3, 0x00, 0x06, 0x20, 0x00,
  0x26, 0x00, 0x02, 0x60, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x06, 0x07, 0x01, 0xC0, 0x3F, 0xF0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0xC0, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x7F, 0xF8,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0xFF, 0x8C, 0x30, 0x19, 0x8C, 0x01, 0xB3, 0x00, 0x1E, 0x40, 0x01,
  0xD8, 0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xD0, 0x00, 0x1A, 0x00, 0x03, 0x60, 0x00, 0x64, 0x00, 0x1C,
  0xC0, 0x03, 0x8C, 0x00, 0xB0, 0xC0, 0x66, 0x0F, 0xF8, 0xC0, 0x10, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x22,
  0x00, 0x0C, 0x60, 0x01, 0x07, 0x00, 0xE0, 0x38, 0x70, 0x01, 0xF8, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x80, 0xC3, 0xFC, 0x31, 0x81, 0x8C, 0xC0, 0x33, 0x60, 0x06,
  0xF0, 0x00, 0xB8, 0x00, 0x2E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x40, 0xDF, 0x00, 0x00,
  0x00, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92,
  0x00, 0x80, 0x70, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x0C,
  0x03, 0x23, 0x87, 0x80, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01, 0xB0, 0x00, 0xCC,
  0x00, 0x63, 0x00, 0x30, 0xC0, 0x18, 0x30, 0x0C, 0x0C, 0x02, 0x03, 0x01,
  0x00, 0xC0, 0xC0, 0x30, 0x60, 0x0C, 0x30, 0x03, 0x18, 0x00, 0xCC, 0x00,
  0x37, 0x80, 0x0F, 0x30, 0x03, 0x84, 0x00, 0xC1, 0x80, 0x30, 0x30, 0x0C,
  0x06, 0x03, 0x00, 0x80, 0xC0, 0x30, 0x30, 0x06, 0x0C, 0x00, 0x83, 0x00,
  0x30, 0xC0, 0x06, 0x30, 0x00, 0x8C, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x20, 0x20,
  0xFF, 0x00, 0xFF, 0x08, 0x60, 0x60, 0x60, 0x72, 0x20, 0x0C, 0x20, 0x04,
  0x90, 0x01, 0x90, 0x01, 0xAC, 0x00, 0x2C, 0x00, 0x2A, 0x00, 0x0A, 0x00,
  0x0F, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x20, 0x30, 0xFF, 0x0C, 0x60, 0x63, 0x30, 0x0C,
  0xD8, 0x01, 0xBC, 0x00, 0x2E, 0x00, 0x0B, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x0E, 0x07, 0x01, 0x80, 0x18, 0x30, 0x00, 0xC2,
  0x00, 0x04, 0x60, 0x00, 0x64, 0x00, 0x02, 0x40, 0x00, 0x2C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x24, 0x00, 0x02, 0x60,
  0x00, 0x62, 0x00, 0x04, 0x30, 0x00, 0xC1, 0x80, 0x18, 0x0E, 0x07, 0x00,
  0x3F, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0xFF, 0x83, 0x30, 0x18,
  0x6C, 0x01, 0x8F, 0x00, 0x19, 0xC0, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x02,
  0xC0, 0x00, 0x58, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x16,
  0x00, 0x02, 0xC0, 0x00, 0xDC, 0x00, 0x13, 0x80, 0x06, 0x68, 0x01, 0x8C,
  0xC0, 0x61, 0x8F, 0xF8, 0x30, 0x10, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x8C,
  0x30, 0x19, 0x8C, 0x01, 0xB3, 0x00, 0x1E, 0x40, 0x01, 0xD8, 0x00, 0x1A,
  0x00, 0x03, 0x40, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x06, 0x80, 0x00, 0xD0,
  0x00, 0x1A, 0x00, 0x03, 0x60, 0x00, 0x64, 0x00, 0x0C, 0xC0, 0x03, 0x8C,
  0x00, 0xF0, 0xC0, 0x66, 0x0F, 0xF8, 0xC0, 0x10, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x58, 0x7F,
  0x30, 0x6C, 0x0D, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x07, 0xFC, 0x0E, 0x03, 0x8C, 0x00, 0x64,
  0x00, 0x12, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x50, 0x00,
  0x6C, 0x00, 0x63, 0x80, 0xE0, 0x7F, 0xE0, 0x02, 0x00, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x0F, 0xFF, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x1F, 0x00, 0x40, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x03, 0x60,
  0x01, 0xD8, 0x00, 0xF3, 0x00, 0x6C, 0x60, 0x33, 0x0F, 0xF8, 0xC0, 0x20,
  0x00, 0x40, 0x00, 0x14, 0x00, 0x01, 0x60, 0x00, 0x32, 0x00, 0x02, 0x20,
  0x00, 0x23, 0x00, 0x06, 0x10, 0x00, 0x41, 0x00, 0x04, 0x18, 0x00, 0xC0,
  0x80, 0x08, 0x08, 0x00, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0x00, 0x40, 0x10,
  0x06, 0x03, 0x00, 0x60, 0x20, 0x02, 0x02, 0x00, 0x30, 0x60, 0x03, 0x06,
  0x00, 0x10, 0x40, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x00, 0x88, 0x00, 0x09,
  0x80, 0x00, 0xD8, 0x00, 0x05, 0x00, 0x00, 0x50, 0x00, 0x07, 0x00, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x80, 0x03, 0x00, 0x0D, 0x00, 0x0E,
  0x00, 0x1B, 0x00, 0x14, 0x00, 0x26, 0x00, 0x2C, 0x00, 0xC4, 0x00, 0x58,
  0x01, 0x88, 0x01, 0x90, 0x03, 0x18, 0x02, 0x20, 0x04, 0x30, 0x04, 0x60,
  0x18, 0x20, 0x18, 0xC0, 0x30, 0x40, 0x30, 0x80, 0x60, 0xC0, 0x41, 0x00,
  0x81, 0x80, 0x83, 0x03, 0x01, 0x03, 0x06, 0x06, 0x02, 0x06, 0x04, 0x0C,
  0x06, 0x08, 0x0C, 0x10, 0x0C, 0x10, 0x18, 0x20, 0x08, 0x60, 0x10, 0xC0,
  0x10, 0x80, 0x21, 0x80, 0x31, 0x00, 0x62, 0x00, 0x62, 0x00, 0xC4, 0x00,
  0x4C, 0x00, 0x98, 0x00, 0x90, 0x01, 0x30, 0x01, 0x20, 0x03, 0x40, 0x03,
  0x40, 0x02, 0x80, 0x03, 0x80, 0x05, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x4C, 0x00, 0x18,
  0x80, 0x02, 0x18, 0x00, 0xC1, 0x80, 0x30, 0x30, 0x04, 0x03, 0x01, 0x80,
  0x20, 0x20, 0x06, 0x0C, 0x00, 0x43, 0x00, 0x0C, 0x40, 0x00, 0xD8, 0x00,
  0x0A, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x05, 0x00, 0x01, 0xB0, 0x00,
  0x22, 0x00, 0x0C, 0x60, 0x03, 0x04, 0x00, 0x40, 0xC0, 0x18, 0x0C, 0x02,
  0x00, 0x80, 0xC0, 0x18, 0x30, 0x01, 0x84, 0x00, 0x31, 0x80, 0x03, 0x20,
  0x00, 0x2C, 0x00, 0x06, 0x40, 0x00, 0x12, 0x00, 0x00, 0x98, 0x00, 0x0C,
  0x40, 0x00, 0x62, 0x00, 0x02, 0x18, 0x00, 0x30, 0x40, 0x01, 0x82, 0x00,
  0x08, 0x18, 0x00, 0xC0, 0x40, 0x06, 0x02, 0x00, 0x20, 0x18, 0x03, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x80, 0x18, 0x0C, 0x00, 0x40, 0x60, 0x02, 0x02,
  0x00, 0x18, 0x30, 0x00, 0x41, 0x80, 0x02, 0x08, 0x00, 0x18, 0x40, 0x00,
  0x46, 0x00, 0x02, 0x20, 0x00, 0x19, 0x00, 0x00, 0x58, 0x00, 0x02, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x07, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0xC0, 0x3C, 0x01, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x80, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x1E, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x40, 0x00,
  0x0F, 0x80, 0x00, 0x39, 0xC0, 0x01, 0x60, 0x60, 0x01, 0x40, 0x30, 0x01,
  0x40, 0x18, 0x03, 0xC0, 0x0C, 0x02, 0x80, 0x06, 0x06, 0x80, 0x03, 0x8C,
  0x00, 0x00, 0xF8,
};

const GFXglyph RobotoCondensed_Thin54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 2, 39, 10, 4, -38 },
  { 11, 7, 11, 14, 4, -41 },
  { 21, 25, 38, 26, 2, -38 },
  { 140, 20, 50, 26, 3, -44 },
  { 265, 29, 40, 35, 3, -39 },
  { 410, 24, 40, 29, 3, -39 },
  { 530, 1, 11, 9, 4, -41 },
  { 532, 10, 55, 15, 4, -43 },
  { 601, 10, 55, 15, 1, -43 },
  { 670, 21, 21, 23, 1, -38 },
  { 726, 22, 27, 27, 2, -31 },
  { 801, 4, 11, 10, 2, -4 },
  { 807, 10, 1, 15, 2, -18 },
  { 809, 3, 3, 12, 4, -2 },
  { 811, 15, 41, 19, 1, -38 },
  { 888, 20, 40, 26, 3, -39 },
  { 988, 10, 38, 26, 5, -38 },
  { 1036, 21, 39, 26, 3, -39 },
  { 1139, 20, 40, 26, 3, -39 },
  { 1239, 23, 38, 26, 2, -38 },
  { 1349, 18, 39, 26, 5, -38 },
  { 1437, 20, 39, 26, 3, -38 },
  { 1535, 21, 38, 26, 2, -38 },
  { 1635, 21, 40, 26, 3, -39 },
  { 1740, 20, 39, 26, 3, -39 },
  { 1838, 4, 28, 9, 3, -27 },
  { 1852, 4, 34, 9, 2, -27 },
  { 1869, 19, 21, 25, 2, -28 },
  { 1919, 18, 11, 27, 4, -23 },
  { 1944, 19, 21, 25, 3, -28 },
  { 1994, 16, 40, 21, 3, -39 },
  { 2074, 37, 49, 43, 3, -37 },
  { 2301, 26, 38, 29, 1, -38 },
  { 2425, 21, 38, 29, 5, -38 },
  { 2525, 23, 40, 31, 4, -39 },
  { 2640, 22, 38, 31, 5, -38 },
  { 2745, 20, 38, 27, 5, -38 },
  { 2840, 20, 38, 27, 5, -38 },
  { 2935, 24, 40, 32, 4, -39 },
  { 3055, 23, 38, 33, 5, -38 },
  { 3165, 1, 38, 13, 6, -38 },
  { 3170, 19, 39, 26, 2, -38 },
  { 3263, 23, 38, 30, 5, -38 },
  { 3373, 18, 38, 25, 5, -38 },
  { 3459, 30, 38, 40, 5, -38 },
  { 3602, 24, 38, 33, 5, -38 },
  { 3716, 24, 40, 32, 4, -39 },
  { 3836, 21, 38, 29, 5, -38 },
  { 3936, 24, 46, 32, 4, -39 },
  { 4074, 22, 38, 31, 5, -38 },
  { 4179, 23, 40, 28, 3, -39 },
  { 4294, 25, 38, 28, 2, -38 },
  { 4413, 22, 39, 31, 5, -38 },
  { 4521, 26, 38, 28, 1, -38 },
  { 4645, 39, 38, 42, 2, -38 },
  { 4831, 25, 38, 28, 2, -38 },
  { 4950, 26, 38, 28, 1, -38 },
  { 5074, 23, 38, 28, 3, -38 },
  { 5184, 7, 52, 11, 4, -44 },
  { 5230, 15, 41, 18, 2, -38 },
  { 5307, 7, 52, 11, 0, -44 },
  { 5353, 15, 19, 20, 2, -38 },
  { 5389, 20, 1, 20, 0, 0 },
  { 5392, 7, 7, 14, 4, -41 },
  { 5399, 18, 31, 25, 3, -30 },
  { 5469, 19, 42, 26, 4, -41 },
  { 5569, 19, 31, 24, 3, -30 },
  { 5643, 19, 42, 26, 3, -41 },
  { 5743, 20, 31, 24, 2, -30 },
  { 5821, 13, 42, 16, 2, -42 },
  { 5890, 19, 41, 26, 3, -30 },
  { 5988, 18, 41, 26, 4, -41 },
  { 6081, 3, 40, 11, 4, -40 },
  { 6096, 10, 51, 11, -3, -40 },
  { 6160, 18, 41, 23, 4, -41 },
  { 6253, 1, 41, 11, 5, -41 },
  { 6259, 34, 30, 42, 4, -30 },
  { 6387, 18, 30, 26, 4, -30 },
  { 6455, 20, 31, 26, 3, -30 },
  { 6533, 19, 41, 26, 4, -30 },
  { 6631, 19, 41, 26, 3, -30 },
  { 6729, 11, 30, 16, 4, -30 },
  { 6771, 17, 31, 24, 3, -30 },
  { 6837, 12, 37, 16, 1, -36 },
  { 6893, 18, 30, 26, 4, -29 },
  { 6961, 20, 29, 23, 1, -29 },
  { 7034, 31, 29, 36, 2, -29 },
  { 7147, 19, 29, 23, 2, -29 },
  { 7216, 21, 40, 23, 1, -29 },
  { 7321, 19, 29, 23, 2, -29 },
  { 7390, 13, 54, 16, 2, -42 },
  { 7478, 1, 45, 11, 5, -38 },
  { 7484, 13, 54, 16, 1, -42 },
  { 7572, 24, 9, 33, 4, -21 },
};

const GFXfont RobotoCondensed_Thin54pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin54pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin54pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _ROBOTOCONDENSED_THIN54PT7B_H_
