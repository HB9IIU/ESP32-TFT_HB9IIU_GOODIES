#ifndef _ROBOTOCONDENSED_THIN32PT7B_H_
#define _ROBOTOCONDENSED_THIN32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin32pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0x00, 0x3C, 0x8C, 0x63, 0x19, 0x48, 0x02,
  0x08, 0x04, 0x20, 0x08, 0x40, 0x20, 0x80, 0x41, 0x00, 0x82, 0x1F, 0xFF,
  0x82, 0x10, 0x04, 0x20, 0x08, 0x40, 0x20, 0x80, 0x41, 0x00, 0x82, 0x01,
  0x04, 0x02, 0x10, 0x04, 0x20, 0xFF, 0xFC, 0x20, 0x80, 0x41, 0x00, 0x82,
  0x01, 0x08, 0x02, 0x10, 0x04, 0x20, 0x00, 0x02, 0x00, 0x20, 0x02, 0x01,
  0xF0, 0x20, 0xC4, 0x04, 0x40, 0x24, 0x02, 0x80, 0x28, 0x01, 0x40, 0x04,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x28,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x24, 0x02, 0x20, 0x41, 0xF8, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x38, 0x00, 0x22, 0x00, 0x20, 0x80, 0x10, 0x41, 0x08,
  0x20, 0x84, 0x10, 0x82, 0x08, 0x41, 0x04, 0x40, 0x82, 0x20, 0x22, 0x20,
  0x0E, 0x20, 0x00, 0x10, 0x00, 0x10, 0xE0, 0x08, 0x88, 0x08, 0x82, 0x04,
  0x41, 0x04, 0x20, 0x82, 0x10, 0x42, 0x08, 0x21, 0x04, 0x10, 0x02, 0x08,
  0x00, 0x88, 0x00, 0x38, 0x0F, 0x00, 0x42, 0x02, 0x08, 0x08, 0x10, 0x20,
  0x40, 0x82, 0x02, 0x08, 0x08, 0x40, 0x12, 0x00, 0x50, 0x00, 0x80, 0x05,
  0x00, 0x24, 0x01, 0x08, 0x28, 0x10, 0xA0, 0x22, 0x80, 0x8A, 0x01, 0x28,
  0x03, 0x20, 0x04, 0x40, 0x31, 0x83, 0x21, 0xF0, 0x40, 0xFC, 0x04, 0x20,
  0x84, 0x20, 0x82, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x81, 0x04, 0x10, 0x40, 0x82, 0x08, 0x10, 0x20, 0x81, 0x84, 0x10,
  0x42, 0x08, 0x42, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x10, 0x84, 0x42, 0x22, 0x10, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x06, 0x21, 0x8D, 0x70, 0x1C, 0x00, 0xA0, 0x04, 0x80, 0x42, 0x04, 0x10,
  0x20, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x24, 0x95, 0x80, 0xFC, 0x70, 0x00,
  0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x00, 0x0F, 0x03, 0x08, 0x40, 0x44, 0x02, 0x40, 0x28,
  0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x24, 0x02, 0x40, 0x42,
  0x08, 0x1F, 0x00, 0x04, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x40, 0x1F, 0x02, 0x08,
  0x40, 0x48, 0x02, 0x80, 0x28, 0x02, 0x80, 0x20, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0xFF, 0xF0, 0x1F, 0x02, 0x0C, 0x40,
  0x48, 0x02, 0x80, 0x28, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x80, 0xF0, 0x00, 0xC0, 0x02, 0x00, 0x20, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x02, 0x40, 0x22, 0x04, 0x1F, 0x80, 0x00, 0x40, 0x01, 0x00, 0x0A,
  0x00, 0x28, 0x01, 0x20, 0x08, 0x80, 0x22, 0x01, 0x08, 0x04, 0x20, 0x20,
  0x80, 0x82, 0x04, 0x08, 0x10, 0x20, 0x80, 0x86, 0x02, 0x10, 0x08, 0xFF,
  0xFC, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x7F, 0xE8, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x9F,
  0x1C, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30,
  0x06, 0x00, 0xC0, 0x24, 0x04, 0xC1, 0x07, 0xC0, 0x03, 0x80, 0xC0, 0x10,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x8F, 0x0B, 0x0C, 0xC0,
  0x28, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x24, 0x02, 0x60, 0x43, 0x0C, 0x0F, 0x00, 0xFF, 0xF8, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x1F, 0x02, 0x0C,
  0x40, 0x44, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x24, 0x04,
  0x20, 0xC1, 0xF0, 0x20, 0xC4, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x40, 0x26, 0x04, 0x1F, 0x00, 0x1F, 0x04, 0x11, 0x01,
  0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x14, 0x06, 0x41, 0x47, 0xC8, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x08, 0x06, 0x0F, 0x00, 0xB0, 0x00, 0x00, 0x02, 0xC0, 0x4C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x25, 0x28, 0x00, 0x20, 0x08, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x02, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x06, 0x03, 0x01, 0x80, 0x40,
  0x30, 0x08, 0x00, 0x3E, 0x20, 0xA0, 0x50, 0x18, 0x0C, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40, 0x20, 0x10, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFE, 0x00, 0x0C, 0x06, 0x00, 0x40,
  0x04, 0x02, 0x00, 0x08, 0x10, 0x00, 0x10, 0x80, 0x00, 0x22, 0x00, 0x00,
  0x90, 0x0F, 0x02, 0x40, 0xC2, 0x09, 0x02, 0x08, 0x18, 0x10, 0x20, 0x60,
  0x40, 0x81, 0x82, 0x02, 0x06, 0x08, 0x08, 0x18, 0x20, 0x20, 0x60, 0x80,
  0x81, 0x82, 0x04, 0x0A, 0x08, 0x10, 0x28, 0x20, 0x40, 0xA0, 0x82, 0x84,
  0x81, 0x12, 0x11, 0x03, 0x87, 0x84, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x81, 0x80, 0x01, 0xF8,
  0x00, 0x01, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x48, 0x00, 0x88,
  0x01, 0x10, 0x02, 0x20, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x80, 0x81,
  0x01, 0x02, 0x02, 0x08, 0x02, 0x1F, 0xFC, 0x20, 0x08, 0x80, 0x11, 0x00,
  0x12, 0x00, 0x28, 0x00, 0x50, 0x00, 0x60, 0x00, 0x80, 0xFF, 0x08, 0x0C,
  0x80, 0x68, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02,
  0x80, 0xCF, 0xF8, 0x80, 0x48, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x28, 0x04, 0xFF, 0x80, 0x0F, 0xC0, 0x40, 0xC2,
  0x00, 0x90, 0x02, 0x40, 0x05, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x05, 0x00, 0x14, 0x00, 0x50, 0x02, 0x20, 0x08, 0x40, 0xC0, 0xFC,
  0x00, 0xFF, 0x04, 0x06, 0x20, 0x09, 0x00, 0x28, 0x01, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x05, 0x00, 0x28, 0x02, 0x40,
  0x63, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFC, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFE, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x00, 0x0F, 0xC0, 0xC0, 0xC4, 0x01, 0x10, 0x02, 0x80, 0x0A, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x81, 0xFE,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x50, 0x01,
  0x60, 0x08, 0xC0, 0xC0, 0xFC, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x7F, 0xFF, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0xFF,
  0xFF, 0xFE, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x80, 0x18, 0x01, 0x40, 0x24, 0x02, 0x40, 0x63, 0x0C, 0x0F,
  0x00, 0x80, 0x1A, 0x00, 0x48, 0x02, 0x20, 0x10, 0x80, 0x82, 0x04, 0x08,
  0x30, 0x20, 0x80, 0x84, 0x02, 0x20, 0x09, 0x80, 0x2A, 0x00, 0xC4, 0x02,
  0x08, 0x08, 0x20, 0x20, 0x40, 0x80, 0x82, 0x01, 0x08, 0x04, 0x20, 0x08,
  0x80, 0x12, 0x00, 0x68, 0x00, 0x80, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x3F, 0xF8, 0x80, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x05, 0xA0,
  0x01, 0x68, 0x00, 0x59, 0x00, 0x26, 0x40, 0x09, 0x90, 0x02, 0x62, 0x01,
  0x18, 0x80, 0x46, 0x20, 0x11, 0x84, 0x08, 0x61, 0x02, 0x18, 0x41, 0x06,
  0x08, 0x41, 0x82, 0x10, 0x60, 0x48, 0x18, 0x12, 0x06, 0x04, 0x81, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x68,
  0x01, 0xA0, 0x06, 0x40, 0x18, 0x80, 0x62, 0x01, 0x84, 0x06, 0x10, 0x18,
  0x20, 0x60, 0x81, 0x81, 0x06, 0x02, 0x18, 0x08, 0x60, 0x11, 0x80, 0x46,
  0x00, 0x98, 0x02, 0x60, 0x05, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x40, 0x0F,
  0xC0, 0x20, 0x60, 0x80, 0x22, 0x00, 0x44, 0x00, 0x50, 0x00, 0xA0, 0x01,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x05, 0x00, 0x09, 0x00, 0x12, 0x00,
  0x42, 0x00, 0x82, 0x06, 0x03, 0xF0, 0x00, 0xFF, 0x88, 0x04, 0x80, 0x28,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28,
  0x04, 0xFF, 0x88, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0x20, 0x60, 0x80, 0x22,
  0x00, 0x44, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x05, 0x00, 0x09, 0x00, 0x12, 0x00, 0x42, 0x00, 0x82, 0x06, 0x03,
  0xF8, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0xFF, 0x84, 0x02,
  0x20, 0x09, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x14,
  0x00, 0xA0, 0x09, 0x00, 0x8F, 0xF8, 0x40, 0x82, 0x02, 0x10, 0x10, 0x80,
  0x44, 0x02, 0x20, 0x09, 0x00, 0x28, 0x01, 0x40, 0x06, 0x00, 0x20, 0x1F,
  0xC1, 0x01, 0x10, 0x05, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x14, 0x01, 0x18, 0x10, 0x3F,
  0x00, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x24, 0x01, 0x10, 0x30, 0x7E, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x12, 0x00, 0x24, 0x00, 0x48, 0x01, 0x08, 0x02,
  0x10, 0x04, 0x20, 0x08, 0x20, 0x20, 0x40, 0x40, 0x80, 0x80, 0x82, 0x01,
  0x04, 0x02, 0x08, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x12, 0x00, 0x14,
  0x00, 0x28, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20,
  0x05, 0x00, 0xA0, 0x0A, 0x01, 0x40, 0x24, 0x02, 0x80, 0x48, 0x04, 0x80,
  0x88, 0x11, 0x01, 0x10, 0x22, 0x04, 0x20, 0x44, 0x08, 0x40, 0x84, 0x10,
  0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x08, 0x21, 0x02, 0x10, 0x22, 0x04,
  0x40, 0x44, 0x04, 0x80, 0x88, 0x09, 0x01, 0x20, 0x12, 0x01, 0x40, 0x28,
  0x02, 0x80, 0x50, 0x05, 0x00, 0x60, 0x0A, 0x00, 0xC0, 0x08, 0x01, 0x00,
  0x10, 0x00, 0x40, 0x04, 0x80, 0x08, 0x80, 0x21, 0x00, 0x41, 0x01, 0x02,
  0x04, 0x02, 0x08, 0x02, 0x20, 0x04, 0x40, 0x05, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x28, 0x00, 0x50, 0x01, 0x10, 0x04, 0x20, 0x08, 0x20, 0x20, 0x20,
  0x40, 0x41, 0x00, 0x44, 0x00, 0x88, 0x00, 0xA0, 0x00, 0x80, 0x80, 0x03,
  0x80, 0x09, 0x00, 0x13, 0x00, 0x42, 0x00, 0x84, 0x02, 0x04, 0x04, 0x08,
  0x10, 0x08, 0x20, 0x10, 0x80, 0x11, 0x00, 0x24, 0x00, 0x28, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xFF, 0xF8, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x03, 0xFF, 0xE0, 0xF2, 0x49, 0x24, 0x92,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x38, 0x80, 0x40, 0x10, 0x08,
  0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40,
  0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00,
  0x80, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0xF0, 0x08, 0x06, 0x05, 0x02, 0x41, 0x21, 0x10,
  0x84, 0x42, 0x41, 0x20, 0x50, 0x20, 0xFF, 0xF0, 0x46, 0x21, 0x1F, 0x0C,
  0x11, 0x01, 0x40, 0x28, 0x04, 0x00, 0x80, 0x10, 0x02, 0x3F, 0xC8, 0x0A,
  0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x36, 0x09, 0x3E, 0x20, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0xF8, 0xE0, 0x90, 0x0A,
  0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0x40, 0x28, 0x05, 0x00, 0xB0, 0x25, 0xF8, 0x1F, 0x0C, 0x11, 0x01, 0x40,
  0x28, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x50, 0x13, 0x04, 0x1F, 0x00, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0xF9, 0x20, 0xA8, 0x0E, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x80, 0xC8, 0x28, 0xF9, 0x0F, 0x81, 0x04, 0x20, 0x24, 0x01, 0x40, 0x14,
  0x01, 0x80, 0x1F, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x01, 0x02, 0x0F, 0xC0, 0x07, 0x18, 0x10, 0x10, 0x10, 0x10,
  0x10, 0xFE, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F, 0x24, 0x15, 0x01, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x50, 0x19, 0x05, 0x1F, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x80,
  0x88, 0x30, 0xF8, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x7C, 0xA0, 0xB0, 0x28, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x70, 0x05, 0x55,
  0x55, 0x55, 0x54, 0x04, 0x30, 0x00, 0x00, 0x00, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x42,
  0x0B, 0xC0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x02,
  0x81, 0x20, 0x88, 0x42, 0x20, 0x88, 0x24, 0x0A, 0x03, 0x40, 0x88, 0x22,
  0x08, 0x42, 0x08, 0x82, 0x20, 0x48, 0x0A, 0x01, 0xFF, 0xFF, 0xFF, 0x8F,
  0x83, 0xC4, 0x82, 0x61, 0x28, 0x14, 0x05, 0x80, 0x60, 0x2C, 0x02, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x08, 0x9F, 0x28, 0x2C, 0x0A,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x1F, 0x02, 0x0C, 0x40, 0x48, 0x02,
  0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x28, 0x02, 0x40, 0x42, 0x0C, 0x1F, 0x00, 0x9F, 0x1C, 0x12, 0x01,
  0x40, 0x28, 0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x05, 0x00, 0xA0, 0x16, 0x04, 0xBF, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x1F, 0x24, 0x15, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x50, 0x19, 0x05, 0x1F, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x9E, 0x8C, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x80, 0x3F, 0x10, 0x28, 0x06, 0x01, 0x80, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x01, 0x00, 0x60, 0x18, 0x05, 0x02, 0x3F,
  0x00, 0x20, 0x40, 0x81, 0x0F, 0xC4, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x80, 0xE0, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x14, 0x02, 0x80, 0x50, 0x19, 0x05, 0x1F, 0x20, 0x80, 0x18, 0x02, 0x40,
  0x24, 0x02, 0x40, 0x42, 0x04, 0x20, 0x42, 0x08, 0x10, 0x81, 0x08, 0x11,
  0x00, 0x90, 0x09, 0x00, 0xA0, 0x06, 0x00, 0x60, 0x04, 0x00, 0x80, 0x40,
  0x28, 0x08, 0x09, 0x02, 0x81, 0x20, 0x50, 0x24, 0x0A, 0x04, 0x41, 0x41,
  0x08, 0x44, 0x21, 0x08, 0x84, 0x21, 0x10, 0x82, 0x41, 0x20, 0x48, 0x24,
  0x09, 0x04, 0x81, 0x20, 0x90, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x08, 0x02, 0x00, 0x40, 0x24, 0x04, 0x20, 0x42, 0x08, 0x10, 0x80, 0x90,
  0x0A, 0x00, 0x60, 0x04, 0x00, 0xA0, 0x09, 0x01, 0x10, 0x10, 0x82, 0x08,
  0x60, 0x44, 0x02, 0x80, 0x20, 0x80, 0x18, 0x02, 0x40, 0x24, 0x02, 0x40,
  0x42, 0x04, 0x20, 0x42, 0x08, 0x10, 0x81, 0x08, 0x10, 0x80, 0x90, 0x09,
  0x00, 0x90, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x10, 0x06, 0x00, 0x7F, 0xE0, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x04, 0x00, 0xFF, 0xF0, 0x01, 0x06, 0x04, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0xC0,
  0x20, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08,
  0x04, 0x06, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x20, 0x10, 0x10, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x04, 0x03,
  0x06, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x20, 0xC0, 0x3C, 0x02, 0x84, 0x05, 0x04, 0x14, 0x04, 0x28, 0x07,
  0x80,
};

const GFXglyph RobotoCondensed_Thin32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 23, 6, 2, -23 },
  { 7, 5, 6, 8, 2, -24 },
  { 11, 15, 23, 16, 1, -23 },
  { 55, 12, 29, 15, 2, -26 },
  { 99, 17, 23, 21, 2, -23 },
  { 148, 14, 23, 17, 2, -23 },
  { 189, 1, 6, 5, 2, -24 },
  { 190, 6, 32, 9, 2, -25 },
  { 214, 5, 32, 9, 1, -25 },
  { 234, 13, 12, 13, 0, -23 },
  { 254, 13, 17, 16, 1, -19 },
  { 282, 3, 6, 6, 1, -2 },
  { 285, 6, 1, 9, 1, -11 },
  { 286, 2, 2, 7, 2, -2 },
  { 287, 9, 25, 11, 1, -23 },
  { 316, 12, 23, 15, 2, -23 },
  { 351, 6, 23, 15, 3, -23 },
  { 369, 12, 23, 15, 2, -23 },
  { 404, 12, 23, 15, 2, -23 },
  { 439, 14, 23, 15, 1, -23 },
  { 480, 11, 23, 15, 3, -23 },
  { 512, 12, 23, 15, 2, -23 },
  { 547, 13, 23, 15, 1, -23 },
  { 585, 12, 23, 15, 2, -23 },
  { 620, 11, 23, 15, 2, -23 },
  { 652, 2, 17, 6, 2, -17 },
  { 657, 3, 21, 5, 1, -17 },
  { 665, 11, 13, 15, 1, -17 },
  { 683, 11, 7, 16, 2, -14 },
  { 693, 11, 13, 15, 2, -17 },
  { 711, 9, 23, 12, 2, -23 },
  { 737, 22, 29, 26, 2, -22 },
  { 817, 15, 23, 17, 1, -23 },
  { 861, 12, 23, 17, 3, -23 },
  { 896, 14, 23, 18, 2, -23 },
  { 937, 13, 23, 18, 3, -23 },
  { 975, 12, 23, 16, 3, -23 },
  { 1010, 12, 23, 16, 3, -23 },
  { 1045, 14, 23, 19, 3, -23 },
  { 1086, 14, 23, 20, 3, -23 },
  { 1127, 1, 23, 8, 3, -23 },
  { 1130, 12, 23, 16, 1, -23 },
  { 1165, 14, 23, 18, 3, -23 },
  { 1206, 11, 23, 15, 3, -23 },
  { 1238, 18, 23, 24, 3, -23 },
  { 1290, 14, 23, 20, 3, -23 },
  { 1331, 15, 23, 19, 2, -23 },
  { 1375, 12, 23, 17, 3, -23 },
  { 1410, 15, 27, 19, 2, -23 },
  { 1461, 13, 23, 18, 3, -23 },
  { 1499, 13, 23, 17, 2, -23 },
  { 1537, 15, 23, 17, 1, -23 },
  { 1581, 13, 23, 19, 3, -23 },
  { 1619, 15, 23, 17, 1, -23 },
  { 1663, 23, 23, 25, 1, -23 },
  { 1730, 15, 23, 17, 1, -23 },
  { 1774, 15, 23, 17, 1, -23 },
  { 1818, 13, 23, 17, 2, -23 },
  { 1856, 3, 31, 7, 3, -26 },
  { 1868, 9, 25, 11, 1, -23 },
  { 1897, 4, 31, 7, 0, -26 },
  { 1913, 9, 11, 12, 1, -23 },
  { 1926, 12, 1, 12, 0, 0 },
  { 1928, 4, 4, 8, 2, -24 },
  { 1930, 11, 17, 15, 2, -17 },
  { 1954, 11, 24, 15, 3, -24 },
  { 1987, 11, 17, 14, 2, -17 },
  { 2011, 11, 24, 15, 2, -24 },
  { 2044, 12, 17, 14, 1, -17 },
  { 2070, 8, 24, 9, 1, -24 },
  { 2094, 11, 24, 16, 2, -17 },
  { 2127, 10, 24, 15, 3, -24 },
  { 2157, 2, 23, 6, 2, -23 },
  { 2163, 6, 30, 7, -2, -23 },
  { 2186, 10, 24, 14, 3, -24 },
  { 2216, 1, 24, 6, 3, -24 },
  { 2219, 21, 17, 25, 2, -17 },
  { 2264, 10, 17, 15, 3, -17 },
  { 2286, 12, 17, 16, 2, -17 },
  { 2312, 11, 24, 15, 3, -17 },
  { 2345, 11, 24, 15, 2, -17 },
  { 2378, 6, 17, 10, 3, -17 },
  { 2391, 10, 17, 14, 2, -17 },
  { 2413, 7, 21, 9, 1, -21 },
  { 2432, 11, 17, 15, 2, -17 },
  { 2456, 12, 17, 14, 1, -17 },
  { 2482, 19, 17, 21, 1, -17 },
  { 2523, 12, 17, 14, 1, -17 },
  { 2549, 12, 24, 14, 1, -17 },
  { 2585, 12, 17, 14, 1, -17 },
  { 2611, 8, 32, 9, 1, -25 },
  { 2643, 1, 27, 6, 3, -23 },
  { 2647, 8, 32, 9, 0, -25 },
  { 2679, 15, 5, 19, 2, -12 },
};

const GFXfont RobotoCondensed_Thin32pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin32pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOCONDENSED_THIN32PT7B_H_
