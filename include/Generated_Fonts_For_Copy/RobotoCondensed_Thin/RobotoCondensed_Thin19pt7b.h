#ifndef _ROBOTOCONDENSED_THIN19PT7B_H_
#define _ROBOTOCONDENSED_THIN19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xC4, 0xB6, 0xD0, 0x12, 0x12, 0x12, 0x7E, 0x22, 0x24, 0x24,
  0x24, 0x24, 0x24, 0x5E, 0x44, 0x48, 0x40, 0x00, 0x00, 0xF2, 0x18, 0x30,
  0x20, 0x20, 0x30, 0x18, 0x08, 0x18, 0x30, 0x50, 0x9E, 0x00, 0x00, 0x70,
  0x24, 0x08, 0x92, 0x24, 0x92, 0x1D, 0x00, 0x40, 0x20, 0x09, 0x84, 0x91,
  0x24, 0x89, 0x22, 0x40, 0x60, 0x38, 0x22, 0x11, 0x08, 0x84, 0x81, 0x80,
  0x80, 0xA0, 0x88, 0x42, 0xA1, 0x50, 0x48, 0x33, 0xE8, 0xF0, 0x12, 0x24,
  0x44, 0x88, 0x88, 0x88, 0x84, 0x44, 0x22, 0x10, 0x84, 0x22, 0x21, 0x11,
  0x11, 0x11, 0x11, 0x22, 0x24, 0x80, 0x08, 0x08, 0xCB, 0x3C, 0x18, 0x24,
  0x42, 0x10, 0x10, 0x10, 0x10, 0x7E, 0x10, 0x10, 0x10, 0x10, 0x10, 0xF0,
  0x40, 0x80, 0x04, 0x10, 0x82, 0x08, 0x41, 0x04, 0x20, 0x82, 0x10, 0x41,
  0x08, 0x00, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x14, 0x47, 0x00, 0x3C, 0x92, 0x49, 0x24, 0x92, 0x00, 0x38, 0x8A, 0x0C,
  0x10, 0x20, 0x41, 0x04, 0x08, 0x20, 0x81, 0x04, 0x1F, 0x80, 0x3C, 0x86,
  0x0C, 0x10, 0x20, 0x47, 0x02, 0x02, 0x06, 0x0C, 0x14, 0x27, 0x80, 0x04,
  0x0C, 0x0C, 0x14, 0x14, 0x24, 0x44, 0x44, 0x84, 0xFE, 0x04, 0x04, 0x04,
  0x04, 0xFA, 0x08, 0x20, 0x83, 0xE0, 0x41, 0x04, 0x10, 0x61, 0x85, 0xE0,
  0x18, 0x41, 0x02, 0x08, 0x17, 0xB0, 0xC1, 0x83, 0x06, 0x0C, 0x14, 0x27,
  0x80, 0x7E, 0x04, 0x08, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20, 0x41, 0x02,
  0x00, 0x00, 0x3C, 0x86, 0x0C, 0x18, 0x28, 0x4F, 0x22, 0x83, 0x06, 0x0C,
  0x18, 0x2F, 0x80, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xA3, 0x3A, 0x04,
  0x08, 0x20, 0x47, 0x00, 0x80, 0x40, 0x80, 0x78, 0x04, 0x62, 0x30, 0xC0,
  0x81, 0x81, 0x7C, 0x01, 0xF0, 0x80, 0xC0, 0x60, 0x20, 0x43, 0x18, 0x40,
  0x72, 0x20, 0x41, 0x04, 0x20, 0x84, 0x20, 0x80, 0x00, 0x00, 0x80, 0x0F,
  0xC0, 0x81, 0x08, 0x04, 0x80, 0x14, 0x38, 0xC2, 0x06, 0x22, 0x31, 0x11,
  0x90, 0x8C, 0x84, 0x64, 0x23, 0x13, 0x18, 0xE7, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x1F, 0x80, 0x08, 0x03, 0x00, 0xC0, 0x48, 0x12, 0x04, 0x82, 0x10,
  0x84, 0x21, 0x0F, 0xC4, 0x09, 0x02, 0x40, 0xA0, 0x10, 0xF9, 0x0A, 0x0C,
  0x18, 0x30, 0xBE, 0x42, 0x83, 0x06, 0x0C, 0x18, 0x2F, 0x80, 0x3E, 0x20,
  0x90, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x28, 0x14,
  0x11, 0xF0, 0x78, 0x84, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x82, 0x84, 0x78, 0x7D, 0x02, 0x04, 0x08, 0x10, 0x3E, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x0F, 0x80, 0x7D, 0x02, 0x04, 0x08, 0x10, 0x3E, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x00, 0x00, 0x7C, 0x82, 0x81, 0x81, 0x80, 0x80,
  0x80, 0x86, 0x81, 0x81, 0x81, 0x81, 0x81, 0x7E, 0x01, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x01, 0xFF, 0xFC,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x06, 0x0C, 0x28, 0x4F,
  0x00, 0x02, 0x84, 0x84, 0x88, 0x90, 0xA0, 0xE0, 0xA0, 0x90, 0x88, 0x84,
  0x84, 0x82, 0x01, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x83, 0xE0, 0x80, 0x20, 0x18, 0x07, 0x03, 0xC0, 0xE8, 0x3A, 0x16, 0x85,
  0x92, 0x64, 0x99, 0x26, 0x31, 0x8C, 0x41, 0x00, 0x81, 0x81, 0xC1, 0xC1,
  0xA1, 0x91, 0x91, 0x89, 0x89, 0x85, 0x85, 0x83, 0x83, 0x81, 0x3E, 0x20,
  0x90, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x28, 0x14,
  0x11, 0xF0, 0xFD, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFE, 0x81, 0x02, 0x04,
  0x08, 0x00, 0x00, 0x3E, 0x20, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x28, 0x14, 0x11, 0xF0, 0x04, 0x01, 0xFC, 0x82, 0x82,
  0x82, 0x82, 0x82, 0x82, 0xFC, 0x88, 0x84, 0x84, 0x82, 0x82, 0x01, 0x3C,
  0x42, 0x81, 0x81, 0x80, 0x40, 0x38, 0x06, 0x01, 0x01, 0x81, 0x81, 0xC1,
  0x3E, 0x7E, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x00, 0x01, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x2F, 0x80, 0x80, 0x50, 0x24, 0x09, 0x02, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x12, 0x04, 0x81, 0x20, 0x30, 0x0C, 0x00, 0x00, 0x82, 0x0C,
  0x10, 0x61, 0x43, 0x0A, 0x18, 0x50, 0xA2, 0x89, 0x22, 0x49, 0x12, 0x48,
  0x91, 0x45, 0x0C, 0x18, 0x60, 0xC3, 0x06, 0x00, 0x10, 0x81, 0x81, 0x42,
  0x24, 0x24, 0x18, 0x08, 0x18, 0x18, 0x24, 0x42, 0x42, 0x81, 0x81, 0x80,
  0x90, 0x24, 0x10, 0x84, 0x21, 0x04, 0x81, 0x20, 0x30, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x7F, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08,
  0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0xFE, 0xAA, 0xAA, 0xAA, 0xAA, 0xA0,
  0x84, 0x21, 0x04, 0x21, 0x04, 0x21, 0x04, 0x21, 0x04, 0x20, 0x55, 0x55,
  0x55, 0x55, 0x50, 0x23, 0x14, 0xA9, 0x46, 0x20, 0x7C, 0x44, 0x79, 0x0A,
  0x08, 0x17, 0xB0, 0x60, 0xC1, 0x84, 0xF4, 0x81, 0x02, 0x04, 0x0B, 0xD8,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x37, 0x80, 0x79, 0x0A, 0x0C, 0x08,
  0x10, 0x20, 0x41, 0x84, 0xF0, 0x02, 0x04, 0x08, 0x17, 0xB0, 0xE0, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x2F, 0xC0, 0x79, 0x0A, 0x0C, 0x1F, 0xF0, 0x20,
  0x40, 0x80, 0xF8, 0x24, 0x44, 0x64, 0x44, 0x44, 0x44, 0x44, 0x7B, 0x0E,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0xFC, 0x08, 0x10, 0x4F, 0x00, 0x02,
  0x08, 0x20, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x10, 0x8F, 0xFC,
  0x20, 0x02, 0x49, 0x24, 0x92, 0x49, 0x38, 0x02, 0x08, 0x20, 0x8A, 0x4A,
  0x30, 0xC2, 0x8A, 0x24, 0x88, 0x10, 0xFF, 0xFC, 0xBC, 0xEC, 0x31, 0x82,
  0x18, 0x21, 0x82, 0x18, 0x21, 0x82, 0x18, 0x21, 0x82, 0x18, 0x21, 0x7A,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x10, 0x3C, 0x86, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x42, 0x78, 0xBD, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC3,
  0x7A, 0x04, 0x08, 0x10, 0x00, 0x7B, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x42, 0x7C, 0x08, 0x10, 0x20, 0x40, 0x52, 0x49, 0x24, 0x80, 0x7A, 0x18,
  0x20, 0x70, 0x20, 0x41, 0x85, 0xE0, 0x21, 0x08, 0xC2, 0x10, 0x84, 0x21,
  0x08, 0x41, 0x80, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x46, 0x74,
  0x83, 0x0A, 0x14, 0x24, 0x89, 0x12, 0x18, 0x30, 0x40, 0x84, 0x30, 0x8A,
  0x31, 0x45, 0x24, 0xA4, 0xA4, 0x94, 0xA2, 0x8C, 0x21, 0x84, 0x00, 0x86,
  0x14, 0x8C, 0x10, 0xC2, 0x92, 0x86, 0x10, 0x83, 0x0A, 0x14, 0x24, 0x89,
  0x12, 0x18, 0x30, 0x20, 0x81, 0x02, 0x08, 0x00, 0x7C, 0x08, 0x20, 0x81,
  0x04, 0x08, 0x20, 0x81, 0xF8, 0x12, 0x24, 0x44, 0x44, 0x48, 0x44, 0x44,
  0x44, 0x22, 0x10, 0xFF, 0xFF, 0x80, 0x82, 0x08, 0x42, 0x10, 0x84, 0x20,
  0xC4, 0x42, 0x10, 0x84, 0x22, 0x20, 0x70, 0xC4, 0x61, 0xC0,
};

const GFXglyph RobotoCondensed_Thin19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 14, 4, 1, -14 },
  { 3, 3, 4, 5, 1, -14 },
  { 5, 8, 14, 9, 1, -14 },
  { 19, 7, 18, 9, 1, -16 },
  { 35, 10, 14, 12, 1, -14 },
  { 53, 9, 14, 10, 1, -14 },
  { 69, 1, 4, 3, 1, -14 },
  { 70, 4, 19, 5, 1, -15 },
  { 80, 4, 19, 5, 0, -15 },
  { 90, 8, 7, 8, 0, -14 },
  { 97, 8, 10, 9, 1, -11 },
  { 107, 1, 4, 4, 1, -1 },
  { 108, 3, 1, 5, 1, -7 },
  { 109, 1, 1, 4, 1, -1 },
  { 110, 6, 15, 7, 0, -14 },
  { 122, 7, 14, 9, 1, -14 },
  { 135, 3, 14, 9, 2, -14 },
  { 141, 7, 14, 9, 1, -14 },
  { 154, 7, 14, 9, 1, -14 },
  { 167, 8, 14, 9, 1, -14 },
  { 181, 6, 14, 9, 2, -14 },
  { 192, 7, 14, 9, 1, -14 },
  { 205, 7, 14, 9, 1, -14 },
  { 218, 7, 14, 9, 1, -14 },
  { 231, 7, 14, 9, 1, -14 },
  { 244, 1, 10, 3, 1, -10 },
  { 246, 1, 13, 3, 1, -10 },
  { 248, 6, 8, 9, 1, -10 },
  { 254, 7, 3, 9, 1, -8 },
  { 257, 7, 8, 9, 1, -10 },
  { 264, 6, 14, 7, 1, -14 },
  { 275, 13, 17, 15, 1, -13 },
  { 303, 10, 14, 10, 0, -14 },
  { 321, 7, 14, 10, 2, -14 },
  { 334, 9, 14, 11, 1, -14 },
  { 350, 8, 14, 11, 2, -14 },
  { 364, 7, 14, 10, 2, -14 },
  { 377, 7, 14, 10, 2, -14 },
  { 390, 8, 14, 11, 2, -14 },
  { 404, 8, 14, 12, 2, -14 },
  { 418, 1, 14, 5, 2, -14 },
  { 420, 7, 14, 9, 1, -14 },
  { 433, 8, 14, 11, 2, -14 },
  { 447, 6, 14, 9, 2, -14 },
  { 458, 10, 14, 14, 2, -14 },
  { 476, 8, 14, 12, 2, -14 },
  { 490, 9, 14, 11, 1, -14 },
  { 506, 7, 14, 10, 2, -14 },
  { 519, 9, 16, 11, 1, -14 },
  { 537, 8, 14, 11, 2, -14 },
  { 551, 8, 14, 10, 1, -14 },
  { 565, 8, 14, 10, 1, -14 },
  { 579, 7, 14, 11, 2, -14 },
  { 592, 10, 14, 10, 0, -14 },
  { 610, 13, 14, 15, 1, -14 },
  { 633, 8, 14, 10, 1, -14 },
  { 647, 10, 14, 10, 0, -14 },
  { 665, 8, 14, 10, 1, -14 },
  { 679, 2, 18, 4, 2, -15 },
  { 684, 5, 15, 6, 1, -14 },
  { 694, 2, 18, 4, 0, -15 },
  { 699, 5, 7, 7, 1, -14 },
  { 704, 7, 1, 7, 0, 0 },
  { 705, 3, 2, 5, 1, -14 },
  { 706, 7, 10, 9, 1, -10 },
  { 715, 7, 14, 9, 1, -14 },
  { 728, 7, 10, 9, 1, -10 },
  { 737, 7, 14, 9, 1, -14 },
  { 750, 7, 10, 9, 1, -10 },
  { 759, 4, 14, 5, 1, -14 },
  { 766, 7, 14, 9, 1, -10 },
  { 779, 6, 14, 9, 2, -14 },
  { 790, 1, 14, 4, 1, -14 },
  { 792, 3, 18, 4, -1, -14 },
  { 799, 6, 14, 8, 2, -14 },
  { 810, 1, 14, 4, 1, -14 },
  { 812, 12, 10, 15, 1, -10 },
  { 827, 6, 10, 9, 2, -10 },
  { 835, 7, 10, 9, 1, -10 },
  { 844, 7, 14, 9, 1, -10 },
  { 857, 7, 14, 9, 1, -10 },
  { 870, 3, 10, 6, 2, -10 },
  { 874, 6, 10, 8, 1, -10 },
  { 882, 5, 13, 5, 0, -13 },
  { 891, 7, 10, 9, 1, -10 },
  { 900, 7, 10, 8, 1, -10 },
  { 909, 11, 10, 13, 1, -10 },
  { 923, 6, 10, 8, 1, -10 },
  { 931, 7, 14, 8, 1, -10 },
  { 944, 7, 10, 8, 1, -10 },
  { 953, 4, 19, 6, 1, -15 },
  { 963, 1, 17, 4, 1, -14 },
  { 966, 5, 19, 6, 0, -15 },
  { 978, 9, 3, 11, 1, -7 },
};

const GFXfont RobotoCondensed_Thin19pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin19pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin19pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOCONDENSED_THIN19PT7B_H_
