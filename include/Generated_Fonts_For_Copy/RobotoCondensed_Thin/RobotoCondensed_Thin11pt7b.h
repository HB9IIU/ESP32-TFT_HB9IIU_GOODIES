#ifndef _ROBOTOCONDENSED_THIN11PT7B_H_
#define _ROBOTOCONDENSED_THIN11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin11pt7bBitmaps[] PROGMEM = {
  0x00, 0x70, 0x00, 0x29, 0x4A, 0x65, 0x39, 0x48, 0x0E, 0x98, 0xC2, 0x11,
  0xE0, 0xC3, 0x4D, 0x38, 0x3D, 0x51, 0x47, 0xE5, 0x28, 0x8C, 0x5A, 0x5C,
  0x00, 0x6A, 0xAA, 0xA9, 0x15, 0x55, 0x56, 0x2E, 0x25, 0x01, 0x1C, 0x42,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x94, 0x94, 0x80, 0xE9, 0x99, 0x99, 0x9E,
  0x55, 0x54, 0xE1, 0x12, 0x24, 0x8E, 0xE1, 0x12, 0x01, 0x1E, 0x11, 0x8C,
  0xA5, 0x38, 0x40, 0xE8, 0x8E, 0x11, 0x1E, 0x48, 0x8E, 0x99, 0x9E, 0x78,
  0x44, 0x22, 0x10, 0x80, 0xE9, 0x9E, 0x99, 0x9E, 0xE9, 0x99, 0xF1, 0x2E,
  0x00, 0x00, 0x16, 0x86, 0x10, 0x66, 0x88, 0xA8, 0xE4, 0x94, 0x00, 0x7D,
  0x06, 0xED, 0x1C, 0xB9, 0x72, 0xDF, 0x80, 0xF0, 0x20, 0xC3, 0x12, 0x49,
  0xE8, 0xA0, 0xF9, 0x9E, 0x99, 0x97, 0xF4, 0x21, 0x08, 0x42, 0x3E, 0x74,
  0x63, 0x18, 0xC6, 0x2E, 0x68, 0x8E, 0x88, 0x86, 0x68, 0x8E, 0x88, 0x80,
  0x74, 0x61, 0x09, 0x46, 0x2E, 0x0C, 0x63, 0xF8, 0xC6, 0x21, 0x7E, 0x01,
  0x11, 0x11, 0x17, 0x04, 0xA9, 0x8A, 0x52, 0x40, 0x08, 0x88, 0x88, 0x86,
  0x82, 0x18, 0x73, 0xCE, 0xDB, 0x48, 0x84, 0x73, 0x5A, 0xCE, 0x61, 0xF4,
  0x63, 0x18, 0xC6, 0x3E, 0xF9, 0x99, 0xF8, 0x80, 0xF4, 0x63, 0x18, 0xC6,
  0x3E, 0x00, 0xF4, 0xA3, 0x2F, 0x42, 0x40, 0xF8, 0x8C, 0x31, 0x1F, 0x71,
  0x08, 0x42, 0x10, 0x80, 0x09, 0x99, 0x99, 0x9F, 0x82, 0x24, 0x92, 0x50,
  0xC3, 0x00, 0x88, 0x99, 0x59, 0x55, 0x55, 0x66, 0x66, 0x22, 0x02, 0x4C,
  0x42, 0x29, 0x20, 0x81, 0x24, 0x8C, 0x20, 0x82, 0x00, 0x71, 0x22, 0x48,
  0x86, 0x7F, 0xC0, 0x11, 0x24, 0x49, 0x00, 0x7F, 0xC0, 0xBC, 0x60, 0x40,
  0xE4, 0xFB, 0xC0, 0x08, 0x8E, 0x99, 0x99, 0xE0, 0xF2, 0x49, 0xC0, 0x04,
  0xFB, 0x6D, 0xE0, 0x79, 0xB8, 0x86, 0x09, 0x24, 0x92, 0x40, 0xF6, 0xDB,
  0xCF, 0x12, 0x7B, 0x6D, 0x00, 0x0F, 0x00, 0x00, 0x55, 0x50, 0x12, 0x5D,
  0x35, 0x00, 0x7F, 0x00, 0xEF, 0x26, 0x4C, 0x99, 0x20, 0x40, 0xF6, 0xDA,
  0x00, 0xE9, 0x99, 0x9E, 0xE9, 0x99, 0x9E, 0x80, 0xF6, 0xDB, 0xC8, 0xAA,
  0x80, 0xF3, 0x13, 0xC0, 0x09, 0x24, 0x90, 0x16, 0xDB, 0xC0, 0x89, 0x55,
  0x62, 0x13, 0x25, 0xB3, 0x62, 0x40, 0x00, 0x05, 0x26, 0x50, 0x89, 0x55,
  0x62, 0x24, 0x31, 0x24, 0x42, 0x29, 0x24, 0x12, 0x48, 0x80, 0x7F, 0x00,
  0x09, 0x24, 0x02, 0x48, 0x00, 0xC9, 0xC0,
};

const GFXglyph RobotoCondensed_Thin11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 8, 2, 1, -8 },
  { 2, 1, 2, 3, 1, -8 },
  { 3, 5, 8, 5, 0, -8 },
  { 8, 4, 10, 5, 1, -9 },
  { 13, 6, 8, 7, 1, -8 },
  { 19, 5, 8, 6, 1, -8 },
  { 24, 1, 2, 2, 0, -8 },
  { 25, 2, 12, 3, 1, -9 },
  { 28, 2, 12, 3, 0, -9 },
  { 31, 4, 4, 5, 0, -8 },
  { 33, 5, 6, 5, 0, -6 },
  { 37, 1, 2, 2, 0, -1 },
  { 38, 3, 1, 3, 0, -4 },
  { 39, 1, 1, 2, 1, -1 },
  { 40, 3, 9, 4, 0, -8 },
  { 44, 4, 8, 5, 1, -8 },
  { 48, 2, 8, 5, 1, -8 },
  { 50, 4, 8, 5, 1, -8 },
  { 54, 4, 8, 5, 1, -8 },
  { 58, 5, 8, 5, 0, -8 },
  { 63, 4, 8, 5, 1, -8 },
  { 67, 4, 8, 5, 1, -8 },
  { 71, 5, 8, 5, 0, -8 },
  { 76, 4, 8, 5, 1, -8 },
  { 80, 4, 8, 5, 1, -8 },
  { 84, 1, 6, 2, 1, -6 },
  { 85, 1, 7, 2, 0, -6 },
  { 86, 4, 5, 5, 0, -6 },
  { 89, 4, 2, 5, 1, -5 },
  { 90, 3, 5, 5, 1, -6 },
  { 92, 3, 8, 4, 1, -8 },
  { 95, 7, 10, 9, 1, -8 },
  { 104, 6, 8, 6, 0, -8 },
  { 110, 4, 8, 6, 1, -8 },
  { 114, 5, 8, 6, 1, -8 },
  { 119, 5, 8, 6, 1, -8 },
  { 124, 4, 8, 6, 1, -8 },
  { 128, 4, 8, 6, 1, -8 },
  { 132, 5, 8, 7, 1, -8 },
  { 137, 5, 8, 7, 1, -8 },
  { 142, 1, 8, 3, 1, -8 },
  { 143, 4, 8, 5, 0, -8 },
  { 147, 5, 8, 6, 1, -8 },
  { 152, 4, 8, 5, 1, -8 },
  { 156, 6, 8, 8, 1, -8 },
  { 162, 5, 8, 7, 1, -8 },
  { 167, 5, 8, 6, 1, -8 },
  { 172, 4, 8, 6, 1, -8 },
  { 176, 5, 9, 6, 1, -8 },
  { 182, 5, 8, 6, 1, -8 },
  { 187, 4, 8, 6, 1, -8 },
  { 191, 5, 8, 6, 0, -8 },
  { 196, 4, 8, 6, 1, -8 },
  { 200, 6, 8, 6, 0, -8 },
  { 206, 8, 8, 9, 0, -8 },
  { 214, 5, 8, 6, 0, -8 },
  { 219, 6, 8, 6, 0, -8 },
  { 225, 4, 8, 6, 1, -8 },
  { 229, 1, 11, 2, 1, -9 },
  { 231, 3, 9, 4, 0, -8 },
  { 235, 1, 11, 2, 0, -9 },
  { 237, 2, 4, 4, 1, -8 },
  { 238, 4, 1, 4, 0, 0 },
  { 239, 1, 2, 3, 1, -9 },
  { 240, 3, 6, 5, 1, -6 },
  { 243, 4, 9, 5, 1, -9 },
  { 248, 3, 6, 5, 1, -6 },
  { 251, 3, 9, 5, 1, -9 },
  { 255, 4, 6, 5, 0, -6 },
  { 258, 3, 9, 3, 0, -9 },
  { 262, 3, 8, 5, 1, -6 },
  { 265, 3, 9, 5, 1, -9 },
  { 269, 1, 9, 2, 1, -9 },
  { 271, 2, 11, 2, -1, -9 },
  { 274, 3, 9, 5, 1, -9 },
  { 278, 1, 9, 2, 1, -9 },
  { 280, 7, 6, 9, 1, -6 },
  { 286, 3, 6, 5, 1, -6 },
  { 289, 4, 6, 5, 1, -6 },
  { 292, 4, 8, 5, 1, -6 },
  { 296, 3, 8, 5, 1, -6 },
  { 299, 2, 6, 3, 1, -6 },
  { 301, 3, 6, 5, 1, -6 },
  { 304, 3, 7, 3, 0, -7 },
  { 307, 3, 6, 5, 1, -6 },
  { 310, 4, 6, 5, 0, -6 },
  { 313, 7, 6, 7, 0, -6 },
  { 319, 4, 6, 5, 0, -6 },
  { 322, 4, 8, 5, 0, -6 },
  { 326, 4, 6, 5, 0, -6 },
  { 329, 3, 11, 3, 0, -9 },
  { 334, 1, 9, 2, 1, -8 },
  { 336, 3, 11, 3, 0, -9 },
  { 341, 5, 2, 7, 1, -4 },
};

const GFXfont RobotoCondensed_Thin11pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin11pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOCONDENSED_THIN11PT7B_H_
