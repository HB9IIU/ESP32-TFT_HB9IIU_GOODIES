#ifndef _ROBOTOCONDENSED_THIN10PT7B_H_
#define _ROBOTOCONDENSED_THIN10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin10pt7bBitmaps[] PROGMEM = {
  0x00, 0x70, 0x00, 0x01, 0x94, 0xA5, 0x38, 0x00, 0x56, 0x44, 0x4D, 0x40,
  0xC6, 0xB8, 0x45, 0x94, 0x60, 0xEA, 0xCC, 0xA9, 0xF0, 0x00, 0x2A, 0xAA,
  0x80, 0x15, 0x55, 0x40, 0x0F, 0x24, 0x23, 0x88, 0x40, 0x00, 0x00, 0x00,
  0x04, 0xA4, 0xA4, 0xF6, 0xDB, 0x78, 0xD5, 0x50, 0xE4, 0x95, 0x30, 0xE4,
  0x90, 0x78, 0x11, 0x94, 0xA7, 0x08, 0x40, 0xD2, 0x72, 0x78, 0x53, 0xDB,
  0x78, 0x71, 0x12, 0x22, 0x00, 0xF6, 0xFB, 0x78, 0xF6, 0xDE, 0x70, 0x00,
  0x00, 0x34, 0x42, 0x48, 0x8D, 0xC0, 0x64, 0x90, 0x00, 0x7A, 0x1A, 0x71,
  0xCF, 0x5F, 0x60, 0x60, 0x21, 0x14, 0xA6, 0xC6, 0x00, 0xE9, 0x9E, 0x99,
  0x60, 0xF8, 0x88, 0x88, 0xF0, 0x69, 0x99, 0x99, 0x60, 0x68, 0x8C, 0x88,
  0x60, 0x68, 0x8C, 0x88, 0x00, 0xF8, 0x89, 0x89, 0xF0, 0x09, 0x9F, 0x99,
  0x00, 0x7C, 0x01, 0x11, 0x19, 0x70, 0x1A, 0xCC, 0xAA, 0x10, 0x12, 0x49,
  0x10, 0x06, 0x18, 0xF5, 0xD6, 0x92, 0x40, 0x89, 0xDB, 0xB9, 0x10, 0xF9,
  0x99, 0x99, 0xF0, 0xF9, 0x9E, 0x88, 0x00, 0xF9, 0x99, 0x99, 0xF1, 0xF9,
  0x9C, 0xA9, 0x00, 0x74, 0x50, 0x60, 0x85, 0xC0, 0x71, 0x08, 0x42, 0x10,
  0x80, 0x09, 0x99, 0x99, 0xF0, 0x84, 0x52, 0xA5, 0x10, 0x80, 0x80, 0x91,
  0x5A, 0x6A, 0x64, 0x24, 0x04, 0x0A, 0x88, 0x45, 0x28, 0x20, 0x8A, 0x54,
  0x42, 0x10, 0x80, 0x38, 0x84, 0x44, 0x20, 0xC0, 0x7F, 0x80, 0x91, 0x24,
  0x48, 0x7F, 0x80, 0x49, 0x80, 0x60, 0x40, 0x71, 0x79, 0xF0, 0x12, 0x7B,
  0x6F, 0x78, 0x88, 0x70, 0x04, 0xFB, 0x6F, 0x7B, 0x88, 0x70, 0x49, 0x24,
  0x90, 0xF6, 0xDE, 0x78, 0x12, 0x7B, 0x68, 0x1C, 0x1F, 0x00, 0x12, 0x4D,
  0x31, 0x7E, 0xFE, 0x9A, 0x69, 0x00, 0xF6, 0xD0, 0xF6, 0xDE, 0xF6, 0xDF,
  0x00, 0xF6, 0xDE, 0x40, 0xAA, 0x00, 0xD1, 0x16, 0x15, 0x54, 0x16, 0xDE,
  0x89, 0x66, 0x20, 0x12, 0xD7, 0x52, 0x08, 0x16, 0x26, 0x10, 0x89, 0x66,
  0x24, 0x40, 0x32, 0x24, 0x20, 0x09, 0x20, 0x92, 0x40, 0x7E, 0x09, 0x20,
  0x92, 0x40, 0xC3,
};

const GFXglyph RobotoCondensed_Thin10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 2, 0, -7 },
  { 2, 1, 2, 3, 1, -8 },
  { 3, 5, 7, 5, 0, -7 },
  { 8, 3, 9, 5, 1, -8 },
  { 12, 5, 7, 7, 1, -7 },
  { 17, 4, 7, 5, 1, -7 },
  { 21, 1, 2, 2, 0, -8 },
  { 22, 2, 10, 3, 1, -8 },
  { 25, 2, 10, 3, 0, -8 },
  { 28, 4, 4, 4, 0, -7 },
  { 30, 5, 4, 5, 0, -5 },
  { 33, 1, 2, 2, 0, -1 },
  { 34, 2, 1, 3, 0, -4 },
  { 35, 1, 1, 2, 1, -1 },
  { 36, 3, 8, 3, 0, -7 },
  { 39, 3, 7, 5, 1, -7 },
  { 42, 2, 7, 5, 1, -7 },
  { 44, 3, 7, 5, 1, -7 },
  { 47, 3, 7, 5, 1, -7 },
  { 50, 5, 7, 5, 0, -7 },
  { 55, 3, 7, 5, 1, -7 },
  { 58, 3, 7, 5, 1, -7 },
  { 61, 4, 7, 5, 0, -7 },
  { 65, 3, 7, 5, 1, -7 },
  { 68, 3, 7, 5, 1, -7 },
  { 71, 1, 6, 2, 0, -6 },
  { 72, 1, 7, 2, 0, -6 },
  { 73, 4, 4, 5, 0, -5 },
  { 75, 3, 2, 5, 1, -4 },
  { 76, 3, 4, 5, 1, -5 },
  { 78, 3, 7, 4, 0, -7 },
  { 81, 6, 9, 8, 1, -7 },
  { 88, 5, 7, 5, 0, -7 },
  { 93, 4, 7, 5, 1, -7 },
  { 97, 4, 7, 6, 1, -7 },
  { 101, 4, 7, 6, 1, -7 },
  { 105, 4, 7, 5, 1, -7 },
  { 109, 4, 7, 5, 1, -7 },
  { 113, 4, 7, 6, 1, -7 },
  { 117, 4, 7, 6, 1, -7 },
  { 121, 1, 7, 2, 1, -7 },
  { 122, 4, 7, 5, 0, -7 },
  { 126, 4, 7, 6, 1, -7 },
  { 130, 3, 7, 5, 1, -7 },
  { 133, 6, 7, 7, 1, -7 },
  { 139, 4, 7, 6, 1, -7 },
  { 143, 4, 7, 6, 1, -7 },
  { 147, 4, 7, 5, 1, -7 },
  { 151, 4, 8, 6, 1, -7 },
  { 155, 4, 7, 6, 1, -7 },
  { 159, 5, 7, 5, 0, -7 },
  { 164, 5, 7, 5, 0, -7 },
  { 169, 4, 7, 6, 1, -7 },
  { 173, 5, 7, 5, 0, -7 },
  { 178, 8, 7, 8, 0, -7 },
  { 185, 5, 7, 5, 0, -7 },
  { 190, 5, 7, 5, 0, -7 },
  { 195, 5, 7, 5, 0, -7 },
  { 200, 1, 10, 2, 1, -8 },
  { 202, 3, 8, 3, 0, -7 },
  { 205, 1, 10, 2, 0, -8 },
  { 207, 3, 4, 4, 0, -7 },
  { 209, 4, 1, 4, 0, 0 },
  { 210, 1, 2, 3, 1, -8 },
  { 211, 4, 5, 5, 0, -5 },
  { 214, 3, 8, 5, 1, -8 },
  { 217, 4, 5, 5, 0, -5 },
  { 220, 3, 8, 5, 1, -8 },
  { 223, 4, 5, 5, 0, -5 },
  { 226, 3, 8, 3, 0, -8 },
  { 229, 3, 7, 5, 1, -5 },
  { 232, 3, 8, 5, 1, -8 },
  { 235, 1, 7, 2, 0, -7 },
  { 236, 1, 9, 2, 0, -7 },
  { 238, 3, 8, 4, 1, -8 },
  { 241, 1, 8, 2, 0, -8 },
  { 242, 6, 5, 8, 1, -5 },
  { 246, 3, 5, 5, 1, -5 },
  { 248, 3, 5, 5, 1, -5 },
  { 250, 3, 7, 5, 1, -5 },
  { 253, 3, 7, 5, 1, -5 },
  { 256, 2, 5, 3, 1, -5 },
  { 258, 3, 5, 4, 1, -5 },
  { 260, 2, 7, 3, 0, -7 },
  { 262, 3, 5, 5, 1, -5 },
  { 264, 4, 5, 4, 0, -5 },
  { 267, 6, 5, 7, 0, -5 },
  { 271, 4, 5, 4, 0, -5 },
  { 274, 4, 7, 4, 0, -5 },
  { 278, 4, 5, 4, 0, -5 },
  { 281, 3, 10, 3, 0, -8 },
  { 285, 1, 8, 2, 1, -7 },
  { 286, 3, 10, 3, 0, -8 },
  { 290, 4, 2, 6, 1, -4 },
};

const GFXfont RobotoCondensed_Thin10pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin10pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOCONDENSED_THIN10PT7B_H_
