#ifndef _ROBOTOCONDENSED_THIN47PT7B_H_
#define _ROBOTOCONDENSED_THIN47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin47pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x00, 0x00,
  0x06, 0xC0, 0x46, 0x8D, 0x1A, 0x3C, 0x78, 0xB1, 0x62, 0xC4, 0x00, 0xC0,
  0x40, 0x04, 0x06, 0x00, 0x20, 0x20, 0x01, 0x01, 0x00, 0x08, 0x08, 0x00,
  0x40, 0x40, 0x06, 0x02, 0x00, 0x20, 0x30, 0x01, 0x01, 0x80, 0x08, 0x08,
  0x1F, 0xFF, 0xFE, 0x02, 0x02, 0x00, 0x30, 0x10, 0x01, 0x80, 0x80, 0x08,
  0x0C, 0x00, 0x40, 0x40, 0x02, 0x02, 0x00, 0x10, 0x10, 0x00, 0x80, 0x80,
  0x0C, 0x04, 0x00, 0x40, 0x60, 0x02, 0x02, 0x00, 0x10, 0x10, 0x1F, 0xFF,
  0xFE, 0x04, 0x04, 0x00, 0x60, 0x20, 0x03, 0x03, 0x00, 0x10, 0x18, 0x00,
  0x80, 0x80, 0x04, 0x04, 0x00, 0x20, 0x20, 0x01, 0x01, 0x00, 0x18, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x3F, 0x00,
  0x60, 0xE0, 0x40, 0x18, 0x40, 0x04, 0x60, 0x03, 0x20, 0x00, 0x90, 0x00,
  0x48, 0x00, 0x34, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x03, 0x40, 0x01, 0x30,
  0x01, 0x8C, 0x01, 0x83, 0x83, 0x80, 0x3F, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x19, 0x80, 0x00, 0x10,
  0x20, 0x00, 0x18, 0x18, 0x00, 0x08, 0x04, 0x02, 0x04, 0x02, 0x01, 0x02,
  0x01, 0x01, 0x81, 0x00, 0x80, 0x80, 0x80, 0x40, 0x80, 0x40, 0x20, 0x40,
  0x20, 0x10, 0x40, 0x10, 0x08, 0x60, 0x0C, 0x0C, 0x20, 0x02, 0x04, 0x30,
  0x00, 0xCC, 0x10, 0x00, 0x3C, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x1E, 0x00, 0x04, 0x31, 0x80, 0x04, 0x10, 0x60, 0x06, 0x10, 0x10, 0x02,
  0x08, 0x0C, 0x03, 0x0C, 0x02, 0x01, 0x04, 0x01, 0x01, 0x02, 0x00, 0x80,
  0x81, 0x00, 0x40, 0x80, 0x80, 0x20, 0x40, 0x60, 0x10, 0x40, 0x10, 0x18,
  0x00, 0x08, 0x08, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x71, 0x80, 0x02, 0x06, 0x00, 0x20, 0x10, 0x01,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x10, 0x08,
  0x00, 0x80, 0xC0, 0x04, 0x0C, 0x00, 0x10, 0xC0, 0x00, 0x8C, 0x00, 0x02,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x09, 0x00, 0x00, 0x84, 0x00,
  0x0C, 0x30, 0x0C, 0xC0, 0xC0, 0x64, 0x02, 0x03, 0x60, 0x08, 0x12, 0x00,
  0x60, 0x90, 0x01, 0x84, 0x80, 0x04, 0x64, 0x00, 0x12, 0x20, 0x00, 0xF1,
  0x00, 0x03, 0x0C, 0x00, 0x18, 0x20, 0x01, 0x20, 0xC0, 0x11, 0x83, 0x87,
  0x06, 0x07, 0xE0, 0x10, 0xFF, 0xFA, 0x80, 0x00, 0x80, 0x80, 0x80, 0xC0,
  0x40, 0x40, 0x20, 0x30, 0x10, 0x08, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x18, 0x04, 0x02,
  0x01, 0x80, 0x40, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x04,
  0x01, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x0C, 0x04,
  0x06, 0x02, 0x02, 0x01, 0x01, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x0C, 0x0D, 0xC3,
  0x1C, 0x0E, 0xDC, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x04, 0x80, 0x03, 0x30,
  0x01, 0x86, 0x00, 0x40, 0x80, 0x30, 0x10, 0x18, 0x06, 0x04, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x0F, 0xFF, 0xFE, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x24, 0x92, 0x5A, 0x80, 0xFF, 0x80, 0xEC, 0x00, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x00, 0x03, 0xE0, 0x06, 0x1C, 0x06, 0x03,
  0x06, 0x00, 0xC2, 0x00, 0x22, 0x00, 0x19, 0x00, 0x05, 0x80, 0x02, 0xC0,
  0x01, 0x40, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0x60,
  0x00, 0x90, 0x00, 0x48, 0x00, 0x62, 0x00, 0x21, 0x80, 0x30, 0x60, 0x30,
  0x18, 0x70, 0x03, 0xE0, 0x00, 0x00, 0x83, 0xC7, 0x2E, 0x18, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x07, 0xE0, 0x0E, 0x1C, 0x0C,
  0x03, 0x04, 0x00, 0xC4, 0x00, 0x26, 0x00, 0x1A, 0x00, 0x0D, 0x00, 0x02,
  0x80, 0x01, 0x40, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x01, 0x83, 0x01, 0x80,
  0x20, 0x40, 0x04, 0x20, 0x01, 0x88, 0x00, 0x26, 0x00, 0x09, 0x00, 0x02,
  0x40, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x01, 0xF8, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x50, 0x00, 0x14, 0x00, 0x05, 0x80, 0x03, 0x20, 0x00, 0x8C,
  0x00, 0x61, 0x80, 0x30, 0x38, 0x38, 0x03, 0xF8, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0A, 0x00, 0x01, 0xA0, 0x00, 0x12, 0x00, 0x03, 0x20,
  0x00, 0x22, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x08, 0x20, 0x01, 0x82,
  0x00, 0x10, 0x20, 0x03, 0x02, 0x00, 0x20, 0x20, 0x04, 0x02, 0x00, 0x40,
  0x20, 0x08, 0x02, 0x01, 0x80, 0x20, 0x10, 0x02, 0x03, 0x00, 0x20, 0x20,
  0x02, 0x06, 0x00, 0x20, 0xC0, 0x02, 0x0F, 0xFF, 0xFF, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x47, 0xE0, 0x58, 0x38,
  0x60, 0x0C, 0x40, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x01, 0x40, 0x03, 0x40, 0x02, 0x20, 0x06, 0x30, 0x0C, 0x1C, 0x18,
  0x07, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x7E, 0x0C, 0xE1, 0xC4, 0xC0, 0x32, 0x80, 0x09, 0xC0, 0x02,
  0xC0, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x68,
  0x00, 0x22, 0x00, 0x31, 0x80, 0x10, 0x60, 0x10, 0x1C, 0x30, 0x03, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x00, 0x03, 0xF0, 0x03, 0x87, 0x01, 0x80, 0x60, 0xC0,
  0x04, 0x20, 0x01, 0x88, 0x00, 0x26, 0x00, 0x09, 0x00, 0x03, 0x40, 0x00,
  0xD0, 0x00, 0x36, 0x00, 0x0C, 0x80, 0x02, 0x20, 0x00, 0x84, 0x00, 0x41,
  0x80, 0x20, 0x18, 0x30, 0x03, 0xF8, 0x03, 0x03, 0x81, 0x00, 0x30, 0x80,
  0x06, 0x60, 0x00, 0xD0, 0x00, 0x14, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0x60, 0x00, 0xC8, 0x00, 0x61,
  0x80, 0x30, 0x38, 0x38, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0x87, 0x01,
  0x80, 0x60, 0x40, 0x0C, 0x20, 0x01, 0x08, 0x00, 0x64, 0x00, 0x09, 0x00,
  0x02, 0x40, 0x00, 0xB0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x50, 0x00, 0x14, 0x00, 0x0D, 0x00, 0x03, 0x60, 0x01, 0xC8, 0x00, 0x53,
  0x00, 0x24, 0x60, 0x1B, 0x0E, 0x18, 0xC0, 0xFC, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x36, 0x76, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x22, 0x22, 0x26, 0x6C, 0x80, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x07, 0xC0, 0x61, 0xC3, 0x01, 0x98, 0x02, 0x40, 0x0F, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x08, 0x08, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x04, 0x30, 0x00,
  0x00, 0x06, 0x30, 0x01, 0xF0, 0x02, 0x20, 0x07, 0x18, 0x02, 0x60, 0x0C,
  0x0C, 0x02, 0x40, 0x18, 0x04, 0x03, 0x40, 0x10, 0x04, 0x03, 0x40, 0x20,
  0x04, 0x01, 0xC0, 0x20, 0x04, 0x01, 0x80, 0x60, 0x04, 0x01, 0x80, 0x40,
  0x0C, 0x01, 0x80, 0x40, 0x0C, 0x01, 0x80, 0x40, 0x08, 0x01, 0x80, 0x40,
  0x08, 0x03, 0x80, 0x40, 0x08, 0x03, 0x80, 0x40, 0x08, 0x02, 0x80, 0x40,
  0x08, 0x02, 0x80, 0x40, 0x18, 0x02, 0x80, 0x40, 0x18, 0x06, 0xC0, 0x40,
  0x18, 0x04, 0xC0, 0x40, 0x28, 0x0C, 0x40, 0x20, 0x44, 0x08, 0x40, 0x31,
  0x86, 0x30, 0x60, 0x0F, 0x03, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x04, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40, 0x00, 0x04, 0xC0,
  0x00, 0x08, 0x80, 0x00, 0x11, 0x00, 0x00, 0x43, 0x00, 0x00, 0x82, 0x00,
  0x01, 0x04, 0x00, 0x06, 0x08, 0x00, 0x08, 0x08, 0x00, 0x10, 0x10, 0x00,
  0x60, 0x20, 0x00, 0x80, 0x20, 0x01, 0x00, 0x40, 0x06, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x60, 0x02, 0x00, 0x80, 0x06, 0x01, 0x00,
  0x04, 0x07, 0xFF, 0xF8, 0x08, 0x00, 0x18, 0x10, 0x00, 0x10, 0x60, 0x00,
  0x20, 0x80, 0x00, 0x61, 0x00, 0x00, 0x46, 0x00, 0x00, 0x88, 0x00, 0x01,
  0x90, 0x00, 0x01, 0x20, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xFF, 0xF0, 0x30,
  0x07, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x01, 0x30, 0x00, 0x6C, 0x00,
  0x0B, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x02,
  0xC0, 0x01, 0x30, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x70, 0xFF, 0xF8, 0x30,
  0x01, 0x8C, 0x00, 0x13, 0x00, 0x02, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x33, 0x00, 0x38, 0xFF, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x38, 0x38, 0x03, 0x00, 0x30, 0x20, 0x00, 0x83, 0x00,
  0x02, 0x10, 0x00, 0x19, 0x80, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x12,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x68, 0x00, 0x03, 0x40, 0x00, 0x12, 0x00, 0x00, 0x98, 0x00, 0x04, 0x40,
  0x00, 0x63, 0x00, 0x02, 0x0C, 0x00, 0x20, 0x30, 0x03, 0x00, 0xE0, 0xE0,
  0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x0C, 0x01, 0xC0, 0xC0, 0x07, 0x0C, 0x00,
  0x18, 0xC0, 0x00, 0x8C, 0x00, 0x04, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0xC0,
  0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00,
  0x04, 0xC0, 0x00, 0x8C, 0x00, 0x18, 0xC0, 0x07, 0x0C, 0x01, 0xC0, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xFF, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x70,
  0x70, 0x18, 0x00, 0xC3, 0x00, 0x04, 0x20, 0x00, 0x26, 0x00, 0x03, 0x40,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x1F, 0xF8, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x14, 0x00,
  0x01, 0x40, 0x00, 0x16, 0x00, 0x01, 0x20, 0x00, 0x11, 0x00, 0x03, 0x0C,
  0x00, 0xE0, 0x70, 0x78, 0x01, 0xFE, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x18, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x60, 0x00, 0xB0, 0x00,
  0x48, 0x00, 0x64, 0x00, 0x21, 0x00, 0x30, 0xC0, 0x30, 0x38, 0x70, 0x07,
  0xE0, 0x00, 0xC0, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x00, 0x8C, 0x00, 0x10,
  0xC0, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x10,
  0x0C, 0x02, 0x00, 0xC0, 0x40, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x30,
  0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC9, 0x00, 0x0D, 0x18, 0x00, 0xE0,
  0xC0, 0x0C, 0x04, 0x00, 0xC0, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x0C,
  0x00, 0x80, 0xC0, 0x04, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x10,
  0xC0, 0x00, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0E, 0x80, 0x00, 0x02, 0xD0, 0x00, 0x00, 0x5B, 0x00, 0x00, 0x1B,
  0x20, 0x00, 0x02, 0x64, 0x00, 0x00, 0x4C, 0x40, 0x00, 0x11, 0x88, 0x00,
  0x02, 0x39, 0x80, 0x00, 0x47, 0x10, 0x00, 0x10, 0xE2, 0x00, 0x02, 0x1C,
  0x60, 0x00, 0xC3, 0x84, 0x00, 0x10, 0x70, 0x80, 0x02, 0x0E, 0x08, 0x00,
  0xC1, 0xC1, 0x00, 0x10, 0x38, 0x20, 0x02, 0x07, 0x02, 0x00, 0x80, 0xE0,
  0x40, 0x10, 0x1C, 0x0C, 0x06, 0x03, 0x80, 0x80, 0x80, 0x70, 0x10, 0x10,
  0x0E, 0x01, 0x06, 0x01, 0xC0, 0x20, 0x80, 0x38, 0x04, 0x10, 0x07, 0x00,
  0x44, 0x00, 0xE0, 0x08, 0x80, 0x1C, 0x01, 0xB0, 0x03, 0x80, 0x14, 0x00,
  0x70, 0x02, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x04, 0x00, 0x20, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1D, 0x00, 0x00,
  0xEC, 0x00, 0x07, 0x20, 0x00, 0x38, 0x80, 0x01, 0xC6, 0x00, 0x0E, 0x10,
  0x00, 0x70, 0xC0, 0x03, 0x82, 0x00, 0x1C, 0x08, 0x00, 0xE0, 0x60, 0x07,
  0x01, 0x00, 0x38, 0x0C, 0x01, 0xC0, 0x20, 0x0E, 0x01, 0x80, 0x70, 0x04,
  0x03, 0x80, 0x10, 0x1C, 0x00, 0xC0, 0xE0, 0x02, 0x07, 0x00, 0x18, 0x38,
  0x00, 0x41, 0xC0, 0x01, 0x0E, 0x00, 0x0C, 0x70, 0x00, 0x23, 0x80, 0x01,
  0x9C, 0x00, 0x04, 0xE0, 0x00, 0x17, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x18, 0x01, 0xFC, 0x00, 0x38, 0x38, 0x03, 0x00, 0x30, 0x20, 0x00,
  0xC3, 0x00, 0x02, 0x10, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x03, 0x40,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0xD0, 0x00,
  0x04, 0x40, 0x00, 0x23, 0x00, 0x02, 0x08, 0x00, 0x30, 0x30, 0x03, 0x00,
  0xE0, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x30, 0x03, 0x8C, 0x00, 0x33,
  0x00, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0B, 0x00, 0x06, 0xC0, 0x03, 0x30, 0x03, 0x8F, 0xFF, 0x83,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x38,
  0x38, 0x03, 0x00, 0x30, 0x20, 0x00, 0xC3, 0x00, 0x02, 0x10, 0x00, 0x09,
  0x00, 0x00, 0x48, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0x40,
  0x00, 0x0A, 0x00, 0x00, 0xD0, 0x00, 0x04, 0x40, 0x00, 0x23, 0x00, 0x02,
  0x08, 0x00, 0x30, 0x30, 0x03, 0x00, 0xE0, 0xE0, 0x01, 0xFF, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0xFF, 0xF8, 0x08, 0x00, 0xE0, 0x80, 0x03, 0x08, 0x00,
  0x18, 0x80, 0x00, 0x88, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80,
  0x00, 0x68, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x04, 0x80, 0x00, 0x48,
  0x00, 0x04, 0x80, 0x00, 0x88, 0x00, 0x18, 0x80, 0x03, 0x08, 0x00, 0xE0,
  0xFF, 0xF8, 0x08, 0x01, 0x80, 0x80, 0x08, 0x08, 0x00, 0xC0, 0x80, 0x04,
  0x08, 0x00, 0x60, 0x80, 0x02, 0x08, 0x00, 0x30, 0x80, 0x01, 0x08, 0x00,
  0x08, 0x80, 0x00, 0xC8, 0x00, 0x04, 0x80, 0x00, 0x68, 0x00, 0x02, 0x80,
  0x00, 0x30, 0x01, 0xFC, 0x00, 0x70, 0x70, 0x18, 0x00, 0xC3, 0x00, 0x04,
  0x20, 0x00, 0x26, 0x00, 0x02, 0x40, 0x00, 0x34, 0x00, 0x01, 0x40, 0x00,
  0x14, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x16, 0x00, 0x01,
  0x20, 0x00, 0x33, 0x00, 0x06, 0x18, 0x00, 0xC0, 0x70, 0x78, 0x01, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0xA0, 0x00, 0x36, 0x00, 0x04, 0x40, 0x01, 0x86, 0x00, 0x60, 0x70, 0x78,
  0x03, 0xF8, 0x00, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x09, 0x00, 0x00, 0x13,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x06, 0x08,
  0x00, 0x08, 0x10, 0x00, 0x10, 0x20, 0x00, 0x60, 0x60, 0x00, 0x80, 0x40,
  0x01, 0x00, 0x80, 0x06, 0x01, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x80, 0x04, 0x01, 0x00, 0x08, 0x06, 0x00, 0x18, 0x08,
  0x00, 0x10, 0x10, 0x00, 0x20, 0x20, 0x00, 0x60, 0x80, 0x00, 0x41, 0x00,
  0x00, 0x82, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x10, 0x00, 0x02, 0x20, 0x00,
  0x04, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x10, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x50, 0x00, 0x78, 0x00, 0x28, 0x00, 0x34, 0x00, 0x14, 0x00, 0x12, 0x00,
  0x19, 0x00, 0x09, 0x00, 0x08, 0x80, 0x04, 0xC0, 0x04, 0x40, 0x06, 0x20,
  0x02, 0x20, 0x02, 0x10, 0x03, 0x08, 0x01, 0x08, 0x01, 0x04, 0x00, 0x86,
  0x00, 0x82, 0x00, 0xC3, 0x00, 0x41, 0x00, 0x40, 0x80, 0x60, 0x40, 0x20,
  0x40, 0x20, 0x20, 0x10, 0x30, 0x10, 0x10, 0x18, 0x18, 0x08, 0x08, 0x0C,
  0x04, 0x0C, 0x02, 0x04, 0x02, 0x04, 0x01, 0x02, 0x01, 0x02, 0x00, 0x81,
  0x00, 0xC3, 0x00, 0x41, 0x80, 0x21, 0x00, 0x10, 0x80, 0x10, 0x80, 0x08,
  0x40, 0x08, 0x40, 0x04, 0x20, 0x06, 0x60, 0x03, 0x30, 0x03, 0x20, 0x00,
  0x90, 0x00, 0x90, 0x00, 0x48, 0x00, 0x48, 0x00, 0x24, 0x00, 0x2C, 0x00,
  0x12, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x0C, 0x80, 0x00,
  0x63, 0x00, 0x01, 0x04, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x30, 0x01, 0x80,
  0x40, 0x04, 0x01, 0x80, 0x20, 0x02, 0x01, 0x80, 0x04, 0x04, 0x00, 0x18,
  0x30, 0x00, 0x20, 0x80, 0x00, 0xC4, 0x00, 0x01, 0x30, 0x00, 0x02, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xA0, 0x00, 0x06, 0xC0, 0x00,
  0x11, 0x00, 0x00, 0x86, 0x00, 0x06, 0x08, 0x00, 0x10, 0x10, 0x00, 0xC0,
  0x60, 0x02, 0x00, 0x80, 0x10, 0x03, 0x00, 0xC0, 0x04, 0x02, 0x00, 0x08,
  0x18, 0x00, 0x30, 0x40, 0x00, 0x42, 0x00, 0x01, 0x98, 0x00, 0x02, 0x40,
  0x00, 0x0C, 0xC0, 0x00, 0x04, 0x80, 0x00, 0x19, 0x80, 0x00, 0x21, 0x00,
  0x00, 0xC3, 0x00, 0x01, 0x02, 0x00, 0x06, 0x06, 0x00, 0x08, 0x04, 0x00,
  0x30, 0x0C, 0x00, 0x40, 0x08, 0x01, 0x80, 0x08, 0x02, 0x00, 0x10, 0x0C,
  0x00, 0x10, 0x10, 0x00, 0x20, 0x60, 0x00, 0x20, 0x80, 0x00, 0x42, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x90, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFC, 0x80, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0xFC, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0xFC, 0x02, 0x00, 0x38, 0x01, 0x40,
  0x0A, 0x00, 0xC8, 0x04, 0x40, 0x22, 0x03, 0x18, 0x10, 0x40, 0x82, 0x0C,
  0x18, 0x40, 0x42, 0x02, 0x30, 0x19, 0x00, 0x48, 0x02, 0xC0, 0x18, 0xFF,
  0xFF, 0x80, 0x41, 0x83, 0x06, 0x08, 0x30, 0x03, 0xF0, 0x06, 0x0E, 0x04,
  0x01, 0x84, 0x00, 0x46, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x7F, 0xE1, 0xE0, 0x11, 0x80,
  0x09, 0x80, 0x04, 0x80, 0x02, 0xC0, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50,
  0x00, 0x6C, 0x00, 0x32, 0x00, 0x29, 0x80, 0x24, 0x70, 0xE2, 0x0F, 0xC1,
  0x80, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x87, 0xE0, 0x9C,
  0x38, 0xB0, 0x0C, 0xE0, 0x04, 0xC0, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0x80,
  0x02, 0xC0, 0x06, 0xC0, 0x04, 0xA0, 0x0C, 0x9C, 0x38, 0x87, 0xE0, 0x03,
  0xF0, 0x07, 0x0E, 0x06, 0x01, 0x84, 0x00, 0x66, 0x00, 0x12, 0x00, 0x09,
  0x00, 0x06, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x50, 0x00, 0x68, 0x00, 0x22, 0x00, 0x11, 0x00, 0x18, 0x40, 0x18,
  0x1C, 0x38, 0x03, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x07, 0xE1, 0x1C, 0x39, 0x30, 0x0D, 0x60, 0x05, 0x40, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x03, 0x60, 0x03, 0x30, 0x0D, 0x1C,
  0x39, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0x0E, 0x06, 0x01, 0x86, 0x00, 0x62,
  0x00, 0x12, 0x00, 0x09, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x08, 0x60, 0x0C, 0x1C, 0x1C, 0x03, 0xF8, 0x00, 0x01, 0xE0, 0xC0,
  0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x03, 0xFF,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x00, 0x07, 0xE1,
  0x1C, 0x39, 0x30, 0x0D, 0x60, 0x05, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x40, 0x01, 0x40, 0x03, 0x60, 0x07, 0x30, 0x0D, 0x1C, 0x39, 0x07, 0xE1,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x60, 0x02, 0x30, 0x04, 0x1C, 0x18, 0x07, 0xE0, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x0F, 0x84, 0x61, 0xC9, 0x00, 0xD6, 0x00, 0xA8, 0x01,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0xEC, 0x00, 0x00, 0x09, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x48, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x18, 0xF0, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x34, 0x00, 0xC8, 0x01, 0x10,
  0x04, 0x20, 0x10, 0x40, 0x40, 0x81, 0x81, 0x06, 0x02, 0x18, 0x04, 0x60,
  0x09, 0x80, 0x13, 0x00, 0x29, 0x00, 0x63, 0x00, 0x83, 0x01, 0x02, 0x02,
  0x02, 0x04, 0x06, 0x08, 0x04, 0x10, 0x04, 0x20, 0x0C, 0x40, 0x0C, 0x80,
  0x09, 0x00, 0x1A, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x83, 0xE0,
  0x0F, 0x84, 0x61, 0xC1, 0x87, 0x24, 0x02, 0x10, 0x0D, 0x40, 0x09, 0x00,
  0x2E, 0x00, 0x50, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x08, 0x83, 0xE1, 0x18, 0x72, 0x40, 0x35, 0x80,
  0x2A, 0x00, 0x58, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x07, 0xE0, 0x0E, 0x0C, 0x0C, 0x03, 0x04, 0x00,
  0x44, 0x00, 0x32, 0x00, 0x0B, 0x00, 0x05, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x48, 0x00, 0x24, 0x00,
  0x31, 0x00, 0x10, 0xC0, 0x10, 0x38, 0x30, 0x07, 0xE0, 0x00, 0x87, 0xE0,
  0x9C, 0x38, 0xB0, 0x0C, 0xE0, 0x04, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02,
  0x80, 0x02, 0xC0, 0x02, 0xC0, 0x04, 0xA0, 0x0C, 0x9C, 0x38, 0x87, 0xE0,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x07, 0xE1, 0x1C, 0x39,
  0x30, 0x0D, 0x60, 0x07, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x01,
  0x40, 0x03, 0x60, 0x03, 0x30, 0x0D, 0x1C, 0x39, 0x07, 0xE1, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x87, 0xC6, 0x24, 0x14, 0x0C, 0x06,
  0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x07,
  0xE0, 0x18, 0x38, 0x30, 0x04, 0x60, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x03, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x40, 0x01, 0x40, 0x03, 0x60, 0x02, 0x30, 0x06, 0x1C, 0x18, 0x07,
  0xF0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x07, 0xFE,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x1F, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x3C, 0x00,
  0x68, 0x01, 0x58, 0x06, 0x9C, 0x39, 0x0F, 0xC2, 0xC0, 0x00, 0xD0, 0x00,
  0x24, 0x00, 0x09, 0x80, 0x06, 0x20, 0x01, 0x08, 0x00, 0x43, 0x00, 0x30,
  0x40, 0x08, 0x10, 0x02, 0x06, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x0C,
  0x0C, 0x01, 0x02, 0x00, 0x40, 0x80, 0x18, 0x60, 0x02, 0x10, 0x00, 0x84,
  0x00, 0x33, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x78, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x04, 0x00, 0x78, 0x01, 0x80, 0x09,
  0x00, 0x28, 0x01, 0x20, 0x05, 0x00, 0x24, 0x00, 0xA0, 0x0C, 0xC0, 0x34,
  0x01, 0x88, 0x04, 0xC0, 0x21, 0x00, 0x88, 0x04, 0x20, 0x11, 0x01, 0x86,
  0x06, 0x30, 0x30, 0x40, 0x82, 0x04, 0x08, 0x10, 0x40, 0x81, 0x06, 0x08,
  0x30, 0x30, 0x81, 0x86, 0x02, 0x10, 0x10, 0x80, 0x42, 0x02, 0x10, 0x08,
  0xC0, 0x46, 0x01, 0x90, 0x0C, 0xC0, 0x12, 0x00, 0x90, 0x02, 0x40, 0x12,
  0x00, 0x58, 0x02, 0x40, 0x0A, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x90, 0x00, 0x8C, 0x00,
  0xC2, 0x00, 0xC0, 0x80, 0x40, 0x60, 0x60, 0x10, 0x20, 0x0C, 0x30, 0x02,
  0x10, 0x00, 0x90, 0x00, 0x78, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x04, 0x80, 0x06, 0x60, 0x02, 0x10, 0x02, 0x0C, 0x03, 0x03, 0x01, 0x00,
  0x81, 0x80, 0x60, 0x80, 0x10, 0x80, 0x0C, 0xC0, 0x03, 0x40, 0x00, 0x80,
  0xC0, 0x00, 0xD0, 0x00, 0x24, 0x00, 0x09, 0x80, 0x06, 0x20, 0x01, 0x08,
  0x00, 0x43, 0x00, 0x30, 0x40, 0x08, 0x10, 0x02, 0x06, 0x01, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x0C, 0x0C, 0x01, 0x02, 0x00, 0x40, 0x80, 0x18, 0x20,
  0x02, 0x18, 0x00, 0x84, 0x00, 0x31, 0x00, 0x04, 0xC0, 0x01, 0x20, 0x00,
  0x68, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x20, 0x18, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x20, 0x38, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x40, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x07,
  0x00, 0x40, 0x00, 0x1E, 0x00, 0x03, 0x18, 0x00, 0xD0, 0x30, 0x07, 0x00,
  0x80, 0x28, 0x02, 0x01, 0x40, 0x08, 0x1A, 0x00, 0x31, 0x90, 0x00, 0xF8,
};

const GFXglyph RobotoCondensed_Thin47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 33, 9, 3, -33 },
  { 14, 7, 9, 12, 3, -35 },
  { 22, 21, 33, 23, 2, -33 },
  { 109, 17, 41, 23, 3, -37 },
  { 197, 25, 33, 31, 3, -33 },
  { 301, 21, 33, 25, 3, -33 },
  { 388, 2, 9, 8, 3, -35 },
  { 391, 9, 48, 13, 3, -37 },
  { 445, 9, 48, 13, 1, -37 },
  { 499, 18, 18, 20, 1, -33 },
  { 540, 19, 25, 23, 2, -28 },
  { 600, 3, 9, 9, 2, -4 },
  { 604, 9, 1, 13, 2, -16 },
  { 606, 3, 2, 10, 3, -2 },
  { 607, 13, 36, 16, 1, -33 },
  { 666, 17, 33, 23, 3, -33 },
  { 737, 9, 33, 23, 4, -33 },
  { 775, 17, 33, 23, 3, -33 },
  { 846, 18, 33, 23, 2, -33 },
  { 921, 20, 33, 23, 2, -33 },
  { 1004, 16, 33, 23, 4, -33 },
  { 1070, 17, 33, 23, 3, -33 },
  { 1141, 18, 33, 23, 2, -33 },
  { 1216, 18, 33, 23, 2, -33 },
  { 1291, 18, 33, 23, 2, -33 },
  { 1366, 3, 24, 8, 3, -24 },
  { 1375, 4, 29, 8, 2, -24 },
  { 1390, 16, 19, 21, 2, -25 },
  { 1428, 17, 10, 23, 3, -20 },
  { 1450, 16, 19, 21, 3, -25 },
  { 1488, 14, 33, 18, 2, -33 },
  { 1546, 32, 42, 38, 3, -32 },
  { 1714, 23, 33, 25, 1, -33 },
  { 1809, 18, 33, 25, 4, -33 },
  { 1884, 21, 33, 27, 3, -33 },
  { 1971, 20, 33, 27, 4, -33 },
  { 2054, 18, 33, 24, 4, -33 },
  { 2129, 18, 33, 24, 4, -33 },
  { 2204, 20, 33, 28, 4, -33 },
  { 2287, 21, 33, 29, 4, -33 },
  { 2374, 1, 33, 11, 5, -33 },
  { 2379, 17, 33, 23, 2, -33 },
  { 2450, 20, 33, 26, 4, -33 },
  { 2533, 16, 33, 22, 4, -33 },
  { 2599, 27, 33, 35, 4, -33 },
  { 2711, 21, 33, 29, 4, -33 },
  { 2798, 21, 33, 27, 3, -33 },
  { 2885, 18, 33, 25, 4, -33 },
  { 2960, 21, 39, 27, 3, -33 },
  { 3063, 20, 33, 27, 4, -33 },
  { 3146, 20, 33, 24, 2, -33 },
  { 3229, 22, 33, 25, 1, -33 },
  { 3320, 19, 33, 27, 4, -33 },
  { 3399, 23, 33, 25, 1, -33 },
  { 3494, 33, 33, 37, 2, -33 },
  { 3631, 22, 33, 25, 1, -33 },
  { 3722, 23, 33, 25, 1, -33 },
  { 3817, 20, 33, 25, 2, -33 },
  { 3900, 6, 45, 10, 4, -38 },
  { 3934, 13, 36, 16, 2, -33 },
  { 3993, 6, 45, 10, 0, -38 },
  { 4027, 13, 17, 17, 2, -33 },
  { 4055, 17, 1, 17, 0, 0 },
  { 4058, 6, 6, 12, 3, -35 },
  { 4063, 17, 25, 22, 2, -25 },
  { 4117, 16, 35, 23, 4, -35 },
  { 4187, 17, 25, 21, 2, -25 },
  { 4241, 16, 35, 23, 3, -35 },
  { 4311, 17, 25, 21, 2, -25 },
  { 4365, 11, 35, 14, 2, -35 },
  { 4414, 16, 35, 23, 3, -25 },
  { 4484, 15, 35, 23, 4, -35 },
  { 4550, 3, 34, 9, 3, -34 },
  { 4563, 8, 44, 10, -2, -34 },
  { 4607, 15, 35, 20, 4, -35 },
  { 4673, 1, 35, 9, 4, -35 },
  { 4678, 29, 25, 37, 4, -25 },
  { 4769, 15, 25, 23, 4, -25 },
  { 4816, 17, 25, 23, 3, -25 },
  { 4870, 16, 35, 23, 4, -25 },
  { 4940, 16, 35, 23, 3, -25 },
  { 5010, 9, 25, 14, 4, -25 },
  { 5039, 16, 25, 21, 2, -25 },
  { 5089, 11, 32, 14, 1, -32 },
  { 5133, 15, 25, 23, 4, -25 },
  { 5180, 18, 25, 20, 1, -25 },
  { 5237, 27, 25, 31, 2, -25 },
  { 5322, 17, 25, 20, 1, -25 },
  { 5376, 18, 35, 20, 1, -25 },
  { 5455, 17, 25, 20, 2, -25 },
  { 5509, 11, 47, 14, 2, -37 },
  { 5574, 2, 39, 9, 4, -33 },
  { 5584, 12, 47, 14, 0, -37 },
  { 5655, 21, 8, 28, 4, -18 },
};

const GFXfont RobotoCondensed_Thin47pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin47pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin47pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOCONDENSED_THIN47PT7B_H_
