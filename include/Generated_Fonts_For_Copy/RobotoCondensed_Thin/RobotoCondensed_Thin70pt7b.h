#ifndef _ROBOTOCONDENSED_THIN70PT7B_H_
#define _ROBOTOCONDENSED_THIN70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin70pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6C, 0x00, 0x00, 0x00, 0x07, 0xFD, 0x00, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0C, 0x00, 0x06, 0x00, 0x20, 0x00, 0x03, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x20,
  0x03, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x18, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x04, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x10, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x10, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x60, 0x02, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x30, 0x00, 0x01, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x08, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x08, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xC0, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x18, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x20, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x09, 0x80, 0x00, 0x02, 0x20, 0x00, 0x00,
  0x88, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x03, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x07, 0x07, 0x00, 0x03, 0x80,
  0xE0, 0x01, 0xC0, 0x0F, 0x01, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x60, 0x00,
  0xC0, 0x02, 0x01, 0x80, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x06, 0x00, 0x60,
  0x30, 0x00, 0x0C, 0x03, 0x01, 0x80, 0x00, 0x38, 0x18, 0x06, 0x00, 0x00,
  0x7F, 0xE0, 0x30, 0x00, 0x00, 0x7E, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x7E, 0x00, 0x00, 0x18, 0x07, 0xFC, 0x00,
  0x00, 0x60, 0x38, 0x18, 0x00, 0x03, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x06,
  0x00, 0x40, 0x00, 0x60, 0x10, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x06, 0x00,
  0x0C, 0x03, 0x00, 0x08, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x02, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x86,
  0x00, 0xC0, 0x03, 0x18, 0x00, 0xC0, 0x06, 0x30, 0x00, 0xC0, 0x0C, 0xC0,
  0x01, 0x80, 0x11, 0x80, 0x01, 0x80, 0x66, 0x00, 0x01, 0x80, 0xCC, 0x00,
  0x03, 0x81, 0x98, 0x00, 0x03, 0x03, 0x30, 0x00, 0x03, 0x0C, 0x60, 0x00,
  0x03, 0x18, 0xC0, 0x00, 0x07, 0x21, 0x80, 0x00, 0x06, 0xC3, 0x00, 0x00,
  0x07, 0x83, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x6C, 0x0C, 0x00, 0x01, 0x8C, 0x0C, 0x00, 0x06, 0x0C, 0x1E, 0x00, 0x38,
  0x1C, 0x0F, 0x01, 0xE0, 0x18, 0x0F, 0xFF, 0x00, 0x18, 0x03, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xA0, 0x00, 0x10, 0x01, 0xC0, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x1C, 0x00,
  0x40, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x0F, 0xE0, 0x18, 0x0F, 0x9F, 0x83,
  0x07, 0x80, 0x7C, 0x67, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x60, 0x06, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x19, 0x8C, 0xCE,
  0x20, 0xFF, 0xFF, 0xFF, 0xF0, 0x6F, 0xF6, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3C,
  0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x18, 0x03, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x19, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x06, 0x60, 0x00, 0x01, 0x88, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x60, 0x07, 0x00, 0x38, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC1, 0xE3,
  0x1E, 0x0D, 0xE0, 0x3E, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x3E, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x1C, 0x00,
  0x1C, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x60,
  0x00, 0x03, 0x18, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x3C, 0x0F, 0x00, 0x1C, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x46, 0x00, 0x00, 0x19, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x60, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x00, 0xF0,
  0x1E, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30,
  0x06, 0x00, 0x01, 0x80, 0x70, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0xFE, 0x00, 0x23, 0xFF,
  0xC0, 0x6E, 0x00, 0xE0, 0x78, 0x00, 0x30, 0x70, 0x00, 0x18, 0x20, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x07, 0x80,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x03, 0xF8, 0x01, 0x83, 0xFF, 0xC0,
  0x63, 0xC0, 0x38, 0x11, 0xC0, 0x07, 0x04, 0xC0, 0x00, 0xE3, 0x60, 0x00,
  0x1C, 0xD0, 0x00, 0x03, 0x3C, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x03, 0x00, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xE0, 0x70, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x3C, 0x0F, 0x00, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x26, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x18,
  0x00, 0x06, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x0E, 0x01, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x00,
  0x70, 0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x06, 0x40, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x18, 0x0E, 0x00, 0x1C, 0x01, 0xE0, 0x1E,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x38, 0x1F, 0x00, 0x18, 0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x06,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x03,
  0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xF6, 0x00, 0x00, 0x28, 0xC0,
  0x00, 0x1A, 0x38, 0x00, 0x0C, 0x87, 0x00, 0x06, 0x20, 0xE0, 0x03, 0x18,
  0x1C, 0x03, 0x86, 0x03, 0xFF, 0xC1, 0x80, 0x3F, 0x80, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x76, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0xFF, 0x60,
  0x3B, 0xDE, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x18, 0xC6, 0x31, 0x8C,
  0xE6, 0x33, 0x99, 0x8C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xF8, 0x01, 0xC0,
  0xE0, 0x18, 0x01, 0x81, 0x80, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x00, 0xCC,
  0x00, 0x06, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x01, 0xF8, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0xFE, 0x00, 0x04, 0x18, 0x00,
  0x0E, 0x07, 0x00, 0x06, 0x18, 0x00, 0x18, 0x01, 0x80, 0x06, 0x38, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x30, 0x00, 0x60, 0x01, 0x80, 0x02, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x02, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x60, 0x01, 0x80, 0x01, 0x80, 0x03, 0x60, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x60, 0x01, 0x00, 0x01, 0x80, 0x03, 0x60, 0x03,
  0x00, 0x01, 0x80, 0x03, 0x40, 0x03, 0x00, 0x01, 0x80, 0x03, 0x40, 0x03,
  0x00, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x02,
  0x00, 0x01, 0x00, 0x03, 0xC0, 0x06, 0x00, 0x01, 0x00, 0x03, 0xC0, 0x06,
  0x00, 0x01, 0x00, 0x03, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x06,
  0x00, 0x03, 0x00, 0x03, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x02, 0xC0, 0x06,
  0x00, 0x03, 0x00, 0x06, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x06, 0x40, 0x06,
  0x00, 0x03, 0x00, 0x06, 0x40, 0x06, 0x00, 0x07, 0x00, 0x04, 0x60, 0x02,
  0x00, 0x07, 0x00, 0x0C, 0x60, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x60, 0x03,
  0x00, 0x0F, 0x00, 0x18, 0x60, 0x03, 0x00, 0x19, 0x00, 0x18, 0x60, 0x01,
  0x80, 0x31, 0x80, 0x30, 0x30, 0x01, 0x80, 0x71, 0xC0, 0x60, 0x30, 0x00,
  0xE0, 0xE0, 0xE1, 0xC0, 0x30, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x18, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x50, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x08, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x02, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x03, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x09, 0x80, 0x00, 0x01, 0x30, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x30, 0x00, 0x0E,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x07, 0x83, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x07, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x3C, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x1E, 0x01, 0x80, 0x00,
  0x3C, 0x0C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x07,
  0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x78, 0x18, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x70, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x01,
  0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x05, 0x80, 0x00, 0x06, 0x40, 0x00, 0x03, 0x30,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x60, 0x1C, 0x00, 0x60, 0x07, 0x80, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x30, 0x01, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x78, 0x00,
  0x00, 0xC3, 0x70, 0x00, 0x03, 0x18, 0xC0, 0x00, 0x0C, 0xC1, 0x80, 0x00,
  0x36, 0x03, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0x18, 0x00, 0x0E,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xD8, 0x00, 0x00, 0x00, 0x0B, 0xD8, 0x00,
  0x00, 0x00, 0x1B, 0xD8, 0x00, 0x00, 0x00, 0x1B, 0xCC, 0x00, 0x00, 0x00,
  0x13, 0xCC, 0x00, 0x00, 0x00, 0x33, 0xC4, 0x00, 0x00, 0x00, 0x33, 0xC6,
  0x00, 0x00, 0x00, 0x63, 0xC6, 0x00, 0x00, 0x00, 0x63, 0xC2, 0x00, 0x00,
  0x00, 0x63, 0xC3, 0x00, 0x00, 0x00, 0xC3, 0xC3, 0x00, 0x00, 0x00, 0xC3,
  0xC1, 0x80, 0x00, 0x00, 0x83, 0xC1, 0x80, 0x00, 0x01, 0x83, 0xC1, 0x80,
  0x00, 0x01, 0x83, 0xC0, 0xC0, 0x00, 0x01, 0x03, 0xC0, 0xC0, 0x00, 0x03,
  0x03, 0xC0, 0x40, 0x00, 0x03, 0x03, 0xC0, 0x60, 0x00, 0x06, 0x03, 0xC0,
  0x60, 0x00, 0x06, 0x03, 0xC0, 0x30, 0x00, 0x06, 0x03, 0xC0, 0x30, 0x00,
  0x0C, 0x03, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0xC0, 0x18, 0x00, 0x08, 0x03,
  0xC0, 0x18, 0x00, 0x18, 0x03, 0xC0, 0x08, 0x00, 0x18, 0x03, 0xC0, 0x0C,
  0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0xC0, 0x04, 0x00, 0x30,
  0x03, 0xC0, 0x06, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x60, 0x03, 0xC0,
  0x03, 0x00, 0x40, 0x03, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00,
  0xC0, 0x03, 0xC0, 0x01, 0x80, 0x80, 0x03, 0xC0, 0x01, 0x81, 0x80, 0x03,
  0xC0, 0x00, 0x81, 0x80, 0x03, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0xC0, 0x00,
  0xC3, 0x00, 0x03, 0xC0, 0x00, 0x43, 0x00, 0x03, 0xC0, 0x00, 0x66, 0x00,
  0x03, 0xC0, 0x00, 0x66, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3D, 0x80,
  0x00, 0x00, 0x7B, 0x00, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x01, 0xE3, 0x00,
  0x00, 0x03, 0xC6, 0x00, 0x00, 0x07, 0x86, 0x00, 0x00, 0x0F, 0x0C, 0x00,
  0x00, 0x1E, 0x0C, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x78, 0x18, 0x00,
  0x00, 0xF0, 0x18, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x03, 0xC0, 0x30, 0x00,
  0x07, 0x80, 0x60, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0xC0, 0x00, 0x78, 0x00, 0xC0, 0x00, 0xF0, 0x01, 0x80, 0x01,
  0xE0, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x00, 0x07, 0x80, 0x03, 0x00, 0x0F,
  0x00, 0x03, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x78,
  0x00, 0x0C, 0x00, 0xF0, 0x00, 0x0C, 0x01, 0xE0, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x18, 0x07, 0x80, 0x00, 0x18, 0x0F, 0x00, 0x00, 0x30, 0x1E, 0x00,
  0x00, 0x30, 0x3C, 0x00, 0x00, 0x60, 0x78, 0x00, 0x00, 0x60, 0xF0, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x00, 0xC7, 0x80, 0x00,
  0x01, 0x8F, 0x00, 0x00, 0x01, 0x9E, 0x00, 0x00, 0x03, 0x3C, 0x00, 0x00,
  0x03, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x58,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x03, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x03, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x58, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x78, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x1C,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x60, 0x03, 0x80, 0x03, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x3E, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x20, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x0F, 0x01,
  0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x07, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x60, 0x00,
  0x30, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30,
  0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xF0, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x38, 0x07, 0x80, 0x01, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x06, 0x01,
  0xE0, 0x00, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x08, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x40,
  0x04, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x04,
  0x01, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x50, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x08, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x63, 0x00, 0x00, 0x20, 0x60, 0x00, 0x0C,
  0x20, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x04, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x03, 0x00,
  0x01, 0x81, 0x00, 0x01, 0x80, 0x60, 0x00, 0x20, 0x30, 0x00, 0x30, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0,
  0x18, 0x00, 0x30, 0x08, 0x00, 0x10, 0x03, 0x00, 0x04, 0x01, 0x80, 0x06,
  0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x06, 0x00,
  0x18, 0x01, 0x80, 0x06, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x02, 0x00, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00,
  0xC0, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x10, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x19, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x03, 0x60,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00,
  0x60, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x70, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x58, 0x00, 0x1B, 0x00, 0x03, 0x20, 0x00, 0x46, 0x00, 0x18,
  0xC0, 0x03, 0x0C, 0x00, 0x41, 0x80, 0x18, 0x30, 0x03, 0x03, 0x00, 0x40,
  0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x40, 0x18, 0x18, 0x03, 0x03, 0x00,
  0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00,
  0x33, 0x00, 0x03, 0xC0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x03, 0x81,
  0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xF0,
  0x00, 0x60, 0xE0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x1C,
  0x80, 0x00, 0x0E, 0x60, 0x00, 0x0F, 0x30, 0x00, 0x0D, 0x8C, 0x00, 0x0C,
  0xC7, 0x00, 0x1C, 0x61, 0xE0, 0x3C, 0x10, 0x3F, 0xF8, 0x0C, 0x03, 0xE0,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x7E,
  0x00, 0x83, 0xFF, 0x80, 0x87, 0x01, 0xE0, 0x8C, 0x00, 0x70, 0x98, 0x00,
  0x38, 0xB0, 0x00, 0x18, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00,
  0x06, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xE0, 0x00,
  0x0C, 0xE0, 0x00, 0x18, 0xB0, 0x00, 0x38, 0x9C, 0x00, 0x70, 0x8F, 0x01,
  0xE0, 0x83, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0xF0, 0x1E, 0x00, 0xC0, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x01, 0x30,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x18,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x03, 0x80,
  0x3C, 0x07, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x7E, 0x01, 0x03, 0xFF, 0xC1,
  0x07, 0x80, 0xE1, 0x0E, 0x00, 0x31, 0x1C, 0x00, 0x19, 0x18, 0x00, 0x0D,
  0x30, 0x00, 0x05, 0x30, 0x00, 0x07, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x01, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x60, 0x00, 0x01, 0x60, 0x00, 0x01,
  0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x07, 0x18, 0x00, 0x05,
  0x1C, 0x00, 0x0D, 0x0E, 0x00, 0x39, 0x07, 0x80, 0xE1, 0x01, 0xFF, 0xC1,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xF0, 0x1E,
  0x00, 0xE0, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0x3E, 0x03, 0xC0, 0x07,
  0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC3, 0x07, 0x80, 0xE3, 0x0E, 0x00, 0x33,
  0x18, 0x00, 0x1B, 0x38, 0x00, 0x0F, 0x30, 0x00, 0x07, 0x30, 0x00, 0x07,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x30, 0x00, 0x07, 0x18, 0x00, 0x0F, 0x1C, 0x00, 0x1F, 0x0E, 0x00, 0x3B,
  0x07, 0x80, 0xE3, 0x03, 0xFF, 0xC3, 0x00, 0x7E, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x30, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x0E, 0x00, 0x1C, 0x07, 0x00, 0x78, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x80,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x0F, 0x80, 0x80, 0xFF, 0xC2, 0x0E,
  0x07, 0x88, 0x60, 0x07, 0x23, 0x00, 0x0C, 0x98, 0x00, 0x1A, 0x40, 0x00,
  0x6B, 0x00, 0x00, 0xE8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x6E, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x60, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x18, 0x03, 0x0F, 0xE0, 0xFC, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x1A, 0x00, 0x00, 0xC8, 0x00, 0x06, 0x20, 0x00,
  0x30, 0x80, 0x01, 0x82, 0x00, 0x0C, 0x08, 0x00, 0x70, 0x20, 0x03, 0x80,
  0x80, 0x1C, 0x02, 0x00, 0xE0, 0x08, 0x03, 0x00, 0x20, 0x18, 0x00, 0x80,
  0xC0, 0x02, 0x06, 0x00, 0x08, 0x30, 0x00, 0x21, 0x80, 0x00, 0x8F, 0x00,
  0x02, 0x6C, 0x00, 0x0B, 0x18, 0x00, 0x38, 0x30, 0x00, 0xC0, 0xE0, 0x02,
  0x01, 0x80, 0x08, 0x03, 0x00, 0x20, 0x06, 0x00, 0x80, 0x18, 0x02, 0x00,
  0x30, 0x08, 0x00, 0x60, 0x20, 0x01, 0xC0, 0x80, 0x03, 0x02, 0x00, 0x06,
  0x08, 0x00, 0x0C, 0x20, 0x00, 0x30, 0x80, 0x00, 0x62, 0x00, 0x00, 0xC8,
  0x00, 0x03, 0xA0, 0x00, 0x06, 0x80, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x0C, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xC1, 0xC0, 0xF0,
  0x1E, 0x07, 0x8C, 0x30, 0x03, 0x83, 0x80, 0x1C, 0xC6, 0x00, 0x18, 0x70,
  0x00, 0xCC, 0xC0, 0x00, 0xCE, 0x00, 0x06, 0xD8, 0x00, 0x0C, 0xC0, 0x00,
  0x6D, 0x80, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x3E, 0x02, 0x03, 0xFF, 0x08, 0x38, 0x1E, 0x21,
  0x80, 0x1C, 0x8C, 0x00, 0x32, 0x60, 0x00, 0x69, 0x00, 0x01, 0xAC, 0x00,
  0x03, 0xA0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3C, 0x0F, 0x00, 0x1C, 0x00,
  0xE0, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x83, 0x80, 0x00, 0x70, 0xC0,
  0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x09, 0x00, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0xE0, 0x03, 0xC0, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x83, 0xFF,
  0x80, 0x87, 0x01, 0xE0, 0x8C, 0x00, 0x70, 0x98, 0x00, 0x38, 0xB0, 0x00,
  0x18, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00,
  0x18, 0xB0, 0x00, 0x38, 0x9C, 0x00, 0x70, 0x8F, 0x01, 0xE0, 0x83, 0xFF,
  0x80, 0x80, 0x7E, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0xC1, 0x07, 0x80, 0xE1, 0x0E, 0x00, 0x31, 0x1C, 0x00, 0x19, 0x18, 0x00,
  0x0D, 0x30, 0x00, 0x07, 0x30, 0x00, 0x07, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x01, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x60, 0x00, 0x01, 0x60, 0x00,
  0x01, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x07, 0x18, 0x00,
  0x0D, 0x1C, 0x00, 0x1D, 0x0E, 0x00, 0x39, 0x07, 0x80, 0xF1, 0x01, 0xFF,
  0xC1, 0x00, 0x7E, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x7E, 0x07, 0xF8, 0x70,
  0x23, 0x00, 0x98, 0x02, 0x40, 0x0B, 0x00, 0x28, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x78, 0x07, 0x81, 0xC0,
  0x03, 0x83, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x61, 0xC0, 0x03, 0x81, 0xF0, 0x1E,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x03, 0xFF, 0xF7, 0xFF, 0xE0, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x05, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x98, 0x00, 0x07, 0x30, 0x00, 0x1E,
  0x30, 0x00, 0x6C, 0x70, 0x01, 0x98, 0x78, 0x0E, 0x30, 0x3F, 0xF8, 0x60,
  0x1F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x08, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x40, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x02,
  0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0x80, 0x01, 0x00, 0x60, 0x00,
  0x60, 0x18, 0x00, 0x18, 0x04, 0x00, 0x02, 0x03, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x30, 0x20, 0x00, 0x04, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x08, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x60, 0x00, 0x3C, 0x00, 0x06,
  0x60, 0x00, 0x3C, 0x00, 0x06, 0x60, 0x00, 0x24, 0x00, 0x06, 0x30, 0x00,
  0x66, 0x00, 0x0C, 0x30, 0x00, 0x66, 0x00, 0x0C, 0x30, 0x00, 0x66, 0x00,
  0x0C, 0x30, 0x00, 0xC6, 0x00, 0x0C, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x18,
  0x00, 0xC3, 0x00, 0x18, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x18, 0x01, 0x81,
  0x80, 0x18, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x0C, 0x01, 0x81, 0x80, 0x30,
  0x0C, 0x01, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x03,
  0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x06, 0x00, 0xC0,
  0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x03,
  0x06, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x20, 0xC0, 0x03, 0x0C, 0x00,
  0x30, 0xC0, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x01, 0x88, 0x00, 0x31, 0x80,
  0x01, 0x98, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x19, 0x80, 0x00, 0x98,
  0x00, 0x19, 0x00, 0x00, 0xD0, 0x00, 0x0B, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x0C, 0x00,
  0x0C, 0x03, 0x00, 0x07, 0x00, 0x60, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x03,
  0x00, 0x30, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x03, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x18, 0x60, 0x00, 0x03, 0x30, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x18, 0x00,
  0x03, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x06,
  0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0xC0,
  0x01, 0xC0, 0x30, 0x00, 0x30, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x30, 0x00,
  0x30, 0x0C, 0x00, 0x0C, 0x01, 0x00, 0x03, 0x00, 0x60, 0x01, 0x80, 0x18,
  0x00, 0x60, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00,
  0x04, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x08, 0x06,
  0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x21, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0x18, 0x1C, 0x00, 0x03, 0x30, 0x06, 0x00, 0x03, 0x60, 0x03, 0x00,
  0x02, 0x60, 0x01, 0x80, 0x06, 0x40, 0x00, 0xC0, 0x06, 0xC0, 0x00, 0x60,
  0x0C, 0xC0, 0x00, 0x38, 0x18, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xE0,
};

const GFXglyph RobotoCondensed_Thin70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 3, 51, 13, 5, -50 },
  { 21, 9, 14, 18, 5, -53 },
  { 37, 33, 50, 34, 2, -50 },
  { 244, 26, 64, 34, 4, -57 },
  { 452, 38, 52, 46, 4, -51 },
  { 699, 31, 52, 38, 4, -51 },
  { 901, 2, 14, 12, 5, -53 },
  { 905, 13, 71, 19, 5, -55 },
  { 1021, 13, 71, 20, 1, -55 },
  { 1137, 27, 27, 29, 1, -50 },
  { 1229, 29, 36, 35, 3, -41 },
  { 1360, 5, 14, 13, 3, -5 },
  { 1369, 14, 2, 19, 2, -24 },
  { 1373, 4, 4, 15, 5, -3 },
  { 1375, 19, 54, 24, 2, -50 },
  { 1504, 26, 52, 34, 4, -51 },
  { 1673, 14, 50, 34, 6, -50 },
  { 1761, 26, 51, 34, 4, -51 },
  { 1927, 26, 52, 34, 4, -51 },
  { 2096, 29, 50, 34, 3, -50 },
  { 2278, 24, 51, 34, 6, -50 },
  { 2431, 26, 51, 34, 4, -50 },
  { 2597, 27, 50, 34, 3, -50 },
  { 2766, 26, 52, 34, 4, -51 },
  { 2935, 26, 51, 34, 4, -51 },
  { 3101, 4, 37, 12, 4, -36 },
  { 3120, 5, 45, 12, 3, -36 },
  { 3149, 24, 28, 32, 3, -37 },
  { 3233, 24, 16, 34, 5, -31 },
  { 3281, 24, 28, 32, 4, -37 },
  { 3365, 21, 52, 27, 3, -51 },
  { 3502, 48, 63, 56, 4, -48 },
  { 3880, 33, 50, 37, 2, -50 },
  { 4087, 27, 50, 37, 6, -50 },
  { 4256, 30, 52, 40, 5, -51 },
  { 4451, 29, 50, 40, 6, -50 },
  { 4633, 26, 50, 35, 6, -50 },
  { 4796, 27, 50, 35, 6, -50 },
  { 4965, 30, 52, 42, 6, -51 },
  { 5160, 31, 50, 43, 6, -50 },
  { 5354, 2, 50, 17, 7, -50 },
  { 5367, 25, 51, 34, 3, -50 },
  { 5527, 30, 50, 39, 6, -50 },
  { 5715, 24, 50, 32, 6, -50 },
  { 5865, 40, 50, 52, 6, -50 },
  { 6115, 31, 50, 43, 6, -50 },
  { 6309, 31, 52, 41, 5, -51 },
  { 6511, 27, 50, 37, 6, -50 },
  { 6680, 31, 60, 41, 5, -51 },
  { 6913, 29, 50, 40, 6, -50 },
  { 7095, 30, 52, 36, 3, -51 },
  { 7290, 33, 50, 37, 2, -50 },
  { 7497, 29, 51, 41, 6, -50 },
  { 7682, 33, 50, 37, 2, -50 },
  { 7889, 51, 50, 55, 2, -50 },
  { 8208, 33, 50, 37, 2, -50 },
  { 8415, 33, 50, 37, 2, -50 },
  { 8622, 30, 50, 37, 3, -50 },
  { 8810, 8, 68, 14, 6, -57 },
  { 8878, 20, 54, 24, 2, -50 },
  { 9013, 9, 68, 14, 0, -57 },
  { 9090, 19, 25, 26, 3, -50 },
  { 9150, 24, 2, 26, 1, 0 },
  { 9156, 9, 9, 19, 5, -52 },
  { 9167, 25, 39, 33, 3, -38 },
  { 9289, 24, 54, 34, 6, -53 },
  { 9451, 25, 39, 31, 3, -38 },
  { 9573, 24, 54, 34, 4, -53 },
  { 9735, 25, 39, 32, 3, -38 },
  { 9857, 17, 54, 20, 3, -54 },
  { 9972, 24, 52, 34, 4, -38 },
  { 10128, 22, 53, 34, 6, -53 },
  { 10274, 4, 51, 14, 5, -51 },
  { 10300, 12, 65, 14, -3, -51 },
  { 10398, 22, 53, 30, 6, -53 },
  { 10544, 2, 53, 14, 6, -53 },
  { 10558, 44, 38, 54, 5, -38 },
  { 10767, 22, 38, 34, 6, -38 },
  { 10872, 26, 39, 34, 4, -38 },
  { 10999, 24, 52, 34, 6, -38 },
  { 11155, 24, 52, 34, 4, -38 },
  { 11311, 14, 38, 21, 6, -38 },
  { 11378, 23, 39, 31, 4, -38 },
  { 11491, 15, 48, 20, 2, -47 },
  { 11581, 23, 38, 34, 5, -37 },
  { 11691, 26, 37, 30, 2, -37 },
  { 11812, 40, 37, 46, 3, -37 },
  { 11997, 26, 37, 30, 2, -37 },
  { 12118, 26, 51, 30, 2, -37 },
  { 12284, 25, 37, 30, 3, -37 },
  { 12400, 17, 70, 20, 3, -55 },
  { 12549, 2, 59, 14, 6, -50 },
  { 12564, 17, 70, 20, 1, -55 },
  { 12713, 32, 11, 42, 5, -26 },
};

const GFXfont RobotoCondensed_Thin70pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin70pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin70pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _ROBOTOCONDENSED_THIN70PT7B_H_
