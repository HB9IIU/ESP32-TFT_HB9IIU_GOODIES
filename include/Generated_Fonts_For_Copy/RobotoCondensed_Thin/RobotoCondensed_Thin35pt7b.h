#ifndef _ROBOTOCONDENSED_THIN35PT7B_H_
#define _ROBOTOCONDENSED_THIN35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin35pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x50, 0x01, 0x40, 0x99, 0x99, 0x99, 0x90,
  0x01, 0x04, 0x02, 0x04, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08,
  0x02, 0x08, 0x7F, 0xFF, 0x04, 0x08, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10,
  0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x08, 0x20, 0x08, 0x20, 0xFF, 0xFE,
  0x08, 0x20, 0x08, 0x20, 0x08, 0x20, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40,
  0x10, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x1F, 0x01, 0x06, 0x10, 0x19,
  0x00, 0x48, 0x02, 0x40, 0x0A, 0x00, 0x50, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x40, 0x12, 0x00, 0x8C, 0x18, 0x1F, 0x80,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x3C, 0x00, 0x08, 0x40, 0x03, 0x08, 0x00,
  0x40, 0x81, 0x08, 0x10, 0x41, 0x02, 0x08, 0x20, 0x42, 0x04, 0x08, 0x40,
  0x81, 0x10, 0x10, 0x42, 0x01, 0x08, 0x80, 0x1E, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x0F, 0x00, 0x22, 0x10, 0x08, 0x82, 0x01, 0x10, 0x20, 0x42, 0x04,
  0x08, 0x40, 0x82, 0x08, 0x10, 0x41, 0x02, 0x10, 0x20, 0x40, 0x04, 0x10,
  0x00, 0x42, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x18, 0xC0, 0x10, 0x40, 0x20,
  0x40, 0x20, 0x20, 0x20, 0x40, 0x20, 0x40, 0x20, 0x80, 0x11, 0x80, 0x13,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x14, 0x00, 0x22, 0x00, 0x61, 0x02, 0x40,
  0x82, 0x80, 0x82, 0x80, 0x42, 0x80, 0x24, 0x80, 0x14, 0x80, 0x18, 0xC0,
  0x18, 0x40, 0x14, 0x20, 0x62, 0x1F, 0x82, 0xFE, 0x02, 0x08, 0x20, 0x41,
  0x02, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x81, 0x01, 0x02, 0x04, 0x04, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x81, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x20,
  0x81, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x20,
  0x82, 0x08, 0x41, 0x08, 0x21, 0x04, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x61, 0x1C, 0xEB, 0x00, 0xE0, 0x05, 0x00, 0x68, 0x02,
  0x20, 0x20, 0x83, 0x06, 0x10, 0x10, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x01, 0xFF,
  0xFC, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x55, 0x68, 0xFE, 0xA0, 0x00, 0x40,
  0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x00, 0x0F, 0x80, 0x82, 0x08,
  0x08, 0x80, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x80, 0x24, 0x01, 0x20, 0x08, 0x80, 0x82, 0x08, 0x0F,
  0x80, 0x06, 0x35, 0x8C, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x0F,
  0x81, 0x82, 0x10, 0x08, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x08, 0x00, 0x7F, 0xF8, 0x0F, 0x81, 0x83, 0x08, 0x08, 0x80, 0x24, 0x01,
  0x40, 0x0A, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80,
  0xF8, 0x00, 0x30, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xA0, 0x09, 0x80, 0x46, 0x0C, 0x0F, 0x80, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x40, 0x04, 0x80, 0x09, 0x00, 0x22, 0x00, 0x44, 0x01, 0x08,
  0x02, 0x10, 0x08, 0x20, 0x30, 0x40, 0x40, 0x81, 0x01, 0x02, 0x02, 0x08,
  0x04, 0x10, 0x08, 0x40, 0x11, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x3F, 0xF4, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x05, 0xF0, 0x60,
  0xC4, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x14, 0x02, 0x40, 0x23, 0x04, 0x0F, 0x80, 0x01, 0xE0,
  0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x04, 0x7C, 0x24, 0x19, 0x40, 0x6C, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x80, 0x14, 0x01, 0x20, 0x08, 0x80, 0x82,
  0x0C, 0x07, 0x80, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x0F,
  0x81, 0x83, 0x18, 0x08, 0x80, 0x24, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x40, 0x12, 0x00, 0x88, 0x08, 0x60, 0xC0, 0xF8, 0x18, 0x31, 0x00, 0x48,
  0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x05, 0x00,
  0x46, 0x0C, 0x0F, 0x80, 0x0F, 0x81, 0x82, 0x08, 0x08, 0x80, 0x24, 0x01,
  0x40, 0x0A, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0xA0, 0x0D, 0x80, 0xA6, 0x19, 0x0F, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x1E, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x24, 0x95, 0x80, 0x00,
  0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x00, 0x80, 0x00, 0x1E, 0x18, 0x64, 0x0A, 0x01, 0x80,
  0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x08, 0x00, 0x00, 0x7F, 0x80, 0x01, 0x80, 0x60, 0x02, 0x00, 0x10, 0x04,
  0x00, 0x08, 0x08, 0x00, 0x04, 0x10, 0x00, 0x04, 0x30, 0x00, 0x02, 0x20,
  0x1E, 0x02, 0x20, 0x21, 0x02, 0x40, 0x40, 0x81, 0x40, 0x80, 0x81, 0x40,
  0x80, 0x81, 0x81, 0x01, 0x01, 0x81, 0x01, 0x01, 0x81, 0x01, 0x01, 0x81,
  0x01, 0x01, 0x81, 0x01, 0x01, 0x81, 0x01, 0x01, 0x81, 0x01, 0x01, 0x81,
  0x01, 0x02, 0x81, 0x03, 0x02, 0x81, 0x05, 0x04, 0x40, 0x8C, 0x8C, 0x40,
  0x70, 0x70, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x24,
  0x00, 0x11, 0x00, 0x08, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02, 0x08, 0x02,
  0x04, 0x01, 0x02, 0x00, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x08,
  0x20, 0x04, 0x1F, 0xFE, 0x08, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00,
  0x09, 0x00, 0x05, 0x00, 0x02, 0x80, 0x00, 0x80, 0xFF, 0x82, 0x01, 0x88,
  0x03, 0x20, 0x04, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A,
  0x00, 0x48, 0x01, 0x20, 0x18, 0xFF, 0xC2, 0x00, 0x88, 0x01, 0x20, 0x02,
  0x80, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0A, 0x00, 0x28, 0x01,
  0xA0, 0x0C, 0xFF, 0xC0, 0x0F, 0xC0, 0x60, 0x61, 0x80, 0x22, 0x00, 0x28,
  0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x14, 0x00, 0x28, 0x00, 0x48, 0x00, 0x88, 0x02, 0x08,
  0x18, 0x0F, 0xC0, 0xFF, 0x81, 0x00, 0xC2, 0x00, 0x44, 0x00, 0x48, 0x00,
  0x50, 0x00, 0xA0, 0x01, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50, 0x01, 0x20, 0x04, 0x40, 0x30,
  0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFF, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x0F, 0xFF, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x00,
  0x07, 0xE0, 0x30, 0x30, 0x80, 0x32, 0x00, 0x24, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x1F, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x14, 0x00, 0x28, 0x00, 0x48, 0x01, 0x8C, 0x0C, 0x07, 0xE0, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x40,
  0x46, 0x0C, 0x1F, 0x00, 0x80, 0x05, 0x00, 0x12, 0x00, 0x44, 0x01, 0x88,
  0x06, 0x10, 0x08, 0x20, 0x20, 0x40, 0x80, 0x82, 0x01, 0x08, 0x02, 0x30,
  0x04, 0x40, 0x09, 0x40, 0x14, 0x40, 0x30, 0x80, 0x40, 0x80, 0x80, 0x81,
  0x00, 0x82, 0x01, 0x04, 0x01, 0x08, 0x01, 0x10, 0x03, 0x20, 0x02, 0x40,
  0x02, 0x80, 0x02, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0xFF, 0xF0, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3A, 0x00, 0x05, 0xA0, 0x00, 0x59, 0x00, 0x05, 0x90, 0x00, 0x99, 0x00,
  0x09, 0x88, 0x01, 0x18, 0x80, 0x11, 0x88, 0x01, 0x18, 0x40, 0x21, 0x84,
  0x02, 0x18, 0x40, 0x21, 0x82, 0x04, 0x18, 0x20, 0x41, 0x81, 0x04, 0x18,
  0x10, 0x81, 0x81, 0x08, 0x18, 0x09, 0x01, 0x80, 0x90, 0x18, 0x09, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x20, 0x10, 0x80, 0x03, 0x80, 0x06,
  0x80, 0x0D, 0x00, 0x19, 0x00, 0x32, 0x00, 0x62, 0x00, 0xC4, 0x01, 0x84,
  0x03, 0x04, 0x06, 0x08, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x10, 0x60, 0x30,
  0xC0, 0x21, 0x80, 0x23, 0x00, 0x46, 0x00, 0x4C, 0x00, 0x98, 0x00, 0xB0,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x02, 0x07, 0xE0, 0x18, 0x18, 0x30,
  0x04, 0x20, 0x02, 0x40, 0x02, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40,
  0x02, 0x20, 0x02, 0x30, 0x04, 0x18, 0x18, 0x07, 0xE0, 0xFF, 0xC2, 0x00,
  0xC8, 0x01, 0x20, 0x02, 0x80, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x28, 0x00, 0xA0, 0x06, 0x80, 0x33, 0xFF, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x18, 0x18, 0x30, 0x04, 0x20,
  0x02, 0x40, 0x02, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x02, 0x20,
  0x02, 0x30, 0x04, 0x18, 0x18, 0x07, 0xF0, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xC1, 0x00, 0x62, 0x00, 0x44, 0x00,
  0x48, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x12,
  0x00, 0x24, 0x00, 0x88, 0x03, 0x1F, 0xF8, 0x20, 0x20, 0x40, 0x20, 0x80,
  0x41, 0x00, 0x42, 0x00, 0x84, 0x00, 0x88, 0x01, 0x10, 0x01, 0x20, 0x01,
  0x40, 0x02, 0x80, 0x02, 0x0F, 0xC0, 0x60, 0x61, 0x80, 0x22, 0x00, 0x28,
  0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x58, 0x00, 0x90, 0x03, 0x18,
  0x08, 0x0F, 0xE0, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x05, 0x00, 0x16, 0x00, 0x8C, 0x0C, 0x0F,
  0xC0, 0x80, 0x01, 0x40, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x21,
  0x00, 0x10, 0x80, 0x08, 0x40, 0x08, 0x20, 0x04, 0x08, 0x02, 0x04, 0x02,
  0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x80, 0x20, 0x40, 0x08, 0x20, 0x04,
  0x20, 0x02, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x24, 0x00, 0x0A, 0x00,
  0x05, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x80, 0x08, 0x00, 0xA0, 0x06,
  0x00, 0x50, 0x03, 0x00, 0x28, 0x02, 0x80, 0x14, 0x01, 0x20, 0x12, 0x00,
  0x90, 0x08, 0x80, 0x48, 0x04, 0x40, 0x44, 0x02, 0x20, 0x21, 0x02, 0x10,
  0x10, 0x81, 0x04, 0x08, 0x40, 0x82, 0x08, 0x20, 0x41, 0x04, 0x08, 0x20,
  0x82, 0x04, 0x20, 0x41, 0x02, 0x10, 0x11, 0x01, 0x08, 0x08, 0x80, 0x44,
  0x04, 0x40, 0x24, 0x02, 0x20, 0x12, 0x00, 0xA0, 0x09, 0x00, 0x50, 0x02,
  0x80, 0x28, 0x01, 0x80, 0x14, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x40, 0x02, 0x20, 0x06, 0x30, 0x04, 0x10, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x04, 0x10, 0x04, 0x20, 0x02, 0x40, 0x01, 0x40,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x20,
  0x04, 0x10, 0x08, 0x10, 0x10, 0x08, 0x10, 0x04, 0x20, 0x04, 0x20, 0x02,
  0x40, 0x02, 0x80, 0x01, 0x80, 0x01, 0x20, 0x00, 0x90, 0x00, 0x84, 0x00,
  0x42, 0x00, 0x40, 0x80, 0x20, 0x40, 0x20, 0x10, 0x10, 0x08, 0x10, 0x02,
  0x08, 0x01, 0x08, 0x00, 0x44, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0xFF, 0xFE, 0xF8, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0xF0, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00,
  0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04,
  0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0xF0, 0x08, 0x0C, 0x05, 0x02, 0x82, 0x41, 0x10,
  0x88, 0x82, 0x41, 0x40, 0xA0, 0x30, 0x10, 0xFF, 0xF8, 0x43, 0x08, 0x20,
  0x80, 0x1F, 0x82, 0x04, 0x40, 0x28, 0x02, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x1F, 0xE6, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28,
  0x05, 0x41, 0x93, 0xE1, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x9F, 0x8A, 0x0C, 0xC0, 0x28, 0x02, 0x80, 0x28,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x02, 0x80, 0x2C, 0x02, 0xA0, 0xC9, 0xF0, 0x1F, 0x82, 0x04, 0x40, 0x28,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x14, 0x02, 0x20, 0x41, 0xF8, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x1F, 0x92,
  0x05, 0x40, 0x34, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x14, 0x03, 0x20, 0x51,
  0xF9, 0x0F, 0x83, 0x04, 0x40, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F,
  0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04,
  0x00, 0x30, 0x60, 0xF8, 0x07, 0x84, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0xFF, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x00, 0x1F, 0x92,
  0x05, 0x40, 0x34, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x14, 0x03, 0x20, 0x51,
  0xF9, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x40, 0x23, 0x06, 0x0F, 0x80,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x8F,
  0x92, 0x1A, 0x81, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04,
  0xC1, 0xFF, 0xFF, 0x80, 0x04, 0x10, 0x00, 0x00, 0x00, 0x01, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x20, 0xBC, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x50, 0x12, 0x04, 0x41, 0x08, 0x61, 0x18, 0x26,
  0x04, 0x80, 0xB0, 0x19, 0x02, 0x10, 0x42, 0x08, 0x21, 0x02, 0x20, 0x24,
  0x04, 0x80, 0x50, 0x04, 0xFF, 0xFF, 0xFF, 0xC0, 0x8F, 0x03, 0xE2, 0xC3,
  0x10, 0x4A, 0x04, 0x80, 0xB0, 0x0C, 0x02, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x18, 0x02, 0x00, 0x60, 0x08, 0x01, 0x80, 0x20, 0x06, 0x00, 0x80, 0x18,
  0x02, 0x00, 0x60, 0x08, 0x01, 0x80, 0x20, 0x06, 0x00, 0x80, 0x18, 0x02,
  0x00, 0x60, 0x08, 0x01, 0x80, 0x20, 0x06, 0x00, 0x80, 0x10, 0x8F, 0x92,
  0x1A, 0x81, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x0F,
  0x81, 0x83, 0x18, 0x08, 0x80, 0x28, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x09, 0x00, 0x4C,
  0x04, 0x30, 0x60, 0x7C, 0x00, 0x9F, 0x8A, 0x0C, 0xC0, 0x28, 0x02, 0x80,
  0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x02, 0x80, 0x2C, 0x02, 0xA0, 0xC9, 0xF0, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x1F, 0x92, 0x05, 0x40, 0x34,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x40, 0x14, 0x03, 0x20, 0x51, 0xF9, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x9F, 0x43, 0x06,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x00, 0x1F, 0x0C, 0x1B, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0x00, 0x10, 0x03, 0x00, 0x60, 0x0E, 0x01, 0x60,
  0x43, 0xF0, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFE, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x0F, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0A, 0x03, 0x60,
  0xA3, 0xC4, 0x80, 0x0C, 0x00, 0x90, 0x04, 0x80, 0x24, 0x02, 0x10, 0x10,
  0x80, 0x84, 0x08, 0x10, 0x40, 0x82, 0x04, 0x20, 0x11, 0x00, 0x88, 0x04,
  0x80, 0x14, 0x00, 0xA0, 0x06, 0x00, 0x10, 0x00, 0x40, 0x20, 0x14, 0x02,
  0x01, 0x40, 0x50, 0x14, 0x05, 0x01, 0x20, 0x50, 0x22, 0x09, 0x02, 0x20,
  0x88, 0x22, 0x08, 0x82, 0x10, 0x88, 0x41, 0x10, 0x44, 0x11, 0x04, 0x41,
  0x10, 0x44, 0x0A, 0x04, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x28,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x40, 0x12, 0x01, 0x88, 0x08, 0x20, 0x81,
  0x04, 0x04, 0x40, 0x34, 0x00, 0xA0, 0x02, 0x00, 0x30, 0x01, 0x40, 0x11,
  0x00, 0x88, 0x08, 0x20, 0x81, 0x84, 0x04, 0x40, 0x16, 0x00, 0x80, 0x80,
  0x0C, 0x00, 0x50, 0x04, 0x80, 0x24, 0x01, 0x10, 0x10, 0x80, 0x82, 0x04,
  0x10, 0x40, 0x82, 0x02, 0x10, 0x11, 0x00, 0x88, 0x02, 0x40, 0x14, 0x00,
  0xA0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x70, 0x00, 0xFF, 0xE0, 0x06, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x0F, 0xFF, 0x00, 0x81, 0x81, 0x00, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x20, 0x20, 0x60, 0x08, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0xFF,
  0xFF, 0xFF, 0xFC, 0xC0, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0xC0,
  0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x10, 0x30, 0x00, 0x38, 0x02, 0x8C, 0x06, 0x0C,
  0x0C, 0x0C, 0x18, 0x0C, 0x50, 0x07, 0x00,
};

const GFXglyph RobotoCondensed_Thin35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 25, 7, 2, -25 },
  { 8, 4, 7, 9, 3, -26 },
  { 12, 16, 25, 17, 1, -25 },
  { 62, 13, 31, 17, 2, -28 },
  { 113, 19, 25, 23, 2, -25 },
  { 173, 16, 25, 19, 2, -25 },
  { 223, 1, 7, 6, 2, -26 },
  { 224, 7, 36, 10, 2, -28 },
  { 256, 6, 36, 10, 1, -28 },
  { 283, 13, 14, 15, 1, -25 },
  { 306, 15, 19, 17, 1, -21 },
  { 342, 2, 7, 7, 2, -3 },
  { 344, 7, 1, 9, 1, -12 },
  { 345, 2, 2, 8, 3, -2 },
  { 346, 10, 27, 12, 1, -25 },
  { 380, 13, 25, 17, 2, -25 },
  { 421, 7, 25, 17, 3, -25 },
  { 443, 13, 25, 17, 2, -25 },
  { 484, 13, 25, 17, 2, -25 },
  { 525, 15, 25, 17, 1, -25 },
  { 572, 12, 25, 17, 3, -25 },
  { 610, 13, 25, 17, 2, -25 },
  { 651, 14, 25, 17, 1, -25 },
  { 695, 13, 25, 17, 2, -25 },
  { 736, 13, 25, 17, 2, -25 },
  { 777, 2, 18, 6, 2, -18 },
  { 782, 3, 22, 6, 1, -18 },
  { 791, 13, 13, 16, 1, -18 },
  { 813, 13, 8, 17, 2, -15 },
  { 826, 12, 13, 16, 2, -18 },
  { 846, 10, 25, 14, 2, -25 },
  { 878, 24, 32, 28, 2, -24 },
  { 974, 17, 25, 18, 1, -25 },
  { 1028, 14, 25, 19, 3, -25 },
  { 1072, 15, 25, 20, 3, -25 },
  { 1119, 15, 25, 20, 3, -25 },
  { 1166, 13, 25, 18, 3, -25 },
  { 1207, 13, 25, 18, 3, -25 },
  { 1248, 15, 25, 21, 3, -25 },
  { 1295, 15, 25, 22, 3, -25 },
  { 1342, 1, 25, 8, 4, -25 },
  { 1346, 12, 25, 17, 2, -25 },
  { 1384, 15, 25, 19, 3, -25 },
  { 1431, 12, 25, 16, 3, -25 },
  { 1469, 20, 25, 26, 3, -25 },
  { 1532, 15, 25, 22, 3, -25 },
  { 1579, 16, 25, 20, 2, -25 },
  { 1629, 14, 25, 19, 3, -25 },
  { 1673, 16, 30, 20, 2, -25 },
  { 1733, 15, 25, 20, 3, -25 },
  { 1780, 15, 25, 18, 2, -25 },
  { 1827, 16, 25, 18, 1, -25 },
  { 1877, 14, 25, 20, 3, -25 },
  { 1921, 17, 25, 18, 1, -25 },
  { 1975, 25, 25, 28, 1, -25 },
  { 2054, 16, 25, 18, 1, -25 },
  { 2104, 17, 25, 18, 1, -25 },
  { 2158, 15, 25, 18, 2, -25 },
  { 2205, 4, 33, 7, 3, -28 },
  { 2222, 10, 27, 12, 1, -25 },
  { 2256, 4, 33, 7, 0, -28 },
  { 2273, 9, 12, 13, 2, -25 },
  { 2287, 13, 1, 13, 0, 0 },
  { 2289, 5, 5, 9, 2, -27 },
  { 2293, 12, 18, 16, 2, -18 },
  { 2320, 12, 26, 17, 3, -26 },
  { 2359, 12, 18, 16, 2, -18 },
  { 2386, 12, 26, 17, 2, -26 },
  { 2425, 12, 18, 16, 2, -18 },
  { 2452, 9, 26, 10, 1, -26 },
  { 2482, 12, 25, 17, 2, -18 },
  { 2520, 11, 26, 17, 3, -26 },
  { 2556, 1, 25, 7, 3, -25 },
  { 2560, 6, 32, 7, -2, -25 },
  { 2584, 11, 26, 15, 3, -26 },
  { 2620, 1, 26, 7, 3, -26 },
  { 2624, 22, 18, 27, 3, -18 },
  { 2674, 11, 18, 17, 3, -18 },
  { 2699, 13, 18, 17, 2, -18 },
  { 2729, 12, 25, 17, 3, -18 },
  { 2767, 12, 25, 17, 2, -18 },
  { 2805, 7, 18, 11, 3, -18 },
  { 2821, 11, 18, 15, 2, -18 },
  { 2846, 8, 23, 10, 1, -23 },
  { 2869, 11, 18, 17, 3, -18 },
  { 2894, 13, 18, 15, 1, -18 },
  { 2924, 20, 18, 23, 1, -18 },
  { 2969, 13, 18, 15, 1, -18 },
  { 2999, 13, 25, 15, 1, -18 },
  { 3040, 12, 18, 15, 2, -18 },
  { 3067, 9, 35, 10, 1, -27 },
  { 3107, 1, 30, 7, 3, -25 },
  { 3111, 9, 35, 10, 0, -27 },
  { 3151, 15, 6, 21, 3, -14 },
};

const GFXfont RobotoCondensed_Thin35pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin35pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin35pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOCONDENSED_THIN35PT7B_H_
