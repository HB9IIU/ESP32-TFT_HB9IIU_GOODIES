#ifndef _ROBOTOCONDENSED_THIN40PT7B_H_
#define _ROBOTOCONDENSED_THIN40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin40pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x00, 0x0F, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x00, 0x81, 0x00, 0x10, 0x20, 0x06, 0x0C, 0x00, 0x81, 0x00, 0x10,
  0x20, 0x02, 0x04, 0x00, 0x40, 0x80, 0x08, 0x10, 0x3F, 0xFF, 0xE0, 0x40,
  0x80, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x81,
  0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x81, 0x00, 0x10, 0x20, 0x7F, 0xFF,
  0xE0, 0x40, 0x80, 0x08, 0x20, 0x02, 0x04, 0x00, 0x40, 0x80, 0x08, 0x10,
  0x01, 0x02, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x7E, 0x03, 0x06, 0x0C, 0x02, 0x10, 0x02, 0x60,
  0x04, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x05, 0x00, 0x0A, 0x00,
  0x36, 0x00, 0x44, 0x01, 0x86, 0x06, 0x03, 0xF0, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x1E, 0x00, 0x00, 0x8C, 0x00, 0x04, 0x18, 0x00,
  0x10, 0x20, 0x00, 0x80, 0x80, 0x82, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x20, 0x80, 0x80, 0x82, 0x01, 0x02, 0x10, 0x04, 0x18, 0xC0, 0x08, 0xC2,
  0x00, 0x1E, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x78,
  0x00, 0x43, 0x10, 0x01, 0x18, 0x20, 0x08, 0x40, 0x80, 0x41, 0x01, 0x01,
  0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x41, 0x01, 0x01, 0x04, 0x04,
  0x08, 0x00, 0x18, 0x20, 0x00, 0x31, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x03,
  0x08, 0x01, 0x81, 0x00, 0x40, 0x40, 0x10, 0x10, 0x04, 0x04, 0x01, 0x01,
  0x00, 0x40, 0x40, 0x10, 0x20, 0x06, 0x10, 0x00, 0x88, 0x00, 0x14, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x01, 0x90, 0x00, 0x42, 0x02, 0x20, 0xC0, 0x90,
  0x10, 0x24, 0x02, 0x0B, 0x00, 0x42, 0x80, 0x19, 0x20, 0x02, 0x48, 0x00,
  0x71, 0x00, 0x08, 0x40, 0x07, 0x08, 0x02, 0x41, 0x83, 0x08, 0x3F, 0x01,
  0xFF, 0x02, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0x81, 0x01, 0x03, 0x02,
  0x02, 0x80, 0x81, 0x01, 0x01, 0x02, 0x06, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x40, 0x80, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x30, 0x40, 0x81, 0x02, 0x08, 0x10, 0x60, 0x81, 0x04, 0x10, 0x20,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x18, 0x20,
  0xDC, 0x4E, 0x07, 0xE0, 0x03, 0x00, 0x05, 0x00, 0x11, 0x00, 0x63, 0x00,
  0x83, 0x02, 0x02, 0x08, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x6D, 0xB4, 0xB4, 0xFF, 0xF0, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x00, 0x07,
  0xC0, 0x10, 0x60, 0x40, 0x61, 0x00, 0x42, 0x00, 0x48, 0x00, 0x90, 0x01,
  0x20, 0x01, 0x40, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0A, 0x00,
  0x14, 0x00, 0x28, 0x00, 0x90, 0x01, 0x10, 0x02, 0x20, 0x08, 0x20, 0x30,
  0x20, 0xC0, 0x3E, 0x00, 0x01, 0x07, 0x39, 0xC1, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x07, 0xC0, 0x30, 0x60,
  0xC0, 0x63, 0x00, 0x44, 0x00, 0x48, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x03, 0xFF,
  0xF0, 0x07, 0xE0, 0x30, 0x60, 0xC0, 0x21, 0x00, 0x24, 0x00, 0x48, 0x00,
  0x90, 0x01, 0x20, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x03, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xA0, 0x03, 0x60, 0x04,
  0x60, 0x10, 0x60, 0x40, 0x3F, 0x00, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0A, 0x00, 0x05, 0x00, 0x04, 0x80, 0x04, 0x40, 0x02, 0x20, 0x02,
  0x10, 0x01, 0x08, 0x01, 0x04, 0x01, 0x82, 0x00, 0x81, 0x00, 0x80, 0x80,
  0x40, 0x40, 0x40, 0x20, 0x60, 0x10, 0x20, 0x08, 0x30, 0x04, 0x1F, 0xFF,
  0xF0, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x3F, 0xFC, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04,
  0xFC, 0x14, 0x0C, 0x60, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x05, 0x00, 0x14, 0x00, 0x50, 0x01,
  0x20, 0x08, 0xC0, 0x61, 0x83, 0x01, 0xF0, 0x00, 0x70, 0x07, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x0F, 0x82, 0x61, 0x85, 0x00, 0x8C, 0x00, 0xB0, 0x01, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x28, 0x00,
  0x50, 0x00, 0xB0, 0x02, 0x20, 0x04, 0x20, 0x10, 0x30, 0xC0, 0x1F, 0x00,
  0xFF, 0xFE, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x07, 0xE0, 0x30, 0x60, 0xC0, 0x23, 0x00,
  0x24, 0x00, 0x48, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x09,
  0x80, 0x11, 0x80, 0x41, 0x83, 0x00, 0xF8, 0x06, 0x0C, 0x10, 0x06, 0x40,
  0x04, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xA0, 0x01, 0x40, 0x04, 0x40, 0x18, 0x60, 0xE0, 0x3F, 0x00, 0x07, 0xC0,
  0x30, 0x60, 0xC0, 0x61, 0x00, 0x44, 0x00, 0x48, 0x00, 0xB0, 0x01, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x28, 0x00,
  0xD0, 0x01, 0xB0, 0x05, 0x30, 0x12, 0x30, 0x44, 0x1F, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0xC0, 0x07,
  0x00, 0xF8, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x36, 0x6C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xB6, 0x92, 0xD0, 0x00, 0x04, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x00, 0x0F, 0x03, 0x0C, 0x40, 0x64,
  0x02, 0x80, 0x28, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x40, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x08, 0x08, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x04, 0x10, 0x07, 0x80, 0x22, 0x00, 0x86, 0x02,
  0x20, 0x10, 0x20, 0x22, 0x02, 0x02, 0x02, 0x40, 0x60, 0x20, 0x24, 0x04,
  0x02, 0x01, 0x40, 0x40, 0x20, 0x14, 0x08, 0x02, 0x01, 0x40, 0x80, 0x20,
  0x14, 0x08, 0x02, 0x01, 0xC0, 0x80, 0x20, 0x18, 0x08, 0x02, 0x02, 0x80,
  0x80, 0x20, 0x24, 0x08, 0x06, 0x02, 0x40, 0x80, 0x40, 0x24, 0x08, 0x04,
  0x06, 0x40, 0x80, 0xA0, 0x44, 0x04, 0x1A, 0x0C, 0x40, 0x63, 0x11, 0x86,
  0x03, 0xC0, 0xE0, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x19, 0x00, 0x02,
  0x20, 0x00, 0x44, 0x00, 0x08, 0x40, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08,
  0x10, 0x02, 0x02, 0x00, 0x40, 0x40, 0x08, 0x0C, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x08, 0x02, 0x02, 0x00, 0x20, 0x40, 0x04, 0x0F, 0xFF, 0x82, 0x00,
  0x08, 0x40, 0x01, 0x08, 0x00, 0x22, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00,
  0x0B, 0x00, 0x00, 0xC0, 0x00, 0x10, 0xFF, 0xC1, 0x00, 0xE2, 0x00, 0x64,
  0x00, 0x48, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00,
  0x0A, 0x00, 0x24, 0x00, 0xC8, 0x03, 0x1F, 0xF8, 0x20, 0x0C, 0x40, 0x04,
  0x80, 0x05, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x05, 0x00, 0x12, 0x00, 0xC7, 0xFF, 0x00, 0x07,
  0xF0, 0x06, 0x06, 0x0C, 0x00, 0x84, 0x00, 0x64, 0x00, 0x12, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x05, 0x00, 0x06,
  0x80, 0x02, 0x20, 0x03, 0x18, 0x01, 0x03, 0x03, 0x00, 0xFE, 0x00, 0xFF,
  0xC0, 0x80, 0x70, 0x80, 0x18, 0x80, 0x04, 0x80, 0x06, 0x80, 0x02, 0x80,
  0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0x80, 0x06, 0x80,
  0x04, 0x80, 0x18, 0x80, 0x70, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFF, 0xE8, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x00, 0x03, 0xF8, 0x03, 0x03, 0x81, 0x00, 0x30, 0x80, 0x04, 0x60, 0x00,
  0x90, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x01,
  0xFF, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x40, 0x00,
  0x50, 0x00, 0x14, 0x00, 0x04, 0x80, 0x01, 0x30, 0x00, 0xC6, 0x00, 0x60,
  0xE0, 0x60, 0x0F, 0xE0, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xA0, 0x02, 0x40, 0x19, 0x80, 0x43, 0x06, 0x03, 0xE0, 0x80, 0x02, 0x40,
  0x03, 0x20, 0x03, 0x10, 0x01, 0x08, 0x01, 0x04, 0x01, 0x02, 0x01, 0x01,
  0x01, 0x80, 0x81, 0x80, 0x41, 0x80, 0x20, 0x80, 0x10, 0x80, 0x08, 0x80,
  0x04, 0xA0, 0x02, 0x98, 0x01, 0x84, 0x00, 0x81, 0x00, 0x40, 0x40, 0x20,
  0x30, 0x10, 0x08, 0x08, 0x02, 0x04, 0x00, 0x82, 0x00, 0x61, 0x00, 0x10,
  0x80, 0x04, 0x40, 0x01, 0x20, 0x00, 0xD0, 0x00, 0x20, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0xFF, 0xF0, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x05, 0xA0, 0x00, 0x16, 0x80, 0x00, 0x5A,
  0x00, 0x02, 0x64, 0x00, 0x09, 0x90, 0x00, 0x26, 0x20, 0x01, 0x18, 0x80,
  0x04, 0x62, 0x00, 0x21, 0x84, 0x00, 0x86, 0x10, 0x02, 0x18, 0x60, 0x10,
  0x60, 0x80, 0x41, 0x82, 0x01, 0x06, 0x04, 0x08, 0x18, 0x10, 0x20, 0x60,
  0x41, 0x81, 0x80, 0x84, 0x06, 0x02, 0x10, 0x18, 0x08, 0x80, 0x60, 0x12,
  0x01, 0x80, 0x48, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x34, 0x00, 0x1A, 0x00, 0x0C, 0x80,
  0x06, 0x60, 0x03, 0x10, 0x01, 0x84, 0x00, 0xC2, 0x00, 0x60, 0x80, 0x30,
  0x60, 0x18, 0x10, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x00, 0x81, 0x80, 0x40,
  0xC0, 0x10, 0x60, 0x0C, 0x30, 0x02, 0x18, 0x00, 0x8C, 0x00, 0x46, 0x00,
  0x13, 0x00, 0x0D, 0x80, 0x02, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x10,
  0x07, 0xF0, 0x03, 0x03, 0x03, 0x00, 0x20, 0x80, 0x04, 0x40, 0x01, 0x10,
  0x00, 0x28, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xA0,
  0x00, 0x24, 0x00, 0x09, 0x00, 0x04, 0x20, 0x01, 0x0C, 0x00, 0x80, 0xC0,
  0xC0, 0x1F, 0xC0, 0xFF, 0xC1, 0x00, 0x62, 0x00, 0x24, 0x00, 0x28, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x50, 0x01, 0x20, 0x0C, 0x7F, 0xF0, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x00, 0x07, 0xF0, 0x07, 0x03,
  0x03, 0x00, 0x20, 0x80, 0x04, 0x40, 0x01, 0x30, 0x00, 0x28, 0x00, 0x0A,
  0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xA0, 0x00, 0x2C, 0x00, 0x09,
  0x00, 0x04, 0x20, 0x01, 0x0C, 0x01, 0x80, 0xC0, 0xC0, 0x0F, 0xE0, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0xFF,
  0xC0, 0x80, 0x30, 0x80, 0x08, 0x80, 0x04, 0x80, 0x06, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80,
  0x04, 0x80, 0x08, 0x80, 0x10, 0xFF, 0xC0, 0x80, 0x40, 0x80, 0x20, 0x80,
  0x20, 0x80, 0x10, 0x80, 0x10, 0x80, 0x08, 0x80, 0x08, 0x80, 0x04, 0x80,
  0x06, 0x80, 0x02, 0x80, 0x03, 0x80, 0x01, 0x07, 0xF0, 0x0C, 0x06, 0x0C,
  0x01, 0x8C, 0x00, 0x64, 0x00, 0x12, 0x00, 0x09, 0x00, 0x02, 0x80, 0x01,
  0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x80, 0x03, 0x40, 0x01,
  0x18, 0x01, 0x07, 0x03, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0A, 0x00,
  0x05, 0x00, 0x06, 0x80, 0x02, 0x20, 0x03, 0x18, 0x01, 0x07, 0x03, 0x00,
  0xFE, 0x00, 0x80, 0x00, 0x38, 0x00, 0x05, 0x00, 0x01, 0x20, 0x00, 0x26,
  0x00, 0x04, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x04, 0x10, 0x01, 0x02,
  0x00, 0x20, 0x40, 0x04, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01,
  0x01, 0x80, 0x20, 0x20, 0x04, 0x04, 0x00, 0x41, 0x80, 0x08, 0x20, 0x01,
  0x04, 0x00, 0x10, 0x80, 0x02, 0x20, 0x00, 0x44, 0x00, 0x04, 0x80, 0x00,
  0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x20, 0x00, 0xC0, 0x02, 0x00,
  0x0A, 0x00, 0x18, 0x00, 0x50, 0x00, 0xC0, 0x06, 0x80, 0x0A, 0x00, 0x26,
  0x00, 0x48, 0x01, 0x10, 0x02, 0x40, 0x08, 0x80, 0x22, 0x00, 0xC4, 0x01,
  0x10, 0x04, 0x20, 0x08, 0x40, 0x20, 0x80, 0x42, 0x01, 0x04, 0x04, 0x10,
  0x08, 0x20, 0x20, 0x80, 0x81, 0x01, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x20,
  0x20, 0x80, 0x81, 0x01, 0x04, 0x04, 0x18, 0x08, 0x20, 0x10, 0x80, 0x61,
  0x00, 0x84, 0x01, 0x10, 0x04, 0x20, 0x08, 0x80, 0x23, 0x00, 0x44, 0x00,
  0x90, 0x02, 0x20, 0x04, 0x80, 0x0A, 0x00, 0x24, 0x00, 0x50, 0x01, 0x20,
  0x02, 0x80, 0x06, 0x00, 0x14, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x40, 0x00, 0x4C, 0x00, 0x18, 0x80, 0x02, 0x08, 0x00,
  0x81, 0x80, 0x10, 0x10, 0x04, 0x01, 0x01, 0x80, 0x20, 0x20, 0x02, 0x08,
  0x00, 0x41, 0x00, 0x04, 0x40, 0x00, 0x58, 0x00, 0x0A, 0x00, 0x00, 0x80,
  0x00, 0x38, 0x00, 0x05, 0x00, 0x01, 0x10, 0x00, 0x22, 0x00, 0x08, 0x20,
  0x03, 0x06, 0x00, 0x40, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x80, 0x08,
  0x30, 0x01, 0x84, 0x00, 0x11, 0x00, 0x01, 0x20, 0x00, 0x20, 0x80, 0x00,
  0x28, 0x00, 0x09, 0x00, 0x01, 0x10, 0x00, 0x42, 0x00, 0x18, 0x20, 0x02,
  0x04, 0x00, 0xC0, 0x40, 0x10, 0x0C, 0x06, 0x00, 0x80, 0x80, 0x18, 0x30,
  0x01, 0x04, 0x00, 0x31, 0x80, 0x02, 0x20, 0x00, 0x68, 0x00, 0x05, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x1F, 0xFF, 0xF0, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x43, 0xE0, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0,
  0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40,
  0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87,
  0xE0, 0x04, 0x01, 0x80, 0x28, 0x05, 0x01, 0x20, 0x22, 0x0C, 0x41, 0x08,
  0x20, 0x8C, 0x11, 0x02, 0x20, 0x28, 0x05, 0x00, 0xC0, 0xFF, 0xFC, 0xC2,
  0x08, 0x21, 0x80, 0x0F, 0xC0, 0x60, 0xC2, 0x01, 0x90, 0x02, 0x40, 0x0A,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x3F, 0xE3, 0x80, 0x98, 0x02,
  0x40, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x64, 0x02,
  0x98, 0x31, 0x1F, 0x04, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x3F, 0x09, 0x83, 0x28,
  0x04, 0xC0, 0x0B, 0x00, 0x28, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x2C, 0x00, 0xA8, 0x04, 0x90, 0x32, 0x3F, 0x00, 0x0F, 0xC0, 0x60,
  0xC2, 0x01, 0x90, 0x02, 0x40, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x40, 0x05, 0x00, 0x22, 0x01, 0x86, 0x0C, 0x0F, 0xC0, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x3F, 0x11, 0x83, 0x48, 0x07, 0x60, 0x0D, 0x00, 0x14, 0x00,
  0x50, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00, 0x16, 0x00, 0xC8, 0x03, 0x18,
  0x34, 0x3F, 0x10, 0x07, 0xC0, 0x60, 0xC2, 0x01, 0x90, 0x02, 0x40, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0xC6, 0x06, 0x07, 0xE0, 0x03, 0xC1, 0x80, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x3F, 0xE0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x0F, 0xC4, 0x60, 0xD2, 0x01, 0xD8,
  0x03, 0x40, 0x05, 0x00, 0x14, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00, 0x50, 0x01, 0x40, 0x05,
  0x80, 0x32, 0x00, 0xC6, 0x0D, 0x0F, 0xC4, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x32, 0x00, 0x86, 0x0C, 0x07, 0xC0, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x3E, 0x22, 0x09, 0x20, 0x2A, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0xF0, 0x00,
  0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x80, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x4F, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0xA0, 0x09, 0x00, 0x88, 0x0C,
  0x40, 0xC2, 0x0C, 0x10, 0xC0, 0x84, 0x04, 0x40, 0x26, 0x01, 0x58, 0x0C,
  0x40, 0x41, 0x02, 0x04, 0x10, 0x30, 0x80, 0x84, 0x02, 0x20, 0x19, 0x00,
  0x48, 0x01, 0x40, 0x04, 0xFF, 0xFF, 0xFF, 0xFC, 0x87, 0xC0, 0x7C, 0x4C,
  0x10, 0xC1, 0x2C, 0x04, 0xC0, 0x54, 0x03, 0xC0, 0x3C, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00,
  0x80, 0x08, 0x87, 0xC4, 0x41, 0x24, 0x05, 0x40, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x07, 0xC0, 0x30, 0x60, 0xC0, 0x21, 0x00, 0x24, 0x00, 0x48, 0x00,
  0xD0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x50, 0x00, 0xA0, 0x03, 0x40, 0x04, 0x40, 0x08, 0xC0,
  0x20, 0xC1, 0x80, 0x7C, 0x00, 0x8F, 0xC2, 0x60, 0xCA, 0x01, 0x30, 0x02,
  0xC0, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0B, 0x00,
  0x2A, 0x01, 0x26, 0x0C, 0x8F, 0xC2, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x0F, 0xC4, 0x60, 0xD2,
  0x01, 0xD8, 0x03, 0x40, 0x05, 0x00, 0x14, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x14, 0x00, 0x50, 0x01,
  0x40, 0x05, 0x80, 0x32, 0x00, 0xC6, 0x0D, 0x0F, 0xC4, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x87,
  0x98, 0xA0, 0xA0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x0F, 0xC1, 0x83, 0x10,
  0x04, 0x80, 0x38, 0x00, 0xC0, 0x05, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0E,
  0x00, 0x50, 0x04, 0x60, 0x60, 0xFC, 0x00, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x83, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04,
  0x01, 0xE0, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0xC0, 0x0A, 0x00, 0xD8, 0x0A, 0x60, 0xD1, 0xF8,
  0x80, 0x80, 0x02, 0x80, 0x09, 0x00, 0x12, 0x00, 0x22, 0x00, 0x84, 0x01,
  0x08, 0x02, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20, 0x80, 0x41, 0x00,
  0x82, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x02, 0x80, 0x05, 0x00, 0x0A,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x80, 0x30, 0x05, 0x00, 0x60, 0x0A, 0x00,
  0xC0, 0x12, 0x01, 0x40, 0x64, 0x04, 0x80, 0x88, 0x09, 0x01, 0x10, 0x12,
  0x02, 0x10, 0x22, 0x0C, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82, 0x10,
  0x40, 0x8C, 0x11, 0x81, 0x10, 0x22, 0x02, 0x20, 0x44, 0x04, 0x40, 0x48,
  0x05, 0x00, 0x90, 0x0A, 0x01, 0x40, 0x14, 0x02, 0x80, 0x28, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x08, 0x00, 0x40, 0x04, 0xC0, 0x10, 0x80, 0x20,
  0x80, 0x81, 0x83, 0x01, 0x04, 0x01, 0x10, 0x02, 0x20, 0x02, 0x80, 0x07,
  0x00, 0x04, 0x00, 0x14, 0x00, 0x68, 0x00, 0x88, 0x02, 0x08, 0x04, 0x10,
  0x10, 0x10, 0x60, 0x30, 0x80, 0x22, 0x00, 0x24, 0x00, 0x40, 0x80, 0x02,
  0x80, 0x0D, 0x00, 0x12, 0x00, 0x22, 0x00, 0xC4, 0x01, 0x08, 0x02, 0x08,
  0x0C, 0x10, 0x10, 0x20, 0x20, 0x20, 0xC0, 0x41, 0x00, 0x82, 0x00, 0x8C,
  0x01, 0x10, 0x02, 0x20, 0x02, 0xC0, 0x05, 0x00, 0x0A, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x07, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x20, 0x00, 0xFF, 0xFC, 0x00, 0x81, 0x81, 0x80, 0x80, 0xC0,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x04, 0x0C, 0x0C, 0x01, 0x00, 0x40, 0x20, 0x18, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0x40,
  0x30, 0x0C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x06, 0x00, 0xC0, 0x40,
  0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0x3E, 0x00,
  0x58, 0xC0, 0x14, 0x08, 0x06, 0x01, 0x02, 0x80, 0x31, 0xA0, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_Thin40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 28, 7, 3, -28 },
  { 8, 5, 8, 10, 3, -30 },
  { 13, 19, 28, 19, 1, -28 },
  { 80, 15, 36, 19, 2, -32 },
  { 148, 22, 28, 26, 2, -28 },
  { 225, 18, 28, 21, 2, -28 },
  { 288, 1, 8, 7, 3, -30 },
  { 289, 7, 41, 11, 3, -32 },
  { 325, 7, 41, 11, 1, -32 },
  { 361, 15, 15, 17, 1, -28 },
  { 390, 16, 21, 20, 2, -24 },
  { 432, 3, 8, 8, 2, -3 },
  { 435, 8, 1, 11, 1, -14 },
  { 436, 2, 2, 9, 3, -2 },
  { 437, 11, 30, 14, 1, -28 },
  { 479, 15, 28, 19, 2, -28 },
  { 532, 8, 28, 19, 3, -28 },
  { 560, 15, 28, 19, 2, -28 },
  { 613, 15, 28, 19, 2, -28 },
  { 666, 17, 28, 19, 2, -28 },
  { 726, 14, 28, 19, 3, -28 },
  { 775, 15, 28, 19, 2, -28 },
  { 828, 15, 28, 19, 2, -28 },
  { 881, 15, 28, 19, 2, -28 },
  { 934, 15, 28, 19, 2, -28 },
  { 987, 3, 21, 7, 2, -21 },
  { 995, 3, 26, 7, 2, -21 },
  { 1005, 14, 16, 18, 2, -21 },
  { 1033, 14, 8, 20, 3, -17 },
  { 1047, 14, 16, 18, 2, -21 },
  { 1075, 12, 28, 16, 2, -28 },
  { 1117, 28, 37, 32, 2, -28 },
  { 1247, 19, 28, 21, 1, -28 },
  { 1314, 15, 28, 21, 4, -28 },
  { 1367, 17, 28, 23, 3, -28 },
  { 1427, 16, 28, 23, 4, -28 },
  { 1483, 14, 28, 20, 4, -28 },
  { 1532, 15, 28, 20, 4, -28 },
  { 1585, 18, 28, 24, 3, -28 },
  { 1648, 17, 28, 25, 4, -28 },
  { 1708, 1, 28, 10, 4, -28 },
  { 1712, 14, 28, 19, 2, -28 },
  { 1761, 17, 28, 22, 4, -28 },
  { 1821, 13, 28, 18, 4, -28 },
  { 1867, 22, 28, 30, 4, -28 },
  { 1944, 17, 28, 25, 4, -28 },
  { 2004, 18, 28, 23, 3, -28 },
  { 2067, 15, 28, 21, 4, -28 },
  { 2120, 18, 33, 23, 3, -28 },
  { 2195, 16, 28, 23, 4, -28 },
  { 2251, 17, 28, 21, 2, -28 },
  { 2311, 19, 28, 21, 1, -28 },
  { 2378, 17, 28, 23, 3, -28 },
  { 2438, 19, 28, 21, 1, -28 },
  { 2505, 29, 28, 31, 1, -28 },
  { 2607, 19, 28, 21, 1, -28 },
  { 2674, 19, 28, 21, 1, -28 },
  { 2741, 17, 28, 21, 2, -28 },
  { 2801, 5, 39, 8, 3, -33 },
  { 2826, 11, 30, 14, 1, -28 },
  { 2868, 5, 39, 8, 0, -33 },
  { 2893, 11, 14, 15, 2, -28 },
  { 2913, 14, 1, 15, 0, 0 },
  { 2915, 5, 5, 11, 3, -30 },
  { 2919, 14, 21, 19, 2, -21 },
  { 2956, 14, 30, 19, 3, -30 },
  { 3009, 14, 21, 18, 2, -21 },
  { 3046, 14, 30, 19, 2, -30 },
  { 3099, 14, 21, 18, 2, -21 },
  { 3136, 10, 30, 11, 1, -30 },
  { 3174, 14, 29, 19, 2, -21 },
  { 3225, 13, 30, 19, 3, -30 },
  { 3274, 2, 29, 8, 3, -29 },
  { 3282, 7, 37, 8, -2, -29 },
  { 3315, 13, 30, 17, 3, -30 },
  { 3364, 1, 30, 8, 3, -30 },
  { 3368, 25, 21, 31, 3, -21 },
  { 3434, 13, 21, 19, 3, -21 },
  { 3469, 15, 21, 19, 2, -21 },
  { 3509, 14, 29, 19, 3, -21 },
  { 3560, 14, 29, 19, 2, -21 },
  { 3611, 8, 21, 12, 3, -21 },
  { 3632, 13, 21, 18, 2, -21 },
  { 3667, 9, 27, 12, 1, -27 },
  { 3698, 13, 21, 19, 3, -21 },
  { 3733, 15, 21, 17, 1, -21 },
  { 3773, 23, 21, 26, 2, -21 },
  { 3834, 15, 21, 17, 1, -21 },
  { 3874, 15, 29, 17, 1, -21 },
  { 3929, 14, 21, 17, 2, -21 },
  { 3966, 9, 40, 12, 2, -31 },
  { 4011, 1, 33, 8, 4, -28 },
  { 4016, 10, 40, 12, 0, -31 },
  { 4066, 18, 6, 24, 3, -15 },
};

const GFXfont RobotoCondensed_Thin40pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin40pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin40pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOCONDENSED_THIN40PT7B_H_
