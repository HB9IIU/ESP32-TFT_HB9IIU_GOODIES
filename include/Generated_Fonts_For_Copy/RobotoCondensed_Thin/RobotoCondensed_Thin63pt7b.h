#ifndef _ROBOTOCONDENSED_THIN63PT7B_H_
#define _ROBOTOCONDENSED_THIN63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin63pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xDB, 0x60, 0x00, 0x00, 0x00, 0x76, 0x00, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x40, 0x08, 0x00, 0x02, 0x00, 0x40, 0x00, 0x30, 0x06, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x02, 0x00,
  0x40, 0x00, 0x10, 0x02, 0x00, 0x00, 0x80, 0x10, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x60, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x00,
  0x80, 0x10, 0x00, 0x04, 0x00, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x04, 0x00, 0x80,
  0x00, 0x20, 0x04, 0x00, 0x01, 0x00, 0x20, 0x00, 0x18, 0x03, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x01, 0x00,
  0x20, 0x00, 0x08, 0x01, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x08, 0x01, 0x00, 0x00,
  0x40, 0x08, 0x00, 0x02, 0x00, 0x40, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x08, 0x00, 0x02, 0x00, 0x40,
  0x00, 0x10, 0x02, 0x00, 0x00, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0x80, 0x07, 0x01, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x00, 0xC1,
  0x80, 0x00, 0xC3, 0x00, 0x01, 0x84, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30,
  0x00, 0x06, 0x60, 0x00, 0x04, 0xC0, 0x00, 0x09, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x4C, 0x00, 0x01, 0x98, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x38, 0x38, 0x00, 0xE0, 0x1E, 0x07, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x06, 0x00, 0x40, 0x02, 0x01,
  0x00, 0x18, 0x01, 0x80, 0x40, 0x06, 0x00, 0x40, 0x30, 0x01, 0x80, 0x30,
  0x0C, 0x00, 0x60, 0x08, 0x03, 0x00, 0x18, 0x06, 0x00, 0xC0, 0x06, 0x03,
  0x00, 0x10, 0x01, 0x80, 0xC0, 0x04, 0x00, 0x60, 0x60, 0x01, 0x80, 0x10,
  0x18, 0x00, 0x60, 0x0C, 0x0C, 0x00, 0x08, 0x03, 0x03, 0x00, 0x03, 0x01,
  0x81, 0x80, 0x00, 0x70, 0xC0, 0x40, 0x00, 0x0F, 0xE0, 0x30, 0x00, 0x00,
  0x40, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x18, 0x0F,
  0xE0, 0x00, 0x04, 0x06, 0x1C, 0x00, 0x03, 0x03, 0x01, 0x80, 0x01, 0x81,
  0x80, 0x20, 0x00, 0x60, 0x60, 0x0C, 0x00, 0x30, 0x10, 0x03, 0x00, 0x0C,
  0x0C, 0x00, 0x40, 0x06, 0x03, 0x00, 0x10, 0x01, 0x80, 0xC0, 0x04, 0x00,
  0xC0, 0x30, 0x01, 0x00, 0x20, 0x0C, 0x00, 0x40, 0x18, 0x03, 0x00, 0x10,
  0x04, 0x00, 0xC0, 0x04, 0x03, 0x00, 0x30, 0x01, 0x00, 0x80, 0x04, 0x00,
  0xC0, 0x20, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x80, 0x18, 0x00, 0x0C, 0x01, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x18, 0x00,
  0x03, 0x00, 0xC0, 0x04, 0x20, 0x06, 0x00, 0x46, 0x00, 0x30, 0x04, 0x40,
  0x03, 0x00, 0x4C, 0x00, 0x18, 0x0C, 0xC0, 0x00, 0xC0, 0xC8, 0x00, 0x06,
  0x0C, 0x80, 0x00, 0x60, 0x88, 0x00, 0x03, 0x18, 0x80, 0x00, 0x19, 0x88,
  0x00, 0x00, 0xF0, 0xC0, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0F, 0x06, 0x00, 0x01, 0x98, 0x30, 0x00, 0x31, 0x83, 0x80, 0x06, 0x0C,
  0x0E, 0x01, 0xC0, 0x60, 0x7F, 0xF0, 0x03, 0x00, 0x7C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0xC0, 0x08, 0x03, 0x7C, 0x04, 0x0F, 0x87, 0xC2,
  0x1E, 0x00, 0x79, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x60, 0x30, 0x00, 0x70, 0x18, 0x00, 0x30, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x33, 0x33, 0x33, 0x33, 0x36, 0x6C, 0x80, 0xFF, 0xFF, 0xFF, 0xDF,
  0x80, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x1E, 0x0E, 0x00, 0x70, 0x06, 0x01, 0xC0, 0x06,
  0x03, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x18,
  0xC0, 0x00, 0x11, 0x80, 0x00, 0x32, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0xB0, 0x00, 0x01, 0x60, 0x00, 0x02, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x0B,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x64, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x18,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x30, 0x00, 0x60, 0x30,
  0x01, 0x80, 0x70, 0x06, 0x00, 0x78, 0x38, 0x00, 0x3F, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x76, 0x1E, 0x33, 0xC1, 0xF8, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x1C, 0x0E,
  0x00, 0x60, 0x06, 0x01, 0x80, 0x06, 0x06, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x90, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xC1, 0xE0, 0x06, 0x00, 0x70, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x04, 0x20, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x02, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x1C,
  0x00, 0x18, 0x0E, 0x00, 0x30, 0x03, 0x80, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x08, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x0C, 0x00,
  0x02, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C,
  0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x06,
  0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30,
  0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC3, 0xF8, 0x02, 0x7F, 0xF8, 0x0B, 0x00, 0x70,
  0x38, 0x00, 0x60, 0x80, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x50, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x80,
  0x00, 0x36, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x10, 0x60, 0x00,
  0xC0, 0xC0, 0x06, 0x01, 0xE0, 0x70, 0x01, 0xFF, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x7E,
  0x01, 0x87, 0xFF, 0x83, 0x1C, 0x03, 0x86, 0x60, 0x03, 0x8D, 0x80, 0x03,
  0x9E, 0x00, 0x03, 0x38, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x05,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x36, 0x00, 0x00, 0x4C, 0x00,
  0x01, 0x88, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x60, 0x38, 0x01, 0x80, 0x1C, 0x0E, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0x80, 0x03, 0x81,
  0xE0, 0x0E, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x06, 0x20, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x02, 0x60, 0x00, 0x02, 0x60, 0x00, 0x02, 0x60, 0x00, 0x02, 0x60, 0x00,
  0x02, 0x20, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x04, 0x18, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x07, 0x00, 0x60, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x07, 0x80, 0xE0, 0x0E, 0x00, 0x30, 0x18, 0x00,
  0x1C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x60, 0x00, 0x02, 0x40, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x40, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x18, 0x00,
  0x1C, 0x0E, 0x00, 0x38, 0x07, 0x80, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0x00, 0x03, 0x83, 0xC0, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x40, 0x00,
  0x06, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00,
  0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x20, 0x00,
  0x0F, 0x30, 0x00, 0x0B, 0x10, 0x00, 0x1A, 0x18, 0x00, 0x32, 0x0C, 0x00,
  0x62, 0x07, 0x00, 0xC2, 0x03, 0xFF, 0x86, 0x00, 0xFC, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x6F, 0xE4, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0xEE, 0x40,
  0x18, 0xE3, 0x84, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x8C, 0x30, 0xC6, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x38, 0x38, 0x0C, 0x01,
  0x83, 0x00, 0x18, 0xC0, 0x01, 0x18, 0x00, 0x32, 0x00, 0x06, 0xC0, 0x00,
  0x58, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0x1F, 0x80, 0x01, 0x06, 0x00,
  0x0F, 0xF8, 0x00, 0x21, 0x80, 0x03, 0x81, 0xC0, 0x06, 0x30, 0x00, 0xC0,
  0x0C, 0x00, 0xC4, 0x00, 0x30, 0x01, 0x80, 0x09, 0x80, 0x06, 0x00, 0x20,
  0x01, 0x30, 0x01, 0x80, 0x04, 0x00, 0x26, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x80, 0x0C, 0x00, 0x10, 0x00, 0xF0, 0x01, 0x80, 0x02, 0x00, 0x1E, 0x00,
  0x20, 0x00, 0xC0, 0x03, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0x78, 0x01, 0x80,
  0x03, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x60, 0x01, 0xE0, 0x04, 0x00, 0x0C,
  0x00, 0x3C, 0x00, 0x80, 0x01, 0x80, 0x07, 0x00, 0x10, 0x00, 0x30, 0x00,
  0xE0, 0x02, 0x00, 0x06, 0x00, 0x14, 0x00, 0x40, 0x00, 0xC0, 0x02, 0xC0,
  0x08, 0x00, 0x10, 0x00, 0xD8, 0x01, 0x00, 0x02, 0x00, 0x1B, 0x00, 0x20,
  0x00, 0xC0, 0x03, 0x60, 0x04, 0x00, 0x18, 0x00, 0x4C, 0x00, 0x80, 0x03,
  0x00, 0x19, 0x80, 0x18, 0x00, 0xE0, 0x03, 0x10, 0x03, 0x00, 0x36, 0x00,
  0xC2, 0x00, 0x20, 0x04, 0xC0, 0x18, 0x60, 0x06, 0x01, 0x8C, 0x06, 0x0C,
  0x00, 0x60, 0xE1, 0xC1, 0x80, 0x80, 0x07, 0xF0, 0x1F, 0xE0, 0x18, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x0F, 0x80,
  0x0E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x01, 0x01, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0x10, 0x04, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x01, 0x00, 0x10, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x40, 0x00, 0x20, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x60, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x80, 0x01, 0xE0, 0x80, 0x00, 0x70, 0x80, 0x00, 0x30,
  0x80, 0x00, 0x18, 0x80, 0x00, 0x08, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04,
  0x80, 0x00, 0x04, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x18, 0x80, 0x00, 0x18, 0x80, 0x00, 0x30, 0x80, 0x00, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0xE0, 0x80, 0x00, 0x38,
  0x80, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x18, 0x80, 0x00, 0x70, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x18, 0x03, 0x00, 0x06, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x08, 0x00, 0x1E,
  0x02, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x18, 0x20, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x80,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x04,
  0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x0E, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x70, 0x00, 0x60, 0x0E, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x18, 0x18,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x64, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x78,
  0x01, 0xE0, 0x1E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x64, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0x60, 0x00, 0x30, 0xC0, 0x01, 0x81, 0x80, 0x0C, 0x03,
  0xC0, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x18, 0x40, 0x00, 0x06, 0x08, 0x00, 0x01,
  0xC1, 0x00, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x03, 0x00, 0x80,
  0x00, 0xC0, 0x10, 0x00, 0x30, 0x02, 0x00, 0x0E, 0x00, 0x40, 0x01, 0x80,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x18, 0x00, 0x20, 0x06, 0x00, 0x04, 0x01,
  0x80, 0x00, 0x80, 0x70, 0x00, 0x10, 0x0C, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x08, 0x38, 0x00, 0x01, 0x0D, 0x80, 0x00, 0x23, 0x30,
  0x00, 0x04, 0xC3, 0x00, 0x00, 0x90, 0x30, 0x00, 0x16, 0x06, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x60, 0x06, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0xC0, 0x04, 0x00, 0x0C, 0x00, 0x80, 0x00, 0xC0, 0x10,
  0x00, 0x18, 0x02, 0x00, 0x01, 0x80, 0x40, 0x00, 0x18, 0x08, 0x00, 0x03,
  0x81, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x06, 0x10, 0x00, 0x00, 0x62, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xD0, 0x00, 0x00, 0x00, 0x5B, 0x00, 0x00, 0x00,
  0x1B, 0x60, 0x00, 0x00, 0x03, 0x64, 0x00, 0x00, 0x00, 0x4C, 0xC0, 0x00,
  0x00, 0x19, 0x98, 0x00, 0x00, 0x02, 0x31, 0x80, 0x00, 0x00, 0xC6, 0x30,
  0x00, 0x00, 0x18, 0xC2, 0x00, 0x00, 0x02, 0x18, 0x60, 0x00, 0x00, 0xC3,
  0x0C, 0x00, 0x00, 0x18, 0x60, 0x80, 0x00, 0x02, 0x0C, 0x18, 0x00, 0x00,
  0xC1, 0x83, 0x00, 0x00, 0x18, 0x30, 0x20, 0x00, 0x02, 0x06, 0x06, 0x00,
  0x00, 0xC0, 0xC0, 0x40, 0x00, 0x10, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x10, 0x00, 0x10, 0x0C, 0x03, 0x00, 0x06, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x30, 0x04, 0x00, 0x10, 0x06, 0x00, 0xC0, 0x06,
  0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x02, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80,
  0x0C, 0x06, 0x00, 0x30, 0x00, 0x80, 0x80, 0x06, 0x00, 0x18, 0x30, 0x00,
  0xC0, 0x03, 0x06, 0x00, 0x18, 0x00, 0x20, 0x80, 0x03, 0x00, 0x06, 0x30,
  0x00, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x00, 0x09, 0x80, 0x01, 0x80, 0x01,
  0xB0, 0x00, 0x30, 0x00, 0x14, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x02,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0xC0, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x40, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x78, 0x0F, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x10, 0xC0, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x70, 0x80, 0x00, 0x38, 0x80, 0x00, 0x0C, 0x80, 0x00,
  0x0C, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x80, 0x00,
  0x0C, 0x80, 0x00, 0x38, 0x80, 0x00, 0x70, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x61, 0x00, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x64, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x00, 0x90, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03,
  0x10, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00,
  0x1C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x08, 0x00, 0x07, 0x02,
  0x00, 0x00, 0xE0, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x08, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x04, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x22, 0x00, 0x00, 0x18, 0x80, 0x00, 0x04, 0x20, 0x00,
  0x03, 0x08, 0x00, 0x01, 0x82, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x08, 0x00, 0x30, 0x02, 0x00, 0x06, 0x00, 0x80, 0x01, 0x80,
  0x20, 0x00, 0x30, 0x08, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x20, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x82, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x0C, 0x20, 0x00, 0x03, 0x08, 0x00, 0x00, 0x62, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x30, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x04, 0x60, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x30, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x04, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x07, 0x80, 0x07, 0x00, 0x3E, 0x03,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x14, 0x00, 0x00, 0x05, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x06, 0x18, 0x00, 0x03, 0x07, 0x00, 0x01, 0x80, 0xE0, 0x01, 0xE0,
  0x0F, 0x01, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0x86, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x80, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60,
  0x02, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x20, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x80, 0x0C, 0x00, 0x01, 0x80, 0x10, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x04, 0x01, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x36, 0x00, 0x00, 0x58, 0x00, 0x01, 0x30, 0x00, 0x02,
  0x40, 0x00, 0x18, 0x80, 0x00, 0x32, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x98,
  0x00, 0x06, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x21, 0x80, 0x00, 0xC2, 0x00,
  0x03, 0x04, 0x00, 0x06, 0x10, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0xC1, 0x80, 0x01, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x20,
  0x60, 0x00, 0xC0, 0x80, 0x03, 0x01, 0x00, 0x06, 0x06, 0x00, 0x18, 0x0C,
  0x00, 0x20, 0x30, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x80, 0x04, 0x03, 0x00,
  0x18, 0x04, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x04,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x20, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x60, 0x02, 0x00, 0x80, 0x0C,
  0x03, 0x00, 0x18, 0x0C, 0x00, 0x20, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x00,
  0x80, 0x06, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x10, 0x10, 0x00, 0x60, 0x60,
  0x00, 0xC1, 0x80, 0x01, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x08, 0x10, 0x00,
  0x30, 0x60, 0x00, 0x60, 0x80, 0x00, 0x82, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x30, 0x00, 0x08, 0x60, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x01, 0x8C,
  0x00, 0x03, 0x10, 0x00, 0x0C, 0x40, 0x00, 0x19, 0x80, 0x00, 0x26, 0x00,
  0x00, 0x4C, 0x00, 0x01, 0xB0, 0x00, 0x02, 0x60, 0x00, 0x0D, 0x80, 0x00,
  0x1A, 0x00, 0x00, 0x68, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60,
  0x02, 0x00, 0x03, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x20, 0x0C, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x04, 0x04, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x46, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x00, 0x60, 0x00,
  0x18, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x04, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0xFF, 0xFF,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x00,
  0x80, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x68, 0x00, 0x36, 0x00, 0x11, 0x00,
  0x18, 0xC0, 0x0C, 0x60, 0x04, 0x10, 0x06, 0x0C, 0x03, 0x06, 0x01, 0x01,
  0x01, 0x80, 0xC0, 0xC0, 0x60, 0x40, 0x10, 0x60, 0x0C, 0x30, 0x06, 0x30,
  0x01, 0x18, 0x00, 0xCC, 0x00, 0x6C, 0x00, 0x16, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x18,
  0x06, 0x00, 0x10, 0x00, 0x0F, 0xFE, 0x00, 0x70, 0x1C, 0x07, 0x00, 0x18,
  0x18, 0x00, 0x30, 0xC0, 0x00, 0x46, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60,
  0x00, 0x09, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE1, 0xE0, 0x00, 0x8E, 0x00, 0x02, 0x30, 0x00, 0x09, 0x80,
  0x00, 0x24, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00, 0x00,
  0x2C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x39, 0x00, 0x01, 0xA6,
  0x00, 0x0C, 0x8C, 0x00, 0x63, 0x1C, 0x0F, 0x0C, 0x3F, 0xF0, 0x30, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x3F, 0xF0, 0x31, 0xC0, 0xE0, 0xDC, 0x00,
  0xC3, 0x40, 0x01, 0x8F, 0x00, 0x03, 0x38, 0x00, 0x0C, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00,
  0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xCE, 0x00, 0x03,
  0x3C, 0x00, 0x18, 0xD8, 0x00, 0xC3, 0x3C, 0x0E, 0x0C, 0x3F, 0xF0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x78, 0x1C, 0x03, 0x00,
  0x18, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x62, 0x00, 0x01, 0x98, 0x00, 0x03,
  0x60, 0x00, 0x0D, 0x00, 0x00, 0x34, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x05, 0x00,
  0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x20, 0x00, 0x08, 0xC0, 0x00,
  0x61, 0x80, 0x03, 0x03, 0x00, 0x18, 0x07, 0x81, 0xC0, 0x07, 0xFE, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x80, 0x30, 0x3F, 0xE0, 0xC3, 0x80, 0xE3, 0x1C,
  0x00, 0xCC, 0xC0, 0x01, 0xB3, 0x00, 0x03, 0xD8, 0x00, 0x07, 0x60, 0x00,
  0x1D, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xD0, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x73, 0x00,
  0x03, 0xCC, 0x00, 0x1B, 0x18, 0x00, 0xCC, 0x38, 0x0E, 0x30, 0x3F, 0xE0,
  0xC0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1E, 0x07, 0x00,
  0x70, 0x03, 0x01, 0x80, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x58, 0x00, 0x00, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x02, 0x07, 0x00, 0x1C, 0x07,
  0x80, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x1E, 0x00, 0xFF,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x1F,
  0xF0, 0x43, 0x80, 0xE2, 0x30, 0x01, 0x93, 0x00, 0x06, 0x98, 0x00, 0x1D,
  0x80, 0x00, 0xEC, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x50, 0x00, 0x02, 0xC0, 0x00, 0x36, 0x00, 0x01,
  0x98, 0x00, 0x1C, 0xC0, 0x01, 0xA3, 0x00, 0x19, 0x0F, 0x03, 0x88, 0x1F,
  0xF0, 0x40, 0x18, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x19, 0x00, 0x00, 0x8C, 0x00,
  0x0C, 0x30, 0x00, 0xC0, 0xE0, 0x0C, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x07, 0xFC, 0x18, 0x70, 0x70, 0xC6, 0x00, 0xC6, 0x60, 0x03, 0x36,
  0x00, 0x09, 0xE0, 0x00, 0x6F, 0x00, 0x03, 0x70, 0x00, 0x0B, 0x80, 0x00,
  0x58, 0x00, 0x02, 0xC0, 0x00, 0x16, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x60, 0xDF, 0x00, 0x00, 0x00, 0x0D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x18, 0xFE, 0x1F, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x01, 0x98, 0x00, 0x18, 0xC0,
  0x01, 0x86, 0x00, 0x1C, 0x30, 0x01, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0xC0,
  0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x06, 0x0C,
  0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0xE0, 0x00, 0x6D, 0x80, 0x03,
  0x46, 0x00, 0x1C, 0x30, 0x00, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x30, 0x0C,
  0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x06, 0x03, 0x00, 0x30, 0x18,
  0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x01,
  0x8C, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x10, 0x00,
  0x02, 0x01, 0x03, 0xFE, 0x00, 0x7F, 0xC2, 0x0C, 0x0E, 0x03, 0x81, 0xC4,
  0x70, 0x06, 0x0C, 0x00, 0xC8, 0x80, 0x06, 0x30, 0x00, 0xD3, 0x00, 0x04,
  0xC0, 0x01, 0xAC, 0x00, 0x0D, 0x00, 0x01, 0xD0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x06, 0x0F, 0xF8,
  0x30, 0xE0, 0xE1, 0x8C, 0x01, 0x8C, 0xC0, 0x06, 0x6C, 0x00, 0x13, 0xC0,
  0x00, 0xDE, 0x00, 0x06, 0xE0, 0x00, 0x17, 0x00, 0x00, 0xB0, 0x00, 0x05,
  0x80, 0x00, 0x2C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x07, 0xFE, 0x00, 0x1C, 0x0F, 0x00, 0x60, 0x07,
  0x01, 0x80, 0x07, 0x06, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00, 0x04,
  0x40, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x16, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x05, 0x80, 0x00, 0x19, 0x00, 0x00, 0x33, 0x00, 0x00, 0x46, 0x00, 0x01,
  0x86, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x70, 0x07, 0x03, 0xC0,
  0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0x0F, 0xFC, 0x0C,
  0x70, 0x38, 0x37, 0x00, 0x30, 0xD0, 0x00, 0x63, 0xC0, 0x00, 0xCE, 0x00,
  0x03, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x02,
  0xC0, 0x00, 0x0B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0,
  0x00, 0x33, 0x80, 0x00, 0xCF, 0x00, 0x06, 0x36, 0x00, 0x30, 0xCF, 0x03,
  0x83, 0x0F, 0xFC, 0x0C, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x43, 0xC0, 0xE2,
  0x38, 0x01, 0x93, 0x00, 0x06, 0x98, 0x00, 0x1D, 0x80, 0x00, 0x6C, 0x00,
  0x03, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x50, 0x00, 0x02, 0xC0, 0x00, 0x16, 0x00, 0x01, 0x98, 0x00, 0x1C, 0xC0,
  0x01, 0xA3, 0x00, 0x19, 0x0F, 0x03, 0x88, 0x1F, 0xF0, 0x40, 0x18, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x06, 0x0F, 0xF1,
  0xC1, 0x98, 0x0D, 0x80, 0x68, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x03, 0x80, 0xE0,
  0x30, 0x01, 0xC3, 0x00, 0x06, 0x30, 0x00, 0x19, 0x80, 0x00, 0xC8, 0x00,
  0x02, 0x40, 0x00, 0x13, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x34, 0x00, 0x01, 0xB0, 0x00, 0x18, 0xC0,
  0x00, 0xC7, 0x00, 0x1C, 0x0F, 0x03, 0xC0, 0x3F, 0xF8, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x03, 0xFF, 0xEF, 0xFF, 0x81, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0xE0, 0x02, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x36,
  0x00, 0x07, 0x60, 0x00, 0x53, 0x00, 0x0D, 0x38, 0x01, 0x91, 0xE0, 0x71,
  0x07, 0xFC, 0x10, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0D, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x10, 0x30, 0x00, 0x60, 0x60, 0x00,
  0xC0, 0xC0, 0x01, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x10,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x00, 0x0C, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x10, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00,
  0xC1, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x10, 0x00, 0x02,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x06, 0xC0, 0x00, 0xE0, 0x00, 0x64, 0x00, 0x0A, 0x00, 0x06, 0x60, 0x00,
  0xB0, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x0C, 0x60, 0x01, 0x90, 0x00, 0xC2,
  0x00, 0x11, 0x80, 0x0C, 0x30, 0x01, 0x18, 0x00, 0xC3, 0x00, 0x31, 0x80,
  0x18, 0x30, 0x03, 0x08, 0x01, 0x81, 0x00, 0x20, 0xC0, 0x18, 0x18, 0x06,
  0x0C, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x30, 0x18, 0x06, 0x04, 0x03, 0x00,
  0x80, 0x40, 0x60, 0x30, 0x0C, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x20,
  0x60, 0x0C, 0x08, 0x03, 0x06, 0x00, 0x40, 0x80, 0x30, 0x60, 0x06, 0x18,
  0x03, 0x06, 0x00, 0x61, 0x80, 0x10, 0xC0, 0x06, 0x10, 0x01, 0x8C, 0x00,
  0x23, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x01, 0x8C, 0x00, 0x32, 0x00, 0x08,
  0x80, 0x03, 0x20, 0x00, 0xD8, 0x00, 0x16, 0x00, 0x0D, 0x80, 0x01, 0x60,
  0x00, 0x58, 0x00, 0x1C, 0x00, 0x05, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x0C,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x01,
  0x80, 0x0C, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x03, 0x01, 0x80, 0x06,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0D,
  0x80, 0x00, 0x1A, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0x20, 0x00, 0x08, 0x60, 0x00, 0x30, 0x60,
  0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x30, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x06, 0x00, 0x03, 0x18,
  0x00, 0x06, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0D, 0x00, 0x00, 0x13, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC4, 0x00,
  0x01, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x10, 0x30, 0x00,
  0x60, 0x60, 0x00, 0xC0, 0x40, 0x01, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x04, 0x01, 0x80,
  0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x10, 0x18, 0x00, 0x30, 0x60, 0x00,
  0x60, 0xC0, 0x00, 0x41, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x01,
  0x18, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x20, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x01, 0x30,
  0x30, 0x00, 0x36, 0x01, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x02, 0xC0, 0x03, 0x80, 0x68, 0x00, 0x1C, 0x0C, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF0,
};

const GFXglyph RobotoCondensed_Thin63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 46, 12, 4, -45 },
  { 19, 8, 13, 16, 5, -47 },
  { 32, 29, 45, 31, 2, -45 },
  { 196, 23, 59, 30, 4, -52 },
  { 366, 34, 47, 41, 3, -46 },
  { 566, 28, 47, 34, 4, -46 },
  { 731, 2, 13, 10, 4, -47 },
  { 735, 12, 64, 17, 4, -50 },
  { 831, 12, 64, 18, 1, -50 },
  { 927, 25, 24, 26, 1, -45 },
  { 1002, 27, 34, 31, 2, -38 },
  { 1117, 4, 13, 12, 3, -5 },
  { 1124, 12, 2, 17, 2, -22 },
  { 1127, 3, 4, 14, 5, -3 },
  { 1129, 17, 49, 22, 2, -45 },
  { 1234, 23, 47, 30, 4, -46 },
  { 1370, 13, 45, 30, 5, -45 },
  { 1444, 23, 46, 30, 4, -46 },
  { 1577, 24, 47, 30, 3, -46 },
  { 1718, 26, 45, 30, 3, -45 },
  { 1865, 22, 46, 30, 5, -45 },
  { 1992, 23, 46, 30, 4, -45 },
  { 2125, 24, 45, 30, 3, -45 },
  { 2260, 24, 47, 30, 3, -46 },
  { 2401, 24, 46, 30, 3, -46 },
  { 2539, 4, 33, 11, 4, -32 },
  { 2556, 6, 40, 11, 2, -32 },
  { 2586, 22, 25, 29, 3, -33 },
  { 2655, 22, 15, 31, 4, -28 },
  { 2697, 21, 25, 29, 4, -33 },
  { 2763, 19, 47, 25, 3, -46 },
  { 2875, 43, 57, 51, 4, -43 },
  { 3182, 31, 45, 33, 1, -45 },
  { 3357, 24, 45, 34, 6, -45 },
  { 3492, 27, 47, 36, 5, -46 },
  { 3651, 26, 45, 36, 6, -45 },
  { 3798, 23, 45, 32, 6, -45 },
  { 3928, 23, 45, 32, 6, -45 },
  { 4058, 28, 47, 38, 5, -46 },
  { 4223, 27, 45, 39, 6, -45 },
  { 4375, 1, 45, 15, 7, -45 },
  { 4381, 22, 46, 31, 3, -45 },
  { 4508, 27, 45, 35, 6, -45 },
  { 4660, 21, 45, 29, 6, -45 },
  { 4779, 35, 45, 47, 6, -45 },
  { 4976, 27, 45, 39, 6, -45 },
  { 5128, 29, 47, 37, 4, -46 },
  { 5299, 24, 45, 33, 6, -45 },
  { 5434, 29, 54, 37, 4, -46 },
  { 5630, 26, 45, 36, 6, -45 },
  { 5777, 27, 47, 33, 3, -46 },
  { 5936, 29, 45, 33, 2, -45 },
  { 6100, 26, 46, 37, 5, -45 },
  { 6250, 31, 45, 33, 1, -45 },
  { 6425, 45, 45, 50, 2, -45 },
  { 6679, 29, 45, 33, 2, -45 },
  { 6843, 31, 45, 33, 1, -45 },
  { 7018, 27, 45, 33, 3, -45 },
  { 7170, 8, 61, 13, 5, -51 },
  { 7231, 18, 49, 21, 2, -45 },
  { 7342, 8, 61, 13, 0, -51 },
  { 7403, 17, 22, 23, 3, -45 },
  { 7450, 22, 2, 23, 1, 0 },
  { 7456, 9, 8, 17, 4, -47 },
  { 7465, 22, 35, 29, 3, -34 },
  { 7562, 22, 48, 30, 5, -47 },
  { 7694, 22, 35, 28, 3, -34 },
  { 7791, 22, 48, 30, 4, -47 },
  { 7923, 23, 35, 28, 3, -34 },
  { 8024, 16, 48, 18, 2, -48 },
  { 8120, 21, 47, 31, 4, -34 },
  { 8244, 21, 47, 30, 5, -47 },
  { 8368, 3, 45, 12, 5, -45 },
  { 8385, 11, 58, 13, -3, -45 },
  { 8465, 21, 47, 27, 5, -47 },
  { 8589, 2, 47, 12, 5, -47 },
  { 8601, 39, 34, 49, 5, -34 },
  { 8767, 21, 34, 30, 5, -34 },
  { 8857, 23, 35, 31, 4, -34 },
  { 8958, 22, 47, 30, 5, -34 },
  { 9088, 21, 47, 30, 4, -34 },
  { 9212, 13, 34, 19, 5, -34 },
  { 9268, 21, 35, 28, 3, -34 },
  { 9360, 14, 43, 18, 2, -42 },
  { 9436, 20, 34, 30, 5, -33 },
  { 9521, 23, 33, 27, 2, -33 },
  { 9616, 36, 33, 42, 3, -33 },
  { 9765, 23, 33, 27, 2, -33 },
  { 9860, 23, 46, 27, 2, -33 },
  { 9993, 22, 33, 27, 3, -33 },
  { 10084, 16, 63, 18, 2, -49 },
  { 10210, 1, 53, 13, 6, -45 },
  { 10217, 15, 63, 18, 1, -49 },
  { 10336, 28, 10, 38, 5, -24 },
};

const GFXfont RobotoCondensed_Thin63pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin63pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin63pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _ROBOTOCONDENSED_THIN63PT7B_H_
