#ifndef _ROBOTOCONDENSED_THIN20PT7B_H_
#define _ROBOTOCONDENSED_THIN20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xC4, 0xB6, 0xD0, 0x11, 0x09, 0x04, 0x8B, 0xE2, 0x21, 0x10,
  0x88, 0x48, 0x24, 0x12, 0x1F, 0x88, 0x84, 0x42, 0x00, 0x08, 0x08, 0x3C,
  0x42, 0x82, 0x80, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x81, 0x81, 0x42,
  0x3C, 0x08, 0x08, 0x70, 0x11, 0x02, 0x22, 0x44, 0x88, 0xA1, 0x14, 0x1D,
  0x00, 0x2E, 0x0A, 0x21, 0x44, 0x48, 0x91, 0x10, 0x22, 0x03, 0x80, 0x38,
  0x22, 0x11, 0x08, 0x84, 0x81, 0x80, 0x80, 0xA0, 0x48, 0xC2, 0x60, 0xD0,
  0x28, 0x33, 0xE4, 0xF0, 0x12, 0x24, 0x44, 0x48, 0x88, 0x88, 0x88, 0x44,
  0x44, 0x22, 0x10, 0x84, 0x22, 0x21, 0x11, 0x11, 0x11, 0x11, 0x11, 0x22,
  0x24, 0x80, 0x08, 0x08, 0x08, 0x6F, 0x18, 0x14, 0x24, 0x22, 0x10, 0x10,
  0x10, 0x10, 0x7E, 0x10, 0x10, 0x10, 0x10, 0x10, 0xF0, 0xF0, 0xC0, 0x08,
  0x44, 0x21, 0x10, 0x84, 0x42, 0x11, 0x08, 0x42, 0x00, 0x3C, 0x86, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x14, 0x27, 0x80, 0x3D, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x3C, 0x42, 0x82, 0x82, 0x02, 0x02, 0x04,
  0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0xFF, 0x3C, 0x42, 0x82, 0x81, 0x02,
  0x02, 0x1C, 0x02, 0x02, 0x01, 0x81, 0x81, 0x42, 0x3C, 0x04, 0x0C, 0x0C,
  0x14, 0x14, 0x24, 0x24, 0x44, 0x84, 0xFF, 0x04, 0x04, 0x04, 0x04, 0x7D,
  0x02, 0x04, 0x08, 0x1F, 0x21, 0x01, 0x02, 0x06, 0x0C, 0x18, 0x4F, 0x00,
  0x1C, 0x20, 0x40, 0x40, 0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x82,
  0x42, 0x3C, 0xFE, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x3C, 0x42, 0x82, 0x81, 0x82, 0x42, 0x3C, 0x42,
  0x81, 0x81, 0x81, 0x81, 0x82, 0x7C, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0x60,
  0xA1, 0x3E, 0x04, 0x08, 0x10, 0x47, 0x00, 0x80, 0x40, 0x80, 0xF0, 0x06,
  0x31, 0x84, 0x06, 0x03, 0x01, 0x80, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0xC0,
  0x60, 0x30, 0x10, 0xC6, 0x30, 0x00, 0x7A, 0x18, 0x61, 0x04, 0x10, 0x84,
  0x20, 0x80, 0x00, 0x00, 0x80, 0x07, 0xE0, 0x60, 0x42, 0x00, 0x90, 0x02,
  0x43, 0x85, 0x11, 0x18, 0x84, 0x62, 0x11, 0x88, 0x46, 0x21, 0x18, 0x88,
  0x62, 0x21, 0x88, 0x89, 0x1D, 0xC4, 0x00, 0x08, 0x00, 0x10, 0x00, 0x3E,
  0x00, 0x04, 0x03, 0x00, 0xA0, 0x28, 0x12, 0x04, 0x41, 0x10, 0x84, 0x20,
  0x8F, 0xA4, 0x09, 0x01, 0x40, 0x60, 0x10, 0xFC, 0x82, 0x82, 0x82, 0x82,
  0x82, 0xFC, 0x86, 0x82, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x3E, 0x20, 0x90,
  0x30, 0x18, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x28, 0x14, 0x11,
  0xF0, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x82, 0xFC, 0xFD, 0x02, 0x04, 0x08, 0x10, 0x3E, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x1F, 0xC0, 0xFD, 0x02, 0x04, 0x08, 0x10, 0x3F, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x00, 0x3E, 0x41, 0x81, 0x81, 0x80, 0x80, 0x80,
  0x8F, 0x81, 0x81, 0x81, 0x81, 0x41, 0x3E, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0xFC, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x06, 0x0C, 0x18, 0x4F, 0x00,
  0x81, 0x82, 0x84, 0x88, 0x90, 0xA0, 0xA0, 0xD0, 0x90, 0x88, 0x84, 0x82,
  0x82, 0x81, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x1F, 0xC0, 0x80, 0x30, 0x06, 0x01, 0xE0, 0x3C, 0x0B, 0x41, 0x68,
  0x2C, 0x89, 0x91, 0x32, 0x26, 0x28, 0xC5, 0x18, 0xC3, 0x08, 0x40, 0x80,
  0xC0, 0x70, 0x34, 0x1A, 0x0C, 0x86, 0x43, 0x11, 0x84, 0xC2, 0x60, 0xB0,
  0x58, 0x1C, 0x04, 0x3E, 0x20, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x28, 0x14, 0x11, 0xF0, 0xFC, 0x82, 0x81, 0x81, 0x81,
  0x81, 0x82, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3E, 0x20, 0x90,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x28, 0x14, 0x11,
  0xF0, 0x04, 0x02, 0x00, 0x80, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x82,
  0xFC, 0x88, 0x84, 0x82, 0x82, 0x81, 0x81, 0x3E, 0x20, 0xA0, 0x50, 0x18,
  0x02, 0x00, 0xE0, 0x0C, 0x01, 0x00, 0x60, 0x30, 0x14, 0x11, 0xF0, 0x7F,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x82, 0x7C, 0x80, 0x50, 0x14, 0x09, 0x02, 0x20, 0x88,
  0x22, 0x10, 0x44, 0x11, 0x04, 0x80, 0xA0, 0x28, 0x0C, 0x01, 0x00, 0x82,
  0x06, 0x0C, 0x18, 0x30, 0x61, 0x42, 0x44, 0x89, 0x12, 0x24, 0x48, 0x92,
  0x22, 0x48, 0x50, 0xA1, 0x42, 0x85, 0x0C, 0x14, 0x10, 0x20, 0x40, 0x80,
  0x80, 0xA0, 0x90, 0x84, 0x42, 0x40, 0xA0, 0x20, 0x10, 0x14, 0x12, 0x08,
  0x88, 0x28, 0x14, 0x04, 0x40, 0x50, 0x22, 0x08, 0x84, 0x11, 0x04, 0x80,
  0xA0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x7F, 0x00,
  0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08,
  0x07, 0xFC, 0xEA, 0xAA, 0xAA, 0xAA, 0xAC, 0x84, 0x20, 0x84, 0x20, 0x84,
  0x20, 0x84, 0x20, 0x84, 0x20, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49, 0x27,
  0x80, 0x21, 0x14, 0xA4, 0xC6, 0x20, 0xFE, 0x48, 0x80, 0x7D, 0x06, 0x08,
  0x10, 0x2F, 0xE0, 0xC1, 0x83, 0x0D, 0xE8, 0x82, 0x08, 0x20, 0xFA, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x1F, 0x80, 0x3C, 0x86, 0x0C, 0x18, 0x10,
  0x20, 0x40, 0x82, 0x84, 0xF0, 0x02, 0x04, 0x08, 0x13, 0xE8, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x28, 0x4F, 0x80, 0x3C, 0x86, 0x0C, 0x1F, 0xF0,
  0x20, 0x40, 0x80, 0x84, 0xF0, 0x3A, 0x10, 0x8F, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x00, 0x3E, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x84,
  0xF8, 0x10, 0x28, 0x4F, 0x00, 0x82, 0x08, 0x20, 0xFA, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x40, 0x8F, 0xFE, 0x00, 0x02, 0x49, 0x24, 0x92,
  0x49, 0x27, 0x00, 0x82, 0x08, 0x20, 0x86, 0x29, 0x28, 0xC2, 0x8A, 0x24,
  0x8A, 0x28, 0x40, 0xFF, 0xFE, 0xBC, 0xF6, 0x18, 0x60, 0x83, 0x04, 0x18,
  0x20, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x60, 0x82, 0xFA,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x40, 0x3C, 0x42, 0x82, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x82, 0x42, 0x3C, 0xF9, 0x0A, 0x14, 0x18, 0x30,
  0x60, 0xC1, 0x85, 0x0B, 0xE4, 0x08, 0x10, 0x20, 0x00, 0x3C, 0x86, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x82, 0x84, 0xF8, 0x10, 0x20, 0x40, 0x80, 0xF8,
  0x88, 0x88, 0x88, 0x88, 0x80, 0x79, 0x0A, 0x04, 0x06, 0x03, 0x01, 0x01,
  0x83, 0x09, 0xE0, 0x21, 0x3E, 0x42, 0x10, 0x84, 0x21, 0x08, 0x41, 0x80,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x17, 0xC0, 0x83, 0x06, 0x14,
  0x24, 0x49, 0x12, 0x14, 0x28, 0x20, 0x40, 0x84, 0x30, 0x86, 0x28, 0xC5,
  0x14, 0xA4, 0x94, 0x94, 0x52, 0x8A, 0x31, 0x84, 0x30, 0x82, 0x00, 0x83,
  0x09, 0x21, 0x43, 0x02, 0x0C, 0x24, 0x45, 0x0A, 0x08, 0x83, 0x06, 0x14,
  0x24, 0x49, 0x12, 0x14, 0x28, 0x20, 0x40, 0x82, 0x04, 0x10, 0x00, 0xFC,
  0x08, 0x20, 0x41, 0x02, 0x08, 0x20, 0x41, 0x03, 0xF8, 0x11, 0x08, 0x42,
  0x10, 0x84, 0x44, 0x10, 0x82, 0x10, 0x84, 0x21, 0x08, 0x30, 0xFF, 0xFF,
  0x80, 0xC1, 0x08, 0x42, 0x10, 0x84, 0x10, 0x44, 0x42, 0x10, 0x84, 0x21,
  0x11, 0x00, 0x70, 0x23, 0x20, 0x38,
};

const GFXglyph RobotoCondensed_Thin20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 14, 4, 1, -14 },
  { 3, 3, 4, 5, 1, -15 },
  { 5, 9, 14, 10, 1, -14 },
  { 21, 8, 18, 10, 1, -16 },
  { 39, 11, 14, 13, 1, -14 },
  { 59, 9, 14, 11, 1, -14 },
  { 75, 1, 4, 3, 1, -15 },
  { 76, 4, 21, 5, 1, -16 },
  { 87, 4, 21, 6, 0, -16 },
  { 98, 8, 8, 8, 0, -14 },
  { 106, 8, 10, 10, 1, -11 },
  { 116, 1, 4, 4, 1, -2 },
  { 117, 4, 1, 5, 1, -7 },
  { 118, 2, 1, 4, 1, -1 },
  { 119, 5, 15, 7, 1, -14 },
  { 129, 7, 14, 10, 1, -14 },
  { 142, 4, 14, 10, 2, -14 },
  { 149, 8, 14, 10, 1, -14 },
  { 163, 8, 14, 10, 1, -14 },
  { 177, 8, 14, 10, 1, -14 },
  { 191, 7, 14, 10, 2, -14 },
  { 204, 8, 14, 10, 1, -14 },
  { 218, 8, 14, 10, 1, -14 },
  { 232, 8, 14, 10, 1, -14 },
  { 246, 7, 14, 10, 1, -14 },
  { 259, 1, 10, 3, 1, -10 },
  { 261, 1, 12, 3, 1, -10 },
  { 263, 7, 7, 9, 1, -10 },
  { 270, 7, 5, 10, 1, -9 },
  { 275, 7, 7, 9, 1, -10 },
  { 282, 6, 14, 8, 1, -14 },
  { 293, 14, 18, 16, 1, -14 },
  { 325, 10, 14, 11, 0, -14 },
  { 343, 8, 14, 11, 2, -14 },
  { 357, 9, 14, 11, 1, -14 },
  { 373, 8, 14, 11, 2, -14 },
  { 387, 7, 14, 10, 2, -14 },
  { 400, 7, 14, 10, 2, -14 },
  { 413, 8, 14, 12, 2, -14 },
  { 427, 8, 14, 12, 2, -14 },
  { 441, 1, 14, 5, 2, -14 },
  { 443, 7, 14, 10, 1, -14 },
  { 456, 8, 14, 11, 2, -14 },
  { 470, 7, 14, 9, 2, -14 },
  { 483, 11, 14, 15, 2, -14 },
  { 503, 9, 14, 12, 2, -14 },
  { 519, 9, 14, 12, 1, -14 },
  { 535, 8, 14, 11, 2, -14 },
  { 549, 9, 17, 12, 1, -14 },
  { 569, 8, 14, 11, 2, -14 },
  { 583, 9, 14, 10, 1, -14 },
  { 599, 9, 14, 11, 1, -14 },
  { 615, 8, 14, 12, 2, -14 },
  { 629, 10, 14, 11, 0, -14 },
  { 647, 14, 14, 16, 1, -14 },
  { 672, 9, 14, 11, 1, -14 },
  { 688, 10, 14, 11, 0, -14 },
  { 706, 9, 14, 11, 1, -14 },
  { 722, 2, 19, 4, 2, -16 },
  { 727, 5, 15, 7, 1, -14 },
  { 737, 3, 19, 4, 0, -16 },
  { 745, 5, 7, 7, 1, -14 },
  { 750, 7, 1, 7, 0, 0 },
  { 751, 3, 3, 5, 1, -15 },
  { 753, 7, 11, 9, 1, -11 },
  { 763, 6, 15, 10, 2, -15 },
  { 775, 7, 11, 9, 1, -11 },
  { 785, 7, 15, 10, 1, -15 },
  { 799, 7, 11, 9, 1, -11 },
  { 809, 5, 15, 6, 1, -15 },
  { 819, 7, 15, 10, 1, -11 },
  { 833, 6, 15, 10, 2, -15 },
  { 845, 1, 15, 4, 1, -15 },
  { 847, 3, 19, 4, -1, -15 },
  { 855, 6, 15, 8, 2, -15 },
  { 867, 1, 15, 4, 1, -15 },
  { 869, 13, 11, 16, 1, -11 },
  { 887, 6, 11, 10, 2, -11 },
  { 896, 8, 11, 10, 1, -11 },
  { 907, 7, 15, 10, 2, -11 },
  { 921, 7, 15, 10, 1, -11 },
  { 935, 4, 11, 6, 2, -11 },
  { 941, 7, 11, 9, 1, -11 },
  { 951, 5, 13, 6, 0, -13 },
  { 960, 6, 11, 10, 2, -11 },
  { 969, 7, 11, 8, 1, -11 },
  { 979, 11, 11, 13, 1, -11 },
  { 995, 7, 11, 8, 1, -11 },
  { 1005, 7, 15, 8, 1, -11 },
  { 1019, 7, 11, 8, 1, -11 },
  { 1029, 5, 20, 6, 1, -16 },
  { 1042, 1, 17, 4, 2, -14 },
  { 1045, 5, 20, 6, 0, -16 },
  { 1058, 10, 3, 12, 1, -7 },
};

const GFXfont RobotoCondensed_Thin20pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin20pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin20pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _ROBOTOCONDENSED_THIN20PT7B_H_
