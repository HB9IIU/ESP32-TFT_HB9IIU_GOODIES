#ifndef _ROBOTOCONDENSED_THIN27PT7B_H_
#define _ROBOTOCONDENSED_THIN27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0x20, 0x99, 0x99, 0x90, 0x04, 0x40, 0x44, 0x08, 0x40,
  0x84, 0x08, 0x47, 0xFF, 0x08, 0x40, 0x88, 0x08, 0x81, 0x08, 0x10, 0x81,
  0x08, 0x10, 0x8F, 0xFE, 0x11, 0x02, 0x10, 0x21, 0x02, 0x10, 0x21, 0x00,
  0x08, 0x04, 0x0F, 0x88, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x28, 0x23, 0xE0,
  0x40, 0x20, 0x38, 0x00, 0x88, 0x01, 0x08, 0x44, 0x10, 0x88, 0x22, 0x10,
  0x44, 0x10, 0x90, 0x22, 0x40, 0x38, 0x80, 0x02, 0x00, 0x04, 0xF0, 0x12,
  0x10, 0x24, 0x20, 0x88, 0x41, 0x10, 0x84, 0x21, 0x00, 0x42, 0x00, 0x84,
  0x00, 0xF0, 0x1C, 0x02, 0x20, 0x41, 0x04, 0x10, 0x41, 0x04, 0x20, 0x24,
  0x02, 0x80, 0x10, 0x02, 0x80, 0x48, 0x28, 0x42, 0x82, 0x28, 0x12, 0x81,
  0x48, 0x0C, 0x80, 0xC4, 0x12, 0x3E, 0x20, 0xF8, 0x08, 0x88, 0x44, 0x21,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x04, 0x21, 0x04, 0x20,
  0x82, 0x88, 0x42, 0x22, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x12,
  0x22, 0x48, 0x80, 0x04, 0x00, 0x80, 0x10, 0x22, 0x33, 0xD8, 0x0C, 0x02,
  0x80, 0x48, 0x10, 0x84, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x07, 0xFF, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x55, 0x80, 0xF8, 0x80, 0x02, 0x04, 0x08, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x08,
  0x00, 0x3E, 0x20, 0x90, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x41, 0x20, 0x8F, 0x80, 0x0C,
  0xDC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x40, 0x3E, 0x10, 0x48, 0x0A, 0x02, 0x80, 0xA0, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x0F, 0xFC, 0x1F, 0x04, 0x11, 0x01, 0x20, 0x24, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x81, 0xE0, 0x06, 0x00, 0x20, 0x05, 0x00, 0x60, 0x0A, 0x02,
  0x40, 0x44, 0x10, 0x7C, 0x00, 0x00, 0x80, 0x30, 0x0A, 0x01, 0x40, 0x48,
  0x09, 0x02, 0x20, 0x44, 0x10, 0x84, 0x10, 0x82, 0x20, 0x44, 0x09, 0xFF,
  0xC0, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x3F, 0xD0, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0xF8, 0x41, 0x00, 0x20, 0x04, 0x01, 0x00,
  0x40, 0x18, 0x06, 0x01, 0x40, 0x88, 0x61, 0xE0, 0x0F, 0x04, 0x02, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x78, 0xE1, 0x20, 0x28, 0x0A, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x02, 0x40, 0x98, 0x41, 0xE0, 0xFF, 0xE0, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x00, 0x1F,
  0x04, 0x11, 0x01, 0x20, 0x24, 0x04, 0x80, 0x90, 0x12, 0x02, 0x20, 0x81,
  0xE0, 0xC2, 0x20, 0x24, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x44, 0x18,
  0x7C, 0x00, 0x1F, 0x08, 0x24, 0x05, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x50, 0x14, 0x0C, 0x87, 0x1E, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0xC1, 0xC0, 0x80, 0x04, 0x40, 0x00, 0x00, 0x55, 0x80, 0x00, 0xC0, 0x40,
  0x60, 0x60, 0x60, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x08, 0x18, 0x30, 0x60, 0x40, 0x00, 0x3C, 0x42, 0x41, 0x81, 0x81,
  0x01, 0x01, 0x01, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x03, 0xF8, 0x01, 0x01, 0x81, 0x80, 0x10, 0xC0, 0x04, 0x20,
  0x00, 0x90, 0x00, 0x24, 0x0E, 0x06, 0x04, 0x41, 0x82, 0x10, 0x61, 0x04,
  0x18, 0x41, 0x06, 0x10, 0x41, 0x84, 0x10, 0x61, 0x04, 0x18, 0x81, 0x06,
  0x10, 0x41, 0x84, 0x30, 0xA1, 0x14, 0x28, 0x38, 0xF1, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x20, 0x40, 0x07, 0xE0, 0x00, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x12, 0x00, 0x90, 0x04, 0x80, 0x42, 0x02, 0x10,
  0x10, 0x80, 0x82, 0x08, 0x10, 0x40, 0x83, 0xFE, 0x20, 0x11, 0x00, 0x88,
  0x02, 0x80, 0x14, 0x00, 0xA0, 0x02, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x28,
  0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x9F, 0xE2, 0x02, 0x40, 0x28, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x50, 0x1B, 0xFC, 0x00, 0x1F, 0x82, 0x04,
  0x40, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x02, 0x40, 0x22, 0x04,
  0x1F, 0x80, 0xFF, 0x08, 0x08, 0x80, 0x48, 0x02, 0x80, 0x28, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x28, 0x02, 0x80, 0x48, 0x08, 0xFF, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xE8, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFC, 0xFF, 0xF0, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xF2, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x00, 0x1F, 0x82,
  0x04, 0x40, 0x24, 0x01, 0x80, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x83, 0xF8, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40, 0x13,
  0x02, 0x0F, 0xC0, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0xFF, 0xFF, 0xE0, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x60, 0x18, 0x06, 0x02, 0x40, 0x98, 0x41, 0xE0, 0x80,
  0x28, 0x04, 0x80, 0x88, 0x10, 0x81, 0x08, 0x20, 0x84, 0x08, 0x80, 0x90,
  0x0A, 0x80, 0xC4, 0x08, 0x20, 0x82, 0x08, 0x10, 0x80, 0x88, 0x08, 0x80,
  0x48, 0x02, 0x80, 0x10, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x0F, 0xFC, 0xC0, 0x01, 0xC0, 0x03, 0xA0, 0x03, 0xA0, 0x05,
  0xA0, 0x05, 0x90, 0x05, 0x90, 0x09, 0x90, 0x09, 0x88, 0x11, 0x88, 0x11,
  0x88, 0x11, 0x84, 0x21, 0x84, 0x21, 0x82, 0x21, 0x82, 0x41, 0x82, 0x41,
  0x81, 0x81, 0x81, 0x81, 0x80, 0x81, 0x80, 0x1C, 0x01, 0xA0, 0x1A, 0x01,
  0x90, 0x18, 0x81, 0x88, 0x18, 0x41, 0x84, 0x18, 0x21, 0x82, 0x18, 0x11,
  0x80, 0x98, 0x09, 0x80, 0x58, 0x05, 0x80, 0x38, 0x01, 0x80, 0x10, 0x1F,
  0x82, 0x04, 0x40, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x40,
  0x22, 0x04, 0x1F, 0x80, 0xFF, 0x10, 0x1A, 0x01, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x50, 0x1B, 0xFC, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x00, 0x1F, 0x82, 0x04, 0x40, 0x28,
  0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x40, 0x22, 0x04, 0x1F, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0xFF, 0x08, 0x0C, 0x80, 0x48, 0x02,
  0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x0C, 0xFF, 0x08, 0x10,
  0x81, 0x08, 0x08, 0x80, 0x88, 0x04, 0x80, 0x28, 0x02, 0x80, 0x10, 0x1F,
  0x82, 0x04, 0x40, 0x24, 0x01, 0x40, 0x14, 0x00, 0x40, 0x02, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40,
  0x22, 0x06, 0x1F, 0x80, 0xFF, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x24, 0x08, 0x7C, 0x00,
  0x80, 0x0C, 0x00, 0xA0, 0x04, 0x80, 0x24, 0x02, 0x20, 0x10, 0x80, 0x84,
  0x08, 0x20, 0x40, 0x82, 0x04, 0x20, 0x21, 0x01, 0x08, 0x04, 0x80, 0x24,
  0x01, 0x20, 0x06, 0x00, 0x30, 0x00, 0x80, 0x80, 0x40, 0x30, 0x08, 0x06,
  0x02, 0x80, 0xA0, 0x50, 0x14, 0x0A, 0x04, 0x81, 0x20, 0x90, 0x44, 0x11,
  0x08, 0x82, 0x21, 0x10, 0x84, 0x21, 0x10, 0x88, 0x22, 0x11, 0x04, 0x41,
  0x20, 0x88, 0x24, 0x0A, 0x05, 0x01, 0x40, 0xA0, 0x28, 0x0C, 0x05, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x00, 0x80, 0x14, 0x02, 0x40, 0x22, 0x04, 0x10,
  0x41, 0x08, 0x09, 0x00, 0x90, 0x06, 0x00, 0x20, 0x06, 0x00, 0x90, 0x08,
  0x81, 0x08, 0x20, 0x42, 0x04, 0x40, 0x24, 0x01, 0x80, 0x10, 0x80, 0x14,
  0x00, 0x90, 0x08, 0x80, 0x42, 0x04, 0x10, 0x20, 0x42, 0x02, 0x10, 0x09,
  0x00, 0x48, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x7F, 0xF0, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0xFF, 0xF0, 0xF2, 0x49,
  0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x9C, 0x81, 0x01, 0x02, 0x04,
  0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0x81, 0x02, 0x02, 0x04, 0x08,
  0x08, 0x10, 0x20, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49,
  0x3C, 0x10, 0x18, 0x18, 0x24, 0x24, 0x24, 0x42, 0x42, 0x42, 0x81, 0xFF,
  0xC0, 0x89, 0x10, 0x1F, 0x08, 0x24, 0x09, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x7E, 0x60, 0x50, 0x18, 0x06, 0x02, 0x80, 0x90, 0x53, 0xE4, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x79, 0xC2, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x2B, 0xE0, 0x1F, 0x08,
  0x24, 0x09, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x05,
  0x01, 0x40, 0x88, 0x21, 0xF0, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0xFA, 0x83, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x28, 0x33, 0xE8, 0x1F, 0x08, 0x24, 0x09, 0x01, 0x80, 0x60,
  0x1F, 0xFE, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x21, 0xF0,
  0x0E, 0x20, 0x81, 0x02, 0x04, 0x3F, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0x3E, 0xA0, 0xE0, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0A, 0x0C, 0xFA,
  0x01, 0x00, 0x80, 0x50, 0x47, 0xC0, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x79, 0x42, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x87, 0xFF, 0xF0, 0x10, 0x00, 0x01,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xE0, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x05, 0x04, 0x84, 0x42, 0x22, 0x12, 0x0A,
  0x06, 0x82, 0x21, 0x10, 0x84, 0x41, 0x20, 0x90, 0x28, 0x08, 0xFF, 0xFF,
  0xF8, 0x9E, 0x1E, 0x50, 0x90, 0xB0, 0x30, 0x30, 0x10, 0x18, 0x08, 0x0C,
  0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20,
  0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x02, 0x9E, 0x50, 0xB0,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x02, 0x3E, 0x10, 0x48, 0x0A, 0x02, 0x80, 0xA0, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x0A, 0x02, 0x80, 0x90, 0x43, 0xE0, 0x9E, 0x70, 0xA0,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E,
  0x0A, 0xF9, 0x00, 0x80, 0x40, 0x20, 0x10, 0x00, 0x3E, 0xA0, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0A, 0x0C,
  0xFA, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x9E, 0x8C, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x00, 0x3E, 0x20, 0x90, 0x30, 0x14,
  0x03, 0x00, 0x40, 0x1C, 0x01, 0x00, 0x40, 0x30, 0x18, 0x0A, 0x0C, 0xF8,
  0x20, 0x82, 0x3E, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x70, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0A, 0x0C, 0xFA, 0x80, 0x60, 0x28, 0x09, 0x02,
  0x41, 0x10, 0x42, 0x10, 0x84, 0x22, 0x04, 0x81, 0x20, 0x50, 0x14, 0x03,
  0x00, 0x80, 0x81, 0x01, 0x81, 0x82, 0x41, 0x82, 0x42, 0x82, 0x42, 0x82,
  0x42, 0x44, 0x22, 0x44, 0x24, 0x44, 0x24, 0x24, 0x24, 0x28, 0x14, 0x28,
  0x18, 0x28, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10, 0x80, 0x90, 0x24, 0x10,
  0x88, 0x12, 0x05, 0x00, 0xC0, 0x20, 0x14, 0x04, 0x82, 0x20, 0x84, 0x41,
  0x10, 0x28, 0x08, 0x80, 0x60, 0x28, 0x09, 0x02, 0x41, 0x10, 0x42, 0x10,
  0x84, 0x22, 0x04, 0x81, 0x20, 0x50, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x04, 0x01, 0x03, 0x80, 0x7F, 0x80, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x0F, 0xFC, 0x06,
  0x10, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x18, 0x18,
  0x10, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x10, 0x18, 0xFF,
  0xFF, 0xFE, 0xC0, 0x40, 0x80, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x40, 0x80, 0xC3, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x20,
  0x43, 0x00, 0x78, 0x18, 0x41, 0x82, 0x18, 0x1E,
};

const GFXglyph RobotoCondensed_Thin27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 19, 5, 2, -19 },
  { 4, 4, 5, 7, 2, -20 },
  { 7, 12, 19, 13, 1, -19 },
  { 36, 9, 23, 13, 2, -21 },
  { 62, 15, 19, 18, 1, -19 },
  { 98, 12, 19, 14, 2, -19 },
  { 127, 1, 5, 5, 2, -20 },
  { 128, 5, 27, 7, 2, -21 },
  { 145, 4, 27, 8, 1, -21 },
  { 159, 11, 10, 11, 0, -19 },
  { 173, 11, 15, 13, 1, -17 },
  { 194, 2, 5, 5, 1, -2 },
  { 196, 5, 1, 7, 1, -9 },
  { 197, 1, 1, 6, 2, -1 },
  { 198, 7, 21, 9, 1, -19 },
  { 217, 9, 19, 13, 2, -19 },
  { 239, 6, 19, 13, 2, -19 },
  { 254, 10, 19, 13, 2, -19 },
  { 278, 11, 19, 13, 1, -19 },
  { 305, 11, 19, 13, 1, -19 },
  { 332, 10, 19, 13, 2, -19 },
  { 356, 10, 19, 13, 2, -19 },
  { 380, 11, 19, 13, 1, -19 },
  { 407, 11, 19, 13, 1, -19 },
  { 434, 10, 19, 13, 1, -19 },
  { 458, 1, 14, 5, 2, -14 },
  { 460, 2, 17, 5, 1, -14 },
  { 465, 10, 11, 12, 1, -14 },
  { 479, 9, 7, 13, 2, -12 },
  { 487, 9, 10, 12, 2, -14 },
  { 499, 8, 19, 11, 1, -19 },
  { 518, 18, 25, 22, 2, -19 },
  { 575, 13, 19, 14, 1, -19 },
  { 606, 11, 19, 14, 2, -19 },
  { 633, 12, 19, 15, 2, -19 },
  { 662, 12, 19, 15, 2, -19 },
  { 691, 10, 19, 14, 2, -19 },
  { 715, 11, 19, 14, 2, -19 },
  { 742, 12, 19, 16, 2, -19 },
  { 771, 12, 19, 17, 2, -19 },
  { 800, 1, 19, 6, 3, -19 },
  { 803, 10, 19, 13, 1, -19 },
  { 827, 12, 19, 15, 2, -19 },
  { 856, 10, 19, 12, 2, -19 },
  { 880, 16, 19, 20, 2, -19 },
  { 918, 12, 19, 17, 2, -19 },
  { 947, 12, 19, 16, 2, -19 },
  { 976, 11, 19, 14, 2, -19 },
  { 1003, 12, 23, 16, 2, -19 },
  { 1038, 12, 19, 15, 2, -19 },
  { 1067, 12, 19, 14, 1, -19 },
  { 1096, 12, 19, 14, 1, -19 },
  { 1125, 11, 19, 16, 2, -19 },
  { 1152, 13, 19, 14, 1, -19 },
  { 1183, 19, 19, 21, 1, -19 },
  { 1229, 12, 19, 14, 1, -19 },
  { 1258, 13, 19, 14, 1, -19 },
  { 1289, 12, 19, 14, 1, -19 },
  { 1318, 3, 26, 5, 2, -22 },
  { 1328, 7, 21, 9, 1, -19 },
  { 1347, 3, 26, 5, 0, -22 },
  { 1357, 8, 10, 10, 1, -19 },
  { 1367, 10, 1, 10, 0, 0 },
  { 1369, 3, 4, 7, 2, -21 },
  { 1371, 10, 15, 13, 1, -15 },
  { 1390, 9, 21, 13, 2, -21 },
  { 1414, 10, 15, 12, 1, -15 },
  { 1433, 9, 21, 13, 2, -21 },
  { 1457, 10, 15, 12, 1, -15 },
  { 1476, 7, 21, 8, 1, -21 },
  { 1495, 9, 20, 13, 2, -15 },
  { 1518, 9, 21, 13, 2, -21 },
  { 1542, 1, 20, 5, 2, -20 },
  { 1545, 4, 25, 5, -1, -20 },
  { 1558, 9, 21, 11, 2, -21 },
  { 1582, 1, 21, 5, 2, -21 },
  { 1585, 17, 15, 21, 2, -15 },
  { 1617, 9, 15, 13, 2, -15 },
  { 1634, 10, 15, 13, 2, -15 },
  { 1653, 9, 20, 13, 2, -15 },
  { 1676, 9, 20, 13, 2, -15 },
  { 1699, 6, 15, 8, 2, -15 },
  { 1711, 9, 15, 12, 1, -15 },
  { 1728, 6, 18, 8, 1, -18 },
  { 1742, 9, 15, 13, 2, -15 },
  { 1759, 10, 15, 11, 1, -15 },
  { 1778, 16, 15, 18, 1, -15 },
  { 1808, 10, 15, 11, 1, -15 },
  { 1827, 10, 20, 11, 1, -15 },
  { 1852, 10, 15, 11, 1, -15 },
  { 1871, 7, 27, 8, 1, -21 },
  { 1895, 1, 23, 5, 2, -19 },
  { 1898, 7, 27, 8, 0, -21 },
  { 1922, 12, 4, 16, 2, -10 },
};

const GFXfont RobotoCondensed_Thin27pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin27pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOCONDENSED_THIN27PT7B_H_
