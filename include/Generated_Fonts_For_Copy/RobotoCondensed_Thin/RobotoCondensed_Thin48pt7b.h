#ifndef _ROBOTOCONDENSED_THIN48PT7B_H_
#define _ROBOTOCONDENSED_THIN48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin48pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x40, 0x00,
  0x00, 0x6C, 0x46, 0x8D, 0x1A, 0x34, 0x68, 0xD1, 0xA3, 0xC7, 0x8C, 0x00,
  0x40, 0x40, 0x03, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x20, 0x30, 0x00, 0x80,
  0xC0, 0x02, 0x02, 0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x01, 0x80, 0x80,
  0x04, 0x02, 0x07, 0xFF, 0xFF, 0xC0, 0x40, 0x40, 0x01, 0x01, 0x00, 0x04,
  0x04, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x40, 0x02, 0x03, 0x00, 0x08, 0x0C,
  0x00, 0x20, 0x20, 0x00, 0x80, 0x80, 0x02, 0x02, 0x00, 0x18, 0x08, 0x00,
  0x40, 0x20, 0x3F, 0xFF, 0xFC, 0x04, 0x04, 0x00, 0x10, 0x10, 0x00, 0x40,
  0x40, 0x03, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x20, 0x30, 0x00, 0x80, 0xC0,
  0x02, 0x02, 0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x3F, 0x00, 0x70, 0xE0, 0x60, 0x18,
  0x60, 0x06, 0x60, 0x01, 0x20, 0x00, 0xD0, 0x00, 0x28, 0x00, 0x14, 0x00,
  0x0A, 0x00, 0x05, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x40, 0x00, 0xA0, 0x00, 0xC8, 0x00, 0xC6,
  0x00, 0xC0, 0xE1, 0xC0, 0x1F, 0x80, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x08, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x80, 0x40, 0x10, 0x20, 0x10, 0x0C, 0x08, 0x06,
  0x02, 0x02, 0x01, 0x81, 0x80, 0x80, 0x60, 0x40, 0x20, 0x18, 0x20, 0x08,
  0x04, 0x08, 0x02, 0x01, 0x04, 0x00, 0xC0, 0x43, 0x00, 0x10, 0x20, 0x80,
  0x03, 0x18, 0x60, 0x00, 0x78, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x03, 0xC0, 0x00, 0x41, 0x9C, 0x00, 0x20, 0x81, 0x00,
  0x18, 0x60, 0x20, 0x04, 0x10, 0x08, 0x03, 0x04, 0x02, 0x00, 0x81, 0x00,
  0xC0, 0x60, 0x40, 0x30, 0x10, 0x10, 0x0C, 0x08, 0x04, 0x03, 0x02, 0x01,
  0x00, 0x81, 0x00, 0x40, 0x20, 0x00, 0x18, 0x08, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x31, 0xC0, 0x02,
  0x02, 0x00, 0x30, 0x18, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0x80, 0x10, 0x0C, 0x00, 0x80, 0x40, 0x04, 0x04, 0x00, 0x30,
  0x60, 0x00, 0x86, 0x00, 0x02, 0x40, 0x00, 0x1C, 0x00, 0x00, 0x40, 0x00,
  0x05, 0x00, 0x00, 0x4C, 0x00, 0x04, 0x30, 0x00, 0x40, 0x80, 0x26, 0x02,
  0x01, 0x20, 0x18, 0x0B, 0x00, 0x60, 0x50, 0x01, 0x06, 0x80, 0x04, 0x24,
  0x00, 0x31, 0x20, 0x00, 0xD9, 0x00, 0x02, 0x88, 0x00, 0x0C, 0x60, 0x00,
  0xE1, 0x80, 0x0D, 0x86, 0x00, 0xC4, 0x1C, 0x18, 0x10, 0x3F, 0x00, 0xC0,
  0xFF, 0xFF, 0xA0, 0x00, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x20, 0x20, 0x10,
  0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x18, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x20,
  0x10, 0x04, 0x02, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x80,
  0x20, 0x08, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x04, 0x02, 0x01, 0x80,
  0x40, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x08, 0x04, 0x06, 0x02, 0x03,
  0x01, 0x01, 0x00, 0x80, 0x80, 0x80, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x20, 0x10, 0x17,
  0x02, 0x0E, 0x3C, 0x4E, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00,
  0x13, 0x00, 0x06, 0x20, 0x01, 0x86, 0x00, 0x20, 0x60, 0x0C, 0x06, 0x03,
  0x00, 0x40, 0x40, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0xFF,
  0xFF, 0xF0, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x33, 0x33, 0x32, 0x26,
  0x48, 0xFF, 0x80, 0x1D, 0x80, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x03, 0xE0,
  0x07, 0x1C, 0x06, 0x03, 0x06, 0x00, 0xC2, 0x00, 0x23, 0x00, 0x09, 0x00,
  0x04, 0x80, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0xD0, 0x00, 0x68, 0x00, 0x26, 0x00, 0x11,
  0x00, 0x10, 0xC0, 0x18, 0x30, 0x18, 0x0E, 0x18, 0x01, 0xF0, 0x00, 0x00,
  0xC0, 0xF1, 0xCD, 0xC3, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x07, 0xE0, 0x03, 0x0E, 0x03, 0x00,
  0xC0, 0x80, 0x18, 0x40, 0x03, 0x10, 0x00, 0x48, 0x00, 0x12, 0x00, 0x04,
  0x80, 0x01, 0x20, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xF8, 0x01, 0xC3, 0x80, 0x80, 0x30, 0x40, 0x04, 0x30, 0x00, 0x88, 0x00,
  0x26, 0x00, 0x0D, 0x00, 0x01, 0x40, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x70, 0x01,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0xC0, 0x00, 0x50, 0x00, 0x14, 0x00, 0x05,
  0x00, 0x01, 0x60, 0x00, 0x48, 0x00, 0x23, 0x00, 0x18, 0x60, 0x0C, 0x07,
  0x0E, 0x00, 0x7E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xA0, 0x00, 0x1A, 0x00, 0x01, 0x20, 0x00, 0x22, 0x00, 0x02, 0x20,
  0x00, 0x42, 0x00, 0x0C, 0x20, 0x00, 0x82, 0x00, 0x18, 0x20, 0x01, 0x02,
  0x00, 0x30, 0x20, 0x02, 0x02, 0x00, 0x40, 0x20, 0x0C, 0x02, 0x00, 0x80,
  0x20, 0x18, 0x02, 0x01, 0x00, 0x20, 0x30, 0x02, 0x02, 0x00, 0x20, 0x60,
  0x02, 0x04, 0x00, 0x20, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x3F, 0xFF, 0x90, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x7E, 0x02, 0xE1, 0xC1, 0xC0,
  0x30, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x24, 0x00, 0x13, 0x00, 0x18, 0x80, 0x08, 0x60,
  0x08, 0x0C, 0x18, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC3, 0xF0, 0x33,
  0x87, 0x09, 0x80, 0x62, 0xC0, 0x0C, 0xA0, 0x01, 0x30, 0x00, 0x6C, 0x00,
  0x0A, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x2C, 0x00, 0x09, 0x00, 0x02, 0x60, 0x01, 0x88,
  0x00, 0x43, 0x00, 0x30, 0x60, 0x18, 0x0E, 0x1C, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xC1,
  0xC0, 0x60, 0x0C, 0x08, 0x00, 0xC2, 0x00, 0x08, 0x40, 0x01, 0x98, 0x00,
  0x13, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x09, 0x80, 0x01, 0x10, 0x00,
  0x62, 0x00, 0x08, 0x20, 0x03, 0x06, 0x00, 0xC0, 0x30, 0x60, 0x03, 0xF8,
  0x01, 0xC0, 0xC0, 0x60, 0x04, 0x18, 0x00, 0x46, 0x00, 0x0C, 0x80, 0x00,
  0x90, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x05, 0x00, 0x01,
  0xA0, 0x00, 0x34, 0x00, 0x04, 0xC0, 0x01, 0x8C, 0x00, 0x20, 0xC0, 0x18,
  0x0E, 0x0E, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x01, 0x87, 0x00, 0xC0, 0x60,
  0x40, 0x0C, 0x30, 0x01, 0x88, 0x00, 0x26, 0x00, 0x09, 0x00, 0x03, 0x40,
  0x00, 0x50, 0x00, 0x14, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x50, 0x00,
  0x14, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0xC8, 0x00, 0x32, 0x00, 0x14,
  0x40, 0x0D, 0x18, 0x06, 0x43, 0x87, 0x10, 0x3F, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x5F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x17, 0xC0, 0x27, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x22, 0x22, 0x26, 0x6C, 0x80,
  0x00, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x20, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x30, 0x60, 0xC0,
  0x63, 0x00, 0x44, 0x00, 0x48, 0x00, 0xB0, 0x01, 0x60, 0x02, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x10, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x7C, 0x00, 0xC4, 0x00, 0x63, 0x00,
  0x22, 0x00, 0x40, 0x60, 0x13, 0x00, 0x40, 0x30, 0x09, 0x00, 0x40, 0x18,
  0x04, 0x80, 0x20, 0x08, 0x02, 0x40, 0x20, 0x04, 0x01, 0xE0, 0x10, 0x02,
  0x00, 0xF0, 0x08, 0x01, 0x00, 0x70, 0x0C, 0x00, 0x80, 0x38, 0x04, 0x00,
  0x40, 0x1C, 0x02, 0x00, 0x20, 0x0E, 0x01, 0x00, 0x10, 0x05, 0x00, 0x80,
  0x08, 0x02, 0x80, 0x40, 0x0C, 0x01, 0x40, 0x20, 0x06, 0x00, 0xA0, 0x10,
  0x03, 0x00, 0xD0, 0x08, 0x03, 0x80, 0x4C, 0x04, 0x01, 0x40, 0x26, 0x01,
  0x01, 0xA0, 0x21, 0x00, 0x81, 0x98, 0x30, 0x80, 0x31, 0x86, 0x30, 0x60,
  0x0F, 0x01, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x02, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40,
  0x00, 0x06, 0x40, 0x00, 0x08, 0x80, 0x00, 0x11, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x82, 0x00, 0x01, 0x04, 0x00, 0x02, 0x04, 0x00, 0x0C, 0x08, 0x00,
  0x10, 0x10, 0x00, 0x20, 0x30, 0x00, 0xC0, 0x20, 0x01, 0x00, 0x40, 0x02,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x03, 0x00, 0xC0,
  0x02, 0x01, 0x00, 0x04, 0x02, 0x00, 0x0C, 0x0F, 0xFF, 0xF8, 0x10, 0x00,
  0x10, 0x20, 0x00, 0x30, 0xC0, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x8C, 0x00, 0x01, 0x98, 0x00, 0x01, 0x20, 0x00, 0x02, 0x40, 0x00, 0x07,
  0x80, 0x00, 0x04, 0xFF, 0xF0, 0x18, 0x03, 0x83, 0x00, 0x08, 0x60, 0x00,
  0x8C, 0x00, 0x19, 0x80, 0x01, 0x30, 0x00, 0x26, 0x00, 0x06, 0xC0, 0x00,
  0xD8, 0x00, 0x1B, 0x00, 0x02, 0x60, 0x00, 0x4C, 0x00, 0x09, 0x80, 0x02,
  0x30, 0x00, 0xC6, 0x00, 0xE0, 0xFF, 0xFC, 0x18, 0x00, 0xC3, 0x00, 0x06,
  0x60, 0x00, 0x4C, 0x00, 0x05, 0x80, 0x00, 0xB0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x05,
  0x80, 0x01, 0xB0, 0x00, 0x26, 0x00, 0x08, 0xC0, 0x0E, 0x1F, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x38, 0x1C, 0x03, 0x00, 0x30, 0x30, 0x00, 0xC3, 0x00,
  0x03, 0x10, 0x00, 0x09, 0x80, 0x00, 0x48, 0x00, 0x03, 0x40, 0x00, 0x0A,
  0x00, 0x00, 0x50, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x58, 0x00, 0x06, 0x40,
  0x00, 0x22, 0x00, 0x01, 0x18, 0x00, 0x18, 0x60, 0x01, 0x81, 0x80, 0x18,
  0x07, 0x03, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x0C, 0x01, 0xC0, 0xC0,
  0x03, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x04, 0xC0, 0x00, 0x2C,
  0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0xC0, 0x01, 0x8C,
  0x00, 0x30, 0xC0, 0x1C, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xFF, 0xFF, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x38, 0x38, 0x03, 0x00,
  0x30, 0x20, 0x00, 0xC2, 0x00, 0x02, 0x30, 0x00, 0x19, 0x00, 0x00, 0x48,
  0x00, 0x02, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x12, 0x00, 0x00, 0x98, 0x00, 0x04,
  0x60, 0x00, 0xC1, 0x80, 0x0C, 0x07, 0x03, 0xC0, 0x0F, 0xF0, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x24, 0x00, 0x13,
  0x00, 0x18, 0x80, 0x08, 0x60, 0x18, 0x0C, 0x18, 0x03, 0xF0, 0x00, 0xC0,
  0x00, 0x26, 0x00, 0x03, 0x30, 0x00, 0x31, 0x80, 0x03, 0x0C, 0x00, 0x30,
  0x60, 0x01, 0x03, 0x00, 0x10, 0x18, 0x01, 0x80, 0xC0, 0x18, 0x06, 0x01,
  0x80, 0x30, 0x18, 0x01, 0x80, 0x80, 0x0C, 0x08, 0x00, 0x60, 0x80, 0x03,
  0x0C, 0x00, 0x18, 0xC0, 0x00, 0xCF, 0x00, 0x06, 0xCC, 0x00, 0x34, 0x20,
  0x01, 0xC0, 0x80, 0x0C, 0x06, 0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x18,
  0x01, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x30, 0x00, 0x81, 0x80, 0x02,
  0x0C, 0x00, 0x18, 0x60, 0x00, 0x63, 0x00, 0x01, 0x18, 0x00, 0x04, 0xC0,
  0x00, 0x36, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7D, 0x00, 0x00, 0x0B, 0xA0, 0x00, 0x01, 0x76, 0x00, 0x00,
  0x6E, 0x40, 0x00, 0x09, 0xC8, 0x00, 0x01, 0x39, 0x80, 0x00, 0x47, 0x10,
  0x00, 0x08, 0xE2, 0x00, 0x03, 0x1C, 0x60, 0x00, 0x43, 0x84, 0x00, 0x08,
  0x70, 0x80, 0x03, 0x0E, 0x08, 0x00, 0x41, 0xC1, 0x00, 0x08, 0x38, 0x30,
  0x02, 0x07, 0x02, 0x00, 0x40, 0xE0, 0x40, 0x18, 0x1C, 0x0C, 0x02, 0x03,
  0x80, 0x80, 0x40, 0x70, 0x10, 0x18, 0x0E, 0x01, 0x02, 0x01, 0xC0, 0x20,
  0x40, 0x38, 0x06, 0x18, 0x07, 0x00, 0x42, 0x00, 0xE0, 0x08, 0x40, 0x1C,
  0x01, 0x90, 0x03, 0x80, 0x12, 0x00, 0x70, 0x02, 0xC0, 0x0E, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x04, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1D, 0x00, 0x00, 0xEC, 0x00, 0x07,
  0x20, 0x00, 0x38, 0x80, 0x01, 0xC6, 0x00, 0x0E, 0x10, 0x00, 0x70, 0xC0,
  0x03, 0x82, 0x00, 0x1C, 0x08, 0x00, 0xE0, 0x60, 0x07, 0x01, 0x00, 0x38,
  0x0C, 0x01, 0xC0, 0x20, 0x0E, 0x01, 0x80, 0x70, 0x04, 0x03, 0x80, 0x10,
  0x1C, 0x00, 0xC0, 0xE0, 0x02, 0x07, 0x00, 0x18, 0x38, 0x00, 0x41, 0xC0,
  0x01, 0x0E, 0x00, 0x0C, 0x70, 0x00, 0x23, 0x80, 0x01, 0x9C, 0x00, 0x04,
  0xE0, 0x00, 0x37, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x40, 0x00, 0xFE, 0x00, 0x1C, 0x0E, 0x00, 0xC0, 0x0C, 0x06, 0x00,
  0x18, 0x30, 0x00, 0x30, 0x80, 0x00, 0x46, 0x00, 0x01, 0x90, 0x00, 0x02,
  0x40, 0x00, 0x0B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x98, 0x00, 0x06, 0x20, 0x00, 0x10, 0xC0, 0x00,
  0xC1, 0x80, 0x06, 0x03, 0x00, 0x30, 0x07, 0x83, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0xF8, 0x18, 0x01, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0xCC, 0x00, 0x0D,
  0x80, 0x00, 0xB0, 0x00, 0x16, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x16,
  0x00, 0x06, 0xC0, 0x00, 0x98, 0x00, 0x63, 0x00, 0x38, 0x7F, 0xFC, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x1C, 0x0E, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x18, 0x30, 0x00, 0x30, 0x80,
  0x00, 0x46, 0x00, 0x01, 0x90, 0x00, 0x02, 0x40, 0x00, 0x0B, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x24, 0x00, 0x00, 0x98,
  0x00, 0x06, 0x20, 0x00, 0x10, 0xC0, 0x00, 0xC1, 0x80, 0x06, 0x03, 0x00,
  0x30, 0x07, 0x83, 0x80, 0x07, 0xF4, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0xFF,
  0xF8, 0x0C, 0x00, 0xE0, 0xC0, 0x03, 0x0C, 0x00, 0x08, 0xC0, 0x00, 0x4C,
  0x00, 0x04, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x02,
  0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x04, 0xC0, 0x00,
  0x4C, 0x00, 0x08, 0xC0, 0x01, 0x0C, 0x00, 0x60, 0xFF, 0xF8, 0x0C, 0x00,
  0x80, 0xC0, 0x0C, 0x0C, 0x00, 0x40, 0xC0, 0x06, 0x0C, 0x00, 0x20, 0xC0,
  0x03, 0x0C, 0x00, 0x10, 0xC0, 0x01, 0x8C, 0x00, 0x08, 0xC0, 0x00, 0xCC,
  0x00, 0x04, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0x01, 0xFC, 0x00, 0x38, 0x3C, 0x07, 0x00, 0x30, 0x20, 0x00, 0xC2, 0x00,
  0x02, 0x10, 0x00, 0x09, 0x80, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x12,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80,
  0x00, 0x36, 0x00, 0x01, 0x10, 0x00, 0x18, 0xC0, 0x01, 0x83, 0x80, 0x18,
  0x07, 0x83, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x34, 0x00, 0x02, 0x40, 0x00, 0x26, 0x00, 0x06, 0x30,
  0x00, 0xC1, 0x80, 0x18, 0x0F, 0x07, 0x00, 0x3F, 0xC0, 0xC0, 0x00, 0x02,
  0x80, 0x00, 0x0D, 0x00, 0x00, 0x13, 0x00, 0x00, 0x22, 0x00, 0x00, 0xC4,
  0x00, 0x01, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x10, 0x20,
  0x00, 0x20, 0x60, 0x00, 0x40, 0x40, 0x01, 0x80, 0x80, 0x02, 0x01, 0x80,
  0x04, 0x01, 0x00, 0x18, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x01,
  0x80, 0x08, 0x02, 0x00, 0x18, 0x04, 0x00, 0x10, 0x18, 0x00, 0x20, 0x20,
  0x00, 0x60, 0x40, 0x00, 0x41, 0x80, 0x00, 0x82, 0x00, 0x01, 0x04, 0x00,
  0x01, 0x08, 0x00, 0x02, 0x20, 0x00, 0x04, 0x40, 0x00, 0x04, 0x80, 0x00,
  0x0A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F,
  0x00, 0x05, 0x00, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00,
  0x24, 0x00, 0x12, 0x00, 0x19, 0x80, 0x08, 0xC0, 0x04, 0x20, 0x02, 0x10,
  0x01, 0x08, 0x00, 0x84, 0x00, 0x42, 0x00, 0x21, 0x00, 0x30, 0xC0, 0x10,
  0x60, 0x08, 0x30, 0x04, 0x08, 0x02, 0x04, 0x01, 0x02, 0x00, 0x81, 0x00,
  0xC0, 0x80, 0x60, 0x60, 0x20, 0x30, 0x18, 0x18, 0x08, 0x04, 0x04, 0x02,
  0x02, 0x01, 0x01, 0x00, 0x81, 0x80, 0x40, 0x40, 0x20, 0x40, 0x18, 0x30,
  0x0C, 0x10, 0x02, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x43, 0x00, 0x20,
  0x80, 0x10, 0x80, 0x0C, 0x60, 0x06, 0x20, 0x01, 0x18, 0x01, 0x88, 0x00,
  0x44, 0x00, 0x26, 0x00, 0x11, 0x00, 0x09, 0x00, 0x06, 0x40, 0x02, 0x40,
  0x00, 0xB0, 0x00, 0xD0, 0x00, 0x28, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x06,
  0x00, 0x02, 0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0x60, 0x00, 0x10, 0x00,
  0xC0, 0x00, 0x09, 0x00, 0x00, 0x46, 0x00, 0x03, 0x0C, 0x00, 0x08, 0x10,
  0x00, 0x60, 0x60, 0x01, 0x00, 0x80, 0x08, 0x03, 0x00, 0x60, 0x04, 0x01,
  0x00, 0x08, 0x0C, 0x00, 0x30, 0x20, 0x00, 0x41, 0x00, 0x01, 0x84, 0x00,
  0x02, 0x20, 0x00, 0x05, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0xC0, 0x00, 0x05, 0x80, 0x00, 0x32, 0x00, 0x00, 0x8C, 0x00, 0x04, 0x10,
  0x00, 0x30, 0x20, 0x00, 0x80, 0x80, 0x06, 0x01, 0x00, 0x10, 0x06, 0x00,
  0x80, 0x08, 0x06, 0x00, 0x30, 0x10, 0x00, 0x40, 0xC0, 0x00, 0x82, 0x00,
  0x03, 0x10, 0x00, 0x04, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x06, 0x80, 0x00, 0x09, 0x80, 0x00, 0x31, 0x00, 0x00, 0x43, 0x00, 0x01,
  0x82, 0x00, 0x02, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x10, 0x0C, 0x00, 0x60,
  0x08, 0x00, 0x80, 0x18, 0x03, 0x00, 0x10, 0x04, 0x00, 0x10, 0x18, 0x00,
  0x20, 0x20, 0x00, 0x20, 0xC0, 0x00, 0x41, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x88, 0x00, 0x00, 0xB0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x83, 0xF0, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x07, 0xF0, 0x02, 0x00, 0x18, 0x01, 0x40, 0x0B, 0x00,
  0x48, 0x04, 0x40, 0x23, 0x01, 0x08, 0x10, 0x40, 0x83, 0x0C, 0x08, 0x40,
  0x42, 0x03, 0x30, 0x09, 0x00, 0x48, 0x03, 0xC0, 0x08, 0xFF, 0xFF, 0x80,
  0x40, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0x03, 0xF0, 0x07, 0x0E, 0x04, 0x01,
  0x84, 0x00, 0x66, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x3F, 0xF8, 0xF8, 0x0C,
  0xC0, 0x06, 0xC0, 0x03, 0x40, 0x01, 0xA0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1A, 0x00, 0x1D, 0x00, 0x1E, 0xC0, 0x1B, 0x38, 0x71, 0x87,
  0xE0, 0x40, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x87, 0xE0,
  0x9C, 0x38, 0xB0, 0x0C, 0xE0, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0xB0, 0x0C, 0x9C, 0x38,
  0x87, 0xE0, 0x03, 0xF0, 0x07, 0x0E, 0x06, 0x01, 0x86, 0x00, 0x62, 0x00,
  0x13, 0x00, 0x0D, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x28, 0x00, 0x16, 0x00, 0x09, 0x00,
  0x0C, 0xC0, 0x04, 0x30, 0x04, 0x0E, 0x1C, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x07, 0xE1, 0x1C, 0x39, 0x30, 0x0D,
  0x60, 0x07, 0x40, 0x03, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x01,
  0x40, 0x01, 0x20, 0x03, 0x30, 0x05, 0x1C, 0x39, 0x07, 0xE0, 0x03, 0xF0,
  0x07, 0x0E, 0x06, 0x01, 0x86, 0x00, 0x62, 0x00, 0x13, 0x00, 0x0D, 0x00,
  0x02, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x02, 0x0F, 0x0E, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x71, 0x04, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0xFF, 0xC1, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x07, 0xE1, 0x1C, 0x39, 0x30, 0x0D, 0x60, 0x07, 0x40, 0x03, 0x40, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x03, 0x20, 0x03, 0x30, 0x05,
  0x1C, 0x39, 0x07, 0xE1, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x60, 0x02, 0x30, 0x06, 0x1C, 0x1C, 0x07, 0xF0,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x0F, 0x84, 0x70, 0xC9, 0x80,
  0xD6, 0x00, 0xA8, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x3C, 0x00, 0x0A, 0xAA,
  0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06,
  0x04, 0x18, 0xF0, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x14,
  0x00, 0x68, 0x01, 0x90, 0x06, 0x20, 0x18, 0x40, 0x60, 0x81, 0x81, 0x02,
  0x02, 0x08, 0x04, 0x20, 0x08, 0xC0, 0x13, 0x00, 0x2D, 0x00, 0x73, 0x00,
  0xC2, 0x01, 0x02, 0x02, 0x06, 0x04, 0x06, 0x08, 0x04, 0x10, 0x0C, 0x20,
  0x0C, 0x40, 0x08, 0x80, 0x09, 0x00, 0x1A, 0x00, 0x14, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x83, 0xE0, 0x0F, 0xC2, 0x30, 0xE0, 0xE1, 0x89,
  0x80, 0xC6, 0x01, 0x2C, 0x01, 0x30, 0x06, 0xA0, 0x06, 0x80, 0x0B, 0x00,
  0x0C, 0x00, 0x2C, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0x02,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x18, 0x00, 0x20, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x80, 0x02, 0x00, 0x06, 0x00, 0x08, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x80, 0x02, 0x00, 0x06, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x80, 0x01, 0x80, 0x02, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x20, 0x00, 0x60, 0x00, 0x80, 0x01, 0x80, 0x02,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x83, 0xE1, 0x1C, 0x32, 0x60, 0x35,
  0x80, 0x2A, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x03, 0xF0, 0x06, 0x0E, 0x04,
  0x01, 0x84, 0x00, 0x46, 0x00, 0x12, 0x00, 0x0B, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x34, 0x00, 0x13, 0x00, 0x08, 0x80, 0x08, 0x20, 0x0C, 0x0E, 0x1C,
  0x01, 0xF8, 0x00, 0x87, 0xE0, 0x9C, 0x38, 0xB0, 0x0C, 0xE0, 0x06, 0xC0,
  0x02, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x02, 0xE0,
  0x06, 0xB0, 0x0C, 0x9C, 0x38, 0x87, 0xE0, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x07, 0xE1, 0x1C, 0x39, 0x30, 0x0D, 0x60, 0x07, 0x40,
  0x03, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x01, 0x20,
  0x03, 0x30, 0x05, 0x1C, 0x39, 0x07, 0xE1, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x87, 0xA3, 0x09, 0x02, 0x80, 0xA0, 0x30, 0x0C, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00,
  0x0F, 0xE0, 0x70, 0x71, 0x80, 0x36, 0x00, 0x28, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x01, 0x30, 0x06, 0x3C, 0x38, 0x1F,
  0xC0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x3F, 0xF0, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x1F, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0xD0, 0x03, 0xB0, 0x0D, 0x38, 0x72, 0x1F, 0x84, 0xC0, 0x00,
  0x50, 0x00, 0x34, 0x00, 0x09, 0x80, 0x02, 0x20, 0x01, 0x88, 0x00, 0x43,
  0x00, 0x10, 0x40, 0x0C, 0x10, 0x02, 0x06, 0x00, 0x80, 0x80, 0x60, 0x20,
  0x10, 0x0C, 0x04, 0x01, 0x01, 0x00, 0x40, 0x80, 0x18, 0x20, 0x02, 0x08,
  0x00, 0x86, 0x00, 0x31, 0x00, 0x04, 0x40, 0x01, 0x30, 0x00, 0x48, 0x00,
  0x1A, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x04, 0x00,
  0x38, 0x00, 0xC0, 0x05, 0x00, 0x38, 0x01, 0xA0, 0x05, 0x00, 0x36, 0x00,
  0xB0, 0x04, 0xC0, 0x16, 0x00, 0x88, 0x06, 0x40, 0x31, 0x00, 0x88, 0x06,
  0x20, 0x11, 0x80, 0x86, 0x02, 0x10, 0x10, 0x40, 0xC2, 0x06, 0x08, 0x10,
  0x40, 0xC1, 0x02, 0x0C, 0x10, 0x30, 0x40, 0x82, 0x02, 0x18, 0x10, 0x40,
  0x42, 0x02, 0x18, 0x08, 0x40, 0x62, 0x01, 0x98, 0x04, 0x40, 0x12, 0x00,
  0x88, 0x02, 0x40, 0x13, 0x00, 0x48, 0x03, 0x60, 0x0B, 0x00, 0x28, 0x01,
  0xC0, 0x05, 0x00, 0x18, 0x00, 0xA0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x00, 0x60, 0x00, 0x88, 0x00, 0x63, 0x00, 0x30, 0x40, 0x08, 0x08, 0x06,
  0x03, 0x01, 0x00, 0x40, 0xC0, 0x18, 0x20, 0x02, 0x10, 0x00, 0x4C, 0x00,
  0x1A, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1A, 0x00, 0x04,
  0xC0, 0x03, 0x10, 0x00, 0x86, 0x00, 0x40, 0x80, 0x30, 0x10, 0x08, 0x06,
  0x06, 0x00, 0x81, 0x00, 0x30, 0x80, 0x04, 0x60, 0x01, 0x90, 0x00, 0x30,
  0xC0, 0x00, 0x50, 0x00, 0x34, 0x00, 0x09, 0x80, 0x02, 0x20, 0x01, 0x88,
  0x00, 0x43, 0x00, 0x10, 0x40, 0x0C, 0x10, 0x03, 0x06, 0x00, 0x80, 0x80,
  0x20, 0x20, 0x18, 0x0C, 0x04, 0x01, 0x01, 0x00, 0x40, 0xC0, 0x18, 0x20,
  0x02, 0x08, 0x00, 0x86, 0x00, 0x31, 0x00, 0x04, 0x40, 0x01, 0x30, 0x00,
  0x68, 0x00, 0x0A, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x10, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0xE0, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x0E, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0x70, 0x03, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x40,
  0x00, 0x1E, 0x00, 0x01, 0x8C, 0x00, 0x50, 0x30, 0x03, 0x80, 0xC0, 0x18,
  0x03, 0x01, 0xC0, 0x0C, 0x0A, 0x00, 0x31, 0x90, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_Thin48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 34, 9, 3, -34 },
  { 14, 7, 10, 12, 3, -36 },
  { 23, 22, 34, 23, 2, -34 },
  { 117, 17, 42, 23, 3, -38 },
  { 207, 26, 34, 31, 3, -34 },
  { 318, 21, 34, 26, 3, -34 },
  { 408, 2, 10, 8, 3, -36 },
  { 411, 9, 49, 13, 3, -38 },
  { 467, 9, 49, 13, 1, -38 },
  { 523, 19, 19, 20, 1, -34 },
  { 569, 20, 25, 24, 2, -28 },
  { 632, 4, 10, 9, 2, -4 },
  { 637, 9, 1, 13, 2, -16 },
  { 639, 3, 3, 10, 3, -3 },
  { 641, 14, 37, 16, 1, -34 },
  { 706, 17, 34, 23, 3, -34 },
  { 779, 10, 34, 23, 4, -34 },
  { 822, 18, 34, 23, 3, -34 },
  { 899, 18, 34, 23, 2, -34 },
  { 976, 20, 34, 23, 2, -34 },
  { 1061, 17, 34, 23, 4, -34 },
  { 1134, 18, 34, 23, 3, -34 },
  { 1211, 19, 34, 23, 2, -34 },
  { 1292, 19, 34, 23, 2, -34 },
  { 1373, 18, 34, 23, 2, -34 },
  { 1450, 3, 25, 8, 3, -25 },
  { 1460, 4, 31, 8, 2, -25 },
  { 1476, 17, 19, 22, 2, -25 },
  { 1517, 17, 11, 24, 3, -21 },
  { 1541, 16, 19, 22, 3, -25 },
  { 1579, 15, 34, 19, 2, -34 },
  { 1643, 33, 44, 39, 3, -33 },
  { 1825, 23, 34, 25, 1, -34 },
  { 1923, 19, 34, 26, 4, -34 },
  { 2004, 21, 34, 27, 3, -34 },
  { 2094, 20, 34, 28, 4, -34 },
  { 2179, 18, 34, 24, 4, -34 },
  { 2256, 18, 34, 24, 4, -34 },
  { 2333, 21, 34, 29, 4, -34 },
  { 2423, 21, 34, 29, 4, -34 },
  { 2513, 1, 34, 12, 5, -34 },
  { 2518, 17, 34, 23, 2, -34 },
  { 2591, 21, 34, 27, 4, -34 },
  { 2681, 16, 34, 22, 4, -34 },
  { 2749, 27, 34, 36, 4, -34 },
  { 2864, 21, 34, 30, 4, -34 },
  { 2954, 22, 34, 28, 3, -34 },
  { 3048, 19, 34, 25, 4, -34 },
  { 3129, 22, 40, 28, 3, -34 },
  { 3239, 20, 34, 27, 4, -34 },
  { 3324, 21, 34, 25, 2, -34 },
  { 3414, 23, 34, 25, 1, -34 },
  { 3512, 20, 34, 28, 4, -34 },
  { 3597, 23, 34, 25, 1, -34 },
  { 3695, 34, 34, 38, 2, -34 },
  { 3840, 22, 34, 25, 2, -34 },
  { 3934, 23, 34, 25, 1, -34 },
  { 4032, 21, 34, 25, 2, -34 },
  { 4122, 6, 46, 10, 4, -39 },
  { 4157, 13, 37, 16, 2, -34 },
  { 4218, 6, 46, 10, 0, -39 },
  { 4253, 13, 17, 18, 2, -34 },
  { 4281, 17, 1, 18, 0, 0 },
  { 4284, 7, 6, 13, 3, -36 },
  { 4290, 17, 26, 22, 2, -26 },
  { 4346, 16, 36, 23, 4, -36 },
  { 4418, 17, 26, 22, 2, -26 },
  { 4474, 16, 36, 23, 3, -36 },
  { 4546, 17, 26, 22, 2, -26 },
  { 4602, 12, 36, 14, 2, -36 },
  { 4656, 16, 36, 23, 3, -26 },
  { 4728, 15, 36, 23, 4, -36 },
  { 4796, 2, 36, 9, 4, -36 },
  { 4805, 8, 46, 10, -2, -36 },
  { 4851, 15, 36, 20, 4, -36 },
  { 4919, 1, 36, 9, 4, -36 },
  { 4924, 30, 26, 37, 4, -26 },
  { 5022, 15, 26, 23, 4, -26 },
  { 5071, 17, 26, 23, 3, -26 },
  { 5127, 16, 36, 23, 4, -26 },
  { 5199, 16, 36, 23, 3, -26 },
  { 5271, 10, 26, 15, 4, -26 },
  { 5304, 15, 26, 21, 3, -26 },
  { 5353, 11, 32, 14, 1, -32 },
  { 5397, 15, 26, 23, 4, -26 },
  { 5446, 18, 26, 20, 1, -26 },
  { 5505, 27, 26, 32, 2, -26 },
  { 5593, 18, 26, 20, 1, -26 },
  { 5652, 18, 36, 20, 1, -26 },
  { 5733, 17, 26, 20, 2, -26 },
  { 5789, 12, 47, 14, 2, -37 },
  { 5860, 2, 40, 10, 4, -34 },
  { 5870, 12, 47, 14, 0, -37 },
  { 5941, 21, 8, 29, 4, -18 },
};

const GFXfont RobotoCondensed_Thin48pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin48pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin48pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _ROBOTOCONDENSED_THIN48PT7B_H_
