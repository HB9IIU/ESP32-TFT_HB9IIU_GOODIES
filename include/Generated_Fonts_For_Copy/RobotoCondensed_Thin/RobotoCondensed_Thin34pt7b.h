#ifndef _ROBOTOCONDENSED_THIN34PT7B_H_
#define _ROBOTOCONDENSED_THIN34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin34pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x40, 0x0F, 0x4A, 0x52, 0x98, 0xC6, 0x20,
  0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08,
  0x04, 0x10, 0x7F, 0xFF, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10,
  0x04, 0x20, 0x08, 0x20, 0x08, 0x20, 0x08, 0x20, 0xFF, 0xFE, 0x08, 0x20,
  0x08, 0x20, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40,
  0x02, 0x00, 0x20, 0x02, 0x00, 0xF8, 0x30, 0x42, 0x02, 0x40, 0x14, 0x01,
  0x40, 0x14, 0x01, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01,
  0x40, 0x33, 0x06, 0x0F, 0x80, 0x20, 0x02, 0x00, 0x20, 0x3C, 0x00, 0x11,
  0x80, 0x08, 0x20, 0x02, 0x04, 0x10, 0x81, 0x04, 0x20, 0x42, 0x08, 0x10,
  0x82, 0x04, 0x40, 0x82, 0x10, 0x11, 0x88, 0x03, 0xC4, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x21, 0xC0, 0x10, 0x88, 0x04, 0x41, 0x02, 0x10, 0x40,
  0x88, 0x10, 0x42, 0x04, 0x20, 0x81, 0x08, 0x10, 0x40, 0x04, 0x10, 0x00,
  0x88, 0x00, 0x1C, 0x0F, 0x00, 0x21, 0x00, 0x81, 0x01, 0x02, 0x02, 0x04,
  0x04, 0x08, 0x08, 0x10, 0x10, 0x40, 0x11, 0x00, 0x24, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x20, 0x04, 0x40, 0x90, 0x41, 0x40, 0x42, 0x80, 0x45, 0x00,
  0x8A, 0x00, 0xA4, 0x00, 0xC8, 0x01, 0x88, 0x05, 0x08, 0x11, 0x0F, 0x81,
  0xFE, 0x02, 0x08, 0x20, 0x81, 0x02, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04,
  0x08, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x01, 0x02, 0x02, 0x04, 0x08, 0x08, 0x08, 0x08, 0x81, 0x04, 0x08, 0x20,
  0x41, 0x04, 0x08, 0x20, 0x82, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x42, 0x08, 0x20, 0x84, 0x10, 0x42, 0x08, 0x41, 0x08, 0x00, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x41, 0x0C, 0xC4, 0xC0, 0xFC, 0x00,
  0xC0, 0x02, 0x80, 0x11, 0x00, 0x84, 0x06, 0x08, 0x10, 0x10, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0xFF, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x24, 0x92, 0xB0, 0xFE, 0x50, 0x00, 0x80, 0x40,
  0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x80, 0x40, 0x00, 0x0F, 0x81, 0x0C, 0x20, 0x24, 0x02, 0x40, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40, 0x22, 0x02,
  0x10, 0x40, 0xF8, 0x06, 0x37, 0x88, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x0F, 0x81, 0x82, 0x10, 0x08, 0x80, 0x48, 0x01, 0x40, 0x0A, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0x00, 0x1F, 0xFF, 0x0F, 0x81, 0x82, 0x18, 0x08, 0x80, 0x28, 0x01, 0x40,
  0x0A, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x1F, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x05, 0x00, 0x2C,
  0x01, 0x20, 0x10, 0xC1, 0x81, 0xF0, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x05, 0x00, 0x12, 0x00, 0x24, 0x00, 0x88, 0x01, 0x10, 0x04, 0x20, 0x08,
  0x40, 0x20, 0x80, 0x81, 0x01, 0x02, 0x04, 0x04, 0x08, 0x08, 0x20, 0x10,
  0xFF, 0xFE, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x7F, 0xF4, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x05, 0xF0, 0x60, 0xC0, 0x06, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x02, 0x40, 0x24, 0x02,
  0x20, 0x40, 0xF8, 0x01, 0xC0, 0x30, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x8F, 0x84, 0x82, 0x28, 0x09, 0x80, 0x28, 0x01,
  0x40, 0x0A, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x04, 0x80, 0x24,
  0x01, 0x10, 0x10, 0x41, 0x01, 0xF0, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x0F, 0x81, 0x82, 0x10, 0x08, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x50,
  0x02, 0x40, 0x12, 0x01, 0x0C, 0x10, 0x1F, 0x03, 0x04, 0x20, 0x12, 0x00,
  0x50, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x20, 0x08,
  0x81, 0x83, 0xF0, 0x0F, 0x03, 0x0C, 0x60, 0x24, 0x02, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x34, 0x03,
  0x20, 0xD0, 0xF1, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C,
  0x03, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x6C, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x24, 0xB5, 0x00, 0x00, 0x10, 0x02, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x40, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x00, 0x1E,
  0x18, 0x4C, 0x0A, 0x02, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x20, 0x00, 0x7F, 0x00, 0x03, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x60, 0x00, 0xC1, 0x80, 0x00, 0x82, 0x00, 0x00, 0x88, 0x00,
  0x01, 0x10, 0x0F, 0x01, 0x40, 0x61, 0x02, 0x81, 0x02, 0x05, 0x02, 0x04,
  0x0C, 0x08, 0x08, 0x18, 0x10, 0x10, 0x30, 0x20, 0x20, 0x60, 0x40, 0x40,
  0xC1, 0x00, 0x81, 0x82, 0x01, 0x03, 0x04, 0x04, 0x06, 0x08, 0x08, 0x0C,
  0x08, 0x10, 0x28, 0x10, 0x50, 0x48, 0x21, 0x21, 0x10, 0x3C, 0x3C, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x04,
  0x20, 0x04, 0x20, 0x04, 0x20, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x10,
  0x08, 0x10, 0x08, 0x10, 0x08, 0x20, 0x08, 0x3F, 0xFC, 0x20, 0x04, 0x40,
  0x04, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x01, 0x80, 0x01, 0xFF,
  0x84, 0x03, 0x20, 0x09, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02,
  0x80, 0x14, 0x01, 0x20, 0x19, 0xFF, 0x08, 0x06, 0x40, 0x0A, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0A, 0x00,
  0x9F, 0xF8, 0x07, 0xE0, 0x30, 0x30, 0x80, 0x21, 0x00, 0x24, 0x00, 0x48,
  0x00, 0x50, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x80, 0x05,
  0x00, 0x0A, 0x00, 0x12, 0x00, 0x46, 0x01, 0x86, 0x06, 0x03, 0xF0, 0xFF,
  0x82, 0x01, 0x88, 0x01, 0x20, 0x02, 0x80, 0x0A, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x02, 0x80, 0x0A,
  0x00, 0x48, 0x06, 0x3F, 0xE0, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0xFF,
  0xC8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0xFF, 0xC8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x0F,
  0xC0, 0x20, 0x60, 0x80, 0x22, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x1F, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0A, 0x00,
  0x14, 0x00, 0x24, 0x00, 0x86, 0x06, 0x03, 0xF0, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x02, 0x80, 0x98, 0x20, 0xF8, 0x80, 0x0D, 0x00, 0x32, 0x00, 0x44, 0x01,
  0x08, 0x04, 0x10, 0x10, 0x20, 0x40, 0x41, 0x80, 0x82, 0x01, 0x08, 0x02,
  0x20, 0x04, 0xC0, 0x0A, 0x40, 0x18, 0x40, 0x20, 0x40, 0x40, 0x80, 0x80,
  0x81, 0x00, 0x82, 0x01, 0x84, 0x01, 0x08, 0x01, 0x10, 0x01, 0x20, 0x03,
  0x40, 0x02, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x07, 0xFF, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xD0, 0x00, 0x3A, 0x00, 0x0B, 0x40,
  0x01, 0x64, 0x00, 0x2C, 0x80, 0x09, 0x88, 0x01, 0x31, 0x00, 0x46, 0x20,
  0x08, 0xC2, 0x01, 0x18, 0x40, 0x43, 0x08, 0x08, 0x60, 0x81, 0x0C, 0x10,
  0x41, 0x82, 0x08, 0x30, 0x22, 0x06, 0x04, 0x40, 0xC0, 0x48, 0x18, 0x0A,
  0x03, 0x01, 0x40, 0x60, 0x18, 0x0C, 0x02, 0x01, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x0D, 0x00, 0x19, 0x00, 0x32, 0x00, 0x62, 0x00, 0xC4, 0x01, 0x84,
  0x03, 0x04, 0x06, 0x08, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x10, 0x60, 0x30,
  0xC0, 0x21, 0x80, 0x23, 0x00, 0x46, 0x00, 0x4C, 0x00, 0x98, 0x00, 0xB0,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0x07, 0xE0, 0x18, 0x18, 0x20, 0x0C, 0x20,
  0x04, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x02, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x20,
  0x0C, 0x18, 0x18, 0x07, 0xE0, 0xFF, 0xC4, 0x01, 0x20, 0x05, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x28, 0x02, 0x7F, 0xE2, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x07, 0xE0, 0x18, 0x18,
  0x20, 0x0C, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x20, 0x04, 0x20, 0x0C, 0x18, 0x18, 0x07, 0xF0, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0xFF, 0x82, 0x01, 0x88, 0x01, 0x20, 0x02, 0x80,
  0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0,
  0x04, 0x80, 0x23, 0xFE, 0x08, 0x08, 0x20, 0x10, 0x80, 0x42, 0x00, 0x88,
  0x02, 0x20, 0x04, 0x80, 0x12, 0x00, 0x28, 0x00, 0xE0, 0x01, 0x0F, 0xC0,
  0xC0, 0xC4, 0x00, 0x90, 0x02, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x05, 0x00,
  0x23, 0x03, 0x03, 0xF0, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x40, 0x09, 0x00, 0x63, 0x03, 0x03, 0xF0, 0x80, 0x01,
  0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x20, 0x04,
  0x20, 0x04, 0x20, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x08, 0x10,
  0x08, 0x10, 0x08, 0x10, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x02, 0x40,
  0x02, 0x40, 0x02, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x80, 0x08,
  0x01, 0x40, 0x04, 0x00, 0x90, 0x05, 0x00, 0x48, 0x02, 0x80, 0x24, 0x01,
  0x40, 0x12, 0x01, 0x20, 0x10, 0x80, 0x88, 0x08, 0x40, 0x44, 0x04, 0x20,
  0x22, 0x02, 0x10, 0x21, 0x02, 0x04, 0x10, 0x41, 0x02, 0x08, 0x20, 0x81,
  0x04, 0x10, 0x40, 0x84, 0x08, 0x20, 0x42, 0x02, 0x20, 0x11, 0x01, 0x10,
  0x08, 0x80, 0x88, 0x04, 0x80, 0x44, 0x02, 0x40, 0x14, 0x00, 0xA0, 0x0A,
  0x00, 0x50, 0x05, 0x00, 0x30, 0x02, 0x80, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x20, 0x08, 0x10, 0x08, 0x08,
  0x10, 0x08, 0x10, 0x04, 0x20, 0x04, 0x40, 0x02, 0x40, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x02, 0x40, 0x02, 0x40, 0x04, 0x20, 0x04, 0x20, 0x08,
  0x10, 0x10, 0x08, 0x10, 0x08, 0x20, 0x04, 0x20, 0x04, 0x40, 0x02, 0x80,
  0x03, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x20, 0x04, 0x10,
  0x08, 0x10, 0x08, 0x08, 0x10, 0x08, 0x10, 0x04, 0x20, 0x04, 0x20, 0x02,
  0x40, 0x02, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0,
  0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04,
  0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20,
  0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0xF1, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0xF0, 0x08, 0x0C, 0x05, 0x04, 0x82, 0x41, 0x11, 0x08, 0x84, 0x41,
  0x40, 0xA0, 0x50, 0x10, 0xFF, 0xF0, 0x41, 0x0C, 0x20, 0x1F, 0x02, 0x0C,
  0x40, 0x28, 0x02, 0x80, 0x20, 0x02, 0x00, 0x20, 0x02, 0x1F, 0xE6, 0x02,
  0xC0, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x06, 0x41, 0xA3, 0xE2,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x9F,
  0x14, 0x1B, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x02, 0xE0, 0x93, 0xE0,
  0x1F, 0x82, 0x04, 0x40, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x02, 0x80, 0x24, 0x02,
  0x20, 0x41, 0xF8, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x1F, 0x12, 0x0D, 0x40, 0x34, 0x03, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x40, 0x14, 0x03, 0x20, 0x51, 0xF9, 0x1F, 0x82, 0x04, 0x40, 0x28, 0x02,
  0x80, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x30, 0x60, 0xF8, 0x07, 0x84, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0xFF, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x00, 0x1F, 0x12, 0x0D, 0x40, 0x34, 0x03, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x40, 0x14, 0x03, 0x20, 0x51, 0xF9, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x40, 0x23, 0x04, 0x0F, 0x80, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x8F, 0x16, 0x1B, 0x01, 0x60, 0x28, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x04, 0x50, 0x01, 0x55, 0x55, 0x55, 0x55, 0x40,
  0x04, 0x10, 0x00, 0x00, 0x00, 0x01, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x20, 0xBC,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x50, 0x12, 0x04, 0x41, 0x08, 0x41, 0x10, 0x24, 0x05, 0x80, 0xB0, 0x19,
  0x02, 0x20, 0x42, 0x08, 0x21, 0x02, 0x20, 0x44, 0x04, 0x80, 0x50, 0x08,
  0xFF, 0xFF, 0xFF, 0xC0, 0x8F, 0x03, 0xC5, 0x84, 0x61, 0xB0, 0x14, 0x05,
  0x80, 0xA0, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x00, 0x40, 0x8F, 0x16, 0x1B, 0x01, 0x60, 0x28, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x04, 0x0F, 0x81, 0x82, 0x18, 0x08, 0x80, 0x28,
  0x01, 0x40, 0x0A, 0x00, 0x50, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x28, 0x01, 0x40, 0x09, 0x00, 0x48, 0x04, 0x30, 0x40, 0x7C, 0x00, 0x9F,
  0x14, 0x1B, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x02, 0xE0, 0x93, 0xE2,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x00, 0x1F, 0x12,
  0x0D, 0x40, 0x34, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x14, 0x03, 0x20, 0x51,
  0xF9, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x9F, 0x43, 0x06, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x00, 0x1F, 0x0C, 0x12, 0x01, 0x40, 0x18, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x0E, 0x00, 0x20, 0x03, 0x00, 0x20, 0x03, 0x00, 0x60,
  0x0C, 0x02, 0x60, 0xC3, 0xE0, 0x10, 0x20, 0x40, 0x81, 0x1F, 0xC4, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x03, 0x80, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x41, 0xA7, 0xC4, 0x80, 0x14, 0x00, 0x90, 0x04, 0x80, 0x44, 0x02, 0x10,
  0x10, 0x81, 0x04, 0x08, 0x10, 0x40, 0x84, 0x04, 0x20, 0x11, 0x00, 0x90,
  0x04, 0x80, 0x14, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x40, 0x20, 0x14,
  0x06, 0x02, 0x40, 0x60, 0x24, 0x05, 0x02, 0x20, 0x90, 0x22, 0x09, 0x06,
  0x20, 0x90, 0x42, 0x08, 0x84, 0x11, 0x08, 0x41, 0x10, 0x84, 0x11, 0x08,
  0x81, 0x10, 0x48, 0x0A, 0x04, 0x80, 0xA0, 0x48, 0x0A, 0x03, 0x00, 0xC0,
  0x30, 0x04, 0x03, 0x00, 0x40, 0x30, 0x40, 0x14, 0x02, 0x20, 0x62, 0x04,
  0x10, 0x80, 0x88, 0x09, 0x00, 0x50, 0x02, 0x00, 0x60, 0x05, 0x00, 0x90,
  0x10, 0x81, 0x04, 0x20, 0x42, 0x02, 0x40, 0x28, 0x01, 0x80, 0x14, 0x00,
  0x90, 0x04, 0x80, 0x24, 0x02, 0x10, 0x10, 0x80, 0x84, 0x08, 0x10, 0x40,
  0x82, 0x04, 0x20, 0x11, 0x00, 0x88, 0x04, 0x80, 0x14, 0x00, 0xA0, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00,
  0x70, 0x00, 0xFF, 0xE0, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x80, 0x1F, 0xFC, 0x01, 0x81, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20, 0x60, 0x08,
  0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x02, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x80, 0x80, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20, 0x60,
  0x00, 0x38, 0x02, 0x88, 0x06, 0x08, 0x0C, 0x08, 0x28, 0x08, 0x50, 0x0F,
  0x00,
};

const GFXglyph RobotoCondensed_Thin34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 24, 6, 2, -24 },
  { 7, 5, 7, 9, 2, -26 },
  { 12, 16, 24, 17, 1, -24 },
  { 60, 12, 30, 16, 2, -27 },
  { 105, 18, 24, 22, 2, -24 },
  { 159, 15, 24, 18, 2, -24 },
  { 204, 1, 7, 6, 2, -26 },
  { 205, 7, 35, 9, 2, -27 },
  { 236, 6, 35, 9, 1, -27 },
  { 263, 14, 13, 14, 0, -24 },
  { 286, 14, 17, 17, 1, -20 },
  { 316, 3, 7, 6, 1, -3 },
  { 319, 7, 1, 9, 1, -12 },
  { 320, 2, 2, 7, 2, -2 },
  { 321, 9, 26, 12, 1, -24 },
  { 351, 12, 24, 16, 2, -24 },
  { 387, 7, 24, 16, 3, -24 },
  { 408, 13, 24, 16, 2, -24 },
  { 447, 13, 24, 16, 2, -24 },
  { 486, 15, 24, 16, 1, -24 },
  { 531, 12, 24, 16, 3, -24 },
  { 567, 13, 24, 16, 2, -24 },
  { 606, 14, 24, 16, 1, -24 },
  { 648, 13, 24, 16, 2, -24 },
  { 687, 12, 24, 16, 2, -24 },
  { 723, 2, 18, 6, 2, -18 },
  { 728, 3, 22, 6, 1, -18 },
  { 737, 12, 14, 15, 1, -18 },
  { 758, 12, 8, 17, 2, -15 },
  { 770, 12, 14, 15, 2, -18 },
  { 791, 10, 24, 13, 2, -24 },
  { 821, 23, 31, 27, 2, -23 },
  { 911, 16, 24, 18, 1, -24 },
  { 959, 13, 24, 18, 3, -24 },
  { 998, 15, 24, 19, 2, -24 },
  { 1043, 14, 24, 19, 3, -24 },
  { 1085, 13, 24, 17, 3, -24 },
  { 1124, 13, 24, 17, 3, -24 },
  { 1163, 15, 24, 20, 3, -24 },
  { 1208, 15, 24, 21, 3, -24 },
  { 1253, 1, 24, 8, 4, -24 },
  { 1256, 11, 24, 16, 2, -24 },
  { 1289, 15, 24, 19, 3, -24 },
  { 1334, 11, 24, 16, 3, -24 },
  { 1367, 19, 24, 25, 3, -24 },
  { 1424, 15, 24, 21, 3, -24 },
  { 1469, 16, 24, 20, 2, -24 },
  { 1517, 13, 24, 18, 3, -24 },
  { 1556, 16, 28, 20, 2, -24 },
  { 1612, 14, 24, 19, 3, -24 },
  { 1654, 14, 24, 18, 2, -24 },
  { 1696, 16, 24, 18, 1, -24 },
  { 1744, 14, 24, 20, 3, -24 },
  { 1786, 16, 24, 18, 1, -24 },
  { 1834, 25, 24, 27, 1, -24 },
  { 1909, 16, 24, 18, 1, -24 },
  { 1957, 16, 24, 18, 1, -24 },
  { 2005, 14, 24, 18, 2, -24 },
  { 2047, 4, 33, 7, 3, -28 },
  { 2064, 10, 26, 12, 1, -24 },
  { 2097, 4, 33, 7, 0, -28 },
  { 2114, 9, 12, 13, 2, -24 },
  { 2128, 12, 1, 13, 0, 0 },
  { 2130, 5, 4, 9, 2, -25 },
  { 2133, 12, 18, 16, 2, -18 },
  { 2160, 11, 26, 16, 3, -26 },
  { 2196, 12, 18, 15, 2, -18 },
  { 2223, 12, 26, 16, 2, -26 },
  { 2262, 12, 18, 15, 2, -18 },
  { 2289, 9, 26, 10, 1, -26 },
  { 2319, 12, 25, 16, 2, -18 },
  { 2357, 11, 26, 16, 3, -26 },
  { 2393, 2, 25, 7, 2, -25 },
  { 2400, 6, 32, 7, -2, -25 },
  { 2424, 11, 26, 14, 3, -26 },
  { 2460, 1, 26, 7, 3, -26 },
  { 2464, 21, 18, 26, 3, -18 },
  { 2512, 11, 18, 16, 3, -18 },
  { 2537, 13, 18, 16, 2, -18 },
  { 2567, 11, 25, 16, 3, -18 },
  { 2602, 12, 25, 16, 2, -18 },
  { 2640, 7, 18, 10, 3, -18 },
  { 2656, 11, 18, 15, 2, -18 },
  { 2681, 7, 23, 10, 1, -23 },
  { 2702, 11, 18, 16, 3, -18 },
  { 2727, 13, 18, 14, 1, -18 },
  { 2757, 20, 18, 22, 1, -18 },
  { 2802, 12, 18, 14, 1, -18 },
  { 2829, 13, 25, 14, 1, -18 },
  { 2870, 11, 18, 14, 2, -18 },
  { 2895, 9, 34, 10, 1, -27 },
  { 2934, 1, 28, 7, 3, -24 },
  { 2938, 9, 34, 10, 0, -27 },
  { 2977, 15, 6, 21, 3, -13 },
};

const GFXfont RobotoCondensed_Thin34pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin34pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin34pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOCONDENSED_THIN34PT7B_H_
