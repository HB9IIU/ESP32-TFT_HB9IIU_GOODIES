#ifndef _ROBOTOCONDENSED_THIN65PT7B_H_
#define _ROBOTOCONDENSED_THIN65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin65pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xD8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x83, 0x83, 0x00, 0x0C, 0x00, 0x80,
  0x00, 0x30, 0x02, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x08, 0x01, 0x80, 0x00, 0x20, 0x06, 0x00, 0x01, 0x80, 0x10, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x00,
  0x30, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x80, 0x18, 0x00, 0x02, 0x00, 0x60, 0x00, 0x18, 0x01, 0x00, 0x00,
  0x60, 0x04, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x10,
  0x03, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x03, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x08, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0,
  0x06, 0x00, 0x40, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01,
  0x00, 0x30, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x30, 0x02, 0x00, 0x00, 0xC0,
  0x08, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x80, 0x18, 0x00, 0x02, 0x00, 0x40, 0x00, 0x18, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x1C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x02, 0x60, 0x00, 0x02, 0x60, 0x00,
  0x02, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x07, 0x00,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x08, 0x04, 0x00, 0x20, 0x03, 0x00,
  0x80, 0x04, 0x00, 0xC0, 0x10, 0x00, 0x80, 0x18, 0x02, 0x00, 0x10, 0x06,
  0x00, 0x40, 0x02, 0x00, 0xC0, 0x08, 0x00, 0x40, 0x30, 0x01, 0x00, 0x08,
  0x06, 0x00, 0x30, 0x03, 0x01, 0x80, 0x06, 0x00, 0x60, 0x30, 0x00, 0xC0,
  0x08, 0x0C, 0x00, 0x0C, 0x03, 0x01, 0x00, 0x00, 0xC0, 0xC0, 0x60, 0x00,
  0x0F, 0xF0, 0x08, 0x00, 0x00, 0xFC, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x03, 0xF0, 0x00,
  0x01, 0x80, 0xF7, 0x80, 0x00, 0x30, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x03,
  0x00, 0x01, 0x81, 0x80, 0x30, 0x00, 0x60, 0x20, 0x06, 0x00, 0x0C, 0x0C,
  0x00, 0x40, 0x03, 0x01, 0x80, 0x08, 0x00, 0x40, 0x30, 0x01, 0x80, 0x18,
  0x06, 0x00, 0x30, 0x02, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x10, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x03, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x30, 0x01, 0x80, 0x08, 0x04, 0x00, 0x10, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60, 0x0C,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x01, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x80, 0x04, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x06,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x43, 0x00, 0x60, 0x02, 0x30, 0x01, 0x80, 0x11, 0x80, 0x06, 0x01, 0x98,
  0x00, 0x30, 0x0C, 0xC0, 0x00, 0xC0, 0x66, 0x00, 0x03, 0x03, 0x20, 0x00,
  0x0C, 0x11, 0x00, 0x00, 0x61, 0x88, 0x00, 0x01, 0x8C, 0x40, 0x00, 0x06,
  0xC3, 0x00, 0x00, 0x1E, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x3C, 0x18, 0x00, 0x03, 0x70, 0x60, 0x00, 0x31, 0x81, 0x80,
  0x07, 0x06, 0x07, 0x00, 0xE0, 0x18, 0x1F, 0xFE, 0x00, 0xE0, 0x0F, 0x00,
  0x00, 0x55, 0x57, 0xFF, 0xC0, 0x00, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x10,
  0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x01, 0xF8, 0x06, 0x03, 0xCF, 0x83,
  0x0F, 0x80, 0xF1, 0x9E, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x30, 0x70, 0x00, 0x30, 0x18, 0x00, 0x18, 0x06, 0x00, 0x18, 0x01, 0x80,
  0x18, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x04, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x18, 0xC6, 0x31, 0x8C, 0xC6, 0x33, 0x99, 0x8C, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x5F, 0xB0, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0x81, 0xC0, 0x0E, 0x00, 0x60, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0x30, 0x30, 0x00, 0x18, 0x30, 0x00, 0x08, 0x20, 0x00, 0x0C,
  0x60, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x40, 0x00, 0x06, 0x40, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x06,
  0x60, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x08,
  0x30, 0x00, 0x18, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x60,
  0x07, 0x81, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x10, 0x07,
  0x03, 0xD0, 0xF1, 0x78, 0x1E, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x78, 0x00, 0x03, 0xFF, 0x80,
  0x07, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x30, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x08, 0x40, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xE0, 0x3C,
  0x00, 0xC0, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0x60, 0x40, 0x00,
  0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x30, 0x00, 0x01, 0x98, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x04, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x01, 0x06, 0x00, 0x01, 0x83, 0x80, 0x01, 0x80, 0xE0, 0x01, 0x80,
  0x1C, 0x03, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x09, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x44, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x06, 0x10, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x30, 0x40, 0x00, 0x06,
  0x08, 0x00, 0x01, 0x81, 0x00, 0x00, 0x20, 0x20, 0x00, 0x0C, 0x04, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x60, 0x10, 0x00, 0x18, 0x02, 0x00, 0x03, 0x00,
  0x40, 0x00, 0xC0, 0x08, 0x00, 0x30, 0x01, 0x00, 0x06, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x0C, 0x00, 0x10, 0x01, 0x80, 0x02,
  0x00, 0x60, 0x00, 0x40, 0x18, 0x00, 0x08, 0x03, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x20, 0x18, 0x00, 0x04, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x61, 0xFC,
  0x00, 0xCF, 0xFE, 0x01, 0xF0, 0x07, 0x03, 0x80, 0x07, 0x06, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x34, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00,
  0x01, 0x10, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x60, 0x00,
  0x60, 0x70, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x7F, 0x00, 0x41, 0xFF, 0xC0, 0xC7, 0x00, 0xE0, 0xCE, 0x00,
  0x30, 0xD8, 0x00, 0x18, 0xD0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x40, 0x00, 0x02, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x06, 0x00,
  0x70, 0x03, 0x80, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0xE0, 0x3C, 0x01, 0xC0, 0x07, 0x00, 0xC0,
  0x01, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x04, 0x30,
  0x00, 0x03, 0x10, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x06,
  0x30, 0x00, 0x03, 0x18, 0x00, 0x03, 0x06, 0x00, 0x01, 0x81, 0x80, 0x01,
  0x80, 0xE0, 0x01, 0x80, 0x1C, 0x03, 0x80, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0x80, 0xF0, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x03, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x01,
  0x83, 0x00, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0x80,
  0xE0, 0x06, 0x00, 0x70, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x02, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x30, 0x00, 0x07, 0x30, 0x00, 0x0D, 0x18, 0x00,
  0x0D, 0x1C, 0x00, 0x19, 0x0E, 0x00, 0x33, 0x07, 0x00, 0xE3, 0x01, 0xFF,
  0x83, 0x00, 0x7E, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x6F, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x4F, 0xF4, 0x33, 0xDE, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x31, 0x98, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x38, 0x1C, 0x0C,
  0x00, 0xC3, 0x00, 0x0C, 0x40, 0x01, 0x98, 0x00, 0x12, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x7E, 0x00, 0x04, 0x18, 0x00, 0x1F, 0xF0, 0x00, 0x61, 0x80, 0x03, 0x81,
  0xC0, 0x06, 0x30, 0x00, 0x60, 0x0E, 0x00, 0x23, 0x00, 0x0C, 0x00, 0x60,
  0x02, 0x30, 0x00, 0x80, 0x06, 0x00, 0x36, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x36, 0x00, 0x30, 0x00, 0x40, 0x03, 0x60,
  0x02, 0x00, 0x04, 0x00, 0x34, 0x00, 0x60, 0x00, 0x40, 0x01, 0xC0, 0x06,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x04, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x40, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0xC0, 0x0C, 0x00, 0x0C, 0x00,
  0x3C, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x3C,
  0x00, 0xC0, 0x00, 0xC0, 0x03, 0xC0, 0x0C, 0x00, 0x08, 0x00, 0x2C, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0x6C, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0xC0, 0x0C, 0x00, 0x38, 0x00, 0x44, 0x00, 0x40, 0x02,
  0x80, 0x0C, 0x60, 0x06, 0x00, 0x6C, 0x00, 0x86, 0x00, 0x60, 0x0C, 0xC0,
  0x18, 0x60, 0x03, 0x00, 0x86, 0x03, 0x02, 0x00, 0x38, 0x38, 0x30, 0x60,
  0x30, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x40, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x06, 0x20, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x01, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x60, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x20, 0x0C,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x10, 0x18,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x08, 0x10,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x30, 0x00, 0x38,
  0x18, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0x60, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x01, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06,
  0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x60,
  0x00, 0x07, 0x30, 0x00, 0x07, 0x18, 0x00, 0x0F, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x04, 0x30,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x30, 0x07, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0x00, 0x03,
  0xC0, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x05, 0x80,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x78, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x70,
  0x03, 0x80, 0x06, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x31,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x00, 0xF0,
  0x07, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x58, 0x00, 0x01, 0x90, 0x00, 0x03, 0x30, 0x00, 0x04, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x60, 0xE0, 0x00, 0xC0, 0xE0, 0x07, 0x00, 0xF0, 0x1C, 0x00,
  0x7F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0E, 0x0C,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x60, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0xC6,
  0xC0, 0x00, 0x0C, 0xC6, 0x00, 0x00, 0xD8, 0x30, 0x00, 0x0F, 0x01, 0x80,
  0x00, 0xE0, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0xC0, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x05, 0xE8, 0x00, 0x00, 0x00, 0x6F, 0x60, 0x00,
  0x00, 0x02, 0x7B, 0x00, 0x00, 0x00, 0x33, 0xC8, 0x00, 0x00, 0x01, 0x9E,
  0x60, 0x00, 0x00, 0x08, 0xF3, 0x00, 0x00, 0x00, 0xC7, 0x8C, 0x00, 0x00,
  0x06, 0x3C, 0x60, 0x00, 0x00, 0x21, 0xE1, 0x00, 0x00, 0x03, 0x0F, 0x0C,
  0x00, 0x00, 0x18, 0x78, 0x60, 0x00, 0x01, 0x83, 0xC1, 0x00, 0x00, 0x0C,
  0x1E, 0x0C, 0x00, 0x00, 0x40, 0xF0, 0x60, 0x00, 0x06, 0x07, 0x81, 0x00,
  0x00, 0x30, 0x3C, 0x0C, 0x00, 0x01, 0x01, 0xE0, 0x20, 0x00, 0x18, 0x0F,
  0x01, 0x80, 0x00, 0xC0, 0x78, 0x0C, 0x00, 0x04, 0x03, 0xC0, 0x20, 0x00,
  0x60, 0x1E, 0x01, 0x80, 0x02, 0x00, 0xF0, 0x0C, 0x00, 0x30, 0x07, 0x80,
  0x20, 0x01, 0x80, 0x3C, 0x01, 0x80, 0x08, 0x01, 0xE0, 0x0C, 0x00, 0xC0,
  0x0F, 0x00, 0x30, 0x06, 0x00, 0x78, 0x01, 0x80, 0x20, 0x03, 0xC0, 0x04,
  0x03, 0x00, 0x1E, 0x00, 0x30, 0x18, 0x00, 0xF0, 0x01, 0x81, 0x80, 0x07,
  0x80, 0x04, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x40, 0x01, 0xE0, 0x01, 0x86,
  0x00, 0x0F, 0x00, 0x04, 0x30, 0x00, 0x78, 0x00, 0x31, 0x00, 0x03, 0xC0,
  0x00, 0x98, 0x00, 0x1E, 0x00, 0x06, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x01,
  0xC8, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x1C, 0x60,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x1C, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x1C, 0x03, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x1C, 0x01, 0x80,
  0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0xC0, 0x06, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x18, 0x01, 0xC0, 0x01,
  0x80, 0x1C, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x18, 0x1C, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x41, 0xC0, 0x00, 0x06,
  0x1C, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x19, 0xC0,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x06,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x60, 0x03, 0x80, 0x03, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x01,
  0x60, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x33, 0x00, 0x00, 0x39, 0x80, 0x00, 0x38, 0xC0,
  0x00, 0x78, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x06,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x60, 0x03, 0x80, 0x07, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF3, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x02, 0x00, 0x01, 0xE0, 0x40, 0x00, 0x0E,
  0x08, 0x00, 0x00, 0xE1, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x08, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x32, 0x00, 0x00, 0x06,
  0x40, 0x00, 0x00, 0x48, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x20, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x04, 0x40, 0x00, 0x01, 0x88, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x07, 0x04, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x02, 0x00, 0x06, 0x00, 0x40, 0x00, 0xC0, 0x08, 0x00, 0x0C,
  0x01, 0x00, 0x00, 0x80, 0x20, 0x00, 0x18, 0x04, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x30, 0x10, 0x00, 0x03, 0x02, 0x00, 0x00, 0x60, 0x40, 0x00, 0x06,
  0x08, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x32, 0x00, 0x00, 0x06,
  0x40, 0x00, 0x00, 0x68, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x00,
  0x70, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x0F, 0x00, 0x07,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x06, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x60,
  0x70, 0x00, 0x30, 0x07, 0x80, 0x78, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x08, 0x03, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x06, 0x20, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x33, 0x00, 0x00, 0x14, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xD8, 0x00, 0x01, 0x8C,
  0x00, 0x01, 0x90, 0x00, 0x02, 0x18, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x30, 0x40,
  0x00, 0x30, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x41, 0x00, 0x01, 0x81, 0x80,
  0x01, 0x83, 0x00, 0x03, 0x03, 0x00, 0x03, 0x06, 0x00, 0x06, 0x02, 0x00,
  0x06, 0x04, 0x00, 0x0C, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x10, 0x0C, 0x00,
  0x30, 0x18, 0x00, 0x60, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x30, 0x00,
  0xC0, 0x20, 0x01, 0x80, 0x30, 0x01, 0x00, 0x60, 0x02, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x30, 0x01, 0x00, 0x20, 0x03, 0x00, 0x60, 0x03, 0x00, 0xC0,
  0x06, 0x01, 0x80, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00,
  0x08, 0x06, 0x00, 0x08, 0x04, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x10, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00,
  0x40, 0xC0, 0x00, 0xC1, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x83, 0x00, 0x01,
  0x82, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x02,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x04, 0x60, 0x00, 0x0C,
  0x60, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x19, 0x00, 0x00, 0x13,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x36, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x58, 0x00, 0x00, 0xD0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x00, 0x19, 0xC0,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x60, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x00, 0x86, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x02,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00,
  0x01, 0x00, 0x18, 0x00, 0x06, 0x00, 0x40, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x08, 0x10, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x04, 0x20, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x05, 0x80, 0x03, 0x20, 0x00, 0xCC, 0x00, 0x23, 0x00,
  0x18, 0x40, 0x06, 0x18, 0x01, 0x06, 0x00, 0xC0, 0x80, 0x30, 0x30, 0x08,
  0x0C, 0x06, 0x01, 0x01, 0x80, 0x60, 0x40, 0x18, 0x30, 0x02, 0x0C, 0x00,
  0xC2, 0x00, 0x31, 0x80, 0x04, 0x60, 0x01, 0x90, 0x00, 0x6C, 0x00, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C,
  0x06, 0x07, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x1C, 0x03, 0x80, 0x60,
  0x01, 0x81, 0x80, 0x01, 0x86, 0x00, 0x03, 0x08, 0x00, 0x03, 0x30, 0x00,
  0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3C, 0x00, 0x30, 0xC0, 0x00, 0x63,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00,
  0x01, 0xD8, 0x00, 0x03, 0x98, 0x00, 0x0F, 0x30, 0x00, 0x32, 0x30, 0x01,
  0xC4, 0x38, 0x0F, 0x08, 0x3F, 0xF8, 0x18, 0x0F, 0x80, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x1F, 0x00, 0x61, 0xFF, 0xC0, 0xC7, 0x01, 0xC1, 0x98,
  0x00, 0xC3, 0x60, 0x00, 0xC7, 0x80, 0x00, 0xCE, 0x00, 0x01, 0x9C, 0x00,
  0x01, 0x30, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00,
  0x0B, 0x00, 0x00, 0x16, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x58, 0x00, 0x00, 0xB0,
  0x00, 0x01, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x27, 0x00, 0x00, 0xCE, 0x00, 0x01, 0x1E, 0x00, 0x06, 0x37, 0x00,
  0x18, 0x67, 0x80, 0xE0, 0xC3, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x07, 0xFF, 0x80, 0x1C, 0x03, 0x80, 0x60, 0x01, 0x81, 0x80, 0x01,
  0x86, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x02, 0x60, 0x00, 0x06,
  0xC0, 0x00, 0x0D, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x32, 0x00, 0x00, 0x66, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x0E, 0x01, 0xC0,
  0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x0F, 0x80, 0x40,
  0xFF, 0xC1, 0x0E, 0x01, 0xC4, 0x70, 0x01, 0x93, 0x80, 0x03, 0x4C, 0x00,
  0x05, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x40, 0x00, 0x05, 0x80,
  0x00, 0x16, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x30, 0x00, 0x1C, 0xE0, 0x00,
  0xD1, 0xC0, 0x06, 0x43, 0x80, 0x71, 0x03, 0xFF, 0x04, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xFF, 0x80, 0x1E, 0x03, 0x80, 0x70, 0x01, 0x81,
  0x80, 0x01, 0x83, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x02, 0x60,
  0x00, 0x06, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x18, 0x0F,
  0x00, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x3F,
  0xC0, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC,
  0x10, 0xE0, 0x1C, 0x47, 0x00, 0x19, 0x38, 0x00, 0x34, 0xC0, 0x00, 0x56,
  0x00, 0x01, 0xD8, 0x00, 0x03, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x50, 0x00, 0x01,
  0x60, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x00, 0x01, 0xCE, 0x00, 0x0D, 0x1C,
  0x00, 0x64, 0x38, 0x07, 0x10, 0x3F, 0xF0, 0x40, 0x3E, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x22, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x30, 0x38,
  0x03, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0xF8, 0x18, 0x3F,
  0xF0, 0xC3, 0x81, 0xC6, 0x30, 0x03, 0x33, 0x00, 0x0D, 0xB0, 0x00, 0x6D,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x08, 0xFF, 0x80, 0x00, 0x00, 0x04, 0x92, 0x49, 0x24,
  0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x80, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x1F, 0xC3, 0xF0, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x06, 0xC0, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x06,
  0x0C, 0x00, 0x60, 0x60, 0x07, 0x03, 0x00, 0x70, 0x18, 0x03, 0x00, 0xC0,
  0x30, 0x06, 0x03, 0x00, 0x30, 0x30, 0x01, 0x83, 0x00, 0x0C, 0x30, 0x00,
  0x63, 0x00, 0x03, 0x3C, 0x00, 0x1B, 0x30, 0x00, 0xF1, 0x80, 0x07, 0x06,
  0x00, 0x30, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x00, 0x30, 0x18, 0x01, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00,
  0x61, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x00, 0x01, 0xD8,
  0x00, 0x06, 0xC0, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x60, 0xFF, 0xC0, 0x1F, 0xF8, 0x30, 0xC0,
  0x70, 0x1C, 0x07, 0x18, 0xC0, 0x0C, 0x18, 0x01, 0xCC, 0xC0, 0x03, 0x18,
  0x00, 0x66, 0xC0, 0x01, 0x98, 0x00, 0x1B, 0xC0, 0x00, 0x58, 0x00, 0x0D,
  0xE0, 0x00, 0x3C, 0x00, 0x02, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x78, 0x00, 0x03, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00,
  0x30, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x80, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x3E, 0x06, 0x0F, 0xFC, 0x30, 0xE0, 0x71, 0x8C, 0x00, 0xCC, 0xC0,
  0x03, 0x6C, 0x00, 0x1B, 0x40, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x02, 0x00, 0x7C, 0x00, 0x03,
  0xFF, 0x80, 0x07, 0x01, 0xE0, 0x0C, 0x00, 0x70, 0x18, 0x00, 0x38, 0x30,
  0x00, 0x18, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x06, 0x40, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x07,
  0x01, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0x87,
  0xFF, 0x03, 0x1C, 0x07, 0x06, 0x60, 0x03, 0x0D, 0x80, 0x03, 0x1E, 0x00,
  0x03, 0x38, 0x00, 0x06, 0x70, 0x00, 0x04, 0xC0, 0x00, 0x0D, 0x80, 0x00,
  0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x58, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x02, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x9C, 0x00, 0x03, 0x38, 0x00,
  0x04, 0x78, 0x00, 0x18, 0xDC, 0x00, 0x61, 0x9E, 0x03, 0x83, 0x0F, 0xFE,
  0x06, 0x03, 0xE0, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x10, 0xE0, 0x1C, 0x47, 0x00,
  0x39, 0x38, 0x00, 0x34, 0xC0, 0x00, 0x56, 0x00, 0x01, 0xD8, 0x00, 0x03,
  0x60, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x58, 0x00, 0x01, 0x60, 0x00, 0x0D, 0x80, 0x00,
  0x33, 0x00, 0x01, 0xCE, 0x00, 0x0D, 0x1C, 0x00, 0x64, 0x38, 0x07, 0x10,
  0x3F, 0xF8, 0x40, 0x3E, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x7E, 0x1F, 0xF1, 0xC1, 0x98, 0x0D, 0x80, 0x68, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xE0, 0x1C, 0x06, 0x00, 0x18, 0x30, 0x00,
  0x31, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x66, 0x00, 0x01,
  0x8C, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x38, 0x07, 0x80, 0x7F, 0xF8, 0x00,
  0x1F, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x0F, 0xFF, 0xBF, 0xFE, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x7C, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x80, 0x00, 0x36, 0x00,
  0x03, 0xB0, 0x00, 0x14, 0xC0, 0x01, 0xA7, 0x00, 0x19, 0x1C, 0x03, 0x88,
  0x3F, 0xF0, 0x40, 0x7C, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x40,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x08, 0x10, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x10, 0x08, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x20, 0x04,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x02, 0x00, 0xC0, 0x03,
  0x00, 0xC0, 0x03, 0x00, 0x80, 0x01, 0x01, 0x80, 0x01, 0x81, 0x80, 0x01,
  0x81, 0x00, 0x00, 0x83, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x66, 0x00, 0x00, 0x64, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x0C, 0x80, 0x00, 0xE0, 0x00, 0x66, 0x00, 0x0D, 0x00, 0x03, 0x30, 0x00,
  0x6C, 0x00, 0x19, 0x80, 0x02, 0x60, 0x01, 0x84, 0x00, 0x33, 0x00, 0x0C,
  0x30, 0x01, 0x88, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0x43,
  0x00, 0x30, 0x20, 0x06, 0x18, 0x01, 0x81, 0x80, 0x30, 0x60, 0x0C, 0x0C,
  0x01, 0x83, 0x00, 0x60, 0x60, 0x08, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x40,
  0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x20, 0x18, 0x0C, 0x03, 0x03,
  0x00, 0xC0, 0xC0, 0x08, 0x18, 0x02, 0x06, 0x00, 0x60, 0xC0, 0x18, 0x30,
  0x03, 0x04, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x02, 0x18, 0x00, 0x43, 0x00,
  0x18, 0xC0, 0x03, 0x10, 0x00, 0xC6, 0x00, 0x18, 0x80, 0x06, 0x30, 0x00,
  0xCC, 0x00, 0x13, 0x00, 0x02, 0x60, 0x00, 0xD8, 0x00, 0x1A, 0x00, 0x06,
  0xC0, 0x00, 0xF0, 0x00, 0x16, 0x00, 0x07, 0x80, 0x00, 0xA0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x06, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC3,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x66, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x66,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x81, 0x00, 0x01, 0x01,
  0x80, 0x03, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x40, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x20, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x08, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00,
  0x30, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x81,
  0x80, 0x00, 0x81, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0x26, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x02, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x00, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x4C, 0x0E, 0x00, 0x06, 0xC0,
  0x38, 0x00, 0x36, 0x00, 0x60, 0x01, 0xE0, 0x03, 0x80, 0x0B, 0x00, 0x0E,
  0x00, 0xD8, 0x00, 0x38, 0x06, 0xC0, 0x00, 0xE0, 0x66, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_Thin65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 47, 12, 5, -46 },
  { 19, 8, 13, 17, 5, -49 },
  { 32, 30, 46, 32, 2, -46 },
  { 205, 24, 60, 31, 4, -53 },
  { 385, 35, 48, 42, 4, -47 },
  { 595, 29, 48, 35, 4, -47 },
  { 769, 2, 13, 11, 4, -49 },
  { 773, 11, 66, 18, 5, -51 },
  { 864, 12, 66, 18, 1, -51 },
  { 963, 25, 25, 27, 1, -46 },
  { 1042, 26, 34, 32, 3, -39 },
  { 1153, 5, 13, 12, 3, -5 },
  { 1162, 13, 2, 17, 2, -22 },
  { 1166, 3, 4, 14, 5, -3 },
  { 1168, 18, 50, 22, 2, -46 },
  { 1281, 24, 48, 31, 4, -47 },
  { 1425, 12, 46, 31, 6, -46 },
  { 1494, 24, 47, 31, 4, -47 },
  { 1635, 25, 48, 31, 3, -47 },
  { 1785, 27, 46, 31, 3, -46 },
  { 1941, 23, 47, 31, 5, -46 },
  { 2077, 24, 47, 31, 4, -46 },
  { 2218, 25, 46, 31, 3, -46 },
  { 2362, 25, 48, 31, 3, -47 },
  { 2512, 24, 47, 31, 3, -47 },
  { 2653, 4, 34, 11, 4, -33 },
  { 2670, 5, 41, 11, 3, -33 },
  { 2696, 22, 26, 30, 3, -34 },
  { 2768, 22, 16, 32, 5, -29 },
  { 2812, 22, 26, 30, 4, -34 },
  { 2884, 19, 48, 25, 3, -47 },
  { 2998, 44, 59, 52, 4, -45 },
  { 3323, 32, 46, 34, 1, -46 },
  { 3507, 25, 46, 35, 6, -46 },
  { 3651, 28, 48, 37, 5, -47 },
  { 3819, 27, 46, 37, 6, -46 },
  { 3975, 24, 46, 33, 6, -46 },
  { 4113, 24, 46, 33, 6, -46 },
  { 4251, 29, 48, 39, 5, -47 },
  { 4425, 28, 46, 40, 6, -46 },
  { 4586, 2, 46, 16, 7, -46 },
  { 4598, 23, 47, 32, 3, -46 },
  { 4734, 28, 46, 36, 6, -46 },
  { 4895, 22, 46, 30, 6, -46 },
  { 5022, 37, 46, 49, 6, -46 },
  { 5235, 28, 46, 40, 6, -46 },
  { 5396, 30, 48, 38, 4, -47 },
  { 5576, 25, 46, 34, 6, -46 },
  { 5720, 30, 55, 38, 4, -47 },
  { 5927, 27, 46, 37, 6, -46 },
  { 6083, 28, 48, 34, 3, -47 },
  { 6251, 30, 46, 34, 2, -46 },
  { 6424, 26, 47, 38, 6, -46 },
  { 6577, 31, 46, 34, 2, -46 },
  { 6756, 47, 46, 51, 2, -46 },
  { 7027, 30, 46, 34, 2, -46 },
  { 7200, 32, 46, 34, 1, -46 },
  { 7384, 28, 46, 34, 3, -46 },
  { 7545, 8, 63, 13, 5, -53 },
  { 7608, 18, 50, 22, 2, -46 },
  { 7721, 8, 63, 13, 0, -53 },
  { 7784, 18, 23, 24, 3, -46 },
  { 7836, 22, 2, 24, 1, 0 },
  { 7842, 8, 8, 17, 5, -48 },
  { 7850, 23, 36, 30, 3, -35 },
  { 7954, 23, 50, 31, 5, -49 },
  { 8098, 23, 36, 29, 3, -35 },
  { 8202, 22, 50, 31, 4, -49 },
  { 8340, 23, 36, 29, 3, -35 },
  { 8444, 17, 50, 19, 2, -50 },
  { 8551, 22, 48, 32, 4, -35 },
  { 8683, 21, 49, 31, 5, -49 },
  { 8812, 3, 46, 13, 5, -46 },
  { 8830, 11, 59, 13, -3, -46 },
  { 8912, 21, 49, 27, 5, -49 },
  { 9041, 1, 49, 13, 6, -49 },
  { 9048, 41, 35, 51, 5, -35 },
  { 9228, 21, 35, 31, 5, -35 },
  { 9320, 24, 36, 31, 4, -35 },
  { 9428, 23, 48, 31, 5, -35 },
  { 9566, 22, 48, 31, 4, -35 },
  { 9698, 13, 35, 20, 5, -35 },
  { 9755, 22, 36, 29, 3, -35 },
  { 9854, 14, 45, 19, 2, -44 },
  { 9933, 21, 35, 31, 5, -34 },
  { 10025, 24, 34, 28, 2, -34 },
  { 10127, 37, 34, 43, 3, -34 },
  { 10285, 24, 34, 28, 2, -34 },
  { 10387, 24, 47, 27, 2, -34 },
  { 10528, 23, 34, 28, 3, -34 },
  { 10626, 15, 65, 19, 3, -51 },
  { 10748, 2, 55, 13, 6, -46 },
  { 10762, 15, 65, 19, 1, -51 },
  { 10884, 29, 11, 39, 5, -25 },
};

const GFXfont RobotoCondensed_Thin65pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin65pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin65pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _ROBOTOCONDENSED_THIN65PT7B_H_
