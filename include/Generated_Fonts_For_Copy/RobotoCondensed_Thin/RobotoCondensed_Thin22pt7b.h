#ifndef _ROBOTOCONDENSED_THIN22PT7B_H_
#define _ROBOTOCONDENSED_THIN22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF1, 0xFF, 0x09, 0x04, 0x41, 0x10, 0x44, 0xFF, 0xC4, 0x41,
  0x10, 0x48, 0x22, 0x08, 0x82, 0x23, 0xFE, 0x22, 0x09, 0x04, 0x41, 0x10,
  0x08, 0x08, 0x3E, 0x41, 0x41, 0x41, 0x41, 0x40, 0x60, 0x18, 0x04, 0x03,
  0x01, 0x81, 0x81, 0x41, 0x41, 0x3E, 0x08, 0x08, 0x70, 0x08, 0x80, 0x88,
  0x48, 0x88, 0x88, 0x88, 0x90, 0x72, 0x00, 0x20, 0x04, 0x00, 0x4E, 0x09,
  0x10, 0x91, 0x11, 0x11, 0x11, 0x01, 0x10, 0x0E, 0x1C, 0x08, 0x84, 0x21,
  0x08, 0x42, 0x09, 0x02, 0x80, 0x40, 0x28, 0x11, 0x18, 0x46, 0x0A, 0x81,
  0xA0, 0x44, 0x18, 0xF9, 0xF0, 0x12, 0x44, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x44, 0x21, 0x84, 0x22, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x22, 0x48, 0x08, 0x04, 0x02, 0x0F, 0x60, 0xC0, 0xA0, 0x88, 0x42,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x00, 0x56, 0xF0, 0x80, 0x04, 0x20, 0x82, 0x10, 0x41, 0x08, 0x20, 0x84,
  0x10, 0x41, 0x08, 0x20, 0x80, 0x3C, 0x42, 0x41, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42, 0x3C, 0x3D, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x3C, 0x21, 0x10, 0x50, 0x28, 0x10, 0x08,
  0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x00, 0xFF, 0x3E,
  0x41, 0x81, 0x81, 0x01, 0x01, 0x02, 0x1C, 0x02, 0x01, 0x01, 0x81, 0x81,
  0x81, 0x41, 0x3E, 0x02, 0x03, 0x01, 0x81, 0x40, 0xA0, 0x90, 0x48, 0x44,
  0x42, 0x21, 0x20, 0x9F, 0xF0, 0x20, 0x10, 0x08, 0x04, 0x7E, 0x40, 0x80,
  0x80, 0x80, 0x80, 0xFC, 0x82, 0x02, 0x01, 0x01, 0x01, 0x81, 0x82, 0x42,
  0x3C, 0x0E, 0x10, 0x20, 0x40, 0x40, 0x80, 0xBE, 0xC1, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x41, 0x41, 0x3E, 0xFF, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x3E, 0x20, 0x90,
  0x50, 0x28, 0x14, 0x09, 0x04, 0x7C, 0x42, 0x40, 0xA0, 0x30, 0x18, 0x0C,
  0x09, 0x04, 0x7C, 0x3C, 0x42, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x43, 0x3D, 0x01, 0x01, 0x02, 0x04, 0x38, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x16, 0x80, 0x03, 0x0C, 0x30, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x80, 0x60, 0x18, 0x06, 0x01, 0x06, 0x18, 0x60,
  0x80, 0x38, 0x8A, 0x0C, 0x10, 0x20, 0x41, 0x02, 0x08, 0x20, 0x40, 0x80,
  0x00, 0x00, 0x08, 0x07, 0xF0, 0x10, 0x10, 0x40, 0x11, 0x00, 0x14, 0x00,
  0x28, 0x38, 0x50, 0x88, 0xC2, 0x11, 0x84, 0x23, 0x10, 0x46, 0x20, 0x8C,
  0x41, 0x18, 0x84, 0x30, 0x94, 0x91, 0xC6, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x7E, 0x00, 0x04, 0x00, 0xC0, 0x28, 0x05, 0x00, 0x90,
  0x12, 0x04, 0x40, 0x84, 0x10, 0x84, 0x10, 0xFE, 0x10, 0x24, 0x04, 0x80,
  0x50, 0x0C, 0x01, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x82,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFE, 0x3E, 0x20, 0xA0, 0x30, 0x18,
  0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x05, 0x04,
  0x7C, 0xFC, 0x41, 0xA0, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x0A, 0x0D, 0xF8, 0xFF, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x3E, 0x20, 0xE0, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00,
  0x87, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x05, 0x02, 0x7E, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0xFF, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0xFF, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x81, 0x81, 0x82, 0x42, 0x3C, 0x80,
  0xC0, 0xA0, 0x90, 0x88, 0x84, 0x42, 0x41, 0x40, 0xD0, 0x44, 0x21, 0x10,
  0x88, 0x24, 0x0A, 0x05, 0x01, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7F, 0x80, 0x18, 0x01, 0xC0, 0x3C,
  0x03, 0xA0, 0x3A, 0x05, 0xA0, 0x59, 0x05, 0x90, 0x99, 0x09, 0x88, 0x98,
  0x91, 0x85, 0x18, 0x51, 0x86, 0x18, 0x21, 0x80, 0x60, 0x1C, 0x06, 0x81,
  0xA0, 0x64, 0x19, 0x06, 0x21, 0x84, 0x61, 0x18, 0x26, 0x09, 0x81, 0x60,
  0x58, 0x0E, 0x01, 0x1F, 0x08, 0x24, 0x05, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x40, 0x50, 0x12, 0x08, 0x7C, 0xFE,
  0x40, 0xA0, 0x50, 0x18, 0x0C, 0x06, 0x05, 0x02, 0xFE, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x1F, 0x08, 0x24, 0x05, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x40, 0x50, 0x12, 0x08,
  0x7C, 0x00, 0x80, 0x20, 0x04, 0xFE, 0x40, 0xA0, 0x50, 0x18, 0x0C, 0x06,
  0x05, 0x02, 0xFE, 0x42, 0x20, 0x90, 0x48, 0x14, 0x0A, 0x03, 0x01, 0x3F,
  0x10, 0x28, 0x0A, 0x02, 0x80, 0x10, 0x02, 0x00, 0x60, 0x07, 0x00, 0x20,
  0x0A, 0x01, 0x80, 0x60, 0x24, 0x08, 0xFC, 0xFF, 0xC2, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x05, 0x04, 0x7C, 0x80, 0x60, 0x18,
  0x06, 0x02, 0x40, 0x90, 0x24, 0x10, 0x84, 0x21, 0x08, 0x81, 0x20, 0x48,
  0x14, 0x05, 0x00, 0xC0, 0x20, 0x81, 0x01, 0x81, 0x02, 0x82, 0x82, 0x82,
  0x82, 0x42, 0x82, 0x42, 0x42, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x24,
  0x24, 0x28, 0x28, 0x28, 0x28, 0x28, 0x28, 0x18, 0x18, 0x10, 0x10, 0x10,
  0x10, 0x80, 0x50, 0x24, 0x10, 0x84, 0x22, 0x04, 0x81, 0x40, 0x20, 0x0C,
  0x05, 0x01, 0x20, 0x88, 0x21, 0x10, 0x28, 0x0A, 0x01, 0x40, 0x28, 0x08,
  0x81, 0x10, 0x41, 0x08, 0x22, 0x02, 0x40, 0x50, 0x06, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0xFF, 0x80, 0x20, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10,
  0x08, 0x03, 0xFF, 0xEA, 0xAA, 0xAA, 0xAA, 0xAA, 0xC0, 0x82, 0x08, 0x10,
  0x41, 0x02, 0x08, 0x20, 0x41, 0x04, 0x08, 0x20, 0x81, 0x04, 0xE4, 0x92,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x9E, 0x20, 0xC3, 0x12, 0x49, 0x28, 0x61,
  0xFF, 0xA4, 0x3C, 0x42, 0x81, 0x01, 0x01, 0x3E, 0x41, 0x81, 0x81, 0x82,
  0x83, 0x7D, 0x81, 0x02, 0x04, 0x08, 0x1F, 0xA0, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0xFC, 0x3C, 0x42, 0x81, 0x81, 0x80, 0x80, 0x80,
  0x80, 0x81, 0x81, 0x42, 0x3C, 0x01, 0x01, 0x01, 0x01, 0x01, 0x3D, 0x43,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x3C, 0x42,
  0x81, 0x81, 0x81, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x40, 0x3E, 0x19, 0x10,
  0x84, 0x7D, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x40, 0x3D, 0x43, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01, 0x01, 0x42,
  0x3C, 0x81, 0x02, 0x04, 0x08, 0x17, 0xB0, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x82, 0x8F, 0xFF, 0x10, 0x00, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x2C, 0x81, 0x02, 0x04, 0x08, 0x10, 0xA2, 0x44, 0x91,
  0x43, 0x05, 0x09, 0x11, 0x22, 0x42, 0x82, 0xFF, 0xFF, 0x80, 0xBC, 0xF3,
  0x0C, 0x28, 0x20, 0x60, 0x81, 0x82, 0x06, 0x08, 0x18, 0x20, 0x60, 0x81,
  0x82, 0x06, 0x08, 0x18, 0x20, 0x60, 0x81, 0xBD, 0x86, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x3C, 0x42, 0x41, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x41, 0x42, 0x3C, 0xFD, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0F, 0xE8, 0x10, 0x20, 0x40, 0x3D, 0x43, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01,
  0xBC, 0x88, 0x88, 0x88, 0x88, 0x88, 0x7D, 0x06, 0x0C, 0x04, 0x07, 0x01,
  0x01, 0x03, 0x06, 0x0B, 0xE0, 0x44, 0x4F, 0x44, 0x44, 0x44, 0x44, 0x44,
  0x30, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x1B, 0xD0,
  0x81, 0x82, 0x82, 0x82, 0x42, 0x44, 0x44, 0x24, 0x28, 0x28, 0x10, 0x10,
  0x82, 0x0C, 0x10, 0xA1, 0x84, 0x8A, 0x24, 0x51, 0x24, 0x91, 0x24, 0x85,
  0x14, 0x30, 0xA1, 0x86, 0x0C, 0x10, 0x40, 0x80, 0x82, 0x42, 0x44, 0x24,
  0x28, 0x10, 0x10, 0x28, 0x24, 0x44, 0x82, 0x82, 0x81, 0x81, 0x82, 0x42,
  0x42, 0x44, 0x24, 0x24, 0x28, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20, 0xC0,
  0xFE, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80, 0xFF,
  0x08, 0x88, 0x42, 0x10, 0x84, 0x22, 0x20, 0x82, 0x10, 0x84, 0x21, 0x08,
  0x41, 0x04, 0xFF, 0xFF, 0xE0, 0xC0, 0x82, 0x08, 0x10, 0x41, 0x04, 0x10,
  0x40, 0xC4, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x23, 0x00, 0x70, 0x62,
  0x18, 0x4A, 0x0C,
};

const GFXglyph RobotoCondensed_Thin22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 16, 4, 2, -16 },
  { 3, 2, 4, 6, 2, -17 },
  { 4, 10, 16, 11, 1, -16 },
  { 24, 8, 20, 11, 1, -18 },
  { 44, 12, 16, 14, 1, -16 },
  { 68, 10, 16, 12, 1, -16 },
  { 88, 1, 4, 4, 1, -17 },
  { 89, 4, 22, 6, 2, -17 },
  { 100, 4, 22, 6, 0, -17 },
  { 111, 9, 8, 9, 0, -16 },
  { 120, 9, 11, 11, 1, -13 },
  { 133, 2, 4, 4, 1, -2 },
  { 134, 4, 1, 6, 1, -8 },
  { 135, 1, 1, 5, 2, -1 },
  { 136, 6, 17, 8, 1, -16 },
  { 149, 8, 16, 11, 1, -16 },
  { 165, 4, 16, 11, 2, -16 },
  { 173, 9, 16, 11, 1, -16 },
  { 191, 8, 16, 11, 1, -16 },
  { 207, 9, 16, 11, 1, -16 },
  { 225, 8, 16, 11, 2, -16 },
  { 241, 8, 16, 11, 1, -16 },
  { 257, 8, 16, 11, 1, -16 },
  { 273, 9, 16, 11, 1, -16 },
  { 291, 8, 16, 11, 1, -16 },
  { 307, 2, 11, 4, 1, -11 },
  { 310, 2, 13, 4, 1, -11 },
  { 314, 8, 8, 10, 1, -11 },
  { 322, 7, 6, 11, 2, -10 },
  { 328, 8, 9, 10, 1, -12 },
  { 337, 7, 16, 9, 1, -16 },
  { 351, 15, 20, 18, 1, -15 },
  { 389, 11, 16, 12, 0, -16 },
  { 411, 8, 16, 12, 2, -16 },
  { 427, 9, 16, 13, 2, -16 },
  { 445, 9, 16, 13, 2, -16 },
  { 463, 8, 16, 11, 2, -16 },
  { 479, 8, 16, 11, 2, -16 },
  { 495, 9, 16, 13, 2, -16 },
  { 513, 10, 16, 14, 2, -16 },
  { 533, 1, 16, 5, 2, -16 },
  { 535, 8, 16, 11, 1, -16 },
  { 551, 9, 16, 12, 2, -16 },
  { 569, 7, 16, 10, 2, -16 },
  { 583, 12, 16, 16, 2, -16 },
  { 607, 10, 16, 14, 2, -16 },
  { 627, 10, 16, 13, 1, -16 },
  { 647, 9, 16, 12, 2, -16 },
  { 665, 10, 19, 13, 1, -16 },
  { 689, 9, 16, 13, 2, -16 },
  { 707, 10, 16, 11, 1, -16 },
  { 727, 10, 16, 12, 1, -16 },
  { 747, 9, 16, 13, 2, -16 },
  { 765, 10, 16, 12, 1, -16 },
  { 785, 16, 16, 17, 1, -16 },
  { 817, 10, 16, 12, 1, -16 },
  { 837, 11, 16, 12, 0, -16 },
  { 859, 10, 16, 12, 1, -16 },
  { 879, 2, 21, 4, 2, -18 },
  { 885, 6, 17, 7, 1, -16 },
  { 898, 3, 21, 4, 0, -18 },
  { 906, 6, 8, 8, 1, -16 },
  { 912, 8, 1, 8, 0, 0 },
  { 913, 2, 3, 6, 2, -17 },
  { 914, 8, 12, 10, 1, -12 },
  { 926, 7, 17, 11, 2, -17 },
  { 941, 8, 12, 10, 1, -12 },
  { 953, 8, 17, 11, 1, -17 },
  { 970, 8, 12, 10, 1, -12 },
  { 982, 5, 17, 6, 1, -17 },
  { 993, 8, 16, 11, 1, -12 },
  { 1009, 7, 17, 11, 2, -17 },
  { 1024, 1, 16, 4, 2, -16 },
  { 1026, 4, 20, 4, -1, -16 },
  { 1036, 7, 17, 9, 2, -17 },
  { 1051, 1, 17, 4, 2, -17 },
  { 1054, 14, 12, 17, 2, -12 },
  { 1075, 7, 12, 11, 2, -12 },
  { 1086, 8, 12, 11, 1, -12 },
  { 1098, 7, 16, 11, 2, -12 },
  { 1112, 8, 16, 11, 1, -12 },
  { 1128, 4, 12, 7, 2, -12 },
  { 1134, 7, 12, 10, 1, -12 },
  { 1145, 4, 15, 6, 1, -15 },
  { 1153, 7, 12, 11, 2, -12 },
  { 1164, 8, 12, 9, 1, -12 },
  { 1176, 13, 12, 15, 1, -12 },
  { 1196, 8, 12, 9, 1, -12 },
  { 1208, 8, 16, 9, 1, -12 },
  { 1224, 8, 12, 9, 1, -12 },
  { 1236, 5, 22, 6, 1, -17 },
  { 1250, 1, 19, 4, 2, -16 },
  { 1253, 6, 22, 6, 0, -17 },
  { 1270, 10, 4, 13, 2, -9 },
};

const GFXfont RobotoCondensed_Thin22pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin22pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOCONDENSED_THIN22PT7B_H_
