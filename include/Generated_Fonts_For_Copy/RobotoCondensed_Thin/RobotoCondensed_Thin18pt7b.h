#ifndef _ROBOTOCONDENSED_THIN18PT7B_H_
#define _ROBOTOCONDENSED_THIN18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x88, 0xB6, 0xD0, 0x02, 0x22, 0x24, 0x7E, 0x24, 0x24, 0x24,
  0x24, 0x44, 0x78, 0x48, 0x48, 0x48, 0x10, 0x20, 0xA2, 0x28, 0x30, 0x60,
  0x20, 0x38, 0x08, 0x0C, 0x18, 0x30, 0x9A, 0x08, 0x10, 0x60, 0x24, 0x09,
  0x12, 0x48, 0x94, 0x19, 0x00, 0x80, 0x2E, 0x12, 0x45, 0x12, 0x44, 0x09,
  0x03, 0x80, 0x38, 0x44, 0x44, 0x48, 0x48, 0x30, 0x50, 0x51, 0x89, 0x85,
  0x82, 0x86, 0x79, 0xF0, 0x12, 0x44, 0x48, 0x88, 0x88, 0x88, 0x84, 0x44,
  0x21, 0x04, 0x22, 0x21, 0x11, 0x11, 0x11, 0x12, 0x22, 0x48, 0x10, 0x23,
  0x49, 0xE1, 0x84, 0x91, 0x00, 0x10, 0x20, 0x43, 0xE1, 0x02, 0x04, 0x08,
  0xF0, 0x40, 0x80, 0x00, 0x42, 0x11, 0x08, 0x44, 0x21, 0x10, 0x84, 0x00,
  0x38, 0x8A, 0x14, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x12, 0x23, 0x80,
  0x74, 0x92, 0x49, 0x24, 0x90, 0x79, 0x0A, 0x14, 0x10, 0x40, 0x82, 0x04,
  0x10, 0x40, 0x82, 0x0F, 0xC0, 0x38, 0x8A, 0x0C, 0x10, 0x20, 0x86, 0x02,
  0x02, 0x06, 0x0C, 0x27, 0x80, 0x00, 0x10, 0x50, 0xA2, 0x48, 0x91, 0x42,
  0xFC, 0x08, 0x10, 0x20, 0x00, 0xFA, 0x08, 0x20, 0x83, 0xC0, 0x81, 0x04,
  0x18, 0x61, 0x78, 0x18, 0x41, 0x04, 0x08, 0x17, 0x31, 0x41, 0x83, 0x06,
  0x0A, 0x23, 0x80, 0x7E, 0x04, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x20,
  0x81, 0x00, 0x00, 0x79, 0x0A, 0x0C, 0x18, 0x30, 0x9E, 0x22, 0x83, 0x06,
  0x0C, 0x17, 0xC0, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x7A, 0x08,
  0x10, 0x47, 0x00, 0x80, 0x80, 0x80, 0xF0, 0x04, 0x66, 0x20, 0x60, 0x60,
  0x40, 0x78, 0x07, 0x80, 0x81, 0x81, 0x81, 0x19, 0x88, 0x00, 0x74, 0x42,
  0x10, 0x84, 0x44, 0x20, 0x00, 0x02, 0x00, 0x0F, 0xC1, 0x02, 0x20, 0x14,
  0x01, 0x47, 0x18, 0x89, 0x88, 0x99, 0x09, 0x91, 0x19, 0x11, 0x91, 0x18,
  0xEE, 0x40, 0x04, 0x00, 0x20, 0x01, 0xF0, 0x08, 0x04, 0x05, 0x02, 0x81,
  0x21, 0x10, 0x88, 0x42, 0x3D, 0x20, 0x90, 0x28, 0x10, 0x08, 0xF9, 0x0A,
  0x14, 0x28, 0x50, 0xBE, 0x42, 0x83, 0x06, 0x0C, 0x27, 0x80, 0x3E, 0x41,
  0x81, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x81, 0x41, 0x3E, 0x79,
  0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x27, 0x80, 0x7A,
  0x08, 0x20, 0x82, 0x0F, 0xA0, 0x82, 0x08, 0x20, 0x78, 0x7A, 0x08, 0x20,
  0x82, 0x0F, 0xA0, 0x82, 0x08, 0x20, 0x00, 0x3E, 0x41, 0x41, 0x80, 0x80,
  0x80, 0x80, 0x83, 0x80, 0x81, 0x41, 0x41, 0x3E, 0x01, 0x06, 0x0C, 0x18,
  0x30, 0x7F, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x00, 0x7F, 0xF0, 0x00, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x18, 0x61, 0x78, 0x03, 0x0A, 0x24, 0x8A,
  0x14, 0x38, 0x48, 0x91, 0x12, 0x14, 0x20, 0x20, 0x02, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x78, 0x00, 0x60, 0x18, 0x0F, 0x03, 0xC1,
  0x68, 0x5A, 0x16, 0x89, 0x92, 0x65, 0x19, 0x46, 0x21, 0x08, 0x40, 0x81,
  0x81, 0xC1, 0xC1, 0xA1, 0x91, 0x91, 0x89, 0x89, 0x85, 0x85, 0x83, 0x01,
  0x3E, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41,
  0x3E, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x61, 0x7C, 0x81, 0x02, 0x04, 0x00,
  0x00, 0x3E, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x41, 0x3E, 0x02, 0x01, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0xBE, 0x44, 0x89,
  0x0A, 0x14, 0x10, 0x20, 0x7C, 0x82, 0x80, 0x80, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x01, 0x81, 0x82, 0x7C, 0x7E, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x01, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x17, 0xC0, 0x80, 0xA0, 0x50, 0x28, 0x22, 0x11,
  0x08, 0x88, 0x44, 0x12, 0x0A, 0x05, 0x01, 0x00, 0x80, 0x80, 0x04, 0x30,
  0xA1, 0x85, 0x0A, 0x28, 0x91, 0x24, 0x89, 0x24, 0x89, 0x24, 0x50, 0xA2,
  0x85, 0x0C, 0x30, 0x40, 0x82, 0x04, 0x00, 0x81, 0x82, 0x42, 0x24, 0x28,
  0x18, 0x10, 0x18, 0x24, 0x44, 0x42, 0x82, 0x81, 0x80, 0xA0, 0x90, 0x44,
  0x42, 0x20, 0xA0, 0x50, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7E,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0xFE,
  0xD2, 0x49, 0x24, 0x92, 0x49, 0x24, 0x98, 0x04, 0x21, 0x04, 0x21, 0x04,
  0x21, 0x04, 0x21, 0x00, 0x55, 0x55, 0x55, 0x55, 0x50, 0x23, 0x15, 0x29,
  0x44, 0x7C, 0x48, 0x7A, 0x18, 0x41, 0x7E, 0x18, 0x61, 0x85, 0xE0, 0x81,
  0x02, 0x04, 0x0B, 0x98, 0xA0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x5F, 0x00,
  0x7A, 0x18, 0x20, 0x82, 0x08, 0x20, 0x85, 0xE0, 0x00, 0x10, 0x41, 0x7E,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xE0, 0x7A, 0x18, 0x61, 0xFE, 0x08,
  0x20, 0x81, 0xF0, 0x24, 0x44, 0x64, 0x44, 0x44, 0x44, 0x44, 0x7A, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x85, 0xF0, 0x41, 0x05, 0xE0, 0x82, 0x08, 0x20,
  0xBB, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x00, 0x87, 0xF8, 0x20, 0x00,
  0x49, 0x24, 0x92, 0x49, 0x38, 0x82, 0x08, 0x20, 0x86, 0x29, 0x28, 0xE2,
  0x89, 0x22, 0x8A, 0x10, 0x7F, 0xF8, 0xB9, 0xEC, 0x61, 0x84, 0x18, 0x21,
  0x82, 0x18, 0x21, 0x82, 0x18, 0x21, 0x82, 0x18, 0x01, 0xBB, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x00, 0x79, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x84, 0xF0, 0xB9, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x85, 0xF2, 0x04,
  0x08, 0x10, 0x00, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xF0, 0x41,
  0x04, 0x00, 0xAC, 0x88, 0x88, 0x88, 0x88, 0x7A, 0x18, 0x60, 0x60, 0x60,
  0x41, 0x85, 0xE0, 0x02, 0x62, 0x22, 0x22, 0x22, 0x22, 0x82, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x45, 0xE0, 0x00, 0x85, 0x0A, 0x22, 0x44, 0x8A, 0x0C,
  0x18, 0x20, 0x80, 0x63, 0x18, 0xC6, 0x32, 0x52, 0x94, 0xA5, 0x29, 0x8A,
  0x21, 0x08, 0x40, 0x86, 0x24, 0x8C, 0x20, 0x85, 0x12, 0x8A, 0x10, 0x00,
  0x85, 0x0A, 0x22, 0x44, 0x8A, 0x0C, 0x18, 0x10, 0x40, 0x81, 0x04, 0x00,
  0x74, 0x20, 0x84, 0x10, 0x84, 0x10, 0x83, 0xE0, 0x12, 0x44, 0x44, 0x44,
  0x84, 0x44, 0x44, 0x44, 0x21, 0xFF, 0xFE, 0x02, 0x08, 0x42, 0x10, 0x84,
  0x18, 0x88, 0x42, 0x10, 0x84, 0x44, 0x00, 0x70, 0x89, 0x87,
};

const GFXglyph RobotoCondensed_Thin18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 13, 3, 1, -13 },
  { 3, 3, 4, 5, 1, -14 },
  { 5, 8, 13, 9, 1, -13 },
  { 18, 7, 17, 9, 1, -15 },
  { 33, 10, 13, 12, 1, -13 },
  { 50, 8, 13, 10, 1, -13 },
  { 63, 1, 4, 3, 1, -14 },
  { 64, 4, 18, 5, 1, -14 },
  { 73, 4, 18, 5, 0, -14 },
  { 82, 7, 7, 8, 0, -13 },
  { 89, 7, 8, 9, 1, -10 },
  { 96, 1, 4, 3, 1, -1 },
  { 97, 3, 1, 5, 1, -7 },
  { 98, 1, 1, 4, 1, -1 },
  { 99, 5, 14, 6, 0, -13 },
  { 108, 7, 13, 9, 1, -13 },
  { 120, 3, 13, 9, 2, -13 },
  { 125, 7, 13, 9, 1, -13 },
  { 137, 7, 13, 9, 1, -13 },
  { 149, 7, 13, 9, 1, -13 },
  { 161, 6, 13, 9, 2, -13 },
  { 171, 7, 13, 9, 1, -13 },
  { 183, 7, 13, 9, 1, -13 },
  { 195, 7, 13, 9, 1, -13 },
  { 207, 7, 13, 9, 1, -13 },
  { 219, 1, 9, 3, 1, -9 },
  { 221, 1, 12, 3, 1, -9 },
  { 223, 6, 7, 8, 1, -9 },
  { 229, 6, 3, 9, 1, -7 },
  { 232, 6, 7, 8, 1, -9 },
  { 238, 5, 13, 7, 1, -13 },
  { 247, 12, 16, 14, 1, -12 },
  { 271, 9, 13, 10, 0, -13 },
  { 286, 7, 13, 10, 2, -13 },
  { 298, 8, 13, 10, 1, -13 },
  { 311, 7, 13, 10, 2, -13 },
  { 323, 6, 13, 9, 2, -13 },
  { 333, 6, 13, 9, 2, -13 },
  { 343, 8, 13, 11, 1, -13 },
  { 356, 7, 13, 11, 2, -13 },
  { 368, 1, 13, 4, 2, -13 },
  { 370, 6, 13, 9, 1, -13 },
  { 380, 7, 13, 10, 2, -13 },
  { 392, 6, 13, 8, 2, -13 },
  { 402, 10, 13, 13, 2, -13 },
  { 419, 8, 13, 11, 2, -13 },
  { 432, 8, 13, 11, 1, -13 },
  { 445, 7, 13, 10, 2, -13 },
  { 457, 8, 15, 11, 1, -13 },
  { 472, 7, 13, 10, 2, -13 },
  { 484, 8, 13, 9, 1, -13 },
  { 497, 8, 13, 9, 1, -13 },
  { 510, 7, 13, 11, 2, -13 },
  { 522, 9, 13, 10, 0, -13 },
  { 537, 13, 13, 14, 1, -13 },
  { 559, 8, 13, 9, 1, -13 },
  { 572, 9, 13, 9, 0, -13 },
  { 587, 8, 13, 9, 1, -13 },
  { 600, 3, 18, 4, 1, -15 },
  { 607, 5, 14, 6, 1, -13 },
  { 616, 2, 18, 4, 0, -15 },
  { 621, 5, 6, 7, 1, -13 },
  { 625, 7, 1, 7, 0, 0 },
  { 626, 3, 2, 5, 1, -13 },
  { 627, 6, 10, 8, 1, -10 },
  { 635, 7, 14, 9, 1, -14 },
  { 648, 6, 10, 8, 1, -10 },
  { 656, 6, 14, 9, 1, -14 },
  { 667, 6, 10, 8, 1, -10 },
  { 675, 4, 14, 5, 1, -14 },
  { 682, 6, 14, 9, 1, -10 },
  { 693, 6, 14, 9, 1, -14 },
  { 704, 1, 14, 4, 1, -14 },
  { 706, 3, 18, 4, -1, -14 },
  { 713, 6, 14, 8, 1, -14 },
  { 724, 1, 14, 4, 1, -14 },
  { 726, 12, 10, 14, 1, -10 },
  { 741, 6, 10, 9, 1, -10 },
  { 749, 7, 10, 9, 1, -10 },
  { 758, 7, 14, 9, 1, -10 },
  { 771, 6, 14, 9, 1, -10 },
  { 782, 4, 10, 5, 1, -10 },
  { 787, 6, 10, 8, 1, -10 },
  { 795, 4, 12, 5, 0, -12 },
  { 801, 6, 10, 9, 1, -10 },
  { 809, 7, 10, 8, 0, -10 },
  { 818, 10, 10, 12, 1, -10 },
  { 831, 6, 10, 8, 1, -10 },
  { 839, 7, 14, 8, 0, -10 },
  { 852, 6, 10, 8, 1, -10 },
  { 860, 4, 18, 5, 1, -14 },
  { 869, 1, 15, 4, 1, -13 },
  { 871, 5, 18, 5, 0, -14 },
  { 883, 8, 3, 11, 1, -7 },
};

const GFXfont RobotoCondensed_Thin18pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin18pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin18pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOCONDENSED_THIN18PT7B_H_
