#ifndef _ROBOTOCONDENSED_THIN44PT7B_H_
#define _ROBOTOCONDENSED_THIN44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0xC7, 0x1C, 0x71,
  0xC6, 0x18, 0x61, 0x84, 0x00, 0x40, 0xC0, 0x02, 0x04, 0x00, 0x30, 0x20,
  0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0x40, 0x02, 0x06, 0x00, 0x10,
  0x20, 0x01, 0x81, 0x01, 0xFF, 0xFF, 0xC0, 0x40, 0x40, 0x02, 0x02, 0x00,
  0x10, 0x30, 0x00, 0x81, 0x00, 0x04, 0x08, 0x00, 0x40, 0x40, 0x02, 0x02,
  0x00, 0x10, 0x10, 0x00, 0x80, 0x80, 0x04, 0x0C, 0x00, 0x20, 0x40, 0x7F,
  0xFF, 0xF0, 0x10, 0x10, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x20, 0x60,
  0x01, 0x02, 0x00, 0x08, 0x10, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x20,
  0x20, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07, 0xE0,
  0x18, 0x38, 0x30, 0x0C, 0x60, 0x04, 0x40, 0x06, 0x40, 0x02, 0xC0, 0x02,
  0xC0, 0x02, 0xC0, 0x03, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x02, 0xC0, 0x02, 0x40, 0x06, 0x20, 0x0C, 0x18, 0x18, 0x07, 0xE0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x1E, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x60, 0x80, 0x00, 0x40, 0x40, 0x00, 0x40, 0x40, 0x20, 0x40,
  0x40, 0x40, 0xC0, 0x40, 0x40, 0xC0, 0x40, 0x80, 0xC0, 0x40, 0x80, 0x40,
  0x41, 0x00, 0x40, 0x43, 0x00, 0x40, 0x42, 0x00, 0x60, 0x86, 0x00, 0x31,
  0x84, 0x00, 0x1F, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x78, 0x00,
  0x10, 0xC4, 0x00, 0x21, 0x02, 0x00, 0x61, 0x03, 0x00, 0x43, 0x01, 0x00,
  0xC2, 0x01, 0x00, 0x82, 0x01, 0x01, 0x02, 0x01, 0x01, 0x02, 0x01, 0x02,
  0x02, 0x01, 0x02, 0x03, 0x01, 0x00, 0x01, 0x03, 0x00, 0x01, 0x82, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x63, 0x00, 0x08, 0x08,
  0x00, 0x80, 0x80, 0x10, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x01, 0x00,
  0x80, 0x10, 0x08, 0x00, 0x81, 0x00, 0x08, 0x20, 0x00, 0xC4, 0x00, 0x04,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x58, 0x00, 0x08, 0x80, 0x01,
  0x04, 0x02, 0x20, 0x60, 0x26, 0x03, 0x02, 0x40, 0x10, 0x24, 0x00, 0x86,
  0x40, 0x04, 0x4C, 0x00, 0x64, 0x40, 0x02, 0xC4, 0x00, 0x18, 0x40, 0x01,
  0x86, 0x00, 0x3C, 0x30, 0x04, 0x41, 0xC1, 0x82, 0x07, 0xE0, 0x10, 0xFF,
  0x80, 0x01, 0x02, 0x06, 0x04, 0x08, 0x08, 0x10, 0x10, 0x30, 0x20, 0x20,
  0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60, 0x20,
  0x20, 0x30, 0x10, 0x10, 0x08, 0x08, 0x04, 0x06, 0x02, 0x01, 0x80, 0x40,
  0x60, 0x20, 0x10, 0x10, 0x08, 0x08, 0x0C, 0x04, 0x04, 0x06, 0x02, 0x02,
  0x02, 0x02, 0x03, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x08,
  0x08, 0x10, 0x10, 0x20, 0x60, 0x40, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x03, 0x02, 0x0E, 0x71, 0x38,
  0x07, 0xF0, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x4C, 0x00, 0x63, 0x00, 0x60,
  0x80, 0x20, 0x20, 0x30, 0x18, 0x10, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x03, 0xFF, 0xFF, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x24, 0x92, 0xD2, 0x80, 0xFF, 0x80, 0xF8, 0x00, 0x10, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x07, 0xC0,
  0x1C, 0x30, 0x30, 0x18, 0x20, 0x0C, 0x40, 0x04, 0x40, 0x06, 0xC0, 0x02,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0xC0, 0x02,
  0x40, 0x06, 0x40, 0x04, 0x20, 0x0C, 0x30, 0x18, 0x1C, 0x30, 0x07, 0xC0,
  0x01, 0x83, 0xCE, 0x7C, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x0F,
  0xC0, 0x18, 0x30, 0x20, 0x18, 0x40, 0x0C, 0xC0, 0x04, 0x80, 0x04, 0x80,
  0x06, 0x80, 0x02, 0x80, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0x03, 0xF0, 0x07, 0x0C, 0x06, 0x01, 0x06, 0x00, 0x42, 0x00, 0x33,
  0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x07, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xA0, 0x00, 0x98, 0x00, 0x44, 0x00,
  0x61, 0x00, 0x60, 0x60, 0xE0, 0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x40, 0x00, 0xD0, 0x00, 0x24, 0x00, 0x11, 0x00, 0x04, 0x40, 0x02,
  0x10, 0x01, 0x84, 0x00, 0x41, 0x00, 0x30, 0x40, 0x08, 0x10, 0x04, 0x04,
  0x01, 0x01, 0x00, 0x80, 0x40, 0x60, 0x10, 0x10, 0x04, 0x0C, 0x01, 0x02,
  0x00, 0x41, 0x00, 0x10, 0xC0, 0x04, 0x3F, 0xFF, 0xF0, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x3F, 0xFE, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x7E, 0x05, 0x07, 0x0C, 0x03, 0x10, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x0D, 0x00, 0x13, 0x00, 0x62, 0x00, 0x83,
  0x06, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x03, 0x80, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x87, 0xE0, 0x8C, 0x38, 0xB0, 0x0C, 0xA0, 0x04, 0xC0, 0x02,
  0x80, 0x02, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0x40, 0x02, 0x40, 0x06, 0x20, 0x04,
  0x30, 0x08, 0x0C, 0x38, 0x07, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x03, 0xF0, 0x06, 0x0C, 0x06, 0x01, 0x86, 0x00, 0x42, 0x00, 0x32, 0x00,
  0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x44,
  0x00, 0x22, 0x00, 0x20, 0x80, 0x20, 0x30, 0x60, 0x07, 0xE0, 0x0C, 0x1C,
  0x18, 0x03, 0x08, 0x00, 0xC8, 0x00, 0x24, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x4C, 0x00, 0x63,
  0x00, 0x60, 0xE0, 0xE0, 0x1F, 0xC0, 0x03, 0xE0, 0x06, 0x1C, 0x06, 0x03,
  0x06, 0x00, 0xC2, 0x00, 0x22, 0x00, 0x19, 0x00, 0x04, 0x80, 0x02, 0xC0,
  0x01, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1A, 0x00, 0x0D,
  0x00, 0x06, 0x80, 0x07, 0x60, 0x03, 0x90, 0x02, 0x84, 0x03, 0x41, 0x87,
  0x20, 0x7E, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x03, 0x00, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x49, 0x2D, 0x68, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x02, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x00, 0x80, 0x00, 0x0F, 0x80, 0xC3, 0x08, 0x0C, 0x80, 0x24, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x20, 0x06, 0x00,
  0x00, 0x40, 0x30, 0x00, 0x01, 0x80, 0x80, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x04, 0x30, 0x00, 0x00, 0x10, 0x80, 0x0F, 0x00, 0x22, 0x00, 0xC3, 0x00,
  0x90, 0x06, 0x04, 0x02, 0x40, 0x30, 0x10, 0x09, 0x00, 0x80, 0x40, 0x2C,
  0x04, 0x01, 0x00, 0xE0, 0x10, 0x04, 0x03, 0x80, 0x40, 0x10, 0x06, 0x02,
  0x00, 0x40, 0x18, 0x08, 0x01, 0x00, 0xE0, 0x20, 0x04, 0x03, 0x80, 0x80,
  0x10, 0x0A, 0x02, 0x00, 0x40, 0x28, 0x08, 0x03, 0x00, 0xA0, 0x20, 0x0C,
  0x02, 0x80, 0x80, 0x30, 0x0A, 0x02, 0x01, 0xC0, 0x48, 0x0C, 0x05, 0x01,
  0x20, 0x10, 0x24, 0x08, 0xC0, 0x63, 0x08, 0x41, 0x00, 0x78, 0x1E, 0x04,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00,
  0x0C, 0x80, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x10, 0x80, 0x01, 0x04,
  0x00, 0x08, 0x20, 0x00, 0x40, 0x80, 0x04, 0x04, 0x00, 0x20, 0x20, 0x01,
  0x01, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x80, 0x60, 0x04,
  0x02, 0x00, 0x20, 0x10, 0x01, 0x81, 0x80, 0x04, 0x0F, 0xFF, 0xE0, 0x40,
  0x01, 0x06, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x18, 0x00, 0x04,
  0x80, 0x00, 0x24, 0x00, 0x01, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x20, 0xFF,
  0xE0, 0x40, 0x1C, 0x20, 0x03, 0x10, 0x00, 0xC8, 0x00, 0x24, 0x00, 0x12,
  0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0xD0, 0x00,
  0x48, 0x00, 0x64, 0x00, 0x22, 0x00, 0x61, 0xFF, 0xE0, 0x80, 0x0C, 0x40,
  0x03, 0x20, 0x00, 0xD0, 0x00, 0x28, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x68, 0x00,
  0x64, 0x00, 0xE3, 0xFF, 0xC0, 0x03, 0xF8, 0x01, 0xC0, 0xC0, 0x60, 0x06,
  0x18, 0x00, 0x42, 0x00, 0x04, 0xC0, 0x00, 0x90, 0x00, 0x1A, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x70, 0x00, 0x0A,
  0x00, 0x01, 0x40, 0x00, 0x6C, 0x00, 0x08, 0x80, 0x01, 0x18, 0x00, 0x41,
  0x80, 0x18, 0x1C, 0x0C, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x20, 0x0E, 0x08,
  0x00, 0x42, 0x00, 0x08, 0x80, 0x01, 0x20, 0x00, 0x68, 0x00, 0x0A, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xA0, 0x00, 0x68, 0x00, 0x12, 0x00, 0x08, 0x80, 0x06,
  0x20, 0x0E, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF,
  0xFC, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xFF, 0xFE, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x03, 0xF8, 0x01,
  0xC1, 0xC0, 0x40, 0x0C, 0x10, 0x00, 0x46, 0x00, 0x0C, 0x80, 0x00, 0xA0,
  0x00, 0x14, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x28, 0x00, 0x05, 0x80,
  0x00, 0x90, 0x00, 0x31, 0x80, 0x1C, 0x1C, 0x0E, 0x00, 0xFF, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x05, 0x00, 0x13, 0x00, 0x62, 0x00, 0x83,
  0x06, 0x01, 0xF0, 0x00, 0x80, 0x00, 0x90, 0x00, 0x32, 0x00, 0x0C, 0x40,
  0x03, 0x08, 0x00, 0x41, 0x00, 0x10, 0x20, 0x04, 0x04, 0x01, 0x80, 0x80,
  0x60, 0x10, 0x18, 0x02, 0x02, 0x00, 0x40, 0x80, 0x08, 0x20, 0x01, 0x08,
  0x00, 0x23, 0x80, 0x04, 0xD0, 0x00, 0xB1, 0x00, 0x1C, 0x30, 0x03, 0x03,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x60, 0x20, 0x06, 0x04, 0x00,
  0x40, 0x80, 0x04, 0x10, 0x00, 0xC2, 0x00, 0x0C, 0x40, 0x00, 0x88, 0x00,
  0x09, 0x00, 0x01, 0xA0, 0x00, 0x10, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x3F, 0xFF, 0x80, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xB4, 0x00, 0x00, 0x5A, 0x00, 0x00, 0x2D, 0x80, 0x00, 0x26,
  0x40, 0x00, 0x13, 0x20, 0x00, 0x19, 0x88, 0x00, 0x08, 0xC4, 0x00, 0x04,
  0x63, 0x00, 0x04, 0x30, 0x80, 0x02, 0x18, 0x40, 0x01, 0x0C, 0x30, 0x01,
  0x06, 0x08, 0x00, 0x83, 0x04, 0x00, 0xC1, 0x81, 0x00, 0x40, 0xC0, 0x80,
  0x20, 0x60, 0x40, 0x30, 0x30, 0x10, 0x10, 0x18, 0x08, 0x08, 0x0C, 0x06,
  0x08, 0x06, 0x01, 0x04, 0x03, 0x00, 0x86, 0x01, 0x80, 0x22, 0x00, 0xC0,
  0x11, 0x00, 0x60, 0x09, 0x80, 0x30, 0x02, 0x80, 0x18, 0x01, 0x40, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x02, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0xD0, 0x00, 0x19, 0x00, 0x03, 0x20, 0x00, 0x62, 0x00, 0x0C, 0x60,
  0x01, 0x84, 0x00, 0x30, 0xC0, 0x06, 0x08, 0x00, 0xC0, 0x80, 0x18, 0x18,
  0x03, 0x01, 0x00, 0x60, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x20, 0x30, 0x04,
  0x06, 0x00, 0x40, 0xC0, 0x0C, 0x18, 0x00, 0x83, 0x00, 0x08, 0x60, 0x01,
  0x0C, 0x00, 0x11, 0x80, 0x03, 0x30, 0x00, 0x26, 0x00, 0x06, 0xC0, 0x00,
  0x58, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x01, 0xF8, 0x00, 0xE0,
  0x60, 0x18, 0x01, 0x83, 0x00, 0x08, 0x20, 0x00, 0x44, 0x00, 0x06, 0x40,
  0x00, 0x2C, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00,
  0x06, 0x20, 0x00, 0x43, 0x00, 0x08, 0x18, 0x01, 0x80, 0xE0, 0x60, 0x03,
  0xF8, 0x00, 0xFF, 0xF0, 0x40, 0x0E, 0x20, 0x01, 0x90, 0x00, 0x68, 0x00,
  0x14, 0x00, 0x0A, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x0D, 0x00, 0x0C,
  0x80, 0x1C, 0x7F, 0xF8, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xE0,
  0x60, 0x18, 0x01, 0x83, 0x00, 0x08, 0x20, 0x00, 0x44, 0x00, 0x06, 0x40,
  0x00, 0x2C, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x2C, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00,
  0x06, 0x20, 0x00, 0x43, 0x00, 0x08, 0x18, 0x01, 0x80, 0xE0, 0x60, 0x03,
  0xFE, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0xFF, 0xF0, 0x20, 0x07, 0x08, 0x00, 0x62,
  0x00, 0x0C, 0x80, 0x01, 0x20, 0x00, 0x68, 0x00, 0x0A, 0x00, 0x02, 0x80,
  0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x01, 0xA0, 0x00,
  0x48, 0x00, 0x32, 0x00, 0x18, 0x80, 0x0C, 0x3F, 0xFC, 0x08, 0x03, 0x02,
  0x00, 0x40, 0x80, 0x18, 0x20, 0x02, 0x08, 0x00, 0xC2, 0x00, 0x10, 0x80,
  0x02, 0x20, 0x00, 0x88, 0x00, 0x12, 0x00, 0x06, 0x80, 0x00, 0xA0, 0x00,
  0x38, 0x00, 0x04, 0x03, 0xF8, 0x01, 0xC0, 0xC0, 0x60, 0x06, 0x10, 0x00,
  0x46, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x03, 0x40, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x28, 0x00, 0x0D, 0x00, 0x01, 0x10, 0x00, 0x61, 0x80, 0x18,
  0x1C, 0x0E, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xF0,
  0x00, 0x24, 0x00, 0x09, 0x80, 0x04, 0x30, 0x03, 0x07, 0x03, 0x00, 0x7F,
  0x00, 0x80, 0x00, 0x0A, 0x00, 0x00, 0xD0, 0x00, 0x04, 0x80, 0x00, 0x26,
  0x00, 0x03, 0x10, 0x00, 0x10, 0x80, 0x00, 0x86, 0x00, 0x04, 0x10, 0x00,
  0x40, 0x80, 0x02, 0x06, 0x00, 0x10, 0x10, 0x01, 0x80, 0x80, 0x08, 0x06,
  0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x10, 0x18,
  0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x10, 0x60, 0x00, 0x82, 0x00, 0x04,
  0x10, 0x00, 0x10, 0x80, 0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x12, 0x00,
  0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x40, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x03, 0x60,
  0x01, 0x40, 0x02, 0x20, 0x01, 0x40, 0x02, 0x20, 0x02, 0x40, 0x02, 0x20,
  0x02, 0x20, 0x06, 0x20, 0x02, 0x20, 0x04, 0x30, 0x06, 0x20, 0x04, 0x10,
  0x04, 0x20, 0x04, 0x10, 0x04, 0x10, 0x0C, 0x10, 0x04, 0x10, 0x08, 0x18,
  0x0C, 0x10, 0x08, 0x08, 0x08, 0x10, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x18, 0x0C, 0x18, 0x08, 0x10, 0x04, 0x10, 0x08, 0x10, 0x04,
  0x10, 0x04, 0x10, 0x04, 0x10, 0x04, 0x30, 0x04, 0x30, 0x04, 0x20, 0x06,
  0x20, 0x06, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02,
  0x60, 0x02, 0x40, 0x03, 0x40, 0x03, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01,
  0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x40, 0x00, 0x11, 0x00, 0x01, 0x8C, 0x00, 0x08, 0x20,
  0x00, 0x81, 0x80, 0x0C, 0x04, 0x00, 0x40, 0x10, 0x06, 0x00, 0xC0, 0x20,
  0x02, 0x02, 0x00, 0x18, 0x30, 0x00, 0x41, 0x00, 0x01, 0x18, 0x00, 0x0C,
  0x80, 0x00, 0x28, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x50, 0x00,
  0x06, 0xC0, 0x00, 0x22, 0x00, 0x03, 0x08, 0x00, 0x10, 0x40, 0x01, 0x01,
  0x00, 0x18, 0x0C, 0x00, 0x80, 0x20, 0x0C, 0x00, 0x80, 0x40, 0x04, 0x04,
  0x00, 0x10, 0x60, 0x00, 0xC2, 0x00, 0x02, 0x30, 0x00, 0x19, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0x98, 0x00, 0x0C, 0x40, 0x00, 0x43,
  0x00, 0x06, 0x08, 0x00, 0x20, 0x60, 0x03, 0x01, 0x00, 0x10, 0x0C, 0x01,
  0x80, 0x20, 0x08, 0x01, 0x80, 0xC0, 0x04, 0x04, 0x00, 0x30, 0x60, 0x00,
  0x82, 0x00, 0x06, 0x30, 0x00, 0x11, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF,
  0xF8, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x3E, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0,
  0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xC0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x90, 0x09, 0x00, 0x90, 0x10, 0x81, 0x08, 0x10, 0x82, 0x04,
  0x20, 0x42, 0x04, 0x40, 0x24, 0x02, 0x40, 0x28, 0x01, 0xFF, 0xFF, 0xC1,
  0x82, 0x04, 0x18, 0x20, 0x07, 0xE0, 0x38, 0x30, 0xC0, 0x33, 0x00, 0x24,
  0x00, 0x28, 0x00, 0x50, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x1F,
  0xF8, 0xE0, 0x12, 0x00, 0x28, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x1A, 0x00, 0x54, 0x01, 0x26, 0x0C, 0x47, 0xE0, 0x80,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC7, 0xE0, 0xCC, 0x18,
  0xF0, 0x0C, 0xE0, 0x04, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xE0, 0x04,
  0xF0, 0x0C, 0xDC, 0x38, 0xC7, 0xE0, 0x07, 0xE0, 0x1C, 0x18, 0x30, 0x0C,
  0x20, 0x06, 0x40, 0x02, 0x40, 0x02, 0x40, 0x03, 0x80, 0x03, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x03, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x20, 0x06, 0x30, 0x0C,
  0x1C, 0x18, 0x07, 0xE0, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x3F,
  0x09, 0xC1, 0x92, 0x01, 0xA8, 0x01, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x14, 0x00, 0x68, 0x00,
  0xC8, 0x02, 0x8C, 0x19, 0x0F, 0xC2, 0x07, 0xE0, 0x0C, 0x18, 0x30, 0x0C,
  0x20, 0x06, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x06,
  0x0C, 0x1C, 0x03, 0xF0, 0x03, 0xE0, 0xC0, 0x20, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x03, 0xFE, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x00, 0x0F, 0xC2, 0x70, 0x65, 0x80, 0x6A, 0x00, 0x5C, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x1A, 0x00, 0x32, 0x00, 0xA7, 0x06, 0x43, 0xF0, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x24, 0x00, 0x44, 0x01, 0x06, 0x0C,
  0x03, 0xF0, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x0F, 0x86, 0x60,
  0xCD, 0x80, 0xDA, 0x00, 0xB8, 0x01, 0x70, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x02, 0xF0, 0x00, 0x55, 0x55, 0x55, 0x55, 0x55, 0x54,
  0x06, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x30, 0x40, 0x86, 0x78, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x36, 0x00, 0xCC, 0x03, 0x18,
  0x04, 0x30, 0x10, 0x60, 0x40, 0xC1, 0x01, 0x84, 0x03, 0x10, 0x06, 0x60,
  0x0D, 0xC0, 0x1E, 0xC0, 0x38, 0x80, 0x60, 0x80, 0xC1, 0x81, 0x81, 0x03,
  0x01, 0x06, 0x03, 0x0C, 0x03, 0x18, 0x02, 0x30, 0x02, 0x60, 0x06, 0xC0,
  0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x83, 0xE0, 0x1F, 0x08, 0xC1, 0x86,
  0x0C, 0x98, 0x08, 0xC0, 0x6B, 0x00, 0x58, 0x02, 0xA0, 0x05, 0x00, 0x3C,
  0x00, 0x60, 0x01, 0xC0, 0x02, 0x00, 0x1C, 0x00, 0x20, 0x01, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x20, 0x01, 0x80, 0x02, 0x00, 0x18, 0x00, 0x20, 0x01,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x20, 0x01, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x20, 0x01, 0x80, 0x02, 0x00, 0x18, 0x00, 0x20, 0x01, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x20, 0x01, 0x80, 0x02, 0x00, 0x18, 0x00, 0x20, 0x01, 0x80,
  0x02, 0x00, 0x10, 0xC3, 0xE1, 0x98, 0x33, 0x60, 0x36, 0x80, 0x2E, 0x00,
  0x5C, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x80, 0x03,
  0xF0, 0x06, 0x0C, 0x06, 0x01, 0x06, 0x00, 0x42, 0x00, 0x32, 0x00, 0x09,
  0x00, 0x04, 0x80, 0x03, 0x40, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x03, 0x40, 0x01, 0x20,
  0x00, 0x88, 0x00, 0xC6, 0x00, 0x41, 0x80, 0x40, 0x60, 0xC0, 0x0F, 0xC0,
  0xC7, 0xE0, 0xDC, 0x18, 0xF0, 0x0C, 0xE0, 0x04, 0xC0, 0x02, 0xC0, 0x02,
  0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02,
  0xC0, 0x02, 0xE0, 0x04, 0xF0, 0x0C, 0xDC, 0x38, 0xC7, 0xE0, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x0F, 0xC2, 0x70, 0xE5, 0x80, 0x6A, 0x00, 0x7C,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x05, 0x00, 0x1A, 0x00, 0x32, 0x00, 0xA7, 0x06, 0x43, 0xF0, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0xC7, 0xE6, 0x34, 0x1C, 0x0E, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x0F, 0xE0, 0x70, 0x60, 0x80, 0x22,
  0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x1A, 0x00, 0x26, 0x00, 0xC7, 0x07, 0x03,
  0xF8, 0x00, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x83, 0xFE,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x04, 0x00, 0xF0, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x40, 0x06,
  0x80, 0x0D, 0x00, 0x1B, 0x00, 0x52, 0x01, 0xA3, 0x0E, 0x43, 0xF0, 0x80,
  0xC0, 0x01, 0x20, 0x00, 0x90, 0x00, 0xCC, 0x00, 0x42, 0x00, 0x21, 0x00,
  0x30, 0xC0, 0x10, 0x20, 0x08, 0x10, 0x04, 0x0C, 0x04, 0x02, 0x02, 0x01,
  0x01, 0x00, 0xC1, 0x00, 0x20, 0x80, 0x10, 0x40, 0x0C, 0x40, 0x02, 0x20,
  0x01, 0x10, 0x00, 0xD0, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xF0, 0x05, 0x00, 0x48, 0x02,
  0x80, 0x24, 0x01, 0x40, 0x12, 0x01, 0xA0, 0x19, 0x80, 0x88, 0x08, 0x40,
  0x44, 0x04, 0x20, 0x22, 0x02, 0x10, 0x21, 0x83, 0x0C, 0x10, 0x41, 0x02,
  0x08, 0x20, 0x81, 0x0C, 0x10, 0x40, 0xC4, 0x0C, 0x60, 0x62, 0x02, 0x20,
  0x11, 0x01, 0x10, 0x09, 0x00, 0x88, 0x04, 0x80, 0x2C, 0x03, 0x40, 0x14,
  0x00, 0xA0, 0x0A, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0x80, 0x40, 0x03, 0x20, 0x02, 0x30, 0x04, 0x10, 0x0C, 0x08, 0x08, 0x08,
  0x18, 0x04, 0x10, 0x06, 0x20, 0x02, 0x60, 0x01, 0x40, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x30, 0x0C, 0x10, 0x08,
  0x08, 0x10, 0x0C, 0x10, 0x04, 0x20, 0x06, 0x60, 0x02, 0x40, 0x01, 0xC0,
  0x01, 0x20, 0x00, 0x90, 0x00, 0x4C, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10,
  0xC0, 0x10, 0x20, 0x08, 0x10, 0x04, 0x0C, 0x06, 0x02, 0x02, 0x01, 0x01,
  0x00, 0xC1, 0x80, 0x20, 0x80, 0x10, 0x40, 0x04, 0x60, 0x02, 0x20, 0x01,
  0x10, 0x00, 0x58, 0x00, 0x28, 0x00, 0x14, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x30, 0x00, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x08, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x40, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x10, 0x01, 0x80, 0x18, 0x0C, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x80, 0x20, 0x00, 0x1E, 0x00,
  0x13, 0x18, 0x01, 0x60, 0xC0, 0x14, 0x06, 0x03, 0x40, 0x30, 0x28, 0x00,
  0x84, 0x80, 0x07, 0x80,
};

const GFXglyph RobotoCondensed_Thin44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 31, 8, 3, -31 },
  { 9, 6, 9, 11, 3, -33 },
  { 16, 21, 31, 21, 1, -31 },
  { 98, 16, 39, 21, 3, -35 },
  { 176, 24, 31, 29, 2, -31 },
  { 269, 20, 31, 24, 2, -31 },
  { 347, 1, 9, 7, 3, -33 },
  { 349, 8, 45, 12, 3, -35 },
  { 394, 8, 45, 12, 1, -35 },
  { 439, 17, 17, 18, 1, -31 },
  { 476, 18, 23, 22, 2, -26 },
  { 528, 3, 9, 8, 2, -3 },
  { 532, 9, 1, 12, 1, -15 },
  { 534, 3, 2, 10, 3, -2 },
  { 535, 12, 34, 15, 1, -31 },
  { 586, 16, 31, 21, 3, -31 },
  { 648, 9, 31, 21, 4, -31 },
  { 683, 16, 31, 21, 3, -31 },
  { 745, 17, 31, 21, 2, -31 },
  { 811, 18, 31, 21, 2, -31 },
  { 881, 15, 31, 21, 4, -31 },
  { 940, 16, 31, 21, 3, -31 },
  { 1002, 17, 31, 21, 2, -31 },
  { 1068, 17, 31, 21, 2, -31 },
  { 1134, 17, 31, 21, 2, -31 },
  { 1200, 2, 23, 8, 3, -23 },
  { 1206, 3, 29, 8, 2, -23 },
  { 1217, 15, 17, 20, 2, -23 },
  { 1249, 15, 10, 22, 3, -19 },
  { 1268, 15, 17, 20, 3, -23 },
  { 1300, 13, 31, 17, 2, -31 },
  { 1351, 30, 40, 35, 3, -30 },
  { 1501, 21, 31, 23, 1, -31 },
  { 1583, 17, 31, 23, 4, -31 },
  { 1649, 19, 31, 25, 3, -31 },
  { 1723, 18, 31, 25, 4, -31 },
  { 1793, 16, 31, 22, 4, -31 },
  { 1855, 16, 31, 22, 4, -31 },
  { 1917, 19, 31, 26, 4, -31 },
  { 1991, 19, 31, 27, 4, -31 },
  { 2065, 1, 31, 11, 5, -31 },
  { 2069, 15, 31, 21, 2, -31 },
  { 2128, 19, 31, 24, 4, -31 },
  { 2202, 15, 31, 20, 4, -31 },
  { 2261, 25, 31, 33, 4, -31 },
  { 2358, 19, 31, 27, 4, -31 },
  { 2432, 20, 31, 26, 3, -31 },
  { 2510, 17, 31, 23, 4, -31 },
  { 2576, 20, 37, 26, 3, -31 },
  { 2669, 18, 31, 25, 4, -31 },
  { 2739, 19, 31, 23, 2, -31 },
  { 2813, 21, 31, 23, 1, -31 },
  { 2895, 18, 31, 26, 4, -31 },
  { 2965, 21, 31, 23, 1, -31 },
  { 3047, 32, 31, 35, 1, -31 },
  { 3171, 21, 31, 23, 1, -31 },
  { 3253, 21, 31, 23, 1, -31 },
  { 3335, 19, 31, 23, 2, -31 },
  { 3409, 5, 43, 9, 4, -36 },
  { 3436, 13, 34, 15, 1, -31 },
  { 3492, 6, 43, 9, 0, -36 },
  { 3525, 12, 16, 16, 2, -31 },
  { 3549, 16, 1, 16, 0, 0 },
  { 3551, 6, 6, 12, 3, -33 },
  { 3556, 15, 23, 21, 2, -23 },
  { 3600, 16, 33, 21, 3, -33 },
  { 3666, 16, 23, 20, 2, -23 },
  { 3712, 15, 33, 21, 3, -33 },
  { 3774, 16, 23, 20, 2, -23 },
  { 3820, 11, 33, 13, 2, -33 },
  { 3866, 15, 32, 21, 3, -23 },
  { 3926, 15, 33, 21, 3, -33 },
  { 3988, 2, 31, 9, 3, -31 },
  { 3996, 7, 40, 9, -2, -31 },
  { 4031, 15, 33, 19, 3, -33 },
  { 4093, 1, 33, 9, 4, -33 },
  { 4098, 28, 23, 34, 3, -23 },
  { 4179, 15, 23, 21, 3, -23 },
  { 4223, 17, 23, 21, 2, -23 },
  { 4272, 16, 32, 21, 3, -23 },
  { 4336, 15, 32, 21, 3, -23 },
  { 4396, 9, 23, 13, 3, -23 },
  { 4422, 15, 23, 19, 2, -23 },
  { 4466, 10, 30, 13, 1, -30 },
  { 4504, 15, 23, 21, 3, -23 },
  { 4548, 17, 23, 19, 1, -23 },
  { 4597, 25, 23, 29, 2, -23 },
  { 4669, 16, 23, 19, 1, -23 },
  { 4715, 17, 32, 19, 1, -23 },
  { 4783, 15, 23, 19, 2, -23 },
  { 4827, 11, 44, 13, 2, -34 },
  { 4888, 1, 37, 9, 4, -31 },
  { 4893, 11, 44, 13, 0, -34 },
  { 4954, 20, 7, 27, 3, -17 },
};

const GFXfont RobotoCondensed_Thin44pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin44pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin44pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _ROBOTOCONDENSED_THIN44PT7B_H_
