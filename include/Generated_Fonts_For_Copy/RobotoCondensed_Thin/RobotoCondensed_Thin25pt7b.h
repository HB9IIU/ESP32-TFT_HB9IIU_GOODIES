#ifndef _ROBOTOCONDENSED_THIN25PT7B_H_
#define _ROBOTOCONDENSED_THIN25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF8, 0x40, 0xB6, 0xDA, 0x08, 0x41, 0x08, 0x22, 0x04, 0x40,
  0x88, 0xFF, 0xC4, 0x20, 0x84, 0x11, 0x02, 0x20, 0x44, 0x08, 0x8F, 0xFE,
  0x42, 0x08, 0x41, 0x10, 0x22, 0x04, 0x40, 0x04, 0x01, 0x01, 0xF0, 0x82,
  0x40, 0x90, 0x14, 0x05, 0x00, 0x40, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x20, 0x06, 0x01, 0x80, 0x50, 0x22, 0x08, 0x7C, 0x04, 0x01, 0x00, 0x38,
  0x01, 0x10, 0x08, 0x42, 0x21, 0x08, 0x84, 0x42, 0x11, 0x04, 0x48, 0x0E,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x23, 0x81, 0x11, 0x04, 0x84, 0x22, 0x10,
  0x88, 0x44, 0x21, 0x00, 0x44, 0x00, 0xE0, 0x1E, 0x02, 0x10, 0x21, 0x02,
  0x10, 0x21, 0x02, 0x20, 0x24, 0x01, 0x80, 0x18, 0x02, 0x40, 0x44, 0x24,
  0x22, 0x81, 0x28, 0x12, 0x80, 0xC4, 0x04, 0x41, 0xA3, 0xE2, 0xF8, 0x11,
  0x24, 0x44, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x44, 0x42, 0x11,
  0x88, 0x44, 0x22, 0x21, 0x11, 0x11, 0x11, 0x11, 0x11, 0x12, 0x22, 0x44,
  0x88, 0x04, 0x01, 0x00, 0x40, 0x11, 0x77, 0x83, 0x00, 0xA0, 0x48, 0x11,
  0x08, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x0F, 0xFC, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x55, 0x80, 0xF8, 0x80, 0x02,
  0x08, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x10,
  0x20, 0x41, 0x02, 0x04, 0x00, 0x3C, 0x21, 0x20, 0x50, 0x28, 0x14, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0A, 0x05, 0x02, 0x42,
  0x1E, 0x00, 0x1B, 0x62, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x40, 0x1E, 0x08, 0x44, 0x0A, 0x02, 0x80, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40, 0x1F,
  0xF0, 0x1E, 0x08, 0x44, 0x09, 0x02, 0x80, 0x40, 0x20, 0x08, 0x04, 0x0E,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x18, 0x05, 0x02, 0x20, 0x87, 0xC0,
  0x01, 0x00, 0x60, 0x0C, 0x02, 0x80, 0x50, 0x12, 0x04, 0x40, 0x88, 0x21,
  0x04, 0x21, 0x04, 0x20, 0x8F, 0xFE, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x7F, 0xA0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFC, 0x41, 0x00,
  0x80, 0x20, 0x10, 0x0C, 0x06, 0x02, 0x82, 0x41, 0x0F, 0x00, 0x0E, 0x18,
  0x10, 0x08, 0x08, 0x04, 0x02, 0xF1, 0x86, 0x81, 0x40, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x02, 0x42, 0x1E, 0x00, 0xFF, 0xC0, 0x20, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x00, 0x1E, 0x08, 0x44, 0x09, 0x01, 0x80,
  0x50, 0x14, 0x08, 0x84, 0x1E, 0x08, 0x44, 0x0A, 0x01, 0x80, 0x60, 0x18,
  0x05, 0x01, 0x40, 0x8F, 0xC0, 0x1E, 0x08, 0x44, 0x09, 0x02, 0x80, 0xA0,
  0x18, 0x06, 0x01, 0x80, 0x50, 0x32, 0x14, 0x79, 0x00, 0x80, 0x20, 0x08,
  0x04, 0x02, 0x0F, 0x00, 0x80, 0x08, 0x40, 0x00, 0x01, 0x56, 0x00, 0x81,
  0x83, 0x06, 0x0C, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x0C, 0x18,
  0x30, 0x20, 0x60, 0x00, 0x3C, 0x42, 0x82, 0x81, 0x01, 0x01, 0x02, 0x02,
  0x04, 0x08, 0x08, 0x10, 0x10, 0x00, 0x00, 0x00, 0x00, 0x10, 0x03, 0xF8,
  0x01, 0x01, 0x80, 0x80, 0x10, 0x40, 0x04, 0x20, 0x00, 0x88, 0x38, 0x24,
  0x11, 0x09, 0x08, 0x41, 0x42, 0x10, 0x51, 0x04, 0x18, 0x41, 0x06, 0x10,
  0x41, 0x84, 0x10, 0xA1, 0x04, 0x28, 0x41, 0x09, 0x08, 0xC4, 0x43, 0xCE,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x7F, 0x00, 0x04, 0x00, 0x40, 0x0A, 0x00, 0xA0, 0x09, 0x01, 0x10, 0x11,
  0x01, 0x10, 0x20, 0x82, 0x08, 0x20, 0x84, 0x04, 0x7F, 0xC4, 0x04, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x01, 0xFE, 0x20, 0x48, 0x0A, 0x02, 0x80, 0xA0,
  0x28, 0x0A, 0x04, 0xFE, 0x20, 0x48, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xBF, 0xC0, 0x1F, 0x0C, 0x11, 0x01, 0x40, 0x28, 0x03, 0x00,
  0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60,
  0x12, 0x02, 0x20, 0x83, 0xE0, 0xFE, 0x10, 0x32, 0x02, 0x40, 0x28, 0x05,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xA0, 0x14, 0x04, 0x81, 0x9F, 0xC0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0xFF, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x7F, 0xC0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0xFF, 0xA0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x00, 0x1F, 0x04, 0x19, 0x01, 0x40, 0x18, 0x03, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x7E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0A, 0x01,
  0x20, 0x43, 0xF0, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0xFF, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0xFF, 0xFF, 0xC0, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x06, 0x03,
  0x02, 0x41, 0x1E, 0x00, 0x80, 0x50, 0x12, 0x04, 0x40, 0x88, 0x21, 0x08,
  0x22, 0x04, 0x80, 0xB0, 0x15, 0x03, 0x10, 0x42, 0x08, 0x21, 0x02, 0x20,
  0x24, 0x04, 0x80, 0x50, 0x04, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x7F, 0xC0, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xE8, 0x03, 0xA0, 0x0E, 0x80,
  0x59, 0x01, 0x64, 0x05, 0x90, 0x26, 0x20, 0x98, 0x84, 0x61, 0x11, 0x84,
  0x46, 0x12, 0x18, 0x28, 0x60, 0xA1, 0x81, 0x06, 0x04, 0x10, 0x80, 0x38,
  0x06, 0x80, 0xD0, 0x19, 0x03, 0x20, 0x62, 0x0C, 0x41, 0x84, 0x30, 0x46,
  0x08, 0xC0, 0x98, 0x13, 0x01, 0x60, 0x2C, 0x03, 0x80, 0x30, 0x04, 0x1F,
  0x0C, 0x11, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0A, 0x02, 0x60, 0x83, 0xE0,
  0xFF, 0x20, 0x28, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xBF,
  0xC8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x1F,
  0x0C, 0x11, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0A, 0x02, 0x60, 0x83, 0xE0,
  0x02, 0x00, 0x20, 0x02, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x28, 0x05, 0x00,
  0xA0, 0x14, 0x02, 0x80, 0x9F, 0xE2, 0x08, 0x40, 0x88, 0x11, 0x01, 0x20,
  0x24, 0x02, 0x80, 0x50, 0x04, 0x1F, 0x04, 0x19, 0x01, 0x20, 0x18, 0x02,
  0x80, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x60, 0x0A, 0x01, 0x20, 0x43, 0xF0, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x05, 0x01, 0x60, 0x87, 0xC0, 0x80, 0x18, 0x02, 0x80, 0x24, 0x02,
  0x40, 0x44, 0x04, 0x40, 0x42, 0x08, 0x20, 0x82, 0x08, 0x11, 0x01, 0x10,
  0x11, 0x00, 0x90, 0x0A, 0x00, 0xA0, 0x04, 0x00, 0x40, 0x80, 0x80, 0x60,
  0x30, 0x18, 0x0C, 0x0A, 0x05, 0x02, 0x41, 0x20, 0x90, 0x48, 0x24, 0x12,
  0x11, 0x08, 0x84, 0x22, 0x11, 0x08, 0x84, 0x42, 0x21, 0x10, 0x90, 0x48,
  0x14, 0x0A, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x60, 0x30, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x28, 0x09, 0x01, 0x10, 0x41, 0x08, 0x22, 0x02, 0x80,
  0x50, 0x04, 0x00, 0x80, 0x28, 0x08, 0x81, 0x10, 0x41, 0x08, 0x22, 0x02,
  0x40, 0x30, 0x04, 0x80, 0x28, 0x02, 0x40, 0x44, 0x04, 0x20, 0x82, 0x08,
  0x11, 0x01, 0x10, 0x0A, 0x00, 0xA0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x7F, 0xE0, 0x08, 0x01, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x1F, 0xFC, 0xF2, 0x49, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x49, 0x27, 0x81, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x20, 0x40, 0x80, 0x81, 0x02, 0x02, 0x04, 0x08, 0x10, 0x10, 0xE4, 0x92,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x4F, 0x10, 0x20, 0xA1, 0x42, 0x48,
  0x91, 0x21, 0x82, 0xFF, 0x80, 0x88, 0x80, 0x3E, 0x20, 0x90, 0x30, 0x10,
  0x08, 0x04, 0xFE, 0x81, 0x80, 0xC0, 0x60, 0x68, 0x53, 0xC8, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0xF9, 0x82, 0x81, 0x40, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x81, 0x60, 0xAF, 0x80, 0x3E, 0x20, 0x90, 0x30,
  0x18, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x50, 0x28, 0x23, 0xE0, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0xFA, 0x83, 0x40, 0xA0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x02, 0x81, 0x40, 0xA0, 0xCF, 0xA0, 0x1E, 0x30, 0x90,
  0x30, 0x18, 0x0F, 0xFE, 0x01, 0x00, 0x80, 0x40, 0x10, 0x0C, 0x11, 0xF0,
  0x1C, 0x82, 0x08, 0x20, 0x8F, 0x88, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x00, 0x3E, 0xA0, 0xD0, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xA0, 0x50, 0x28, 0x33, 0xE8, 0x04, 0x02, 0x01, 0x21, 0x0F, 0x00,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x9C, 0xE1, 0xC1, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x8F, 0xFF, 0x80, 0x10, 0x00,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x2E, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x82, 0x84, 0x84, 0x88, 0x90, 0xA0, 0xD0, 0x90, 0x88,
  0x84, 0x84, 0x82, 0x81, 0xFF, 0xFF, 0xE0, 0xBE, 0x3C, 0xC1, 0x42, 0x81,
  0x81, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81,
  0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x9C, 0xE1, 0xC1,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x1E, 0x08,
  0x44, 0x09, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x14, 0x08,
  0x84, 0x1E, 0x00, 0xBE, 0x60, 0xA0, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x58, 0x2B, 0xE4, 0x02, 0x01, 0x00, 0x80, 0x40, 0x00,
  0x3E, 0xA0, 0xD0, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0x50,
  0x28, 0x33, 0xE8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0xBE, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x00, 0x3E, 0x41, 0x81, 0x80, 0x40, 0x30,
  0x0C, 0x03, 0x01, 0x01, 0x81, 0x41, 0x3E, 0x42, 0x10, 0x8F, 0xA1, 0x08,
  0x42, 0x10, 0x84, 0x20, 0x84, 0x18, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x80, 0xC0, 0x60, 0x48, 0x24,
  0x12, 0x10, 0x88, 0x44, 0x24, 0x0A, 0x05, 0x03, 0x00, 0x80, 0x81, 0x06,
  0x0C, 0x14, 0x30, 0x50, 0xA1, 0x44, 0x89, 0x12, 0x22, 0x48, 0x89, 0x12,
  0x28, 0x50, 0xA1, 0x41, 0x83, 0x04, 0x08, 0x10, 0x20, 0x81, 0x20, 0x90,
  0x84, 0x41, 0x40, 0xC0, 0x20, 0x28, 0x24, 0x11, 0x10, 0x88, 0x28, 0x08,
  0x80, 0xC0, 0x60, 0x48, 0x24, 0x12, 0x10, 0x88, 0x44, 0x24, 0x0A, 0x05,
  0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x70, 0x00, 0xFF, 0x00, 0x80,
  0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x0F, 0xF8,
  0x04, 0x21, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0xC1, 0x02, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x41, 0x02, 0x04, 0xFF, 0xFF, 0xF8, 0xC0, 0x82,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x02, 0x04, 0x21, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x42, 0x08, 0xC0, 0x70, 0x31, 0x86, 0x08, 0xC0, 0xE0,
};

const GFXglyph RobotoCondensed_Thin25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 18, 5, 2, -18 },
  { 4, 3, 5, 6, 2, -19 },
  { 6, 11, 18, 12, 1, -18 },
  { 31, 10, 22, 12, 1, -20 },
  { 59, 14, 18, 16, 1, -18 },
  { 91, 12, 18, 13, 1, -18 },
  { 118, 1, 5, 4, 2, -19 },
  { 119, 4, 26, 7, 2, -20 },
  { 132, 4, 26, 7, 1, -20 },
  { 145, 10, 10, 10, 0, -18 },
  { 158, 10, 13, 12, 1, -15 },
  { 175, 2, 5, 5, 1, -2 },
  { 177, 5, 1, 7, 1, -9 },
  { 178, 1, 1, 5, 2, -1 },
  { 179, 7, 20, 9, 1, -18 },
  { 197, 9, 18, 12, 2, -18 },
  { 218, 5, 18, 12, 2, -18 },
  { 230, 10, 18, 12, 1, -18 },
  { 253, 10, 18, 12, 1, -18 },
  { 276, 11, 18, 12, 1, -18 },
  { 301, 9, 18, 12, 2, -18 },
  { 322, 9, 18, 12, 2, -18 },
  { 343, 10, 18, 12, 1, -18 },
  { 366, 10, 18, 12, 1, -18 },
  { 389, 10, 18, 12, 1, -18 },
  { 412, 1, 13, 4, 2, -13 },
  { 414, 2, 16, 4, 1, -13 },
  { 418, 9, 10, 11, 1, -13 },
  { 430, 8, 6, 12, 2, -11 },
  { 436, 9, 10, 11, 1, -13 },
  { 448, 8, 18, 10, 1, -18 },
  { 466, 18, 23, 20, 1, -17 },
  { 518, 12, 18, 13, 1, -18 },
  { 545, 10, 18, 13, 2, -18 },
  { 568, 11, 18, 14, 2, -18 },
  { 593, 11, 18, 14, 2, -18 },
  { 618, 9, 18, 13, 2, -18 },
  { 639, 10, 18, 13, 2, -18 },
  { 662, 11, 18, 15, 2, -18 },
  { 687, 11, 18, 15, 2, -18 },
  { 712, 1, 18, 6, 3, -18 },
  { 715, 9, 18, 12, 1, -18 },
  { 736, 11, 18, 14, 2, -18 },
  { 761, 9, 18, 11, 2, -18 },
  { 782, 14, 18, 19, 2, -18 },
  { 814, 11, 18, 15, 2, -18 },
  { 839, 11, 18, 15, 2, -18 },
  { 864, 10, 18, 13, 2, -18 },
  { 887, 11, 21, 15, 2, -18 },
  { 916, 11, 18, 14, 2, -18 },
  { 941, 11, 18, 13, 1, -18 },
  { 966, 11, 18, 13, 1, -18 },
  { 991, 10, 18, 15, 2, -18 },
  { 1014, 12, 18, 13, 1, -18 },
  { 1041, 18, 18, 20, 1, -18 },
  { 1082, 11, 18, 13, 1, -18 },
  { 1107, 12, 18, 13, 1, -18 },
  { 1134, 11, 18, 13, 1, -18 },
  { 1159, 3, 24, 5, 2, -20 },
  { 1168, 7, 20, 9, 1, -18 },
  { 1186, 3, 24, 5, 0, -20 },
  { 1195, 7, 9, 9, 1, -18 },
  { 1203, 9, 1, 9, 0, 0 },
  { 1205, 3, 3, 7, 2, -19 },
  { 1207, 9, 13, 12, 1, -13 },
  { 1222, 9, 19, 12, 2, -19 },
  { 1244, 9, 13, 11, 1, -13 },
  { 1259, 9, 19, 12, 1, -19 },
  { 1281, 9, 13, 11, 1, -13 },
  { 1296, 6, 19, 7, 1, -19 },
  { 1311, 9, 18, 12, 1, -13 },
  { 1332, 8, 19, 12, 2, -19 },
  { 1351, 1, 17, 5, 2, -17 },
  { 1354, 4, 22, 5, -1, -17 },
  { 1365, 8, 19, 11, 2, -19 },
  { 1384, 1, 19, 5, 2, -19 },
  { 1387, 16, 13, 19, 2, -13 },
  { 1413, 8, 13, 12, 2, -13 },
  { 1426, 10, 13, 12, 1, -13 },
  { 1443, 9, 18, 12, 2, -13 },
  { 1464, 9, 18, 12, 1, -13 },
  { 1485, 5, 13, 8, 2, -13 },
  { 1494, 8, 13, 11, 1, -13 },
  { 1507, 5, 17, 7, 1, -17 },
  { 1518, 8, 13, 12, 2, -13 },
  { 1531, 9, 13, 11, 1, -13 },
  { 1546, 14, 13, 17, 1, -13 },
  { 1569, 9, 13, 11, 1, -13 },
  { 1584, 9, 18, 11, 1, -13 },
  { 1605, 9, 13, 11, 1, -13 },
  { 1620, 6, 25, 7, 1, -20 },
  { 1639, 1, 21, 5, 2, -18 },
  { 1642, 6, 25, 7, 0, -20 },
  { 1661, 11, 4, 15, 2, -9 },
};

const GFXfont RobotoCondensed_Thin25pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin25pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin25pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOCONDENSED_THIN25PT7B_H_
