#ifndef _ROBOTOCONDENSED_THIN33PT7B_H_
#define _ROBOTOCONDENSED_THIN33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin33pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x00, 0x3C, 0x8C, 0x63, 0x18, 0xC6, 0x20,
  0x02, 0x08, 0x04, 0x10, 0x08, 0x20, 0x10, 0x80, 0x21, 0x00, 0x82, 0x1F,
  0xFF, 0x82, 0x08, 0x04, 0x10, 0x08, 0x20, 0x10, 0x80, 0x41, 0x00, 0x82,
  0x01, 0x04, 0x02, 0x08, 0x04, 0x10, 0xFF, 0xFC, 0x10, 0x80, 0x41, 0x00,
  0x82, 0x01, 0x04, 0x02, 0x08, 0x04, 0x20, 0x00, 0x02, 0x00, 0x20, 0x02,
  0x00, 0xF8, 0x30, 0x44, 0x02, 0x40, 0x24, 0x01, 0x40, 0x14, 0x01, 0x40,
  0x04, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x02, 0x00,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x14, 0x02, 0x20, 0x41, 0xF8, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x38, 0x00, 0x11, 0x00, 0x08, 0x20, 0x02, 0x08,
  0x10, 0x82, 0x08, 0x20, 0x82, 0x08, 0x21, 0x02, 0x08, 0x80, 0x82, 0x20,
  0x11, 0x10, 0x03, 0x84, 0x00, 0x02, 0x00, 0x00, 0x8F, 0x00, 0x44, 0x20,
  0x11, 0x08, 0x08, 0x81, 0x04, 0x20, 0x41, 0x08, 0x10, 0x82, 0x04, 0x20,
  0x81, 0x00, 0x10, 0x80, 0x04, 0x20, 0x00, 0xF0, 0x0F, 0x00, 0x21, 0x00,
  0x81, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x20, 0x10, 0x80, 0x12,
  0x00, 0x28, 0x00, 0x20, 0x00, 0xA0, 0x02, 0x20, 0x48, 0x40, 0x90, 0x41,
  0x40, 0x42, 0x80, 0x49, 0x00, 0x52, 0x00, 0xC4, 0x00, 0x84, 0x02, 0x8C,
  0x18, 0x87, 0xC1, 0x00, 0xFE, 0x04, 0x10, 0x84, 0x10, 0x82, 0x08, 0x41,
  0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04, 0x10, 0x41,
  0x02, 0x08, 0x20, 0x41, 0x02, 0x04, 0x10, 0x82, 0x04, 0x08, 0x20, 0x41,
  0x04, 0x08, 0x20, 0x82, 0x08, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x20,
  0x82, 0x08, 0x21, 0x04, 0x10, 0x82, 0x10, 0x82, 0x00, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0xB8, 0x98, 0x3F, 0x00, 0x60, 0x04, 0x80,
  0x24, 0x02, 0x10, 0x20, 0x41, 0x03, 0x00, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0xFF, 0xFC, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x24, 0x96, 0xB0, 0xFE, 0x70, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20,
  0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x00, 0x0F,
  0x03, 0x0C, 0x20, 0x44, 0x02, 0x40, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x40, 0x24, 0x02, 0x20, 0x43, 0x0C, 0x0F, 0x00, 0x04, 0xFC,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x40, 0x1F, 0x02, 0x0C, 0x40, 0x44, 0x02, 0x80, 0x28,
  0x02, 0x80, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x00, 0xFF, 0xF0, 0x1F, 0x82, 0x04, 0x40, 0x24, 0x02, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0xC0, 0xF0, 0x00, 0xC0, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x23, 0x04,
  0x0F, 0x80, 0x00, 0x20, 0x01, 0x80, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x04,
  0x80, 0x22, 0x00, 0x88, 0x04, 0x20, 0x20, 0x80, 0x82, 0x04, 0x08, 0x10,
  0x20, 0x80, 0x82, 0x02, 0x10, 0x08, 0xFF, 0xFC, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x7F, 0xE8, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x5F, 0x0C, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x14, 0x04,
  0x41, 0x07, 0xC0, 0x03, 0xC0, 0xC0, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x8F, 0x89, 0x04, 0xA0, 0x2C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x14, 0x02, 0x20, 0x23, 0x04,
  0x0F, 0x80, 0xFF, 0xF8, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x00, 0x1F, 0x82, 0x0C, 0x40, 0x24, 0x02, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x40, 0x24, 0x02, 0x30, 0xC0, 0xF0, 0x30, 0xC4,
  0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x26,
  0x06, 0x1F, 0x80, 0x1F, 0x02, 0x0C, 0x40, 0x44, 0x02, 0x80, 0x28, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x40, 0x52, 0x09,
  0x1F, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30,
  0x3C, 0x00, 0xF0, 0x00, 0x00, 0x02, 0xC0, 0x6C, 0x00, 0x00, 0x00, 0x00,
  0x09, 0x25, 0x28, 0x00, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x06, 0x03, 0x00,
  0x80, 0x60, 0x30, 0x08, 0x00, 0x3E, 0x20, 0xA0, 0x30, 0x18, 0x0C, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x60, 0x00, 0x7E, 0x00, 0x07, 0x01,
  0x80, 0x18, 0x00, 0x80, 0x40, 0x00, 0x81, 0x00, 0x00, 0x82, 0x00, 0x01,
  0x08, 0x00, 0x01, 0x10, 0x1E, 0x02, 0x40, 0x42, 0x04, 0x81, 0x02, 0x09,
  0x04, 0x04, 0x14, 0x08, 0x10, 0x28, 0x10, 0x20, 0x30, 0x40, 0x40, 0x60,
  0x80, 0x80, 0xC1, 0x01, 0x02, 0x82, 0x02, 0x05, 0x04, 0x04, 0x0A, 0x08,
  0x08, 0x14, 0x10, 0x30, 0x28, 0x10, 0x60, 0x88, 0x21, 0x22, 0x10, 0x3C,
  0x38, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x30, 0x00, 0x3F, 0x80, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x40, 0x04, 0x40, 0x04, 0x40,
  0x04, 0x20, 0x08, 0x20, 0x08, 0x20, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x08, 0x20, 0x08, 0x3F, 0xF8, 0x20, 0x04, 0x40, 0x04, 0x40, 0x04,
  0x40, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0xFF, 0x84, 0x02, 0x20,
  0x09, 0x00, 0x48, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x24, 0x01,
  0x20, 0x11, 0xFF, 0x08, 0x06, 0x40, 0x0A, 0x00, 0x50, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x28, 0x01, 0x40, 0x33, 0xFE, 0x00, 0x07, 0xE0,
  0x30, 0x20, 0x80, 0x22, 0x00, 0x24, 0x00, 0x48, 0x00, 0xA0, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x80, 0x09, 0x00, 0x11, 0x00, 0x22,
  0x00, 0x83, 0x02, 0x01, 0xF8, 0x00, 0xFF, 0x02, 0x01, 0x08, 0x03, 0x20,
  0x04, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0A,
  0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x32, 0x01, 0x0F, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x0F, 0xFE, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0xFF, 0xF8,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x0F, 0xFE, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0xC0,
  0xC6, 0x01, 0x90, 0x02, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x81, 0xFE, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x50, 0x01, 0x20, 0x0C, 0x40, 0x60,
  0xFE, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0xFF, 0xFF, 0xFE, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x18,
  0x01, 0x40, 0x14, 0x02, 0x60, 0x23, 0x04, 0x0F, 0x80, 0x80, 0x0A, 0x00,
  0x48, 0x02, 0x20, 0x10, 0x80, 0xC2, 0x02, 0x08, 0x10, 0x20, 0x80, 0x84,
  0x02, 0x20, 0x09, 0x80, 0x2B, 0x00, 0xE4, 0x03, 0x08, 0x08, 0x10, 0x20,
  0x60, 0x80, 0x82, 0x01, 0x08, 0x02, 0x20, 0x0C, 0x80, 0x12, 0x00, 0x28,
  0x00, 0x40, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x3F, 0xF8, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x02, 0xD0, 0x00, 0x5A, 0x00, 0x0B, 0x40, 0x02,
  0x64, 0x00, 0x4C, 0x80, 0x09, 0x90, 0x02, 0x31, 0x00, 0x46, 0x20, 0x10,
  0xC2, 0x02, 0x18, 0x40, 0x43, 0x08, 0x10, 0x60, 0x82, 0x0C, 0x10, 0x41,
  0x82, 0x10, 0x30, 0x22, 0x06, 0x04, 0x80, 0xC0, 0x50, 0x18, 0x0A, 0x03,
  0x01, 0x80, 0x60, 0x10, 0x08, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x68, 0x01,
  0x90, 0x06, 0x40, 0x18, 0x80, 0x62, 0x01, 0x84, 0x06, 0x08, 0x18, 0x20,
  0x60, 0x41, 0x81, 0x06, 0x02, 0x18, 0x04, 0x60, 0x11, 0x80, 0x26, 0x00,
  0x98, 0x01, 0x60, 0x05, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x40, 0x07, 0xC0,
  0x30, 0x20, 0x80, 0x22, 0x00, 0x24, 0x00, 0x48, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x80, 0x05, 0x00, 0x12, 0x00, 0x22,
  0x00, 0x83, 0x02, 0x01, 0xF0, 0x00, 0xFF, 0x84, 0x03, 0x20, 0x05, 0x00,
  0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xA0, 0x05,
  0x00, 0xCF, 0xF8, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x30, 0x20,
  0x80, 0x22, 0x00, 0x24, 0x00, 0x48, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x80, 0x05, 0x00, 0x12, 0x00, 0x22, 0x00, 0x83,
  0x02, 0x01, 0xF8, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0xFF,
  0x82, 0x01, 0x88, 0x01, 0x20, 0x04, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0,
  0x02, 0x80, 0x0A, 0x00, 0x48, 0x01, 0x20, 0x18, 0xFF, 0x82, 0x02, 0x08,
  0x08, 0x20, 0x10, 0x80, 0x42, 0x00, 0x88, 0x02, 0x20, 0x04, 0x80, 0x12,
  0x00, 0x28, 0x00, 0x40, 0x0F, 0xC0, 0xC0, 0xC4, 0x01, 0x30, 0x02, 0x80,
  0x0A, 0x00, 0x28, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x02, 0x40, 0x08, 0xC0, 0xC0, 0xFC, 0x00, 0xFF, 0xFE, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x14, 0x01, 0x18, 0x10, 0x3F, 0x00, 0x80, 0x02, 0x80, 0x02, 0x40,
  0x02, 0x40, 0x02, 0x40, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x08, 0x20,
  0x08, 0x10, 0x08, 0x10, 0x10, 0x10, 0x10, 0x08, 0x10, 0x08, 0x20, 0x08,
  0x20, 0x04, 0x20, 0x04, 0x40, 0x04, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x40,
  0x18, 0x02, 0x40, 0x18, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x20,
  0x24, 0x04, 0x20, 0x42, 0x04, 0x20, 0x42, 0x04, 0x20, 0x42, 0x04, 0x10,
  0x42, 0x08, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x10,
  0x81, 0x08, 0x09, 0x00, 0x90, 0x09, 0x00, 0x90, 0x09, 0x00, 0x90, 0x09,
  0x00, 0x90, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x40, 0x02, 0x80, 0x08, 0x80, 0x31, 0x00, 0x41, 0x01, 0x01,
  0x02, 0x02, 0x08, 0x02, 0x10, 0x04, 0x40, 0x05, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x28, 0x00, 0x48, 0x01, 0x10, 0x02, 0x10, 0x08, 0x20, 0x20, 0x20,
  0x40, 0x21, 0x00, 0x42, 0x00, 0x48, 0x00, 0xA0, 0x00, 0x80, 0x80, 0x02,
  0x40, 0x02, 0x40, 0x04, 0x20, 0x04, 0x20, 0x08, 0x10, 0x08, 0x10, 0x10,
  0x08, 0x10, 0x08, 0x20, 0x04, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xF8, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x0F, 0xFF,
  0xC0, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x8F, 0x80, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0xF1, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x1F, 0x18, 0x18, 0x18, 0x24, 0x24, 0x24, 0x42, 0x42, 0x42, 0x81,
  0x81, 0x81, 0xFF, 0xF0, 0x41, 0x08, 0x20, 0x1F, 0x0C, 0x19, 0x01, 0x40,
  0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x1F, 0xEC, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xE0, 0x1E, 0x0D, 0x3E, 0x20, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x9F, 0x1C, 0x13, 0x01, 0x40, 0x28,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xA0, 0x17, 0x04, 0x9F, 0x00, 0x1F, 0x04, 0x19, 0x01, 0x40, 0x18,
  0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x50, 0x11, 0x06, 0x1F, 0x00, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x1F, 0x24, 0x1D, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x80,
  0x50, 0x09, 0x07, 0x1F, 0x20, 0x0F, 0x81, 0x06, 0x20, 0x24, 0x01, 0x40,
  0x14, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x01, 0x02, 0x0F, 0xC0, 0x07, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0xFE, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F, 0x24, 0x15, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x02, 0x80, 0x50, 0x09, 0x07, 0x1F, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x80, 0x48, 0x10, 0xF8, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x9F, 0x28, 0x2C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x40, 0x70, 0x01, 0x55, 0x55, 0x55, 0x55, 0x04, 0x10, 0x00, 0x00, 0x00,
  0x01, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x08, 0x2F, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0xA0, 0x68, 0x32, 0x08, 0x84, 0x22,
  0x09, 0x02, 0x80, 0xD0, 0x22, 0x08, 0x42, 0x10, 0x82, 0x20, 0x48, 0x1A,
  0x02, 0x80, 0x40, 0xFF, 0xFF, 0xFF, 0x80, 0x8F, 0x83, 0xE4, 0x82, 0x20,
  0xA8, 0x0A, 0x03, 0x40, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x10, 0x06, 0x00,
  0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04,
  0x01, 0x80, 0x20, 0x08, 0x9F, 0x28, 0x2C, 0x07, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x1F, 0x82, 0x04, 0x40, 0x24, 0x02, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x02, 0x40,
  0x22, 0x04, 0x1F, 0x80, 0x9F, 0x1C, 0x12, 0x01, 0x40, 0x28, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xA0,
  0x17, 0x04, 0x9F, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x1F, 0x24, 0x1D, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x80, 0x50, 0x09, 0x07, 0x1F,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x9E, 0x8C,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x80, 0x3F,
  0x08, 0x12, 0x01, 0x40, 0x28, 0x05, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x28, 0x03, 0x00, 0x60, 0x12, 0x04, 0x1F, 0x00, 0x20,
  0x40, 0x81, 0x02, 0x1F, 0xC8, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x80, 0x81, 0x01, 0xC0, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x0D, 0x05, 0x3E, 0x40, 0x80, 0x18, 0x01, 0x40, 0x24, 0x02, 0x40,
  0x22, 0x04, 0x20, 0x42, 0x04, 0x10, 0x81, 0x08, 0x10, 0x80, 0x90, 0x09,
  0x00, 0x90, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x40, 0x28, 0x0C, 0x05,
  0x01, 0x80, 0xA0, 0x50, 0x22, 0x09, 0x04, 0x41, 0x20, 0x88, 0x24, 0x11,
  0x08, 0x84, 0x11, 0x08, 0x82, 0x21, 0x10, 0x48, 0x22, 0x09, 0x04, 0x80,
  0xA0, 0x50, 0x14, 0x0A, 0x03, 0x01, 0x40, 0x60, 0x10, 0x04, 0x02, 0x00,
  0x40, 0x24, 0x02, 0x20, 0x43, 0x0C, 0x10, 0x80, 0x90, 0x09, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x09, 0x01, 0x08, 0x10, 0x82, 0x04, 0x20, 0x44, 0x02,
  0x80, 0x10, 0x80, 0x18, 0x01, 0x40, 0x24, 0x02, 0x40, 0x22, 0x04, 0x20,
  0x42, 0x04, 0x10, 0x81, 0x08, 0x10, 0x80, 0x90, 0x09, 0x00, 0x90, 0x06,
  0x00, 0x60, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x18,
  0x07, 0x00, 0x7F, 0xE0, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x04, 0x00, 0xFF, 0xF0, 0x01, 0x02, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x20, 0xC0, 0x20, 0x10, 0x10,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x04, 0x02,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x04, 0x06, 0x01, 0x06, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x20, 0xC0, 0x3C, 0x02, 0x84, 0x05, 0x06, 0x0C, 0x06, 0x28, 0x03, 0x80,
};

const GFXglyph RobotoCondensed_Thin33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 23, 6, 2, -23 },
  { 7, 5, 7, 9, 2, -25 },
  { 12, 15, 23, 16, 1, -23 },
  { 56, 12, 29, 16, 2, -26 },
  { 100, 18, 23, 21, 2, -23 },
  { 152, 15, 23, 18, 2, -23 },
  { 196, 1, 7, 6, 2, -25 },
  { 197, 6, 34, 9, 2, -26 },
  { 223, 6, 34, 9, 1, -26 },
  { 249, 13, 13, 14, 0, -23 },
  { 271, 14, 17, 16, 1, -19 },
  { 301, 3, 7, 6, 1, -3 },
  { 304, 7, 1, 9, 1, -11 },
  { 305, 2, 2, 7, 2, -2 },
  { 306, 9, 25, 11, 1, -23 },
  { 335, 12, 23, 16, 2, -23 },
  { 370, 6, 23, 16, 3, -23 },
  { 388, 12, 23, 16, 2, -23 },
  { 423, 12, 23, 16, 2, -23 },
  { 458, 14, 23, 16, 1, -23 },
  { 499, 11, 23, 16, 3, -23 },
  { 531, 12, 23, 16, 2, -23 },
  { 566, 13, 23, 16, 1, -23 },
  { 604, 12, 23, 16, 2, -23 },
  { 639, 12, 23, 16, 2, -23 },
  { 674, 2, 17, 6, 2, -17 },
  { 679, 3, 21, 6, 1, -17 },
  { 687, 12, 13, 15, 1, -17 },
  { 707, 12, 8, 16, 2, -15 },
  { 719, 11, 13, 15, 2, -17 },
  { 737, 9, 23, 13, 2, -23 },
  { 763, 23, 30, 27, 2, -23 },
  { 850, 16, 23, 17, 1, -23 },
  { 896, 13, 23, 18, 3, -23 },
  { 934, 15, 23, 19, 2, -23 },
  { 978, 14, 23, 19, 3, -23 },
  { 1019, 12, 23, 17, 3, -23 },
  { 1054, 12, 23, 17, 3, -23 },
  { 1089, 14, 23, 20, 3, -23 },
  { 1130, 14, 23, 20, 3, -23 },
  { 1171, 1, 23, 8, 3, -23 },
  { 1174, 12, 23, 16, 1, -23 },
  { 1209, 14, 23, 18, 3, -23 },
  { 1250, 11, 23, 15, 3, -23 },
  { 1282, 19, 23, 25, 3, -23 },
  { 1337, 14, 23, 20, 3, -23 },
  { 1378, 15, 23, 19, 2, -23 },
  { 1422, 13, 23, 17, 3, -23 },
  { 1460, 15, 27, 19, 2, -23 },
  { 1511, 14, 23, 19, 3, -23 },
  { 1552, 14, 23, 17, 2, -23 },
  { 1593, 15, 23, 17, 1, -23 },
  { 1637, 13, 23, 19, 3, -23 },
  { 1675, 16, 23, 17, 1, -23 },
  { 1721, 24, 23, 26, 1, -23 },
  { 1790, 15, 23, 17, 1, -23 },
  { 1834, 16, 23, 17, 1, -23 },
  { 1880, 14, 23, 17, 2, -23 },
  { 1921, 4, 32, 7, 3, -27 },
  { 1937, 9, 25, 11, 1, -23 },
  { 1966, 4, 32, 7, 0, -27 },
  { 1982, 8, 12, 12, 2, -23 },
  { 1994, 12, 1, 12, 0, 0 },
  { 1996, 5, 4, 9, 2, -24 },
  { 1999, 11, 17, 15, 2, -17 },
  { 2023, 11, 25, 16, 3, -25 },
  { 2058, 11, 17, 15, 2, -17 },
  { 2082, 11, 25, 16, 2, -25 },
  { 2117, 12, 17, 15, 1, -17 },
  { 2143, 8, 25, 9, 1, -25 },
  { 2168, 11, 24, 16, 2, -17 },
  { 2201, 10, 25, 16, 3, -25 },
  { 2233, 2, 24, 6, 2, -24 },
  { 2239, 6, 31, 7, -2, -24 },
  { 2263, 10, 25, 14, 3, -25 },
  { 2295, 1, 25, 6, 3, -25 },
  { 2299, 21, 17, 26, 2, -17 },
  { 2344, 10, 17, 16, 3, -17 },
  { 2366, 12, 17, 16, 2, -17 },
  { 2392, 11, 24, 16, 3, -17 },
  { 2425, 11, 24, 16, 2, -17 },
  { 2458, 6, 17, 10, 3, -17 },
  { 2471, 11, 17, 15, 2, -17 },
  { 2495, 7, 22, 9, 1, -22 },
  { 2515, 10, 17, 16, 3, -17 },
  { 2537, 12, 17, 14, 1, -17 },
  { 2563, 19, 17, 22, 1, -17 },
  { 2604, 12, 17, 14, 1, -17 },
  { 2630, 12, 24, 14, 1, -17 },
  { 2666, 12, 17, 14, 1, -17 },
  { 2692, 8, 33, 10, 1, -26 },
  { 2725, 1, 27, 7, 3, -23 },
  { 2729, 8, 33, 10, 0, -26 },
  { 2762, 15, 5, 20, 2, -12 },
};

const GFXfont RobotoCondensed_Thin33pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin33pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin33pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _ROBOTOCONDENSED_THIN33PT7B_H_
