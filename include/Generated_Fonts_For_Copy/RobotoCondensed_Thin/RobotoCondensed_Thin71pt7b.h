#ifndef _ROBOTOCONDENSED_THIN71PT7B_H_
#define _ROBOTOCONDENSED_THIN71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin71pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x49, 0x24, 0x00, 0x00, 0x00, 0x07, 0xFD, 0x80, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x20, 0x00, 0x03, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x40, 0x06, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x04, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x08, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x60, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x10, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x20, 0x03, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x0C, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x20, 0x00, 0x03, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xC0, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x07, 0x00, 0x01, 0xC0,
  0xF0, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x00,
  0xC0, 0x03, 0x01, 0x80, 0x01, 0x80, 0x18, 0x06, 0x00, 0x06, 0x00, 0x60,
  0x30, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x1C, 0x06, 0x00, 0x00,
  0x7F, 0xE0, 0x10, 0x00, 0x00, 0x7E, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x1F, 0x80, 0x00, 0x03, 0x00, 0xFF, 0x80, 0x00, 0x0C, 0x06, 0x07, 0x00,
  0x00, 0x60, 0x30, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x18, 0x00, 0x0C, 0x06,
  0x00, 0x20, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x00,
  0x0C, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x01, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x87, 0x00, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x1C,
  0x03, 0x00, 0x0C, 0x18, 0x03, 0x80, 0x0C, 0x30, 0x01, 0x80, 0x0C, 0x30,
  0x00, 0xC0, 0x0C, 0x60, 0x00, 0x60, 0x0C, 0x60, 0x00, 0x70, 0x0C, 0xC0,
  0x00, 0x30, 0x0C, 0xC0, 0x00, 0x18, 0x18, 0xC0, 0x00, 0x0C, 0x18, 0xC0,
  0x00, 0x0E, 0x18, 0xC0, 0x00, 0x06, 0x30, 0xC0, 0x00, 0x03, 0x30, 0xC0,
  0x00, 0x01, 0xE0, 0xC0, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xB0, 0x30, 0x00, 0x03, 0x38, 0x18,
  0x00, 0x0E, 0x18, 0x0E, 0x00, 0x1C, 0x0C, 0x07, 0x80, 0xF0, 0x06, 0x01,
  0xFF, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x07, 0xF8, 0x06, 0x03, 0xE1, 0xF0,
  0x60, 0xF8, 0x07, 0xC6, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0C, 0x03,
  0x80, 0x01, 0x80, 0x18, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x70, 0x06, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x19, 0x8C, 0xC6, 0x20, 0xFF, 0xFF, 0xFF, 0xF0, 0x6F,
  0xF6, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1C,
  0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x60, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x06, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x18, 0x00, 0x07, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x70, 0x07, 0x00, 0x38, 0x00, 0x70, 0x3C, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x04, 0x00, 0xF0, 0x0F, 0xC1, 0xF3,
  0x1E, 0x0D, 0xE0, 0x3E, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x0E, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xC0,
  0x01, 0xC0, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3C, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x06, 0x40, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x06, 0x70, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x70,
  0x00, 0x18, 0x0F, 0x00, 0x1C, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x01,
  0x90, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x31, 0x00, 0x00, 0x01, 0x84,
  0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x06, 0x01, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x18, 0x01, 0x00, 0x00, 0xE0, 0x04, 0x00, 0x03, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x40, 0x00, 0x60, 0x01, 0x00, 0x03, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x40, 0x03, 0x80, 0x01, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x60, 0x00, 0x10, 0x01, 0x80, 0x00, 0x40, 0x0C,
  0x00, 0x01, 0x00, 0x70, 0x00, 0x04, 0x01, 0x80, 0x00, 0x10, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x86, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x0F,
  0xE0, 0x03, 0x3F, 0xFC, 0x01, 0x70, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0xE0,
  0x00, 0x38, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x70,
  0x00, 0x70, 0x1C, 0x00, 0x70, 0x07, 0x80, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x7F, 0x00, 0x30, 0x7F, 0xF8, 0x06, 0x1C,
  0x03, 0x80, 0x8E, 0x00, 0x18, 0x13, 0x80, 0x01, 0x82, 0x60, 0x00, 0x18,
  0xD8, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x33, 0x80, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0x18,
  0x00, 0x0C, 0x01, 0x80, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x01, 0xE0, 0x78,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x03, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0xC0,
  0x00, 0xE0, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C,
  0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x02, 0x30, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x06, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0x01, 0xE0, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x60, 0x70,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x38, 0x0E, 0x00, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x3C, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x1B,
  0x18, 0x00, 0x0C, 0xC7, 0x00, 0x07, 0x30, 0xE0, 0x03, 0x8C, 0x1E, 0x03,
  0xC3, 0x01, 0xFF, 0xC0, 0x80, 0x1F, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x73, 0x9C, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xBD, 0xE6, 0x00, 0x38, 0xE3, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x18, 0x61, 0x86, 0x18, 0x61, 0x8C, 0x31, 0xC6, 0x38,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x1F, 0xF8, 0x01, 0xC0, 0xE0, 0x18, 0x01, 0x81, 0x80, 0x06,
  0x18, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00,
  0x00, 0xD0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x01, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x01, 0xF0, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0xFE, 0x00, 0x06,
  0x0C, 0x00, 0x07, 0x01, 0x80, 0x01, 0x86, 0x00, 0x07, 0x00, 0x70, 0x00,
  0xC7, 0x00, 0x07, 0x00, 0x18, 0x00, 0x63, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x31, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0xC0, 0x03, 0x00, 0x03, 0x00,
  0x04, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x02, 0x60, 0x00, 0x80, 0x00, 0x80,
  0x01, 0xB0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0xD8, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x6C, 0x00, 0x30, 0x00, 0x30, 0x00, 0x36, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1A, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0D, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x80, 0x06, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xE0, 0x01, 0x00, 0x00, 0xC0, 0x00, 0xB0, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x58, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x6C, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x36, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x19, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x80, 0x04, 0x00, 0x06, 0x00, 0x04, 0x40, 0x02, 0x00,
  0x03, 0x00, 0x06, 0x30, 0x01, 0x80, 0x03, 0x80, 0x03, 0x18, 0x00, 0xC0,
  0x01, 0x40, 0x01, 0x0C, 0x00, 0x60, 0x01, 0xB0, 0x01, 0x86, 0x00, 0x10,
  0x00, 0x98, 0x01, 0x83, 0x00, 0x0C, 0x00, 0xC4, 0x00, 0xC0, 0xC0, 0x03,
  0x00, 0xC3, 0x00, 0xC0, 0x60, 0x01, 0xC1, 0xC0, 0xE1, 0xC0, 0x30, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x0C, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x05, 0x80, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00,
  0x40, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x03, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x02, 0x00,
  0x03, 0xC0, 0x40, 0x00, 0x0E, 0x08, 0x00, 0x00, 0xE1, 0x00, 0x00, 0x0C,
  0x20, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x10, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x19,
  0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x64, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x01, 0x10, 0x00, 0x00, 0x62, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x03, 0x08,
  0x00, 0x00, 0xE1, 0x00, 0x00, 0x38, 0x20, 0x00, 0x1E, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x10, 0x00, 0x0F, 0x02, 0x00, 0x00, 0x38, 0x40,
  0x00, 0x03, 0x88, 0x00, 0x00, 0x31, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x39,
  0x00, 0x00, 0x0E, 0x20, 0x00, 0x03, 0x84, 0x00, 0x01, 0xE0, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x03,
  0x80, 0x01, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x20, 0x00,
  0x3E, 0x01, 0x00, 0x00, 0x38, 0x08, 0x00, 0x00, 0xE0, 0x40, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x64, 0x00, 0x00, 0x06, 0x20,
  0x00, 0x00, 0x71, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x07, 0x02, 0x00, 0x00, 0x70, 0x10, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x3C, 0x03, 0x80, 0x01, 0xF0, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x60, 0x00, 0x01, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x70, 0x1C,
  0x00, 0x70, 0x07, 0x80, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x72, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x82, 0x00, 0x00, 0x1C, 0x08, 0x00,
  0x00, 0xE0, 0x20, 0x00, 0x07, 0x00, 0x80, 0x00, 0x18, 0x02, 0x00, 0x00,
  0xC0, 0x08, 0x00, 0x06, 0x00, 0x20, 0x00, 0x38, 0x00, 0x80, 0x01, 0xC0,
  0x02, 0x00, 0x0E, 0x00, 0x08, 0x00, 0x30, 0x00, 0x20, 0x01, 0x80, 0x00,
  0x80, 0x0C, 0x00, 0x02, 0x00, 0x60, 0x00, 0x08, 0x03, 0x80, 0x00, 0x20,
  0x1C, 0x00, 0x00, 0x80, 0x60, 0x00, 0x02, 0x03, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x20, 0xF0, 0x00, 0x00, 0x86, 0x60, 0x00, 0x02, 0x31, 0xC0,
  0x00, 0x09, 0x83, 0x00, 0x00, 0x2E, 0x06, 0x00, 0x00, 0xB0, 0x0C, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x20, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x02, 0x00, 0x07, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x80, 0x00, 0x30, 0x02, 0x00, 0x00, 0xE0, 0x08, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x03, 0x00, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x1C, 0x08, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x60, 0x80, 0x00, 0x01,
  0xC2, 0x00, 0x00, 0x03, 0x88, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x00, 0x3A, 0x00, 0x00, 0x00, 0x70, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x0B, 0xB0, 0x00, 0x00, 0x00, 0x1B, 0xB0, 0x00, 0x00,
  0x00, 0x1B, 0x90, 0x00, 0x00, 0x00, 0x33, 0x98, 0x00, 0x00, 0x00, 0x33,
  0x98, 0x00, 0x00, 0x00, 0x33, 0x8C, 0x00, 0x00, 0x00, 0x63, 0x8C, 0x00,
  0x00, 0x00, 0x63, 0x8C, 0x00, 0x00, 0x00, 0x43, 0x86, 0x00, 0x00, 0x00,
  0xC3, 0x86, 0x00, 0x00, 0x00, 0xC3, 0x82, 0x00, 0x00, 0x00, 0x83, 0x83,
  0x00, 0x00, 0x01, 0x83, 0x83, 0x00, 0x00, 0x01, 0x83, 0x81, 0x80, 0x00,
  0x03, 0x03, 0x81, 0x80, 0x00, 0x03, 0x03, 0x81, 0x80, 0x00, 0x03, 0x03,
  0x80, 0xC0, 0x00, 0x06, 0x03, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x40,
  0x00, 0x04, 0x03, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x80, 0x60, 0x00, 0x0C,
  0x03, 0x80, 0x20, 0x00, 0x18, 0x03, 0x80, 0x30, 0x00, 0x18, 0x03, 0x80,
  0x30, 0x00, 0x18, 0x03, 0x80, 0x18, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00,
  0x30, 0x03, 0x80, 0x08, 0x00, 0x20, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x04, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x01, 0x80, 0x03, 0x80, 0x01, 0x01, 0x00, 0x03, 0x80,
  0x01, 0x83, 0x00, 0x03, 0x80, 0x01, 0x83, 0x00, 0x03, 0x80, 0x00, 0x86,
  0x00, 0x03, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x80, 0x00, 0xC6, 0x00, 0x03,
  0x80, 0x00, 0x6C, 0x00, 0x03, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x80, 0x00,
  0x6C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x10, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x70, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xF0,
  0x0F, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x02, 0x00, 0x00, 0xF0, 0x40, 0x00, 0x07, 0x08, 0x00, 0x00, 0x71, 0x00,
  0x00, 0x07, 0x20, 0x00, 0x00, 0x64, 0x00, 0x00, 0x0E, 0x80, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x1C, 0x80, 0x00, 0x07, 0x10, 0x00, 0x01, 0xC2, 0x00, 0x00,
  0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x07,
  0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xC3, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x0C, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xE0,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x07, 0x80, 0x01,
  0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0xE0,
  0x1E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x18, 0x00, 0x18, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x00, 0x08, 0xC0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x01, 0x20, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01,
  0x08, 0x00, 0x01, 0x83, 0x00, 0x00, 0x61, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x0C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x20, 0x40, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x08, 0x00, 0x06, 0x03,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18,
  0x0C, 0x00, 0x04, 0x02, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x40, 0x00,
  0xC0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x06, 0x01, 0x80,
  0x03, 0x00, 0x60, 0x00, 0x80, 0x10, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x03,
  0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0xC0,
  0x18, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x02, 0x00, 0x04, 0x01, 0x80, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0C, 0x00,
  0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x20, 0x30,
  0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x06, 0x18, 0x00, 0x01,
  0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x06, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x08, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x7F, 0xFF, 0xF8, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0x90, 0x00, 0x19, 0x80,
  0x01, 0x98, 0x00, 0x30, 0x80, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x04,
  0x00, 0x60, 0x60, 0x04, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80,
  0x30, 0x18, 0x01, 0x81, 0x80, 0x18, 0x10, 0x01, 0x83, 0x00, 0x0C, 0x30,
  0x00, 0xC2, 0x00, 0x0C, 0x60, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0x60,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x38, 0x0C, 0x03, 0x01,
  0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x20, 0x00, 0x03, 0x30, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x78, 0x00, 0x10,
  0x70, 0x00, 0x08, 0x60, 0x00, 0x04, 0x60, 0x00, 0x02, 0x70, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x98, 0x00, 0x00, 0x48, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x60, 0x00,
  0x07, 0x30, 0x00, 0x06, 0x98, 0x00, 0x06, 0x46, 0x00, 0x07, 0x31, 0x80,
  0x06, 0x18, 0xF0, 0x1E, 0x0C, 0x1F, 0xFC, 0x06, 0x01, 0xF0, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x3E, 0x00, 0x81, 0xFF, 0xC0, 0x87,
  0x01, 0xE0, 0x8C, 0x00, 0x70, 0x98, 0x00, 0x18, 0xB0, 0x00, 0x1C, 0xA0,
  0x00, 0x0C, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x80,
  0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x06, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xB0,
  0x00, 0x1C, 0xB8, 0x00, 0x18, 0x9C, 0x00, 0x70, 0x87, 0x01, 0xE0, 0x83,
  0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0xF0, 0x1E, 0x00, 0xE0, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x38,
  0x60, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x90, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x16, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01,
  0x8C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x70, 0x00,
  0xC0, 0x1E, 0x03, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0xF8, 0x06, 0x03, 0xFF, 0x83,
  0x07, 0x80, 0xE1, 0x87, 0x00, 0x1C, 0xC7, 0x00, 0x06, 0x63, 0x00, 0x01,
  0xB3, 0x00, 0x00, 0x79, 0x80, 0x00, 0x1D, 0x80, 0x00, 0x0E, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x0E, 0x60, 0x00, 0x07, 0x18, 0x00, 0x07, 0x8E, 0x00, 0x06, 0xC3, 0x80,
  0x0E, 0x60, 0xF0, 0x1E, 0x30, 0x1F, 0xFC, 0x18, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3C, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x0E, 0x00, 0x0E, 0x07, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x02, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x38, 0x00, 0x0C, 0x07, 0x80, 0x06, 0x00,
  0x78, 0x0F, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x3F, 0xC0, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0xC1, 0xE0,
  0x38, 0x61, 0xC0, 0x07, 0x31, 0xC0, 0x01, 0x98, 0xC0, 0x00, 0x6C, 0xC0,
  0x00, 0x1E, 0x60, 0x00, 0x07, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x03, 0x98,
  0x00, 0x03, 0xC6, 0x00, 0x01, 0xE3, 0x80, 0x01, 0xB0, 0xE0, 0x03, 0x98,
  0x3C, 0x07, 0x8C, 0x07, 0xFF, 0x06, 0x00, 0xFC, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x1C, 0x00,
  0x0E, 0x07, 0x00, 0x0E, 0x01, 0xE0, 0x1E, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x07, 0x80, 0x40, 0x7F, 0xE0,
  0x83, 0x80, 0xE1, 0x0E, 0x00, 0x62, 0x30, 0x00, 0x64, 0xC0, 0x00, 0xC9,
  0x80, 0x00, 0xD6, 0x00, 0x01, 0xA8, 0x00, 0x03, 0x70, 0x00, 0x02, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x6F,
  0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x70, 0xFE, 0x0F, 0xC0, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x80, 0x00, 0x39, 0x00, 0x00, 0xE2, 0x00, 0x03, 0x84, 0x00,
  0x0E, 0x08, 0x00, 0x38, 0x10, 0x00, 0x60, 0x20, 0x01, 0x80, 0x40, 0x06,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x60, 0x02, 0x01, 0xC0, 0x04, 0x07, 0x00,
  0x08, 0x1C, 0x00, 0x10, 0x30, 0x00, 0x20, 0xC0, 0x00, 0x43, 0x80, 0x00,
  0x8F, 0x00, 0x01, 0x33, 0x00, 0x02, 0xC3, 0x00, 0x07, 0x06, 0x00, 0x0C,
  0x06, 0x00, 0x10, 0x06, 0x00, 0x20, 0x0E, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x0C, 0x01, 0x00, 0x1C, 0x02, 0x00, 0x18, 0x04, 0x00, 0x18, 0x08, 0x00,
  0x18, 0x10, 0x00, 0x38, 0x20, 0x00, 0x30, 0x40, 0x00, 0x30, 0x80, 0x00,
  0x71, 0x00, 0x00, 0x62, 0x00, 0x00, 0x64, 0x00, 0x00, 0xE8, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x06, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x30, 0x70, 0x3C, 0x03, 0x80, 0xE1, 0x86, 0x00, 0x70, 0x30,
  0x01, 0x8C, 0x60, 0x01, 0xC3, 0x00, 0x06, 0x66, 0x00, 0x06, 0x30, 0x00,
  0x3B, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xDB, 0x00, 0x00, 0xD8, 0x00, 0x06,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x1E, 0x01, 0x01, 0xFF,
  0x82, 0x0E, 0x03, 0x84, 0x38, 0x01, 0x88, 0xC0, 0x01, 0x93, 0x00, 0x03,
  0x26, 0x00, 0x03, 0x58, 0x00, 0x06, 0xA0, 0x00, 0x0D, 0xC0, 0x00, 0x0B,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3C, 0x0F, 0x00, 0x1C, 0x00,
  0x70, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x06,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x30, 0x00, 0x30, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x3C, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x81, 0xFF, 0xC0, 0x87, 0x01, 0xE0, 0x8C, 0x00, 0x70, 0x98, 0x00,
  0x18, 0xB0, 0x00, 0x1C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xE0, 0x00, 0x0C, 0xB0, 0x00, 0x1C, 0xB8, 0x00, 0x18, 0x9C, 0x00,
  0x70, 0x87, 0x81, 0xE0, 0x83, 0xFF, 0xC0, 0x80, 0x7E, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xE0, 0xC1, 0xE0, 0x38, 0x61, 0xC0,
  0x07, 0x31, 0xC0, 0x01, 0xD8, 0xC0, 0x00, 0x6C, 0xC0, 0x00, 0x1E, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x03, 0x98, 0x00, 0x01, 0xC6,
  0x00, 0x01, 0xE3, 0x80, 0x01, 0xB0, 0xE0, 0x03, 0x98, 0x3C, 0x07, 0x8C,
  0x07, 0xFF, 0x06, 0x00, 0x7C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x3E, 0x07, 0xF8, 0x78, 0x23, 0x80, 0x8C, 0x02, 0x60, 0x0B, 0x00, 0x28,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x38, 0x07, 0x81, 0xC0, 0x03, 0x83, 0x00, 0x01, 0x8C, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00,
  0x0B, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x19, 0x80, 0x00,
  0x33, 0x80, 0x00, 0xC3, 0x80, 0x03, 0x01, 0xE0, 0x3C, 0x01, 0xFF, 0xF0,
  0x00, 0x3E, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xFE, 0x00, 0x3E, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x60, 0x00, 0x1E, 0xC0, 0x00, 0x6C, 0xC0, 0x01, 0xD9, 0xC0, 0x07,
  0x31, 0xE0, 0x38, 0x60, 0xFF, 0xE0, 0xC0, 0x7E, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x09, 0x80, 0x00, 0x06, 0x60,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x18, 0x00, 0x03, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x30, 0x00,
  0x18, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x18,
  0x00, 0x60, 0x06, 0x00, 0x18, 0x00, 0x80, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x0C, 0x00, 0xC0, 0x01, 0x00, 0x30, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06,
  0x00, 0x02, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C,
  0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x10, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x60, 0x00, 0x0E, 0x00, 0x01,
  0x98, 0x00, 0x07, 0x00, 0x00, 0xCC, 0x00, 0x07, 0x80, 0x00, 0x66, 0x00,
  0x03, 0x40, 0x00, 0x63, 0x00, 0x01, 0xB0, 0x00, 0x30, 0xC0, 0x00, 0x98,
  0x00, 0x18, 0x60, 0x00, 0xCC, 0x00, 0x0C, 0x30, 0x00, 0x66, 0x00, 0x0E,
  0x18, 0x00, 0x31, 0x80, 0x06, 0x06, 0x00, 0x10, 0xC0, 0x03, 0x03, 0x00,
  0x18, 0x60, 0x01, 0x81, 0x80, 0x0C, 0x18, 0x01, 0xC0, 0xC0, 0x06, 0x0C,
  0x00, 0xC0, 0x30, 0x02, 0x06, 0x00, 0x60, 0x18, 0x03, 0x03, 0x00, 0x30,
  0x0C, 0x01, 0x80, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x60, 0x18, 0x01, 0x80,
  0xC0, 0x30, 0x0C, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x00, 0x60, 0x30, 0x06,
  0x07, 0x00, 0x30, 0x10, 0x03, 0x03, 0x00, 0x0C, 0x18, 0x01, 0x81, 0x80,
  0x06, 0x0C, 0x00, 0x40, 0xC0, 0x03, 0x06, 0x00, 0x30, 0x60, 0x01, 0x82,
  0x00, 0x18, 0x60, 0x00, 0xE3, 0x00, 0x0C, 0x30, 0x00, 0x31, 0x80, 0x03,
  0x18, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0x40, 0x00, 0xCC, 0x00,
  0x06, 0x60, 0x00, 0x66, 0x00, 0x01, 0xB0, 0x00, 0x1B, 0x00, 0x00, 0xD0,
  0x00, 0x0D, 0x80, 0x00, 0x68, 0x00, 0x06, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x03,
  0x00, 0x60, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0x60,
  0x1C, 0x00, 0x18, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x01, 0x86, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0xC0,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00,
  0x30, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x60, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x18,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x30, 0x00, 0x18,
  0x0C, 0x00, 0x0C, 0x01, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00,
  0x60, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x04,
  0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x60, 0x18, 0x00, 0x08, 0x06, 0x00,
  0x03, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x21, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x80,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xC0,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x18, 0x1C, 0x00, 0x03, 0x30, 0x07,
  0x00, 0x03, 0x60, 0x03, 0x80, 0x03, 0x60, 0x01, 0xC0, 0x03, 0x60, 0x00,
  0xE0, 0x06, 0xC0, 0x00, 0x70, 0x06, 0xC0, 0x00, 0x38, 0x1C, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xE0,
};

const GFXglyph RobotoCondensed_Thin71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 3, 51, 13, 5, -50 },
  { 21, 9, 14, 18, 5, -53 },
  { 37, 33, 50, 35, 2, -50 },
  { 244, 26, 64, 34, 4, -57 },
  { 452, 38, 52, 46, 4, -51 },
  { 699, 32, 52, 38, 4, -51 },
  { 907, 2, 14, 12, 5, -53 },
  { 911, 13, 72, 19, 5, -56 },
  { 1028, 12, 72, 20, 2, -56 },
  { 1136, 28, 27, 30, 1, -50 },
  { 1231, 29, 37, 35, 3, -43 },
  { 1366, 5, 14, 13, 3, -5 },
  { 1375, 14, 2, 19, 2, -24 },
  { 1379, 4, 4, 15, 5, -3 },
  { 1381, 20, 54, 24, 2, -50 },
  { 1516, 26, 52, 34, 4, -51 },
  { 1685, 14, 50, 34, 6, -50 },
  { 1773, 27, 51, 34, 4, -51 },
  { 1946, 26, 52, 34, 4, -51 },
  { 2115, 30, 50, 34, 3, -50 },
  { 2303, 25, 51, 34, 6, -50 },
  { 2463, 27, 51, 34, 4, -50 },
  { 2636, 27, 50, 34, 3, -50 },
  { 2805, 27, 52, 34, 4, -51 },
  { 2981, 26, 51, 34, 4, -51 },
  { 3147, 5, 37, 12, 4, -36 },
  { 3171, 6, 45, 12, 3, -36 },
  { 3205, 25, 28, 32, 3, -37 },
  { 3293, 25, 16, 35, 5, -31 },
  { 3343, 25, 28, 32, 4, -37 },
  { 3431, 21, 52, 28, 3, -51 },
  { 3568, 49, 65, 57, 4, -49 },
  { 3967, 34, 50, 37, 2, -50 },
  { 4180, 27, 50, 38, 7, -50 },
  { 4349, 31, 52, 40, 5, -51 },
  { 4551, 29, 50, 41, 7, -50 },
  { 4733, 26, 50, 36, 7, -50 },
  { 4896, 26, 50, 36, 7, -50 },
  { 5059, 31, 52, 43, 6, -51 },
  { 5261, 30, 50, 44, 7, -50 },
  { 5449, 1, 50, 17, 8, -50 },
  { 5456, 25, 51, 34, 3, -50 },
  { 5616, 30, 50, 39, 7, -50 },
  { 5804, 23, 50, 32, 7, -50 },
  { 5948, 40, 50, 53, 7, -50 },
  { 6198, 30, 50, 44, 7, -50 },
  { 6386, 32, 52, 42, 5, -51 },
  { 6594, 27, 50, 38, 7, -50 },
  { 6763, 32, 60, 42, 5, -51 },
  { 7003, 30, 50, 41, 6, -50 },
  { 7191, 31, 52, 37, 3, -51 },
  { 7393, 33, 50, 37, 2, -50 },
  { 7600, 29, 51, 41, 6, -50 },
  { 7785, 34, 50, 37, 2, -50 },
  { 7998, 51, 50, 56, 2, -50 },
  { 8317, 33, 50, 37, 2, -50 },
  { 8524, 34, 50, 37, 2, -50 },
  { 8737, 31, 50, 37, 3, -50 },
  { 8931, 8, 69, 14, 6, -58 },
  { 9000, 20, 54, 24, 2, -50 },
  { 9135, 9, 69, 14, 0, -58 },
  { 9213, 20, 25, 26, 3, -50 },
  { 9276, 25, 2, 26, 1, 0 },
  { 9283, 9, 9, 19, 5, -53 },
  { 9294, 25, 40, 33, 3, -39 },
  { 9419, 24, 54, 34, 6, -53 },
  { 9581, 25, 40, 32, 3, -39 },
  { 9706, 25, 54, 34, 4, -53 },
  { 9875, 26, 40, 32, 3, -39 },
  { 10005, 17, 54, 20, 3, -54 },
  { 10120, 25, 53, 34, 4, -39 },
  { 10286, 23, 53, 34, 6, -53 },
  { 10439, 4, 52, 14, 5, -52 },
  { 10465, 12, 66, 14, -3, -52 },
  { 10564, 23, 53, 30, 6, -53 },
  { 10717, 2, 53, 14, 6, -53 },
  { 10731, 45, 39, 55, 5, -39 },
  { 10951, 23, 39, 34, 6, -39 },
  { 11064, 26, 40, 34, 4, -39 },
  { 11194, 24, 53, 34, 6, -39 },
  { 11353, 25, 53, 34, 4, -39 },
  { 11519, 14, 39, 22, 6, -39 },
  { 11588, 23, 40, 31, 4, -39 },
  { 11703, 16, 49, 20, 2, -48 },
  { 11801, 23, 39, 34, 6, -38 },
  { 11914, 26, 38, 30, 2, -38 },
  { 12038, 41, 38, 47, 3, -38 },
  { 12233, 26, 38, 30, 2, -38 },
  { 12357, 26, 52, 30, 2, -38 },
  { 12526, 25, 38, 30, 3, -38 },
  { 12645, 17, 70, 21, 3, -55 },
  { 12794, 2, 59, 14, 6, -50 },
  { 12809, 17, 70, 21, 1, -55 },
  { 12958, 32, 11, 43, 5, -26 },
};

const GFXfont RobotoCondensed_Thin71pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin71pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin71pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _ROBOTOCONDENSED_THIN71PT7B_H_
