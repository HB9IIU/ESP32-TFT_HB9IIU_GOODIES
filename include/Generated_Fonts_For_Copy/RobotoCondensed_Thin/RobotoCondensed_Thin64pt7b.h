#ifndef _ROBOTOCONDENSED_THIN64PT7B_H_
#define _ROBOTOCONDENSED_THIN64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin64pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x00, 0x67,
  0x60, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x83, 0x83,
  0x83, 0x83, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0x80,
  0x18, 0x00, 0x02, 0x00, 0x60, 0x00, 0x08, 0x01, 0x00, 0x00, 0x60, 0x04,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x40, 0x0C, 0x00, 0x01, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x80, 0x00,
  0x30, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x08,
  0x01, 0x80, 0x00, 0x20, 0x04, 0x00, 0x00, 0x80, 0x10, 0x00, 0x06, 0x00,
  0x40, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x04, 0x00, 0xC0, 0x00, 0x10, 0x02, 0x00, 0x00, 0xC0, 0x08, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x02, 0x00, 0x40, 0x00, 0x08, 0x01, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x00, 0x20, 0x00, 0x04, 0x00, 0x80,
  0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x20, 0x04, 0x00, 0x00, 0x80, 0x10, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0x00, 0xE0, 0x18, 0x00, 0xE0,
  0x60, 0x00, 0xE0, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x98,
  0x00, 0x01, 0x30, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80,
  0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x30, 0x70, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x30, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x04, 0x02, 0x00, 0x30, 0x03, 0x00, 0x80, 0x0C,
  0x00, 0xC0, 0x20, 0x03, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0x30, 0x0C, 0x00, 0x80, 0x0C, 0x03, 0x00, 0x20, 0x03, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x60, 0x03, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x18, 0x0C, 0x00,
  0x18, 0x06, 0x06, 0x00, 0x03, 0x03, 0x01, 0x80, 0x00, 0xF7, 0x80, 0xC0,
  0x00, 0x0F, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x03, 0xF0, 0x00,
  0x02, 0x03, 0xDE, 0x00, 0x01, 0x80, 0xC0, 0xC0, 0x00, 0x40, 0x60, 0x18,
  0x00, 0x30, 0x30, 0x02, 0x00, 0x08, 0x0C, 0x00, 0xC0, 0x06, 0x02, 0x00,
  0x30, 0x03, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x20, 0x03, 0x00, 0x60, 0x08,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x30, 0x0C, 0x00, 0x80, 0x0C, 0x03, 0x00,
  0x20, 0x03, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x30, 0x10,
  0x00, 0xC0, 0x08, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x60,
  0x1C, 0x00, 0x04, 0x00, 0xC0, 0x00, 0xC0, 0x04, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x80, 0x08,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x00,
  0xC0, 0x06, 0x30, 0x06, 0x00, 0x66, 0x00, 0x60, 0x06, 0x60, 0x03, 0x00,
  0x6C, 0x00, 0x18, 0x06, 0xC0, 0x00, 0xC0, 0x4C, 0x00, 0x0C, 0x0C, 0x80,
  0x00, 0x60, 0xC8, 0x00, 0x03, 0x0C, 0x80, 0x00, 0x19, 0x88, 0x00, 0x01,
  0x98, 0xC0, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x06,
  0x00, 0x00, 0xF0, 0x60, 0x00, 0x0D, 0x83, 0x00, 0x03, 0x8C, 0x18, 0x00,
  0x60, 0x60, 0xE0, 0x1C, 0x06, 0x07, 0xFF, 0x80, 0x30, 0x07, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80,
  0x18, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x40, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x01, 0xF8, 0x06, 0x03, 0xCF, 0x02, 0x0F, 0x80, 0xF1, 0x1E, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x30, 0x18,
  0x00, 0x38, 0x06, 0x00, 0x18, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x1C, 0x00,
  0x30, 0x0C, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x11, 0x11, 0x13, 0x33,
  0x36, 0x6C, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x5F, 0xA0, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFE, 0x00, 0x1C, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x00,
  0x0C, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x32, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x58, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x4C, 0x00, 0x01, 0x98, 0x00, 0x03, 0x10, 0x00, 0x04, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x30, 0x60, 0x00, 0xC0, 0x60, 0x03, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x38, 0x00, 0x7F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x10, 0x0F, 0x03,
  0xD0, 0xE1, 0x78, 0x1E, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x78, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x30, 0x00, 0x30, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0x80, 0xE0, 0x06,
  0x00, 0x30, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x30,
  0x00, 0x06, 0x20, 0x00, 0x06, 0x60, 0x00, 0x02, 0x60, 0x00, 0x02, 0x60,
  0x00, 0x02, 0x60, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x30, 0x00, 0x02, 0x30, 0x00, 0x06, 0x18, 0x00, 0x04, 0x1C,
  0x00, 0x0C, 0x0E, 0x00, 0x18, 0x03, 0x80, 0x70, 0x01, 0xFF, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x40, 0x30, 0x00,
  0x18, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x03,
  0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x18,
  0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x61, 0xFC, 0x00, 0xCF, 0xFE, 0x01, 0x70, 0x0E, 0x03,
  0x80, 0x06, 0x06, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0x30, 0x00, 0x08,
  0x60, 0x00, 0x30, 0x60, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x70, 0x1C, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x7F, 0x00, 0x41, 0xFF, 0xC0,
  0xC7, 0x00, 0xE0, 0xCC, 0x00, 0x30, 0xD8, 0x00, 0x18, 0xF0, 0x00, 0x18,
  0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x04, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x03, 0x80, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x20, 0x00,
  0x02, 0x10, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x04, 0x30,
  0x00, 0x06, 0x18, 0x00, 0x03, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80,
  0xE0, 0x03, 0x80, 0x38, 0x03, 0x80, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0x80, 0xE0, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x02, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x63, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0x80, 0x00,
  0x02, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0x60, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x83,
  0x00, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x3C, 0x03, 0x80, 0x07, 0xFF, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x03, 0x81, 0xE0,
  0x06, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x18, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x02, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x07, 0x30, 0x00, 0x07, 0x30, 0x00, 0x0F, 0x18, 0x00, 0x1B,
  0x18, 0x00, 0x13, 0x0C, 0x00, 0x73, 0x07, 0x00, 0xE3, 0x03, 0xFF, 0x82,
  0x00, 0xFE, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x4F, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x4E, 0xE4, 0x23, 0xDE, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x31, 0x98, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0xFF, 0x80, 0x30, 0x1C, 0x0C, 0x01, 0xC3, 0x00, 0x18, 0xC0, 0x01, 0x98,
  0x00, 0x36, 0x00, 0x02, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x7C, 0x00, 0x0C, 0x18, 0x00, 0x1F, 0xF0,
  0x00, 0xC3, 0x00, 0x03, 0x01, 0x80, 0x04, 0x30, 0x00, 0x60, 0x0C, 0x00,
  0x63, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x66,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x26, 0x00,
  0x20, 0x00, 0xC0, 0x02, 0x40, 0x06, 0x00, 0x0C, 0x00, 0x2C, 0x00, 0x60,
  0x00, 0xC0, 0x02, 0xC0, 0x04, 0x00, 0x0C, 0x00, 0x2C, 0x00, 0x40, 0x00,
  0xC0, 0x02, 0xC0, 0x0C, 0x00, 0x08, 0x00, 0x2C, 0x00, 0xC0, 0x00, 0x80,
  0x02, 0xC0, 0x0C, 0x00, 0x08, 0x00, 0x2C, 0x00, 0xC0, 0x00, 0x80, 0x02,
  0xC0, 0x0C, 0x00, 0x08, 0x00, 0x2C, 0x00, 0x80, 0x01, 0x80, 0x06, 0xC0,
  0x08, 0x00, 0x18, 0x00, 0x6C, 0x00, 0x80, 0x01, 0x80, 0x06, 0xC0, 0x08,
  0x00, 0x18, 0x00, 0x6C, 0x00, 0x80, 0x01, 0x80, 0x04, 0xC0, 0x0C, 0x00,
  0x38, 0x00, 0xCC, 0x00, 0xC0, 0x03, 0x80, 0x0C, 0x40, 0x0C, 0x00, 0x78,
  0x00, 0x84, 0x00, 0x40, 0x04, 0x80, 0x18, 0x60, 0x06, 0x00, 0xCC, 0x03,
  0x06, 0x00, 0x60, 0x18, 0xC0, 0x30, 0x60, 0x03, 0x03, 0x06, 0x0E, 0x03,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x30, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x18,
  0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x20, 0x0C, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x02, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x04, 0x00, 0x06, 0x00, 0x18, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x40, 0x00, 0x18, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x04, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x01, 0x81, 0x80, 0x00, 0x01, 0x03, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x30, 0x00, 0x38, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x43, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00,
  0x04, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x11, 0x80, 0x00, 0x08, 0xC0,
  0x00, 0x0C, 0x60, 0x00, 0x04, 0x30, 0x00, 0x06, 0x18, 0x00, 0x06, 0x0C,
  0x00, 0x0E, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0xE0,
  0xC0, 0x00, 0x38, 0x60, 0x00, 0x06, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x02, 0xC0, 0x00, 0x01, 0x60, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x16, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x18,
  0x00, 0x0E, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x0E, 0x00, 0xF0, 0x03, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06,
  0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x13, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x06, 0x00,
  0x01, 0x80, 0x60, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0C, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x83, 0x00,
  0x03, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xC0, 0x1E, 0x00, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03,
  0x10, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x0E, 0x03, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x90, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0xC3,
  0x00, 0x06, 0x06, 0x00, 0x38, 0x0E, 0x03, 0xC0, 0x1F, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x73, 0x00, 0x00, 0x1C,
  0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x30, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x18, 0x03,
  0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x1C,
  0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x18,
  0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x31, 0xB0, 0x00, 0x06, 0x63, 0x00, 0x00, 0xD8,
  0x30, 0x00, 0x1E, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0x60, 0x06, 0x00,
  0x0C, 0x00, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x0C, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x30, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7A, 0x00, 0x00, 0x00, 0x0F, 0xB0, 0x00, 0x00,
  0x00, 0xFB, 0x00, 0x00, 0x00, 0x0B, 0x98, 0x00, 0x00, 0x01, 0xB9, 0x80,
  0x00, 0x00, 0x1B, 0x88, 0x00, 0x00, 0x03, 0x38, 0xC0, 0x00, 0x00, 0x33,
  0x8C, 0x00, 0x00, 0x02, 0x38, 0x40, 0x00, 0x00, 0x63, 0x86, 0x00, 0x00,
  0x06, 0x38, 0x60, 0x00, 0x00, 0x43, 0x82, 0x00, 0x00, 0x0C, 0x38, 0x30,
  0x00, 0x00, 0xC3, 0xC3, 0x00, 0x00, 0x08, 0x3C, 0x18, 0x00, 0x01, 0x83,
  0xC1, 0x80, 0x00, 0x18, 0x3C, 0x08, 0x00, 0x03, 0x03, 0xC0, 0xC0, 0x00,
  0x30, 0x3C, 0x0C, 0x00, 0x02, 0x03, 0xC0, 0x40, 0x00, 0x60, 0x3C, 0x06,
  0x00, 0x06, 0x03, 0xC0, 0x60, 0x00, 0x40, 0x3C, 0x02, 0x00, 0x0C, 0x03,
  0xC0, 0x30, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0x08, 0x03, 0xC0, 0x10, 0x01,
  0x80, 0x3C, 0x01, 0x80, 0x18, 0x03, 0xC0, 0x08, 0x03, 0x00, 0x3C, 0x00,
  0xC0, 0x30, 0x03, 0xC0, 0x0C, 0x02, 0x00, 0x3C, 0x00, 0x40, 0x60, 0x03,
  0xC0, 0x06, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x40, 0x03, 0xC0, 0x02, 0x0C,
  0x00, 0x3C, 0x00, 0x30, 0xC0, 0x03, 0xC0, 0x01, 0x08, 0x00, 0x3C, 0x00,
  0x11, 0x80, 0x03, 0xC0, 0x01, 0x98, 0x00, 0x3C, 0x00, 0x0B, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3D,
  0x80, 0x00, 0x03, 0xD8, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x03, 0xC4, 0x00,
  0x00, 0x3C, 0x60, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x3C, 0x30, 0x00, 0x03,
  0xC1, 0x80, 0x00, 0x3C, 0x18, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x3C, 0x06,
  0x00, 0x03, 0xC0, 0x60, 0x00, 0x3C, 0x03, 0x00, 0x03, 0xC0, 0x30, 0x00,
  0x3C, 0x01, 0x80, 0x03, 0xC0, 0x18, 0x00, 0x3C, 0x00, 0xC0, 0x03, 0xC0,
  0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x03, 0x00, 0x3C, 0x00, 0x30,
  0x03, 0xC0, 0x01, 0x80, 0x3C, 0x00, 0x18, 0x03, 0xC0, 0x00, 0xC0, 0x3C,
  0x00, 0x06, 0x03, 0xC0, 0x00, 0x60, 0x3C, 0x00, 0x03, 0x03, 0xC0, 0x00,
  0x30, 0x3C, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x08, 0x3C, 0x00, 0x00, 0xC3,
  0xC0, 0x00, 0x06, 0x3C, 0x00, 0x00, 0x63, 0xC0, 0x00, 0x03, 0x3C, 0x00,
  0x00, 0x33, 0xC0, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x0B, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x70, 0x07, 0x80, 0x06, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x21, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x01, 0x30, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x04,
  0x10, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x70, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x30,
  0x00, 0x1C, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x60, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x31, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x70, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x70, 0x07, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x70,
  0x00, 0xF0, 0x0F, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xF1, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x08, 0x00, 0x07, 0x02, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x88, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x06, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x06, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x08, 0x80, 0x00, 0x06, 0x20, 0x00, 0x03,
  0x08, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x08, 0x00, 0x18, 0x02, 0x00, 0x06, 0x00, 0x80, 0x00, 0xC0, 0x20,
  0x00, 0x30, 0x08, 0x00, 0x06, 0x02, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30,
  0x20, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x82, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x0C, 0x20, 0x00, 0x03, 0x08, 0x00, 0x00, 0x62, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x03, 0x20, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x98, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x0C, 0x07, 0x00, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x02, 0x00, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x02, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80,
  0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x04, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x40, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x38, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xE0, 0x00,
  0x02, 0x60, 0x00, 0x06, 0x80, 0x00, 0x19, 0x80, 0x00, 0x12, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x10, 0x00, 0x04,
  0x30, 0x00, 0x0C, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x21, 0x80, 0x00, 0xC1,
  0x00, 0x00, 0x86, 0x00, 0x03, 0x06, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x20, 0x00, 0x20, 0x60, 0x00, 0x40, 0xC0, 0x01, 0x81, 0x80,
  0x01, 0x03, 0x00, 0x06, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C, 0x00,
  0x30, 0x10, 0x00, 0x40, 0x30, 0x00, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x02,
  0x01, 0x80, 0x0C, 0x01, 0x00, 0x18, 0x06, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x08, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x04,
  0x01, 0x80, 0x0C, 0x02, 0x00, 0x18, 0x04, 0x00, 0x30, 0x08, 0x00, 0x60,
  0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x01, 0x01, 0x80, 0x02, 0x03,
  0x00, 0x06, 0x04, 0x00, 0x0C, 0x08, 0x00, 0x18, 0x10, 0x00, 0x30, 0x20,
  0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x00, 0x83, 0x00, 0x01, 0x06, 0x00,
  0x03, 0x08, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x40, 0x00,
  0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x8C, 0x00, 0x01,
  0x10, 0x00, 0x03, 0x30, 0x00, 0x06, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x58, 0x00, 0x00, 0xA0,
  0x00, 0x01, 0x60, 0x00, 0x02, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x02, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x05, 0x80,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x10, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFF, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x2C, 0x00, 0x36, 0x00, 0x19, 0x00, 0x08, 0xC0,
  0x0C, 0x60, 0x06, 0x10, 0x02, 0x0C, 0x03, 0x06, 0x01, 0x81, 0x00, 0x80,
  0xC0, 0xC0, 0x60, 0x60, 0x10, 0x20, 0x0C, 0x30, 0x06, 0x18, 0x01, 0x08,
  0x00, 0xCC, 0x00, 0x66, 0x00, 0x16, 0x00, 0x0F, 0x00, 0x06, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x06, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x70, 0x0E, 0x07, 0x00, 0x1C,
  0x18, 0x00, 0x30, 0xC0, 0x00, 0x66, 0x00, 0x00, 0x98, 0x00, 0x02, 0x60,
  0x00, 0x0D, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0xE0, 0x00, 0xC6, 0x00, 0x03, 0x30, 0x00, 0x0D, 0x80,
  0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF4,
  0x00, 0x02, 0xD8, 0x00, 0x1B, 0x30, 0x01, 0xCC, 0x70, 0x1C, 0x30, 0xFF,
  0xE0, 0xC0, 0xFC, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x01, 0xF0, 0x0C, 0x3F, 0xF8, 0x31, 0x80, 0x70,
  0xDC, 0x00, 0x63, 0x40, 0x00, 0xCF, 0x00, 0x03, 0x38, 0x00, 0x06, 0xC0,
  0x00, 0x1B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x6E,
  0x00, 0x01, 0xB8, 0x00, 0x0C, 0xF0, 0x00, 0x33, 0x60, 0x01, 0x8C, 0xE0,
  0x1C, 0x30, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0x00, 0x1C, 0x03, 0x80, 0x60, 0x03, 0x81, 0x80, 0x03, 0x86, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x04, 0x80, 0x00, 0x09,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x0D, 0x00, 0x00,
  0x13, 0x00, 0x00, 0x26, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x02,
  0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x0E, 0x01, 0xC0, 0x0F, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x03, 0xE0, 0x30, 0x7F, 0xF0, 0xC3, 0x80, 0x63, 0x18,
  0x00, 0xCC, 0xC0, 0x01, 0xB3, 0x00, 0x03, 0xD8, 0x00, 0x07, 0x60, 0x00,
  0x1D, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00,
  0x01, 0xCC, 0x00, 0x07, 0x30, 0x00, 0x3C, 0x60, 0x01, 0xB0, 0xE0, 0x1C,
  0xC1, 0xFF, 0xC3, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x00,
  0x1C, 0x07, 0x80, 0x60, 0x03, 0x81, 0x80, 0x03, 0x86, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x80, 0x00, 0x0B, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x06, 0x0E, 0x00, 0x18, 0x0F, 0x00, 0xE0, 0x07, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0xFF, 0xFC, 0xFF, 0xFC,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x30, 0xE0, 0x38,
  0xC6, 0x00, 0x33, 0x30, 0x00, 0x6C, 0xC0, 0x00, 0xF6, 0x00, 0x01, 0xD8,
  0x00, 0x07, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x60, 0x00, 0x0D,
  0x80, 0x00, 0x73, 0x00, 0x01, 0xCC, 0x00, 0x0F, 0x18, 0x00, 0x6C, 0x38,
  0x07, 0x30, 0x7F, 0xF0, 0xC0, 0x3E, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x62,
  0x00, 0x01, 0x8C, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x38, 0x03, 0x80, 0x7F,
  0xF8, 0x00, 0x3F, 0x80, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x1E, 0x03, 0x07, 0xFE, 0x18, 0x60, 0x38, 0xC6, 0x00,
  0x66, 0x60, 0x03, 0x36, 0x00, 0x0D, 0xA0, 0x00, 0x6F, 0x00, 0x01, 0x70,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0x80, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x1F, 0xC3,
  0xE0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x01, 0xD8, 0x00, 0x1C, 0xC0, 0x00, 0xC6, 0x00,
  0x0C, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0xC0, 0x60, 0x0C, 0x03,
  0x00, 0xC0, 0x18, 0x0E, 0x00, 0xC0, 0xE0, 0x06, 0x06, 0x00, 0x30, 0x60,
  0x01, 0x86, 0x00, 0x0C, 0x60, 0x00, 0x67, 0x80, 0x03, 0x66, 0x00, 0x1E,
  0x30, 0x00, 0xE0, 0xC0, 0x06, 0x03, 0x00, 0x30, 0x18, 0x01, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x60, 0x04, 0x03, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xC0,
  0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0x61, 0x80, 0x01, 0x8C, 0x00, 0x0C,
  0x60, 0x00, 0x33, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0xC7, 0x01, 0xC0, 0xE0, 0x38, 0xCC,
  0x00, 0xE1, 0xC0, 0x0C, 0xC8, 0x00, 0x63, 0x00, 0x06, 0xD8, 0x00, 0x32,
  0x00, 0x06, 0xF0, 0x00, 0x36, 0x00, 0x02, 0xE0, 0x00, 0x14, 0x00, 0x03,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x3C, 0x06, 0x0F, 0xFC, 0x30, 0xC0, 0x71, 0x8C,
  0x00, 0xCC, 0xC0, 0x06, 0x6C, 0x00, 0x1B, 0x40, 0x00, 0xDE, 0x00, 0x02,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00,
  0x7C, 0x00, 0x07, 0xFF, 0x00, 0x1C, 0x07, 0x00, 0x60, 0x03, 0x01, 0x80,
  0x03, 0x06, 0x00, 0x03, 0x08, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00,
  0x0D, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC4, 0x00,
  0x03, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x0E, 0x03,
  0x80, 0x0F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x03, 0x0F, 0xFE,
  0x0C, 0x60, 0x1C, 0x37, 0x00, 0x18, 0xD0, 0x00, 0x33, 0xC0, 0x00, 0xCE,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x02,
  0xC0, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00, 0x03, 0x3C, 0x00, 0x0C, 0xD8,
  0x00, 0x63, 0x38, 0x07, 0x0C, 0x3F, 0xF8, 0x30, 0x1F, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFC,
  0x30, 0xE0, 0x38, 0xC6, 0x00, 0x3B, 0x30, 0x00, 0x6C, 0xC0, 0x00, 0xF6,
  0x00, 0x01, 0xD8, 0x00, 0x07, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xD0, 0x00, 0x03,
  0x60, 0x00, 0x0D, 0x80, 0x00, 0x73, 0x00, 0x01, 0xCC, 0x00, 0x0F, 0x18,
  0x00, 0x6C, 0x38, 0x07, 0x30, 0x7F, 0xF0, 0xC0, 0x3E, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x7E, 0x1F, 0xF1, 0xC1,
  0x98, 0x0D, 0x80, 0x68, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0x80, 0x70,
  0x30, 0x00, 0xC3, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0x6C, 0x00,
  0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x80,
  0x00, 0x66, 0x00, 0x06, 0x38, 0x00, 0x60, 0xF0, 0x0E, 0x01, 0xFF, 0xE0,
  0x01, 0xF8, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x03, 0xFF, 0xEF, 0xFF, 0x81, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x1F, 0xC0, 0x1E, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x80, 0x00, 0x76, 0x00, 0x03,
  0xB0, 0x00, 0x3C, 0xC0, 0x03, 0x67, 0x00, 0x3B, 0x1C, 0x07, 0x18, 0x7F,
  0xF0, 0xC0, 0x7C, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0D, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x26, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x8C, 0x00, 0x02,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x20, 0x60, 0x00, 0xC0,
  0xC0, 0x01, 0x80, 0xC0, 0x02, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x03,
  0x00, 0x20, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x08, 0x02, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x18, 0x00, 0x20, 0x20, 0x00, 0x60, 0xC0, 0x00, 0xC1,
  0x80, 0x00, 0x82, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x02, 0x20,
  0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x34, 0x00, 0x0F, 0x00, 0x02,
  0x60, 0x00, 0xF0, 0x00, 0x66, 0x00, 0x09, 0x00, 0x06, 0x60, 0x01, 0x98,
  0x00, 0x62, 0x00, 0x19, 0x80, 0x04, 0x30, 0x01, 0x98, 0x00, 0xC3, 0x00,
  0x10, 0x80, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC1, 0x00, 0x30, 0xC0, 0x08,
  0x18, 0x03, 0x0C, 0x01, 0x81, 0x80, 0x20, 0x40, 0x18, 0x18, 0x06, 0x06,
  0x01, 0x80, 0x80, 0x60, 0x60, 0x10, 0x0C, 0x04, 0x06, 0x03, 0x00, 0xC0,
  0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0x40, 0xC0, 0x30, 0x20,
  0x06, 0x08, 0x01, 0x06, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01,
  0x86, 0x00, 0x21, 0x00, 0x18, 0x60, 0x03, 0x10, 0x00, 0x8C, 0x00, 0x33,
  0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x32, 0x00, 0x04, 0xC0,
  0x01, 0x20, 0x00, 0x48, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x60,
  0xC0, 0x01, 0x81, 0x80, 0x03, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x03,
  0x00, 0x60, 0x03, 0x00, 0x80, 0x06, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x04,
  0x18, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x10, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x80, 0xC0,
  0x03, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x10, 0x01, 0x80, 0x60, 0x03, 0x01,
  0x80, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x06, 0x60,
  0x00, 0x0D, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0x40,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0x10, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x08, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x04,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x02, 0x00, 0xC0, 0x03,
  0x00, 0xC0, 0x03, 0x01, 0x80, 0x01, 0x01, 0x80, 0x01, 0x81, 0x80, 0x01,
  0x81, 0x00, 0x00, 0x83, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x66, 0x00, 0x00, 0x64, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x38, 0x00,
  0x40, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xCC, 0x0E, 0x00,
  0x06, 0xC0, 0x38, 0x00, 0x24, 0x00, 0x60, 0x03, 0x60, 0x01, 0x80, 0x1B,
  0x00, 0x06, 0x00, 0x90, 0x00, 0x18, 0x0C, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_Thin64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 47, 12, 4, -46 },
  { 25, 8, 13, 17, 5, -48 },
  { 38, 30, 46, 31, 2, -46 },
  { 211, 23, 60, 31, 4, -53 },
  { 384, 34, 48, 42, 4, -47 },
  { 588, 28, 48, 34, 4, -47 },
  { 756, 2, 13, 11, 4, -48 },
  { 760, 12, 66, 17, 4, -51 },
  { 859, 12, 66, 18, 1, -51 },
  { 958, 25, 25, 27, 1, -46 },
  { 1037, 26, 34, 32, 3, -38 },
  { 1148, 4, 13, 12, 3, -5 },
  { 1155, 13, 2, 17, 2, -22 },
  { 1159, 3, 4, 14, 5, -3 },
  { 1161, 18, 50, 22, 2, -46 },
  { 1274, 23, 48, 31, 4, -47 },
  { 1412, 12, 46, 31, 6, -46 },
  { 1481, 24, 47, 31, 4, -47 },
  { 1622, 24, 48, 31, 3, -47 },
  { 1766, 27, 46, 31, 3, -46 },
  { 1922, 23, 47, 31, 5, -46 },
  { 2058, 24, 47, 31, 4, -46 },
  { 2199, 24, 46, 31, 3, -46 },
  { 2337, 25, 48, 31, 3, -47 },
  { 2487, 24, 47, 31, 3, -47 },
  { 2628, 4, 34, 11, 4, -33 },
  { 2645, 5, 41, 11, 3, -33 },
  { 2671, 22, 25, 29, 3, -33 },
  { 2740, 23, 15, 31, 4, -28 },
  { 2784, 22, 25, 29, 4, -33 },
  { 2853, 19, 48, 25, 3, -47 },
  { 2967, 44, 58, 52, 4, -44 },
  { 3286, 31, 46, 34, 1, -46 },
  { 3465, 25, 46, 34, 6, -46 },
  { 3609, 27, 48, 36, 5, -47 },
  { 3771, 26, 46, 37, 6, -46 },
  { 3921, 23, 46, 32, 6, -46 },
  { 4054, 24, 46, 32, 6, -46 },
  { 4192, 28, 48, 38, 5, -47 },
  { 4360, 27, 46, 39, 6, -46 },
  { 4516, 2, 46, 15, 7, -46 },
  { 4528, 22, 47, 31, 3, -46 },
  { 4658, 27, 46, 36, 6, -46 },
  { 4814, 21, 46, 29, 6, -46 },
  { 4935, 36, 46, 48, 6, -46 },
  { 5142, 28, 46, 40, 6, -46 },
  { 5303, 29, 48, 37, 4, -47 },
  { 5477, 25, 46, 34, 6, -46 },
  { 5621, 29, 55, 37, 4, -47 },
  { 5821, 26, 46, 37, 6, -46 },
  { 5971, 28, 48, 33, 3, -47 },
  { 6139, 30, 46, 34, 2, -46 },
  { 6312, 27, 47, 37, 5, -46 },
  { 6471, 31, 46, 34, 1, -46 },
  { 6650, 46, 46, 50, 2, -46 },
  { 6915, 30, 46, 34, 2, -46 },
  { 7088, 31, 46, 34, 1, -46 },
  { 7267, 28, 46, 34, 3, -46 },
  { 7428, 8, 62, 13, 5, -52 },
  { 7490, 18, 50, 22, 2, -46 },
  { 7603, 8, 62, 13, 0, -52 },
  { 7665, 17, 23, 24, 3, -46 },
  { 7714, 22, 2, 24, 1, 0 },
  { 7720, 9, 8, 17, 4, -48 },
  { 7729, 22, 36, 30, 3, -35 },
  { 7828, 22, 49, 31, 5, -48 },
  { 7963, 23, 36, 29, 3, -35 },
  { 8067, 22, 49, 31, 4, -48 },
  { 8202, 23, 36, 29, 3, -35 },
  { 8306, 16, 49, 18, 2, -49 },
  { 8404, 22, 48, 31, 4, -35 },
  { 8536, 21, 48, 31, 5, -48 },
  { 8662, 3, 46, 12, 5, -46 },
  { 8680, 11, 59, 13, -3, -46 },
  { 8762, 21, 48, 27, 5, -48 },
  { 8888, 2, 48, 12, 5, -48 },
  { 8900, 40, 35, 50, 5, -35 },
  { 9075, 21, 35, 31, 5, -35 },
  { 9167, 23, 36, 31, 4, -35 },
  { 9271, 22, 48, 31, 5, -35 },
  { 9403, 22, 48, 31, 4, -35 },
  { 9535, 13, 35, 19, 5, -35 },
  { 9592, 21, 36, 28, 3, -35 },
  { 9687, 14, 44, 18, 2, -43 },
  { 9764, 21, 35, 31, 5, -34 },
  { 9856, 23, 34, 27, 2, -34 },
  { 9954, 36, 34, 42, 3, -34 },
  { 10107, 23, 34, 27, 2, -34 },
  { 10205, 24, 47, 27, 2, -34 },
  { 10346, 22, 34, 27, 3, -34 },
  { 10440, 15, 64, 19, 3, -50 },
  { 10560, 2, 54, 13, 6, -46 },
  { 10574, 15, 64, 19, 1, -50 },
  { 10694, 29, 10, 39, 5, -24 },
};

const GFXfont RobotoCondensed_Thin64pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin64pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin64pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _ROBOTOCONDENSED_THIN64PT7B_H_
