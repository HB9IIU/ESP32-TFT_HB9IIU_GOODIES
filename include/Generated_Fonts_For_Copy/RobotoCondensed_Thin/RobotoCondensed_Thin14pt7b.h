#ifndef _ROBOTOCONDENSED_THIN14PT7B_H_
#define _ROBOTOCONDENSED_THIN14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin14pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0x40, 0x74, 0x04, 0x28, 0xF1, 0x22, 0x45, 0x0A, 0x3C, 0x48,
  0x00, 0x22, 0xA3, 0x08, 0x30, 0x41, 0x0C, 0x54, 0x40, 0xE1, 0x4A, 0xA5,
  0x4F, 0x03, 0xCA, 0x95, 0x4A, 0x1C, 0x72, 0x49, 0x18, 0x42, 0x89, 0x63,
  0x89, 0xD0, 0x40, 0x0A, 0x49, 0x24, 0x92, 0x44, 0x00, 0x09, 0x12, 0x49,
  0x24, 0xA4, 0x00, 0x00, 0x87, 0x8C, 0x48, 0x21, 0x1C, 0x42, 0x10, 0xC0,
  0x40, 0x80, 0x01, 0x12, 0x22, 0x44, 0x44, 0x00, 0x74, 0x63, 0x18, 0xC6,
  0x31, 0x8B, 0x80, 0x64, 0x92, 0x49, 0x20, 0x74, 0x42, 0x11, 0x08, 0x88,
  0x47, 0x80, 0x74, 0x42, 0x11, 0x04, 0x21, 0x8B, 0x80, 0x11, 0x8C, 0xA5,
  0x4B, 0xC2, 0x10, 0x00, 0x74, 0x21, 0x0F, 0x04, 0x31, 0x8B, 0x80, 0x22,
  0x21, 0xE8, 0xC6, 0x31, 0x8B, 0x80, 0x78, 0x44, 0x21, 0x10, 0x84, 0x40,
  0x00, 0x74, 0x63, 0x17, 0x46, 0x31, 0x8B, 0x80, 0x74, 0x63, 0x18, 0xC5,
  0xE1, 0x13, 0x00, 0x81, 0x81, 0x80, 0x16, 0x86, 0x10, 0x70, 0x1C, 0x83,
  0x82, 0x6C, 0x00, 0xE1, 0x11, 0x24, 0x40, 0x04, 0x3F, 0x20, 0x50, 0x31,
  0x19, 0x0D, 0x16, 0x8B, 0x49, 0xA4, 0xCD, 0xE0, 0x08, 0x03, 0xC0, 0x10,
  0x20, 0xA1, 0x42, 0x48, 0x97, 0x21, 0x83, 0x00, 0xFA, 0x28, 0x62, 0xFA,
  0x08, 0x61, 0x87, 0xE0, 0x7A, 0x18, 0x20, 0x82, 0x08, 0x20, 0x85, 0xE0,
  0xBA, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0xE0, 0xF4, 0x21, 0x0F, 0x42,
  0x10, 0x87, 0x80, 0xFA, 0x08, 0x20, 0xF2, 0x08, 0x20, 0x82, 0x00, 0x7A,
  0x18, 0x20, 0x82, 0x38, 0x21, 0x85, 0xE0, 0x82, 0x18, 0x61, 0xFE, 0x18,
  0x61, 0x86, 0x00, 0xFF, 0xC0, 0x08, 0x42, 0x10, 0x84, 0x21, 0x8F, 0x80,
  0x86, 0x29, 0x28, 0xC2, 0x89, 0x22, 0x8A, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x87, 0x80, 0x81, 0x81, 0xC3, 0xC3, 0xA3, 0xA5, 0xA5, 0x95, 0x99,
  0x88, 0x83, 0x1C, 0x69, 0x96, 0x58, 0xE3, 0x86, 0x10, 0x7A, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x85, 0xE0, 0xFA, 0x18, 0x61, 0x87, 0xE8, 0x20, 0x82,
  0x00, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xE0, 0x81, 0xFA, 0x18,
  0x61, 0x87, 0xE8, 0x22, 0x86, 0x10, 0x7A, 0x18, 0x60, 0x60, 0x60, 0x41,
  0x85, 0xE0, 0x7C, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x82,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xE0, 0x81, 0x05, 0x0A, 0x24, 0x44,
  0x8A, 0x14, 0x10, 0x20, 0x04, 0x08, 0x89, 0x29, 0x25, 0x24, 0xA4, 0x94,
  0x8C, 0x61, 0x8C, 0x31, 0x80, 0x00, 0x02, 0x88, 0x91, 0x41, 0x02, 0x0A,
  0x12, 0x44, 0x04, 0x02, 0x85, 0x11, 0x22, 0x82, 0x04, 0x08, 0x10, 0x20,
  0x74, 0x21, 0x04, 0x20, 0x84, 0x10, 0x81, 0xE0, 0xAA, 0xAA, 0xAA, 0x80,
  0x04, 0x44, 0x22, 0x21, 0x11, 0x00, 0x55, 0x55, 0x55, 0x40, 0x4A, 0xD0,
  0x70, 0x80, 0xF0, 0x42, 0x1E, 0xC6, 0x3C, 0x04, 0x21, 0xE8, 0xC6, 0x31,
  0x8C, 0x5C, 0x74, 0x63, 0x08, 0x42, 0x2E, 0x08, 0x42, 0xF8, 0xC6, 0x31,
  0x8C, 0x5E, 0x74, 0x63, 0xF8, 0x42, 0x0E, 0x52, 0x69, 0x24, 0x90, 0x00,
  0x7C, 0x63, 0x18, 0xC6, 0x2F, 0x08, 0x5C, 0x04, 0x21, 0xE8, 0xC6, 0x31,
  0x8C, 0x42, 0x9F, 0xE0, 0x20, 0x12, 0x49, 0x24, 0x92, 0x80, 0x04, 0x21,
  0x2A, 0x53, 0x14, 0xA4, 0x80, 0xFF, 0xE0, 0x77, 0x44, 0x62, 0x31, 0x18,
  0x8C, 0x46, 0x22, 0x11, 0x74, 0x63, 0x18, 0xC6, 0x21, 0x74, 0x63, 0x18,
  0xC6, 0x2E, 0x74, 0x63, 0x18, 0xC6, 0x3E, 0x84, 0x00, 0x7C, 0x63, 0x18,
  0xC6, 0x2F, 0x08, 0x42, 0x52, 0x49, 0x20, 0xF8, 0x84, 0x31, 0x1F, 0x49,
  0x24, 0x92, 0x20, 0x0C, 0x63, 0x18, 0xC6, 0x2F, 0x01, 0x24, 0x92, 0x48,
  0xC3, 0x04, 0x10, 0x91, 0xAA, 0xAA, 0xAA, 0x4A, 0x44, 0x44, 0x01, 0x23,
  0x08, 0x30, 0xC4, 0x80, 0x01, 0x24, 0x92, 0x48, 0xC3, 0x04, 0x20, 0x80,
  0x00, 0x70, 0x88, 0x44, 0x22, 0x0E, 0x29, 0x24, 0xA0, 0x49, 0x24, 0x40,
  0xFF, 0xF0, 0x04, 0x44, 0x42, 0x20, 0x44, 0x44, 0x48, 0xE0, 0x70,
};

const GFXglyph RobotoCondensed_Thin14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 10, 3, 1, -10 },
  { 3, 2, 3, 4, 1, -11 },
  { 4, 7, 10, 7, 0, -10 },
  { 13, 5, 12, 7, 1, -11 },
  { 21, 7, 10, 9, 1, -10 },
  { 30, 6, 10, 8, 1, -10 },
  { 38, 1, 3, 2, 1, -11 },
  { 39, 3, 14, 4, 1, -11 },
  { 45, 3, 14, 4, 0, -11 },
  { 51, 6, 5, 6, 0, -10 },
  { 55, 5, 6, 7, 1, -7 },
  { 59, 1, 3, 3, 1, -1 },
  { 60, 3, 1, 4, 0, -5 },
  { 61, 1, 1, 3, 1, -1 },
  { 62, 4, 11, 5, 0, -10 },
  { 68, 5, 10, 7, 1, -10 },
  { 75, 3, 10, 7, 1, -10 },
  { 79, 5, 10, 7, 1, -10 },
  { 86, 5, 10, 7, 1, -10 },
  { 93, 5, 10, 7, 1, -10 },
  { 100, 5, 10, 7, 1, -10 },
  { 107, 5, 10, 7, 1, -10 },
  { 114, 5, 10, 7, 1, -10 },
  { 121, 5, 10, 7, 1, -10 },
  { 128, 5, 10, 7, 1, -10 },
  { 135, 1, 8, 2, 1, -8 },
  { 136, 1, 10, 2, 1, -8 },
  { 138, 4, 5, 6, 1, -7 },
  { 141, 5, 3, 7, 1, -6 },
  { 143, 5, 5, 6, 1, -7 },
  { 147, 4, 10, 5, 1, -10 },
  { 152, 9, 13, 11, 1, -10 },
  { 167, 7, 10, 7, 0, -10 },
  { 176, 6, 10, 7, 1, -10 },
  { 184, 6, 10, 8, 1, -10 },
  { 192, 6, 10, 8, 1, -10 },
  { 200, 5, 10, 7, 1, -10 },
  { 207, 6, 10, 7, 1, -10 },
  { 215, 6, 10, 8, 1, -10 },
  { 223, 6, 10, 9, 1, -10 },
  { 231, 1, 10, 3, 1, -10 },
  { 233, 5, 10, 7, 1, -10 },
  { 240, 6, 10, 8, 1, -10 },
  { 248, 5, 10, 6, 1, -10 },
  { 255, 8, 10, 10, 1, -10 },
  { 265, 6, 10, 9, 1, -10 },
  { 273, 6, 10, 8, 1, -10 },
  { 281, 6, 10, 7, 1, -10 },
  { 289, 6, 12, 8, 1, -10 },
  { 298, 6, 10, 8, 1, -10 },
  { 306, 6, 10, 7, 1, -10 },
  { 314, 7, 10, 7, 0, -10 },
  { 323, 6, 10, 8, 1, -10 },
  { 331, 7, 10, 7, 0, -10 },
  { 340, 11, 10, 11, 0, -10 },
  { 354, 7, 10, 7, 0, -10 },
  { 363, 7, 10, 7, 0, -10 },
  { 372, 6, 10, 7, 1, -10 },
  { 380, 2, 13, 3, 1, -11 },
  { 384, 4, 11, 5, 0, -10 },
  { 390, 2, 13, 3, 0, -11 },
  { 394, 3, 5, 5, 1, -10 },
  { 396, 5, 1, 5, 0, 0 },
  { 397, 2, 2, 4, 1, -11 },
  { 398, 5, 8, 7, 1, -8 },
  { 403, 5, 11, 7, 1, -11 },
  { 410, 5, 8, 6, 1, -8 },
  { 415, 5, 11, 7, 1, -11 },
  { 422, 5, 8, 6, 1, -8 },
  { 427, 3, 11, 4, 1, -11 },
  { 432, 5, 11, 7, 1, -8 },
  { 439, 5, 11, 7, 1, -11 },
  { 446, 1, 11, 3, 1, -11 },
  { 448, 3, 14, 3, -1, -11 },
  { 454, 5, 11, 6, 1, -11 },
  { 461, 1, 11, 3, 1, -11 },
  { 463, 9, 8, 11, 1, -8 },
  { 472, 5, 8, 7, 1, -8 },
  { 477, 5, 8, 7, 1, -8 },
  { 482, 5, 11, 7, 1, -8 },
  { 489, 5, 11, 7, 1, -8 },
  { 496, 3, 8, 4, 1, -8 },
  { 499, 4, 8, 6, 1, -8 },
  { 503, 3, 9, 4, 0, -9 },
  { 507, 5, 8, 7, 1, -8 },
  { 512, 6, 8, 6, 0, -8 },
  { 518, 8, 8, 9, 1, -8 },
  { 526, 6, 8, 6, 0, -8 },
  { 532, 6, 11, 6, 0, -8 },
  { 541, 5, 8, 6, 1, -8 },
  { 546, 3, 14, 4, 1, -11 },
  { 552, 1, 12, 3, 1, -10 },
  { 554, 4, 14, 4, 0, -11 },
  { 561, 6, 2, 8, 1, -5 },
};

const GFXfont RobotoCondensed_Thin14pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin14pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin14pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOCONDENSED_THIN14PT7B_H_
