#ifndef _ROBOTOCONDENSED_THIN15PT7B_H_
#define _ROBOTOCONDENSED_THIN15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB8, 0x10, 0x28, 0x51, 0xE2, 0x44, 0x89, 0x12, 0x78,
  0x50, 0x20, 0x03, 0xA3, 0x08, 0x20, 0xC1, 0x08, 0x62, 0xE0, 0x00, 0xE0,
  0xA0, 0x94, 0xA8, 0xE8, 0x10, 0x17, 0x29, 0x29, 0x09, 0x07, 0x70, 0x92,
  0x22, 0x86, 0x0C, 0x24, 0x4A, 0x8D, 0x19, 0xC0, 0x40, 0x29, 0x49, 0x24,
  0x92, 0x44, 0x88, 0x09, 0x12, 0x49, 0x24, 0x94, 0x80, 0x00, 0x45, 0xCC,
  0x29, 0x20, 0x20, 0x82, 0x1E, 0x20, 0x82, 0x08, 0xC0, 0x00, 0x80, 0x00,
  0x84, 0x22, 0x10, 0x84, 0x42, 0x10, 0x00, 0x74, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x5C, 0x74, 0x92, 0x49, 0x24, 0x00, 0x72, 0x20, 0x82, 0x08, 0x41,
  0x08, 0x41, 0x0F, 0x80, 0x74, 0x42, 0x10, 0x88, 0x21, 0x0C, 0x5C, 0x00,
  0x42, 0x8A, 0x49, 0x28, 0xBE, 0x08, 0x20, 0x00, 0x71, 0x08, 0x20, 0x70,
  0x20, 0x41, 0x86, 0x27, 0x80, 0x22, 0x21, 0x0F, 0x46, 0x31, 0x8C, 0x5C,
  0x78, 0x42, 0x11, 0x08, 0x84, 0x22, 0x10, 0x72, 0x28, 0x61, 0x89, 0xC8,
  0xA1, 0x86, 0x17, 0x80, 0x74, 0x63, 0x18, 0xC5, 0xE1, 0x08, 0x5C, 0x81,
  0x81, 0x80, 0x19, 0x31, 0x82, 0x0C, 0x73, 0x80, 0x83, 0x06, 0x36, 0x40,
  0xF9, 0x11, 0x12, 0x20, 0x00, 0x40, 0x1F, 0x08, 0x24, 0x06, 0x39, 0x90,
  0x64, 0x9A, 0x26, 0x89, 0xA2, 0x67, 0xE8, 0x01, 0x00, 0x3E, 0x00, 0x10,
  0x18, 0x18, 0x24, 0x24, 0x24, 0x44, 0x5A, 0x42, 0x82, 0x80, 0xFA, 0x18,
  0x61, 0x86, 0xE8, 0x61, 0x86, 0x1B, 0x80, 0x79, 0x0A, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x83, 0x09, 0xE0, 0xB9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x0A, 0xE0, 0xBA, 0x08, 0x20, 0x82, 0xC8, 0x20, 0x82, 0x0B, 0x80,
  0xBA, 0x08, 0x20, 0x82, 0xC8, 0x20, 0x82, 0x08, 0x00, 0x3C, 0x86, 0x0C,
  0x08, 0x10, 0xA0, 0xC1, 0x82, 0x84, 0xF0, 0x83, 0x06, 0x0C, 0x18, 0x37,
  0xE0, 0xC1, 0x83, 0x06, 0x08, 0x7F, 0xC0, 0x00, 0x42, 0x10, 0x84, 0x21,
  0x0C, 0x5C, 0x85, 0x12, 0x24, 0x8A, 0x1C, 0x24, 0x44, 0x89, 0x0A, 0x00,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x2C, 0x80, 0xC0, 0x70, 0x78, 0x3A,
  0x2D, 0x16, 0x4B, 0x29, 0x94, 0xC4, 0x62, 0x20, 0x81, 0x87, 0x0D, 0x19,
  0x32, 0x62, 0xC5, 0x87, 0x0E, 0x08, 0x79, 0x0A, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x09, 0xE0, 0xFA, 0x18, 0x61, 0x87, 0xE8, 0x20, 0x82, 0x08,
  0x00, 0x79, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x09, 0xE0, 0x20,
  0x00, 0xF9, 0x0A, 0x14, 0x28, 0x5F, 0x20, 0x44, 0x85, 0x0A, 0x00, 0x7A,
  0x18, 0x20, 0x40, 0xE0, 0x41, 0x06, 0x17, 0x80, 0x7C, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x00, 0x82, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x86, 0x17, 0x80, 0x00, 0x42, 0x42, 0x42, 0x44, 0x24, 0x24, 0x24, 0x18,
  0x18, 0x00, 0x00, 0x22, 0x18, 0xC6, 0x31, 0x92, 0x64, 0xA5, 0x29, 0x4A,
  0x61, 0x08, 0x40, 0x10, 0x00, 0x84, 0x91, 0x21, 0x82, 0x06, 0x12, 0x24,
  0x84, 0x00, 0x00, 0x42, 0x42, 0x24, 0x24, 0x18, 0x10, 0x10, 0x10, 0x10,
  0x00, 0x7C, 0x10, 0x84, 0x10, 0x82, 0x10, 0x42, 0x07, 0x80, 0xAA, 0xAA,
  0xAA, 0xA0, 0x02, 0x10, 0x82, 0x10, 0x82, 0x10, 0x84, 0x10, 0x55, 0x55,
  0x55, 0x50, 0x44, 0xA9, 0x10, 0x70, 0x90, 0x74, 0x42, 0x17, 0xC6, 0x3F,
  0x84, 0x21, 0x0F, 0x46, 0x31, 0x8C, 0x63, 0xE0, 0x74, 0x61, 0x08, 0x42,
  0x2E, 0x00, 0x42, 0x17, 0xC6, 0x31, 0x8C, 0x62, 0xE0, 0x74, 0x63, 0xF8,
  0x42, 0x0E, 0x52, 0x4D, 0x24, 0x92, 0x00, 0x74, 0x63, 0x18, 0xC6, 0x2F,
  0x08, 0x5C, 0x84, 0x21, 0x0F, 0x46, 0x31, 0x8C, 0x63, 0x00, 0x9F, 0xE0,
  0x20, 0x12, 0x49, 0x24, 0x92, 0x80, 0x84, 0x21, 0x08, 0xCA, 0x98, 0xA4,
  0xA5, 0x10, 0xFF, 0xF0, 0xF3, 0xA3, 0x18, 0x86, 0x21, 0x88, 0x62, 0x18,
  0x86, 0x01, 0xF4, 0x63, 0x18, 0xC6, 0x30, 0x74, 0x63, 0x18, 0xC6, 0x2E,
  0xF4, 0x63, 0x18, 0xC6, 0x3E, 0x84, 0x20, 0x74, 0x63, 0x18, 0xC6, 0x2F,
  0x08, 0x40, 0xD2, 0x49, 0x24, 0xF4, 0x60, 0xC1, 0x04, 0x3E, 0x04, 0x64,
  0x44, 0x44, 0x42, 0x84, 0x63, 0x18, 0xC6, 0x2E, 0x05, 0x14, 0x92, 0x28,
  0xC1, 0x04, 0x00, 0x99, 0x99, 0xA9, 0xA6, 0x66, 0x46, 0x40, 0x01, 0x22,
  0x84, 0x10, 0xA4, 0x81, 0x05, 0x14, 0x92, 0x28, 0xC1, 0x04, 0x10, 0x80,
  0x00, 0x68, 0x84, 0x44, 0x22, 0x0E, 0x29, 0x24, 0x94, 0x09, 0x24, 0x88,
  0xFF, 0xF8, 0x04, 0x42, 0x22, 0x20, 0x22, 0x22, 0x24, 0x80, 0xE3, 0x3C,
};

const GFXglyph RobotoCondensed_Thin15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 11, 3, 1, -11 },
  { 3, 2, 3, 4, 1, -11 },
  { 4, 7, 11, 7, 0, -11 },
  { 14, 5, 13, 7, 1, -12 },
  { 23, 8, 11, 10, 1, -11 },
  { 34, 7, 11, 8, 1, -11 },
  { 44, 1, 3, 3, 1, -11 },
  { 45, 3, 15, 4, 1, -12 },
  { 51, 3, 15, 4, 0, -12 },
  { 57, 6, 6, 6, 0, -11 },
  { 62, 6, 8, 7, 1, -9 },
  { 68, 1, 3, 3, 1, -1 },
  { 69, 2, 1, 4, 1, -6 },
  { 70, 1, 1, 3, 1, -1 },
  { 71, 5, 12, 5, 0, -11 },
  { 79, 5, 11, 7, 1, -11 },
  { 86, 3, 11, 7, 1, -11 },
  { 91, 6, 11, 7, 1, -11 },
  { 100, 5, 11, 7, 1, -11 },
  { 107, 6, 11, 7, 1, -11 },
  { 116, 6, 11, 7, 1, -11 },
  { 125, 5, 11, 7, 1, -11 },
  { 132, 5, 11, 7, 1, -11 },
  { 139, 6, 11, 7, 1, -11 },
  { 148, 5, 11, 7, 1, -11 },
  { 155, 1, 8, 3, 1, -8 },
  { 156, 1, 10, 3, 1, -8 },
  { 158, 5, 6, 7, 1, -8 },
  { 162, 5, 2, 7, 1, -6 },
  { 164, 5, 6, 7, 1, -8 },
  { 168, 4, 11, 6, 1, -11 },
  { 174, 10, 13, 12, 1, -10 },
  { 191, 8, 11, 8, 0, -11 },
  { 202, 6, 11, 8, 1, -11 },
  { 211, 7, 11, 9, 1, -11 },
  { 221, 7, 11, 9, 1, -11 },
  { 231, 6, 11, 8, 1, -11 },
  { 240, 6, 11, 8, 1, -11 },
  { 249, 7, 11, 9, 1, -11 },
  { 259, 7, 11, 9, 1, -11 },
  { 269, 1, 11, 4, 1, -11 },
  { 271, 5, 11, 7, 1, -11 },
  { 278, 7, 11, 8, 1, -11 },
  { 288, 5, 11, 7, 1, -11 },
  { 295, 9, 11, 11, 1, -11 },
  { 308, 7, 11, 9, 1, -11 },
  { 318, 7, 11, 9, 1, -11 },
  { 328, 6, 11, 8, 1, -11 },
  { 337, 7, 13, 9, 1, -11 },
  { 349, 7, 11, 9, 1, -11 },
  { 359, 6, 11, 8, 1, -11 },
  { 368, 7, 11, 8, 0, -11 },
  { 378, 6, 11, 9, 1, -11 },
  { 387, 8, 11, 8, 0, -11 },
  { 398, 10, 11, 12, 1, -11 },
  { 412, 7, 11, 8, 0, -11 },
  { 422, 8, 11, 8, 0, -11 },
  { 433, 6, 11, 8, 1, -11 },
  { 442, 2, 14, 3, 1, -12 },
  { 446, 5, 12, 5, 0, -11 },
  { 454, 2, 14, 3, 0, -12 },
  { 458, 4, 5, 6, 1, -11 },
  { 461, 5, 1, 6, 0, 0 },
  { 462, 2, 2, 4, 1, -11 },
  { 463, 5, 8, 7, 1, -8 },
  { 468, 5, 12, 7, 1, -12 },
  { 476, 5, 8, 7, 1, -8 },
  { 481, 5, 12, 7, 1, -12 },
  { 489, 5, 8, 7, 1, -8 },
  { 494, 3, 12, 4, 1, -12 },
  { 499, 5, 11, 7, 1, -8 },
  { 506, 5, 12, 7, 1, -12 },
  { 514, 1, 11, 3, 1, -11 },
  { 516, 3, 14, 3, -1, -11 },
  { 522, 5, 12, 6, 1, -12 },
  { 530, 1, 12, 3, 1, -12 },
  { 532, 10, 8, 12, 1, -8 },
  { 542, 5, 8, 7, 1, -8 },
  { 547, 5, 8, 7, 1, -8 },
  { 552, 5, 11, 7, 1, -8 },
  { 559, 5, 11, 7, 1, -8 },
  { 566, 3, 8, 5, 1, -8 },
  { 569, 5, 8, 7, 1, -8 },
  { 574, 4, 10, 4, 0, -10 },
  { 579, 5, 8, 7, 1, -8 },
  { 584, 6, 8, 6, 0, -8 },
  { 590, 8, 8, 10, 1, -8 },
  { 598, 6, 8, 6, 0, -8 },
  { 604, 6, 11, 6, 0, -8 },
  { 613, 5, 8, 6, 1, -8 },
  { 618, 3, 15, 4, 1, -12 },
  { 624, 1, 13, 3, 1, -11 },
  { 626, 4, 15, 4, 0, -12 },
  { 634, 7, 2, 9, 1, -5 },
};

const GFXfont RobotoCondensed_Thin15pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin15pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOCONDENSED_THIN15PT7B_H_
