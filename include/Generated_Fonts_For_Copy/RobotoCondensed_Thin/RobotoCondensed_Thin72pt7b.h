#ifndef _ROBOTOCONDENSED_THIN72PT7B_H_
#define _ROBOTOCONDENSED_THIN72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin72pt7bBitmaps[] PROGMEM = {
  0x00, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44,
  0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xEF, 0xE6, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x1B, 0x06, 0xC1, 0xB0, 0x60, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x60, 0x02, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x40, 0x00, 0x03, 0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x20, 0x03, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x08,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x07,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x62, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x8C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x03,
  0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x00, 0x78,
  0x07, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x30, 0x03, 0x00, 0x04,
  0x00, 0x60, 0x06, 0x00, 0x08, 0x01, 0x80, 0x0C, 0x00, 0x10, 0x03, 0x00,
  0x18, 0x00, 0x20, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x00, 0x80, 0x06, 0x03, 0x00,
  0x01, 0x80, 0x08, 0x06, 0x00, 0x03, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00,
  0xE0, 0x30, 0x00, 0x03, 0x03, 0x80, 0xC0, 0x00, 0x03, 0xFE, 0x01, 0x80,
  0x00, 0x03, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x01, 0xF8, 0x00,
  0x00, 0x30, 0x0F, 0xF8, 0x00, 0x00, 0x60, 0x38, 0x18, 0x00, 0x01, 0x80,
  0xC0, 0x18, 0x00, 0x03, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x30,
  0x00, 0x18, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x40, 0x00, 0xC0,
  0x20, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x80, 0x03,
  0x00, 0x18, 0x01, 0x00, 0x06, 0x00, 0x60, 0x02, 0x00, 0x0C, 0x00, 0xC0,
  0x04, 0x00, 0x18, 0x03, 0x00, 0x08, 0x00, 0x30, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x18, 0x00, 0x30, 0x00, 0x80, 0x30, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x06, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x18, 0x03, 0x00, 0x06, 0x18, 0x01, 0x80, 0x06,
  0x30, 0x00, 0xC0, 0x06, 0x20, 0x00, 0xE0, 0x06, 0x60, 0x00, 0x60, 0x04,
  0x60, 0x00, 0x30, 0x0C, 0xC0, 0x00, 0x18, 0x0C, 0xC0, 0x00, 0x1C, 0x0C,
  0xC0, 0x00, 0x0C, 0x0C, 0xC0, 0x00, 0x06, 0x18, 0xC0, 0x00, 0x03, 0x18,
  0xC0, 0x00, 0x03, 0xB0, 0xC0, 0x00, 0x01, 0xB0, 0xC0, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xF0, 0x30, 0x00, 0x01, 0xB0,
  0x38, 0x00, 0x03, 0x18, 0x1C, 0x00, 0x06, 0x0C, 0x0E, 0x00, 0x1C, 0x0E,
  0x07, 0x80, 0xF8, 0x06, 0x01, 0xFF, 0xE0, 0x03, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x03, 0xF0, 0x06, 0x00, 0xF7, 0xE0, 0x60, 0x7C,
  0x0F, 0x86, 0x1F, 0x00, 0x1F, 0x6F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x60, 0x70, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00,
  0x60, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x19, 0xCC, 0xE6, 0x20, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF6, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1E,
  0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x03, 0x60, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x06, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x60, 0x30, 0x00, 0x38, 0x06, 0x00, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x04, 0x00,
  0xF0, 0x0F, 0x40, 0xF1, 0x1F, 0x05, 0xE0, 0x1E, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x03,
  0xC0, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x0C,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x02,
  0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0,
  0x0F, 0x01, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x0E, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC6, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x0F, 0xE0,
  0x03, 0x3F, 0xFC, 0x01, 0xB8, 0x07, 0x80, 0xF0, 0x00, 0xE0, 0x60, 0x00,
  0x38, 0x20, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x18, 0x38, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x03, 0xE0, 0x78, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x7F, 0x00, 0x30, 0x7F, 0xF8,
  0x06, 0x1C, 0x03, 0xC0, 0xC6, 0x00, 0x1C, 0x19, 0x80, 0x01, 0xC2, 0x60,
  0x00, 0x18, 0x58, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x33, 0x80, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x18, 0x38, 0x00, 0x06, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x03, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x30, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0xE0, 0x03, 0xC0, 0x78,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0xE0,
  0x00, 0xE0, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x01,
  0xC0, 0x1F, 0x01, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x0F, 0x30, 0x00, 0x06, 0xC6, 0x00, 0x01,
  0xB1, 0xC0, 0x00, 0xCC, 0x38, 0x00, 0xE3, 0x07, 0x80, 0xF0, 0xC0, 0x7F,
  0xF0, 0x30, 0x07, 0xF0, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x73, 0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xEF, 0x30,
  0x38, 0xF3, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x8E, 0x30, 0xC6, 0x38, 0x40, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00,
  0x70, 0x3C, 0x03, 0x00, 0x38, 0x18, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00,
  0x03, 0x18, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x64, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0xF0, 0x00, 0x0C,
  0x0C, 0x00, 0x03, 0xFF, 0x00, 0x03, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0xC1, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x10, 0x60, 0x00, 0x60, 0x03, 0x00,
  0x06, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x63, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0xC0, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x98, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x26, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x09, 0x80, 0x06, 0x00,
  0x03, 0x00, 0x02, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x98, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x24, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x09, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x02, 0xC0, 0x03, 0x00, 0x00, 0x80, 0x01, 0xB0, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x6C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1B, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x01, 0xB0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x64, 0x00, 0x30, 0x00, 0x18, 0x00, 0x19,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x60, 0x03, 0x00, 0x03, 0x80, 0x03,
  0x18, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xC6, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x21, 0x80, 0x0C, 0x00, 0x1E, 0x00, 0x18, 0x60, 0x01, 0x00, 0x05, 0x80,
  0x06, 0x18, 0x00, 0x60, 0x03, 0x30, 0x03, 0x03, 0x00, 0x18, 0x01, 0x8C,
  0x01, 0x80, 0xC0, 0x03, 0x00, 0xC1, 0x80, 0xE0, 0x30, 0x00, 0x60, 0xE0,
  0x70, 0x70, 0x0E, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x01, 0x80, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x10, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0C, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0C, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x02, 0x00, 0x01, 0xE0,
  0x40, 0x00, 0x0E, 0x08, 0x00, 0x00, 0xE1, 0x00, 0x00, 0x0C, 0x20, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x19, 0x00, 0x00,
  0x03, 0x20, 0x00, 0x00, 0x64, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x04, 0x40, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x71, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x07, 0x04, 0x00, 0x03, 0xC0, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x02, 0x00, 0x00, 0xF0, 0x40, 0x00, 0x07,
  0x08, 0x00, 0x00, 0x31, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x74, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x50, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x03, 0x20, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x70, 0x80, 0x00, 0x3C, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x60, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x3E,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x1E, 0x01, 0x00, 0x00, 0x3C, 0x08,
  0x00, 0x00, 0x70, 0x40, 0x00, 0x01, 0xC2, 0x00, 0x00, 0x06, 0x10, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x00, 0x64, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x19, 0x00, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0xC2, 0x00, 0x00, 0x1C, 0x10,
  0x00, 0x03, 0xC0, 0x80, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x88, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x88, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x07, 0x80, 0x01, 0xE0,
  0x03, 0xE0, 0x1F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x31, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x0E, 0x00, 0x38, 0x03, 0xC0, 0x78, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x80, 0x00, 0x00, 0x32, 0x00, 0x00, 0x01, 0xC8, 0x00, 0x00,
  0x0E, 0x20, 0x00, 0x00, 0x70, 0x80, 0x00, 0x03, 0x82, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0x60, 0x20, 0x00, 0x03, 0x80, 0x80, 0x00, 0x1C, 0x02,
  0x00, 0x00, 0xE0, 0x08, 0x00, 0x07, 0x00, 0x20, 0x00, 0x18, 0x00, 0x80,
  0x00, 0xC0, 0x02, 0x00, 0x06, 0x00, 0x08, 0x00, 0x38, 0x00, 0x20, 0x01,
  0xC0, 0x00, 0x80, 0x0E, 0x00, 0x02, 0x00, 0x30, 0x00, 0x08, 0x01, 0x80,
  0x00, 0x20, 0x0C, 0x00, 0x00, 0x80, 0x70, 0x00, 0x02, 0x03, 0x80, 0x00,
  0x08, 0x1C, 0x00, 0x00, 0x20, 0x70, 0x00, 0x00, 0x83, 0x60, 0x00, 0x02,
  0x19, 0xC0, 0x00, 0x08, 0xC3, 0x00, 0x00, 0x26, 0x06, 0x00, 0x00, 0xB0,
  0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x20, 0x00,
  0xC0, 0x00, 0x80, 0x03, 0x80, 0x02, 0x00, 0x06, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x80, 0x00, 0x70, 0x02, 0x00, 0x00, 0xC0,
  0x08, 0x00, 0x01, 0x80, 0x20, 0x00, 0x03, 0x00, 0x80, 0x00, 0x0E, 0x02,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0xE0, 0x80,
  0x00, 0x01, 0xC2, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x06, 0x20, 0x00,
  0x00, 0x1C, 0x80, 0x00, 0x00, 0x3A, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xA0, 0x00, 0x00, 0x00, 0x0F, 0xB0, 0x00, 0x00, 0x00, 0x0F,
  0xB0, 0x00, 0x00, 0x00, 0x0B, 0x98, 0x00, 0x00, 0x00, 0x1B, 0x98, 0x00,
  0x00, 0x00, 0x1B, 0x98, 0x00, 0x00, 0x00, 0x33, 0x8C, 0x00, 0x00, 0x00,
  0x33, 0x8C, 0x00, 0x00, 0x00, 0x33, 0x84, 0x00, 0x00, 0x00, 0x63, 0x86,
  0x00, 0x00, 0x00, 0x63, 0x86, 0x00, 0x00, 0x00, 0x43, 0x83, 0x00, 0x00,
  0x00, 0xC3, 0x83, 0x00, 0x00, 0x00, 0xC3, 0x83, 0x00, 0x00, 0x01, 0x83,
  0x81, 0x80, 0x00, 0x01, 0x83, 0x81, 0x80, 0x00, 0x01, 0x83, 0x81, 0x80,
  0x00, 0x03, 0x03, 0x80, 0xC0, 0x00, 0x03, 0x03, 0x80, 0xC0, 0x00, 0x02,
  0x03, 0x80, 0x40, 0x00, 0x06, 0x03, 0x80, 0x60, 0x00, 0x06, 0x03, 0x80,
  0x60, 0x00, 0x0C, 0x03, 0x80, 0x30, 0x00, 0x0C, 0x03, 0x80, 0x30, 0x00,
  0x0C, 0x03, 0x80, 0x30, 0x00, 0x18, 0x03, 0x80, 0x18, 0x00, 0x18, 0x03,
  0x80, 0x18, 0x00, 0x18, 0x03, 0x80, 0x08, 0x00, 0x30, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x03, 0x80, 0x0C, 0x00, 0x20, 0x03, 0x80, 0x06, 0x00, 0x60,
  0x03, 0x80, 0x06, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x80,
  0x03, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x80, 0x01, 0x01,
  0x80, 0x03, 0x80, 0x01, 0x81, 0x80, 0x03, 0x80, 0x01, 0x81, 0x00, 0x03,
  0x80, 0x00, 0x83, 0x00, 0x03, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x80, 0x00,
  0xC6, 0x00, 0x03, 0x80, 0x00, 0x66, 0x00, 0x03, 0x80, 0x00, 0x66, 0x00,
  0x03, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7B, 0x00, 0x00,
  0x00, 0xF6, 0x00, 0x00, 0x01, 0xE6, 0x00, 0x00, 0x03, 0xCC, 0x00, 0x00,
  0x07, 0x8C, 0x00, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x1E, 0x18, 0x00, 0x00,
  0x3C, 0x18, 0x00, 0x00, 0x78, 0x30, 0x00, 0x00, 0xF0, 0x30, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x07, 0x80, 0x60, 0x00, 0x0F,
  0x00, 0xC0, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x78,
  0x01, 0x80, 0x00, 0xF0, 0x01, 0x80, 0x01, 0xE0, 0x03, 0x00, 0x03, 0xC0,
  0x03, 0x00, 0x07, 0x80, 0x06, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x78, 0x00, 0x0C, 0x00, 0xF0, 0x00,
  0x18, 0x01, 0xE0, 0x00, 0x18, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x80, 0x00,
  0x30, 0x0F, 0x00, 0x00, 0x30, 0x1E, 0x00, 0x00, 0x60, 0x3C, 0x00, 0x00,
  0x60, 0x78, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x00, 0xC1, 0xE0, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x01, 0x87, 0x80, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x03,
  0x1E, 0x00, 0x00, 0x03, 0x3C, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x06,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x02, 0x00,
  0x00, 0xF0, 0x40, 0x00, 0x07, 0x08, 0x00, 0x00, 0x31, 0x00, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x74, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x74, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x03, 0x10, 0x00, 0x01, 0xE2, 0x00, 0x00, 0xF0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xE3, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x02, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x01, 0xE0,
  0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x04, 0xC0, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3E, 0x01, 0xF0,
  0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x02, 0x60, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x03,
  0x80, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x30, 0x00, 0x40, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x01, 0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x98, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x02, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x20, 0x00, 0x18, 0x0C, 0x00, 0x06,
  0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x30, 0x06, 0x00,
  0x04, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x10, 0x00, 0x30, 0x06,
  0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x03, 0x00,
  0x04, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x03,
  0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x0C,
  0x06, 0x00, 0x02, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18,
  0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x19, 0xC0,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xFF, 0xFC,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xFF,
  0xFC, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x98, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x10, 0xC0, 0x03, 0x0C, 0x00,
  0x30, 0xC0, 0x02, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x40, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01,
  0x81, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x20, 0x00, 0x66, 0x00,
  0x06, 0x60, 0x00, 0x64, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3C, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x07, 0x80, 0x01, 0x83, 0x80, 0x00, 0x61,
  0x80, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x19, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x39, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x07, 0x98,
  0x00, 0x01, 0x66, 0x00, 0x00, 0xD8, 0xC0, 0x00, 0xE6, 0x18, 0x00, 0x71,
  0x83, 0xC0, 0xF0, 0x60, 0x7F, 0xF8, 0x1C, 0x03, 0xE0, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x7C, 0x00,
  0xC1, 0xFF, 0xC0, 0x63, 0xC0, 0x78, 0x33, 0x80, 0x0E, 0x1B, 0x00, 0x03,
  0x0F, 0x00, 0x00, 0xC7, 0x80, 0x00, 0x73, 0x80, 0x00, 0x19, 0x80, 0x00,
  0x0C, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x05, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0x78, 0x00, 0x06, 0x26, 0x00,
  0x06, 0x13, 0x80, 0x07, 0x08, 0x78, 0x0E, 0x04, 0x1F, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xE0, 0x3C, 0x01,
  0xC0, 0x07, 0x01, 0xC0, 0x00, 0xC1, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x20, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x0E, 0x00, 0x01, 0x83, 0x80, 0x01, 0x80, 0xE0, 0x01, 0x80, 0x3C, 0x07,
  0x80, 0x07, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x7C, 0x03, 0x01, 0xFF, 0xC1,
  0x83, 0xC0, 0x78, 0xC3, 0x80, 0x0E, 0x63, 0x80, 0x01, 0xB1, 0x80, 0x00,
  0x79, 0x80, 0x00, 0x3C, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x60, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x03, 0xC3, 0x00, 0x03, 0x61, 0xC0,
  0x03, 0x30, 0x78, 0x0F, 0x18, 0x0F, 0xFE, 0x0C, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x1E, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x0E, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x06, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x03, 0x60, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x00,
  0x78, 0x0F, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x1F, 0xF0, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF0, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0xC1, 0xE0, 0x3C, 0x61, 0xC0,
  0x07, 0x31, 0xC0, 0x00, 0xD8, 0xC0, 0x00, 0x2C, 0xC0, 0x00, 0x1E, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x06, 0x40, 0x00, 0x03, 0x30, 0x00, 0x03, 0x98, 0x00, 0x01, 0xC6,
  0x00, 0x01, 0xE1, 0x80, 0x01, 0xB0, 0xE0, 0x01, 0x98, 0x3C, 0x07, 0x8C,
  0x07, 0xFF, 0x06, 0x00, 0x7C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x38, 0x00, 0x06, 0x0E, 0x00,
  0x03, 0x03, 0x80, 0x03, 0x00, 0xF0, 0x07, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x0F, 0x00,
  0xC0, 0xFF, 0xC1, 0x87, 0x81, 0xE3, 0x1C, 0x00, 0xC6, 0x70, 0x00, 0xCC,
  0xC0, 0x00, 0xDB, 0x00, 0x01, 0xBC, 0x00, 0x03, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xC0, 0x6F, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x00, 0x60, 0x07, 0x00, 0xF0, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x18, 0x03, 0x8F, 0xE0, 0xFC, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x1D, 0x80, 0x00,
  0x73, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x30, 0x00, 0xC0, 0x60, 0x03, 0x00, 0xC0, 0x0E, 0x01, 0x80, 0x38, 0x03,
  0x00, 0xE0, 0x06, 0x03, 0x80, 0x0C, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x60, 0x00, 0x61, 0x80, 0x00, 0xC7, 0x00, 0x01, 0x9F, 0x00, 0x03, 0x66,
  0x00, 0x07, 0x86, 0x00, 0x0E, 0x0E, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x0C,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x18,
  0x06, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x30, 0x30, 0x00, 0x30,
  0x60, 0x00, 0x70, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x63, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x03, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x0C, 0x1C,
  0x07, 0x00, 0xF0, 0x3C, 0x30, 0xC0, 0x06, 0x07, 0x00, 0x38, 0xC6, 0x00,
  0x0C, 0x38, 0x00, 0x73, 0x30, 0x00, 0x39, 0xC0, 0x00, 0xCC, 0xC0, 0x00,
  0x66, 0x00, 0x01, 0xB6, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xD0, 0x00, 0x02,
  0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x01, 0x81,
  0xFF, 0x83, 0x0F, 0x03, 0xC6, 0x38, 0x01, 0x8C, 0xE0, 0x01, 0x99, 0x80,
  0x01, 0xB6, 0x00, 0x03, 0x78, 0x00, 0x06, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x01, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x07,
  0x00, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x81, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x40, 0xFF, 0xE0, 0x21, 0xE0,
  0x3C, 0x11, 0x80, 0x07, 0x0D, 0x80, 0x01, 0x87, 0x80, 0x00, 0x63, 0x80,
  0x00, 0x39, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x70,
  0x00, 0x06, 0x3C, 0x00, 0x03, 0x1F, 0x00, 0x03, 0x0D, 0xC0, 0x03, 0x86,
  0x3C, 0x0F, 0x03, 0x0F, 0xFF, 0x01, 0x80, 0x7C, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0xC1,
  0xE0, 0x3C, 0x61, 0xC0, 0x07, 0x31, 0xC0, 0x00, 0xD8, 0xC0, 0x00, 0x3C,
  0xC0, 0x00, 0x1E, 0x60, 0x00, 0x07, 0x70, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01,
  0x98, 0x00, 0x01, 0xC6, 0x00, 0x01, 0xE1, 0x80, 0x01, 0xB0, 0xE0, 0x03,
  0x98, 0x3C, 0x07, 0x8C, 0x07, 0xFF, 0x06, 0x00, 0x7C, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0x07, 0xFC, 0x38, 0x31,
  0x80, 0xCC, 0x03, 0x60, 0x0D, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x3C, 0x07, 0x80,
  0xC0, 0x01, 0x83, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x98, 0x00, 0x03, 0x20,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x31, 0x80, 0x00, 0xE3, 0x80,
  0x03, 0x81, 0xE0, 0x3E, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0x00, 0x3E,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xB0, 0x00, 0x07, 0x60, 0x00, 0x1E, 0xE0,
  0x00, 0x7C, 0xC0, 0x00, 0xD8, 0xC0, 0x07, 0x30, 0xE0, 0x3C, 0x60, 0xFF,
  0xE0, 0xC0, 0x3E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x60, 0x18, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x18,
  0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x18, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x06, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xD8, 0x00, 0x07, 0x00, 0x00, 0xEC, 0x00, 0x03, 0x80, 0x00, 0x66, 0x00,
  0x03, 0x60, 0x00, 0x33, 0x00, 0x01, 0xB0, 0x00, 0x18, 0xC0, 0x00, 0xD8,
  0x00, 0x1C, 0x60, 0x00, 0x66, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x06,
  0x18, 0x00, 0x31, 0x80, 0x03, 0x06, 0x00, 0x18, 0xC0, 0x03, 0x83, 0x00,
  0x0C, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x0C,
  0x00, 0x60, 0x30, 0x03, 0x06, 0x00, 0x70, 0x18, 0x03, 0x01, 0x80, 0x30,
  0x0C, 0x01, 0x80, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x01, 0x80,
  0x60, 0x18, 0x0E, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x06,
  0x03, 0x00, 0x30, 0x18, 0x03, 0x01, 0x80, 0x0C, 0x08, 0x00, 0xC1, 0xC0,
  0x06, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x30, 0x60, 0x01, 0x83,
  0x00, 0x08, 0x30, 0x00, 0x63, 0x00, 0x06, 0x18, 0x00, 0x31, 0x80, 0x03,
  0x18, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x46, 0x00,
  0x03, 0x60, 0x00, 0x33, 0x00, 0x01, 0xB0, 0x00, 0x1B, 0x00, 0x00, 0xD8,
  0x00, 0x0D, 0x80, 0x00, 0x68, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x00, 0x60, 0x01, 0xC0, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0x60,
  0x0C, 0x00, 0x18, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0xC0, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x60, 0x01, 0xC0, 0x30, 0x00,
  0x30, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x0E, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18,
  0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x06, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x60, 0x08, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00,
  0x30, 0x00, 0x60, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x80, 0x1C, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x20, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x08, 0x0C,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x80, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x01, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xC7, 0x07, 0x00, 0x00, 0x66, 0x00, 0xC0, 0x00, 0x33, 0x00, 0x30,
  0x00, 0x13, 0x00, 0x0C, 0x00, 0x19, 0x80, 0x03, 0x00, 0x0C, 0xC0, 0x00,
  0xC0, 0x04, 0x40, 0x00, 0x30, 0x06, 0x60, 0x00, 0x0E, 0x06, 0x30, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
};

const GFXglyph RobotoCondensed_Thin72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 52, 13, 5, -51 },
  { 27, 10, 14, 19, 5, -54 },
  { 45, 34, 51, 35, 2, -51 },
  { 262, 27, 67, 35, 4, -59 },
  { 489, 39, 53, 47, 4, -52 },
  { 748, 32, 53, 39, 4, -52 },
  { 960, 2, 15, 12, 5, -54 },
  { 964, 13, 74, 20, 5, -57 },
  { 1085, 13, 74, 20, 2, -57 },
  { 1206, 28, 28, 30, 1, -51 },
  { 1304, 30, 38, 36, 3, -43 },
  { 1447, 5, 14, 14, 3, -6 },
  { 1456, 14, 2, 19, 2, -25 },
  { 1460, 4, 4, 16, 5, -3 },
  { 1462, 20, 55, 25, 2, -51 },
  { 1600, 26, 53, 35, 4, -52 },
  { 1773, 14, 51, 35, 6, -51 },
  { 1863, 27, 52, 35, 4, -52 },
  { 2039, 27, 53, 35, 4, -52 },
  { 2218, 30, 51, 35, 3, -51 },
  { 2410, 25, 52, 35, 6, -51 },
  { 2573, 27, 52, 35, 4, -51 },
  { 2749, 28, 51, 35, 3, -51 },
  { 2928, 27, 53, 35, 4, -52 },
  { 3107, 26, 52, 35, 4, -52 },
  { 3276, 5, 38, 12, 4, -37 },
  { 3300, 6, 45, 12, 3, -37 },
  { 3334, 25, 29, 33, 3, -38 },
  { 3425, 25, 17, 35, 5, -32 },
  { 3479, 25, 29, 33, 4, -38 },
  { 3570, 22, 53, 28, 3, -52 },
  { 3716, 50, 66, 58, 4, -50 },
  { 4129, 34, 51, 38, 2, -51 },
  { 4346, 27, 51, 38, 7, -51 },
  { 4519, 31, 53, 41, 5, -52 },
  { 4725, 29, 51, 41, 7, -51 },
  { 4910, 26, 51, 36, 7, -51 },
  { 5076, 26, 51, 36, 7, -51 },
  { 5242, 31, 53, 43, 6, -52 },
  { 5448, 31, 51, 44, 7, -51 },
  { 5646, 2, 51, 17, 8, -51 },
  { 5659, 25, 52, 35, 3, -51 },
  { 5822, 30, 51, 40, 7, -51 },
  { 6014, 24, 51, 33, 7, -51 },
  { 6167, 40, 51, 54, 7, -51 },
  { 6422, 31, 51, 45, 7, -51 },
  { 6620, 32, 53, 42, 5, -52 },
  { 6832, 27, 51, 38, 7, -51 },
  { 7005, 32, 61, 42, 5, -52 },
  { 7249, 30, 51, 41, 6, -51 },
  { 7441, 30, 53, 37, 4, -52 },
  { 7640, 34, 51, 38, 2, -51 },
  { 7857, 30, 52, 42, 6, -51 },
  { 8052, 34, 51, 38, 2, -51 },
  { 8269, 52, 51, 57, 2, -51 },
  { 8601, 34, 51, 38, 2, -51 },
  { 8818, 34, 51, 38, 2, -51 },
  { 9035, 31, 51, 38, 3, -51 },
  { 9233, 9, 70, 15, 6, -59 },
  { 9312, 20, 55, 25, 2, -51 },
  { 9450, 9, 70, 15, 0, -59 },
  { 9529, 20, 26, 27, 3, -51 },
  { 9594, 25, 2, 27, 1, 0 },
  { 9601, 9, 9, 19, 5, -54 },
  { 9612, 26, 40, 34, 3, -39 },
  { 9742, 25, 55, 35, 6, -54 },
  { 9914, 25, 40, 32, 4, -39 },
  { 10039, 25, 55, 35, 4, -54 },
  { 10211, 26, 40, 33, 3, -39 },
  { 10341, 18, 55, 21, 3, -55 },
  { 10465, 25, 54, 35, 4, -39 },
  { 10634, 23, 54, 35, 6, -54 },
  { 10790, 4, 52, 14, 5, -52 },
  { 10816, 12, 67, 15, -3, -52 },
  { 10917, 23, 54, 30, 6, -54 },
  { 11073, 2, 54, 14, 6, -54 },
  { 11087, 46, 39, 56, 5, -39 },
  { 11312, 23, 39, 35, 6, -39 },
  { 11425, 27, 40, 35, 4, -39 },
  { 11560, 25, 54, 35, 6, -39 },
  { 11729, 25, 54, 35, 4, -39 },
  { 11898, 14, 39, 22, 6, -39 },
  { 11967, 23, 40, 32, 4, -39 },
  { 12082, 16, 49, 21, 2, -48 },
  { 12180, 23, 39, 35, 6, -38 },
  { 12293, 27, 38, 31, 2, -38 },
  { 12422, 41, 38, 48, 3, -38 },
  { 12617, 26, 38, 31, 2, -38 },
  { 12741, 27, 53, 30, 2, -38 },
  { 12920, 25, 38, 31, 3, -38 },
  { 13039, 17, 72, 21, 3, -56 },
  { 13192, 2, 61, 14, 6, -51 },
  { 13208, 17, 72, 21, 1, -56 },
  { 13361, 33, 12, 43, 5, -28 },
};

const GFXfont RobotoCondensed_Thin72pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin72pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin72pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _ROBOTOCONDENSED_THIN72PT7B_H_
