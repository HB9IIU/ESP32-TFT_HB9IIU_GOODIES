#ifndef _ROBOTOCONDENSED_THIN9PT7B_H_
#define _ROBOTOCONDENSED_THIN9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin9pt7bBitmaps[] PROGMEM = {
  0x00, 0x70, 0x00, 0x17, 0x55, 0x56, 0x00, 0x1E, 0x44, 0x4F, 0x00, 0xE5,
  0xBC, 0x43, 0x8C, 0x60, 0xCA, 0xC8, 0xCA, 0xE0, 0x00, 0x7F, 0x00, 0x15,
  0x55, 0x00, 0x06, 0x40, 0x06, 0x20, 0x00, 0x00, 0x00, 0x25, 0x24, 0xA4,
  0xF6, 0xDB, 0x78, 0xD5, 0x54, 0xE4, 0xA5, 0x30, 0x71, 0x11, 0x11, 0x70,
  0x02, 0x55, 0x71, 0x00, 0xD2, 0x32, 0x78, 0x13, 0xDB, 0x78, 0x71, 0x22,
  0x24, 0x40, 0x79, 0x97, 0x99, 0x70, 0x79, 0x99, 0x71, 0x20, 0x00, 0x00,
  0x24, 0x42, 0x48, 0x09, 0x40, 0xF4, 0x90, 0x00, 0x7A, 0x1A, 0x75, 0x97,
  0xF8, 0x18, 0x23, 0x14, 0xA7, 0x4A, 0x00, 0xF6, 0xF9, 0x58, 0xE8, 0x88,
  0x88, 0xE0, 0x69, 0x99, 0x99, 0x60, 0x52, 0x69, 0x10, 0x52, 0x69, 0x00,
  0xE9, 0x88, 0x99, 0xF0, 0x19, 0x9F, 0x99, 0x10, 0x7C, 0x11, 0x11, 0x19,
  0xE0, 0x0A, 0xC8, 0xCA, 0x00, 0x12, 0x49, 0x10, 0x0C, 0x67, 0x3D, 0xF4,
  0x80, 0x89, 0x9D, 0xBB, 0x10, 0xE9, 0x99, 0x99, 0xE0, 0xF6, 0xF9, 0x00,
  0xE9, 0x99, 0x99, 0xE0, 0xE9, 0x9E, 0x8A, 0x00, 0x78, 0x86, 0x19, 0x70,
  0x62, 0x22, 0x22, 0x00, 0x16, 0xDB, 0x78, 0x84, 0x94, 0xA5, 0x30, 0x80,
  0x93, 0x26, 0xAB, 0x66, 0xC8, 0x80, 0x00, 0x05, 0x62, 0x65, 0x00, 0x82,
  0x94, 0xC2, 0x10, 0x00, 0x31, 0x22, 0x44, 0x20, 0x7E, 0x91, 0x24, 0x89,
  0x7E, 0x48, 0x80, 0x40, 0x40, 0x31, 0x59, 0xE0, 0x13, 0xDB, 0x78, 0x79,
  0x89, 0x70, 0x27, 0xDB, 0x78, 0x7B, 0x88, 0x60, 0x49, 0x24, 0x80, 0xF6,
  0xDE, 0x58, 0x13, 0xDB, 0x48, 0x38, 0x3E, 0x12, 0x69, 0x80, 0x7C, 0xFD,
  0x6B, 0x52, 0x00, 0xF6, 0xD2, 0xF6, 0xDE, 0xF6, 0xDF, 0x00, 0xF6, 0xDE,
  0x48, 0xAA, 0x00, 0xD1, 0x96, 0x15, 0x40, 0x36, 0xDE, 0x8A, 0x64, 0x20,
  0x82, 0x95, 0x92, 0x40, 0x06, 0x46, 0x00, 0x89, 0x66, 0x24, 0x40, 0x12,
  0x44, 0x60, 0x09, 0x20, 0x12, 0x00, 0x7E, 0x15, 0x45, 0x00, 0xD2,
};

const GFXglyph RobotoCondensed_Thin9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 2, 0, -7 },
  { 2, 1, 2, 2, 1, -7 },
  { 3, 4, 7, 4, 0, -7 },
  { 7, 3, 9, 4, 1, -8 },
  { 11, 5, 7, 6, 0, -7 },
  { 16, 4, 7, 5, 1, -7 },
  { 20, 1, 2, 2, 0, -7 },
  { 21, 1, 9, 2, 1, -7 },
  { 23, 2, 9, 3, 0, -7 },
  { 26, 4, 3, 4, 0, -7 },
  { 28, 4, 4, 4, 0, -5 },
  { 30, 1, 2, 2, 0, -1 },
  { 31, 2, 1, 2, 0, -4 },
  { 32, 1, 1, 2, 0, -1 },
  { 33, 3, 8, 3, 0, -7 },
  { 36, 3, 7, 4, 1, -7 },
  { 39, 2, 7, 4, 1, -7 },
  { 41, 3, 7, 4, 1, -7 },
  { 44, 4, 7, 4, 0, -7 },
  { 48, 4, 7, 4, 0, -7 },
  { 52, 3, 7, 4, 1, -7 },
  { 55, 3, 7, 4, 1, -7 },
  { 58, 4, 7, 4, 0, -7 },
  { 62, 4, 7, 4, 0, -7 },
  { 66, 4, 7, 4, 0, -7 },
  { 70, 1, 4, 2, 0, -4 },
  { 71, 1, 5, 2, 0, -4 },
  { 72, 4, 4, 4, 0, -5 },
  { 74, 3, 2, 4, 1, -4 },
  { 75, 3, 4, 4, 1, -5 },
  { 77, 3, 7, 4, 0, -7 },
  { 80, 6, 8, 7, 1, -6 },
  { 86, 5, 7, 5, 0, -7 },
  { 91, 3, 7, 5, 1, -7 },
  { 94, 4, 7, 5, 1, -7 },
  { 98, 4, 7, 5, 1, -7 },
  { 102, 3, 7, 5, 1, -7 },
  { 105, 3, 7, 5, 1, -7 },
  { 108, 4, 7, 5, 1, -7 },
  { 112, 4, 7, 6, 1, -7 },
  { 116, 1, 7, 2, 1, -7 },
  { 117, 4, 7, 4, 0, -7 },
  { 121, 4, 7, 5, 1, -7 },
  { 125, 3, 7, 4, 1, -7 },
  { 128, 5, 7, 7, 1, -7 },
  { 133, 4, 7, 6, 1, -7 },
  { 137, 4, 7, 5, 1, -7 },
  { 141, 3, 7, 5, 1, -7 },
  { 144, 4, 8, 5, 1, -7 },
  { 148, 4, 7, 5, 1, -7 },
  { 152, 4, 7, 5, 0, -7 },
  { 156, 4, 7, 5, 0, -7 },
  { 160, 3, 7, 5, 1, -7 },
  { 163, 5, 7, 5, 0, -7 },
  { 168, 7, 7, 7, 0, -7 },
  { 175, 4, 7, 5, 0, -7 },
  { 179, 5, 7, 5, 0, -7 },
  { 184, 4, 7, 5, 0, -7 },
  { 188, 1, 8, 2, 1, -7 },
  { 189, 3, 8, 3, 0, -7 },
  { 192, 1, 8, 2, 0, -7 },
  { 193, 3, 3, 3, 0, -7 },
  { 195, 3, 1, 3, 0, 0 },
  { 196, 1, 2, 2, 1, -8 },
  { 197, 4, 5, 4, 0, -5 },
  { 200, 3, 7, 4, 1, -7 },
  { 203, 4, 5, 4, 0, -5 },
  { 206, 3, 7, 4, 1, -7 },
  { 209, 4, 5, 4, 0, -5 },
  { 212, 3, 7, 3, 0, -7 },
  { 215, 3, 7, 4, 1, -5 },
  { 218, 3, 7, 4, 1, -7 },
  { 221, 1, 6, 2, 0, -6 },
  { 222, 1, 8, 2, 0, -6 },
  { 223, 3, 7, 4, 1, -7 },
  { 226, 1, 7, 2, 0, -7 },
  { 227, 5, 5, 7, 1, -5 },
  { 231, 3, 5, 4, 1, -5 },
  { 233, 3, 5, 4, 1, -5 },
  { 235, 3, 7, 4, 1, -5 },
  { 238, 3, 7, 4, 1, -5 },
  { 241, 2, 5, 3, 1, -5 },
  { 243, 3, 5, 4, 0, -5 },
  { 245, 2, 6, 3, 0, -6 },
  { 247, 3, 5, 4, 1, -5 },
  { 249, 4, 5, 4, 0, -5 },
  { 252, 6, 5, 6, 0, -5 },
  { 256, 4, 5, 4, 0, -5 },
  { 259, 4, 7, 4, 0, -5 },
  { 263, 4, 5, 4, 0, -5 },
  { 266, 3, 9, 3, 0, -7 },
  { 270, 1, 8, 2, 0, -7 },
  { 271, 2, 9, 3, 0, -7 },
  { 274, 4, 2, 5, 1, -4 },
};

const GFXfont RobotoCondensed_Thin9pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin9pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOCONDENSED_THIN9PT7B_H_
