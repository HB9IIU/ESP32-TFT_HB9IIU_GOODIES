#ifndef _ROBOTOCONDENSED_THIN24PT7B_H_
#define _ROBOTOCONDENSED_THIN24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF0, 0x80, 0xB6, 0xDA, 0x08, 0x81, 0x10, 0x22, 0x04, 0x47,
  0xFE, 0x22, 0x04, 0x40, 0x88, 0x11, 0x02, 0x20, 0x44, 0x10, 0x8F, 0xFC,
  0x44, 0x08, 0x81, 0x10, 0x22, 0x00, 0x04, 0x02, 0x07, 0x84, 0x24, 0x0A,
  0x05, 0x02, 0x80, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x06, 0x03, 0x01,
  0x40, 0xB0, 0x87, 0x80, 0x80, 0x40, 0x38, 0x02, 0x40, 0x21, 0x09, 0x08,
  0x88, 0x44, 0x42, 0x41, 0x24, 0x07, 0x20, 0x02, 0x00, 0x13, 0x81, 0x22,
  0x09, 0x10, 0x88, 0x84, 0x44, 0x42, 0x20, 0x11, 0x00, 0x70, 0x1C, 0x04,
  0x40, 0x84, 0x10, 0x82, 0x20, 0x44, 0x09, 0x00, 0xC0, 0x28, 0x08, 0x85,
  0x10, 0xC1, 0x28, 0x15, 0x01, 0xA0, 0x22, 0x0A, 0x3E, 0x20, 0xF8, 0x12,
  0x24, 0x48, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x44, 0x22, 0x10,
  0x88, 0x44, 0x22, 0x21, 0x11, 0x11, 0x11, 0x11, 0x11, 0x22, 0x24, 0x48,
  0x80, 0x04, 0x01, 0x00, 0x43, 0x96, 0x1E, 0x03, 0x01, 0x20, 0x44, 0x21,
  0x00, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x0F, 0xFC, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x55, 0x80, 0xF0, 0x80, 0x04, 0x10,
  0x42, 0x08, 0x21, 0x04, 0x10, 0x82, 0x08, 0x41, 0x04, 0x20, 0x82, 0x00,
  0x1E, 0x10, 0x90, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0A, 0x05, 0x04, 0x42, 0x1E, 0x00, 0x1B, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x3E, 0x20, 0x90, 0x30, 0x18,
  0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x00, 0x80, 0x80,
  0x80, 0x7F, 0x80, 0x1E, 0x10, 0x90, 0x30, 0x18, 0x08, 0x04, 0x02, 0x02,
  0x1E, 0x00, 0x80, 0x20, 0x18, 0x0C, 0x05, 0x02, 0xC2, 0x1E, 0x00, 0x01,
  0x00, 0xC0, 0x50, 0x14, 0x09, 0x04, 0x41, 0x10, 0x84, 0x21, 0x10, 0x44,
  0x13, 0xFF, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x7F, 0x40, 0x40,
  0x40, 0x40, 0x40, 0xBC, 0x42, 0x01, 0x01, 0x01, 0x01, 0x81, 0x81, 0x81,
  0x41, 0x3E, 0x0F, 0x08, 0x08, 0x08, 0x04, 0x02, 0x02, 0x79, 0x42, 0xC0,
  0xC0, 0x60, 0x30, 0x18, 0x0A, 0x05, 0x02, 0x42, 0x1E, 0x00, 0xFF, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x20, 0x20, 0x00, 0x1E, 0x30, 0x90, 0x28, 0x18, 0x0C,
  0x05, 0x02, 0xC2, 0x1E, 0x10, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x83,
  0x3E, 0x00, 0x1E, 0x30, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x40,
  0xA0, 0xCF, 0xA0, 0x10, 0x08, 0x08, 0x04, 0x04, 0x3C, 0x00, 0x40, 0x00,
  0x01, 0x40, 0x00, 0x05, 0x68, 0x01, 0x06, 0x08, 0x30, 0xC0, 0xC0, 0x30,
  0x08, 0x06, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x10, 0x06,
  0x00, 0xC0, 0x10, 0x08, 0x18, 0x30, 0x20, 0x60, 0x00, 0x3C, 0x86, 0x0C,
  0x10, 0x20, 0x40, 0x82, 0x08, 0x10, 0x40, 0x80, 0x00, 0x00, 0x00, 0x10,
  0x03, 0xF0, 0x02, 0x06, 0x06, 0x00, 0x82, 0x00, 0x22, 0x00, 0x12, 0x07,
  0x09, 0x0C, 0x42, 0x84, 0x21, 0x44, 0x10, 0xC2, 0x08, 0x61, 0x04, 0x30,
  0x82, 0x18, 0x42, 0x0C, 0x21, 0x06, 0x10, 0x84, 0x88, 0xA2, 0x43, 0x8E,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x81, 0x00, 0x3F, 0x00, 0x04,
  0x01, 0x80, 0x28, 0x05, 0x01, 0x20, 0x22, 0x04, 0x41, 0x08, 0x20, 0x84,
  0x11, 0x02, 0x3F, 0xC4, 0x05, 0x00, 0xA0, 0x14, 0x01, 0x80, 0x20, 0xFE,
  0x40, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x02, 0xFE, 0x40, 0xA0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x03, 0xFE, 0x00, 0x3F, 0x10, 0x28, 0x06, 0x01,
  0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60,
  0x18, 0x05, 0x02, 0x3F, 0x00, 0xFE, 0x20, 0x48, 0x0A, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A,
  0x04, 0xFE, 0x00, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0xFF, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x1F, 0x18, 0x24, 0x06, 0x01,
  0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x21, 0xF8, 0x06, 0x01, 0x80, 0x60,
  0x14, 0x04, 0x81, 0x1F, 0x80, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0xFF, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x20, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x0A,
  0x04, 0x84, 0x3C, 0x00, 0x80, 0x60, 0x28, 0x12, 0x08, 0x84, 0x22, 0x08,
  0x82, 0x40, 0xB0, 0x32, 0x08, 0x42, 0x08, 0x82, 0x20, 0x48, 0x0A, 0x02,
  0x80, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x07, 0x00, 0x3C, 0x00,
  0xE8, 0x05, 0xA0, 0x16, 0x80, 0x59, 0x02, 0x64, 0x09, 0x90, 0x26, 0x21,
  0x18, 0x84, 0x62, 0x21, 0x84, 0x86, 0x12, 0x18, 0x30, 0x60, 0xC1, 0x82,
  0x04, 0x80, 0x38, 0x07, 0x00, 0xD0, 0x19, 0x03, 0x20, 0x62, 0x0C, 0x41,
  0x84, 0x30, 0x46, 0x08, 0xC0, 0x98, 0x13, 0x01, 0x60, 0x2C, 0x03, 0x80,
  0x20, 0x3F, 0x10, 0x28, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x02, 0x3F, 0x00, 0xFE,
  0x40, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x7F, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x3F, 0x10, 0x28, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x05, 0x02, 0x3F, 0x00, 0x40, 0x08, 0x01, 0xFE, 0x20, 0x48, 0x0A,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0x81, 0x3F, 0x88, 0x22, 0x08, 0x81,
  0x20, 0x48, 0x0A, 0x01, 0x80, 0x40, 0x1F, 0x18, 0x24, 0x06, 0x01, 0x80,
  0x50, 0x04, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x04, 0x01, 0x80, 0x60, 0x14,
  0x05, 0x82, 0x1F, 0x00, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x02,
  0x1F, 0x00, 0x80, 0x30, 0x06, 0x01, 0x20, 0x24, 0x04, 0x80, 0x90, 0x21,
  0x04, 0x20, 0x84, 0x20, 0x44, 0x08, 0x81, 0x20, 0x14, 0x02, 0x80, 0x60,
  0x04, 0x00, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x50, 0x30, 0x28, 0x24, 0x14,
  0x12, 0x12, 0x09, 0x08, 0x84, 0x84, 0x42, 0x22, 0x22, 0x12, 0x11, 0x09,
  0x04, 0x84, 0x82, 0x41, 0x41, 0x40, 0xC0, 0xA0, 0x60, 0x30, 0x30, 0x18,
  0x08, 0x08, 0x00, 0x80, 0x48, 0x09, 0x02, 0x10, 0x42, 0x10, 0x22, 0x02,
  0x80, 0x60, 0x04, 0x01, 0x40, 0x48, 0x08, 0x82, 0x10, 0x41, 0x10, 0x12,
  0x02, 0x80, 0x20, 0x80, 0x30, 0x09, 0x01, 0x20, 0x42, 0x08, 0x42, 0x04,
  0x40, 0x90, 0x0A, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x7F, 0xC0, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0xFF,
  0xC0, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x27, 0x82, 0x08,
  0x10, 0x41, 0x02, 0x08, 0x20, 0x41, 0x04, 0x08, 0x20, 0x81, 0x04, 0x10,
  0xE4, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x4F, 0x10, 0x60, 0xA1,
  0x44, 0x88, 0x91, 0x42, 0x82, 0xFF, 0x80, 0x88, 0x80, 0x3E, 0x20, 0xA0,
  0x50, 0x20, 0x10, 0x08, 0xFC, 0x82, 0x81, 0x40, 0xA0, 0x50, 0x67, 0xC8,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0xC2, 0xBC, 0x3E, 0x20, 0x90, 0x30, 0x18, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x50, 0x28, 0x23, 0xE0, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x09, 0xF5, 0x06, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x02, 0x81, 0x41, 0x8F, 0x40, 0x3E, 0x20, 0x90, 0x50, 0x18, 0x0F,
  0xFE, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x23, 0xE0, 0x1C, 0x82, 0x08,
  0x23, 0xE2, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x80, 0x3E,
  0xA0, 0xD0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x50, 0x28,
  0x31, 0xE8, 0x04, 0x02, 0x01, 0x41, 0x1F, 0x00, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x8F, 0xFF, 0x80, 0x10, 0x00, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x2C, 0x80, 0x80, 0x80, 0x80, 0x80, 0x82, 0x84, 0x88,
  0x90, 0x90, 0xA0, 0xE0, 0x90, 0x88, 0x88, 0x84, 0x82, 0x82, 0xFF, 0xFF,
  0xC0, 0xBC, 0x79, 0x85, 0x0A, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20,
  0x60, 0x40, 0xC0, 0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18,
  0x10, 0x20, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x1E, 0x10, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x50, 0x24, 0x21, 0xE0, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0xC2, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x3E, 0xA0, 0xD0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x50,
  0x28, 0x31, 0xE8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0xBE, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x00, 0x3E, 0x41, 0x81, 0x80, 0x40, 0x30,
  0x0C, 0x02, 0x01, 0x01, 0x81, 0x41, 0x3E, 0x42, 0x11, 0xF4, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x20, 0x87, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x83, 0x7D, 0x80, 0xC0, 0xA0, 0x48, 0x24, 0x22,
  0x10, 0x88, 0x48, 0x24, 0x0A, 0x06, 0x03, 0x00, 0x80, 0x82, 0x06, 0x0C,
  0x18, 0x30, 0x91, 0x42, 0x44, 0x89, 0x12, 0x24, 0x49, 0x0A, 0x24, 0x28,
  0x50, 0xA1, 0x42, 0x86, 0x04, 0x08, 0x10, 0x20, 0x81, 0x42, 0x42, 0x24,
  0x24, 0x18, 0x08, 0x18, 0x24, 0x24, 0x42, 0x41, 0x81, 0x80, 0xC0, 0xA0,
  0x48, 0x24, 0x22, 0x10, 0x88, 0x48, 0x24, 0x0A, 0x06, 0x03, 0x00, 0x80,
  0x80, 0x40, 0x20, 0x20, 0x60, 0x00, 0xFF, 0x01, 0x00, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x0F, 0xF8, 0x0C, 0x41, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x30, 0x40, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x41, 0x03, 0xFF, 0xFF, 0xF0, 0xC0, 0x82, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x03, 0x08, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x82, 0x30,
  0x70, 0x31, 0x06, 0x11, 0x41, 0xC0,
};

const GFXglyph RobotoCondensed_Thin24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 17, 4, 2, -17 },
  { 4, 3, 5, 6, 2, -18 },
  { 6, 11, 17, 12, 1, -17 },
  { 30, 9, 21, 12, 1, -19 },
  { 54, 13, 17, 16, 1, -17 },
  { 82, 11, 17, 13, 1, -17 },
  { 106, 1, 5, 4, 1, -18 },
  { 107, 4, 25, 7, 2, -19 },
  { 120, 4, 25, 7, 1, -19 },
  { 133, 10, 9, 10, 0, -17 },
  { 145, 10, 13, 12, 1, -15 },
  { 162, 2, 5, 5, 1, -2 },
  { 164, 4, 1, 6, 1, -9 },
  { 165, 1, 1, 5, 2, -1 },
  { 166, 6, 18, 8, 1, -17 },
  { 180, 9, 17, 12, 1, -17 },
  { 200, 5, 17, 12, 2, -17 },
  { 211, 9, 17, 12, 1, -17 },
  { 231, 9, 17, 12, 1, -17 },
  { 251, 10, 17, 12, 1, -17 },
  { 273, 8, 17, 12, 2, -17 },
  { 290, 9, 17, 12, 1, -17 },
  { 310, 9, 17, 12, 1, -17 },
  { 330, 9, 17, 12, 1, -17 },
  { 350, 9, 17, 12, 1, -17 },
  { 370, 2, 12, 4, 1, -12 },
  { 373, 2, 15, 4, 1, -12 },
  { 377, 8, 10, 11, 1, -13 },
  { 387, 8, 6, 12, 2, -11 },
  { 393, 9, 10, 11, 1, -13 },
  { 405, 7, 17, 9, 1, -17 },
  { 420, 17, 22, 19, 1, -17 },
  { 467, 11, 17, 13, 1, -17 },
  { 491, 9, 17, 13, 2, -17 },
  { 511, 10, 17, 14, 2, -17 },
  { 533, 10, 17, 14, 2, -17 },
  { 555, 9, 17, 12, 2, -17 },
  { 575, 9, 17, 12, 2, -17 },
  { 595, 10, 17, 14, 2, -17 },
  { 617, 11, 17, 15, 2, -17 },
  { 641, 1, 17, 6, 2, -17 },
  { 644, 9, 17, 12, 1, -17 },
  { 664, 10, 17, 13, 2, -17 },
  { 686, 8, 17, 11, 2, -17 },
  { 703, 14, 17, 18, 2, -17 },
  { 733, 11, 17, 15, 2, -17 },
  { 757, 10, 17, 14, 2, -17 },
  { 779, 9, 17, 13, 2, -17 },
  { 799, 10, 20, 14, 2, -17 },
  { 824, 10, 17, 14, 2, -17 },
  { 846, 10, 17, 12, 1, -17 },
  { 868, 11, 17, 13, 1, -17 },
  { 892, 10, 17, 14, 2, -17 },
  { 914, 11, 17, 13, 1, -17 },
  { 938, 17, 17, 19, 1, -17 },
  { 975, 11, 17, 13, 1, -17 },
  { 999, 11, 17, 13, 1, -17 },
  { 1023, 10, 17, 13, 1, -17 },
  { 1045, 3, 24, 5, 2, -20 },
  { 1054, 6, 18, 8, 1, -17 },
  { 1068, 3, 24, 5, 0, -20 },
  { 1077, 7, 9, 9, 1, -17 },
  { 1085, 9, 1, 9, 0, 0 },
  { 1087, 3, 3, 6, 2, -18 },
  { 1089, 9, 13, 11, 1, -13 },
  { 1104, 8, 18, 12, 2, -18 },
  { 1122, 9, 13, 11, 1, -13 },
  { 1137, 9, 18, 12, 1, -18 },
  { 1158, 9, 13, 11, 1, -13 },
  { 1173, 6, 18, 7, 1, -18 },
  { 1187, 9, 18, 12, 1, -13 },
  { 1208, 8, 18, 12, 2, -18 },
  { 1226, 1, 17, 5, 2, -17 },
  { 1229, 4, 22, 5, -1, -17 },
  { 1240, 8, 18, 10, 2, -18 },
  { 1258, 1, 18, 5, 2, -18 },
  { 1261, 15, 13, 19, 2, -13 },
  { 1286, 8, 13, 12, 2, -13 },
  { 1299, 9, 13, 12, 1, -13 },
  { 1314, 8, 18, 12, 2, -13 },
  { 1332, 9, 18, 12, 1, -13 },
  { 1353, 5, 13, 7, 2, -13 },
  { 1362, 8, 13, 11, 1, -13 },
  { 1375, 5, 16, 7, 1, -16 },
  { 1385, 8, 13, 12, 2, -13 },
  { 1398, 9, 13, 10, 1, -13 },
  { 1413, 14, 13, 16, 1, -13 },
  { 1436, 8, 13, 10, 1, -13 },
  { 1449, 9, 18, 10, 1, -13 },
  { 1470, 9, 13, 10, 1, -13 },
  { 1485, 6, 24, 7, 1, -19 },
  { 1503, 1, 20, 5, 2, -17 },
  { 1506, 6, 24, 7, 0, -19 },
  { 1524, 11, 4, 14, 2, -9 },
};

const GFXfont RobotoCondensed_Thin24pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin24pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin24pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOCONDENSED_THIN24PT7B_H_
