#ifndef _ROBOTOCONDENSED_THIN37PT7B_H_
#define _ROBOTOCONDENSED_THIN37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xE0, 0xC0, 0x9C, 0xE7, 0x39, 0x4A, 0x40, 0x01, 0x02,
  0x00, 0x82, 0x00, 0x41, 0x00, 0x20, 0x80, 0x20, 0x40, 0x10, 0x20, 0x08,
  0x10, 0xFF, 0xFF, 0x02, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x81, 0x00,
  0x40, 0x80, 0x20, 0x40, 0x10, 0x40, 0x08, 0x20, 0x04, 0x10, 0x04, 0x08,
  0x3F, 0xFF, 0xC1, 0x02, 0x00, 0x82, 0x00, 0x41, 0x00, 0x20, 0x80, 0x10,
  0x40, 0x10, 0x20, 0x08, 0x10, 0x00, 0x01, 0x00, 0x04, 0x00, 0x10, 0x01,
  0xF0, 0x18, 0x20, 0x80, 0x46, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x14,
  0x00, 0x50, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x40, 0x0D, 0x00, 0x22, 0x01, 0x86, 0x0C, 0x0F, 0xC0, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x3C, 0x00, 0x06, 0x20, 0x00, 0x41, 0x00, 0x08, 0x10, 0x00,
  0x81, 0x02, 0x08, 0x10, 0x20, 0x81, 0x04, 0x08, 0x10, 0x40, 0x81, 0x08,
  0x04, 0x11, 0x80, 0x62, 0x10, 0x03, 0xC2, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x43, 0xC0, 0x08, 0x46, 0x00, 0x88, 0x20, 0x10, 0x81, 0x02,
  0x08, 0x10, 0x20, 0x81, 0x04, 0x08, 0x10, 0x40, 0x81, 0x08, 0x08, 0x10,
  0x00, 0x82, 0x00, 0x04, 0x20, 0x00, 0x3C, 0x07, 0x80, 0x04, 0x20, 0x04,
  0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x20, 0x80,
  0x10, 0xC0, 0x08, 0xC0, 0x02, 0x80, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x90,
  0x00, 0x84, 0x04, 0x81, 0x02, 0x40, 0xC1, 0x40, 0x21, 0x20, 0x08, 0x90,
  0x02, 0x48, 0x01, 0xC4, 0x00, 0x61, 0x00, 0x30, 0xC0, 0x24, 0x30, 0x63,
  0x07, 0xC0, 0x80, 0x55, 0x68, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0x41,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0x40, 0x83, 0x04, 0x80, 0x81, 0x01,
  0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x08, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x04,
  0x08, 0x10, 0x41, 0x02, 0x08, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x07, 0x08, 0x73, 0xAE, 0x01, 0xC0, 0x03, 0x00, 0x12, 0x00,
  0x8C, 0x06, 0x18, 0x10, 0x20, 0x80, 0x40, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x55, 0x78, 0xFE,
  0xF0, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00,
  0x07, 0x80, 0x61, 0x82, 0x03, 0x08, 0x04, 0x40, 0x09, 0x00, 0x24, 0x00,
  0xA0, 0x02, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x90, 0x02, 0x40,
  0x09, 0x00, 0x22, 0x01, 0x08, 0x0C, 0x18, 0x60, 0x1E, 0x00, 0x03, 0x0D,
  0x71, 0x81, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x0F, 0x80, 0x41, 0x82, 0x01, 0x10, 0x04, 0x40, 0x0A, 0x00, 0x28, 0x00,
  0xA0, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0xFF, 0xF0, 0x0F, 0xC0,
  0x40, 0x82, 0x01, 0x10, 0x02, 0x40, 0x0A, 0x00, 0x28, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x18, 0x07, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00,
  0x24, 0x00, 0x88, 0x04, 0x18, 0x20, 0x3F, 0x00, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x24, 0x00, 0x88, 0x01, 0x10, 0x04,
  0x20, 0x08, 0x40, 0x20, 0x80, 0x41, 0x01, 0x02, 0x06, 0x04, 0x08, 0x08,
  0x20, 0x10, 0x40, 0x21, 0x00, 0x43, 0xFF, 0xF8, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x3F, 0xF9, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x13, 0xE0, 0xE0, 0xC4, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xA0, 0x05, 0x00, 0x44, 0x02,
  0x30, 0x60, 0x7C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x1F, 0x09, 0x82, 0x28,
  0x04, 0xC0, 0x0B, 0x00, 0x28, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x40, 0x0D, 0x00, 0x22, 0x00, 0x8C, 0x04, 0x18, 0x20,
  0x1F, 0x00, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x00,
  0x0F, 0xC0, 0x41, 0x82, 0x01, 0x10, 0x02, 0x40, 0x09, 0x00, 0x28, 0x00,
  0x50, 0x02, 0x40, 0x09, 0x00, 0x22, 0x01, 0x04, 0x08, 0x0F, 0xC0, 0x61,
  0x86, 0x01, 0x10, 0x02, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x14, 0x00, 0x98, 0x06, 0x30, 0x30, 0x3F, 0x00, 0x0F, 0x80,
  0x41, 0x82, 0x03, 0x10, 0x04, 0x40, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x40, 0x0D, 0x00, 0x52, 0x02,
  0x44, 0x12, 0x0F, 0x88, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x78, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x3C, 0x2C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x24, 0x92, 0xB0, 0x00, 0x10,
  0x06, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x40, 0x00, 0x1F, 0x0C, 0x11, 0x01, 0x40, 0x28,
  0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x30, 0x1C,
  0x00, 0x30, 0x00, 0x80, 0x18, 0x00, 0x10, 0x0C, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x04, 0x20, 0x0F, 0x00, 0x98,
  0x0C, 0x20, 0x24, 0x06, 0x04, 0x09, 0x01, 0x01, 0x02, 0x40, 0x80, 0x40,
  0x90, 0x20, 0x20, 0x28, 0x08, 0x08, 0x0A, 0x04, 0x02, 0x02, 0x81, 0x00,
  0x80, 0xA0, 0x40, 0x20, 0x28, 0x10, 0x08, 0x0A, 0x04, 0x02, 0x02, 0x81,
  0x01, 0x80, 0x90, 0x40, 0x60, 0x44, 0x08, 0x28, 0x11, 0x03, 0x11, 0x08,
  0x40, 0x78, 0x3C, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x14,
  0x00, 0x05, 0x00, 0x01, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x40,
  0x04, 0x10, 0x01, 0x04, 0x00, 0x40, 0x80, 0x20, 0x20, 0x08, 0x08, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x40, 0x10, 0x10, 0x02, 0x07, 0xFF, 0x82, 0x00,
  0x20, 0x80, 0x04, 0x20, 0x01, 0x10, 0x00, 0x44, 0x00, 0x09, 0x00, 0x02,
  0x80, 0x00, 0xA0, 0x00, 0x20, 0xFF, 0xC1, 0x00, 0x62, 0x00, 0x44, 0x00,
  0x48, 0x00, 0x90, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x09, 0x00, 0x12,
  0x00, 0x64, 0x01, 0x8F, 0xFC, 0x10, 0x06, 0x20, 0x02, 0x40, 0x02, 0x80,
  0x05, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xA0, 0x01,
  0x40, 0x04, 0x80, 0x11, 0xFF, 0xC0, 0x07, 0xE0, 0x18, 0x18, 0x20, 0x04,
  0x40, 0x04, 0x40, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02,
  0x40, 0x02, 0x40, 0x06, 0x20, 0x04, 0x18, 0x18, 0x07, 0xE0, 0xFF, 0xC0,
  0x80, 0x30, 0x80, 0x18, 0x80, 0x04, 0x80, 0x04, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x18, 0x80, 0x30,
  0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF,
  0xF2, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFF, 0xF0,
  0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xFA, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00, 0x07, 0xF0,
  0x18, 0x08, 0x30, 0x04, 0x60, 0x02, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x40, 0x01, 0x40, 0x01, 0x20, 0x01, 0x30, 0x03, 0x08, 0x0C,
  0x07, 0xF0, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x40, 0x0B, 0x00, 0x48,
  0x04, 0x30, 0xC0, 0xFC, 0x00, 0x80, 0x02, 0x80, 0x04, 0x80, 0x08, 0x80,
  0x10, 0x80, 0x30, 0x80, 0x60, 0x80, 0x40, 0x80, 0x80, 0x81, 0x00, 0x82,
  0x00, 0x84, 0x00, 0x8C, 0x00, 0x9C, 0x00, 0x92, 0x00, 0xA3, 0x00, 0xC1,
  0x00, 0x80, 0x80, 0x80, 0x40, 0x80, 0x60, 0x80, 0x20, 0x80, 0x10, 0x80,
  0x08, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x02, 0x80, 0x01, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x07, 0xFF, 0xC0, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE8, 0x00, 0x07,
  0x40, 0x00, 0x3A, 0x00, 0x02, 0xC8, 0x00, 0x16, 0x40, 0x01, 0x31, 0x00,
  0x09, 0x88, 0x00, 0x4C, 0x40, 0x04, 0x61, 0x00, 0x23, 0x08, 0x01, 0x18,
  0x40, 0x10, 0xC1, 0x00, 0x86, 0x08, 0x08, 0x30, 0x40, 0x41, 0x81, 0x02,
  0x0C, 0x08, 0x20, 0x60, 0x21, 0x03, 0x01, 0x08, 0x18, 0x08, 0x80, 0xC0,
  0x24, 0x06, 0x01, 0x40, 0x30, 0x0A, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x00,
  0x40, 0xC0, 0x00, 0xE0, 0x00, 0x68, 0x00, 0x34, 0x00, 0x19, 0x00, 0x0C,
  0x40, 0x06, 0x20, 0x03, 0x08, 0x01, 0x84, 0x00, 0xC1, 0x00, 0x60, 0xC0,
  0x30, 0x20, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x01, 0x03, 0x00, 0xC1, 0x80,
  0x20, 0xC0, 0x08, 0x60, 0x04, 0x30, 0x01, 0x18, 0x00, 0x8C, 0x00, 0x26,
  0x00, 0x0B, 0x00, 0x05, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x07, 0xE0, 0x18,
  0x18, 0x20, 0x04, 0x40, 0x06, 0x40, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x02, 0x40, 0x02, 0x40, 0x06, 0x20, 0x0C, 0x18, 0x18, 0x07,
  0xE0, 0xFF, 0xE1, 0x00, 0x62, 0x00, 0x24, 0x00, 0x28, 0x00, 0x50, 0x00,
  0xA0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x14, 0x00, 0x28,
  0x00, 0x90, 0x06, 0x3F, 0xF8, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x00, 0x03, 0xF0, 0x06, 0x06, 0x04, 0x00, 0x84, 0x00, 0x66, 0x00,
  0x12, 0x00, 0x09, 0x00, 0x02, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x14, 0x00, 0x1B, 0x00,
  0x08, 0x80, 0x0C, 0x20, 0x0C, 0x0C, 0x0C, 0x01, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0xFF, 0xC0, 0x80, 0x30,
  0x80, 0x08, 0x80, 0x04, 0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x10,
  0xFF, 0xC0, 0x80, 0x40, 0x80, 0x20, 0x80, 0x20, 0x80, 0x10, 0x80, 0x10,
  0x80, 0x08, 0x80, 0x08, 0x80, 0x04, 0x80, 0x06, 0x80, 0x02, 0x80, 0x03,
  0x07, 0xE0, 0x18, 0x18, 0x20, 0x04, 0x40, 0x06, 0x40, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x40, 0x02, 0x20, 0x04,
  0x18, 0x18, 0x07, 0xE0, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x28, 0x00, 0x50, 0x01, 0x90, 0x06, 0x18, 0x18, 0x0F,
  0xC0, 0x80, 0x00, 0xA0, 0x00, 0x24, 0x00, 0x09, 0x00, 0x06, 0x40, 0x01,
  0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x08, 0x10, 0x02, 0x04, 0x00, 0x81,
  0x00, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x00, 0x40, 0x80, 0x10,
  0x20, 0x04, 0x10, 0x01, 0x04, 0x00, 0x21, 0x00, 0x08, 0x80, 0x02, 0x20,
  0x00, 0x48, 0x00, 0x14, 0x00, 0x05, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x28, 0x00, 0x80, 0x09, 0x00, 0x28, 0x01, 0x20, 0x05,
  0x00, 0x24, 0x00, 0xA0, 0x04, 0x40, 0x12, 0x00, 0x88, 0x04, 0x40, 0x21,
  0x00, 0x88, 0x04, 0x20, 0x11, 0x00, 0x84, 0x02, 0x10, 0x10, 0x40, 0x82,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x02,
  0x10, 0x10, 0x80, 0x42, 0x02, 0x10, 0x08, 0x40, 0x42, 0x01, 0x10, 0x04,
  0x40, 0x12, 0x00, 0x88, 0x02, 0x40, 0x12, 0x00, 0x48, 0x02, 0x40, 0x0A,
  0x00, 0x28, 0x01, 0x40, 0x05, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x40, 0x00, 0xB0, 0x00, 0x88, 0x00, 0xC2, 0x00,
  0x41, 0x00, 0x40, 0x40, 0x20, 0x20, 0x20, 0x08, 0x30, 0x02, 0x10, 0x01,
  0x10, 0x00, 0x48, 0x00, 0x28, 0x00, 0x08, 0x00, 0x06, 0x00, 0x05, 0x00,
  0x06, 0x40, 0x02, 0x10, 0x02, 0x08, 0x01, 0x02, 0x01, 0x01, 0x01, 0x80,
  0x40, 0x80, 0x30, 0x80, 0x08, 0x40, 0x02, 0x40, 0x01, 0x60, 0x00, 0x40,
  0x80, 0x00, 0x90, 0x00, 0x24, 0x00, 0x10, 0x80, 0x04, 0x20, 0x02, 0x04,
  0x00, 0x81, 0x00, 0x40, 0x20, 0x10, 0x08, 0x08, 0x01, 0x02, 0x00, 0x41,
  0x00, 0x08, 0x40, 0x02, 0x20, 0x00, 0x48, 0x00, 0x14, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0xFF,
  0xFE, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0xF0, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x20, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x43, 0xF0, 0x08, 0x03, 0x01, 0x40, 0x50, 0x12, 0x08, 0x82,
  0x20, 0x84, 0x41, 0x10, 0x24, 0x0A, 0x02, 0x80, 0x40, 0xFF, 0xF8, 0x84,
  0x62, 0x10, 0x0F, 0x81, 0x83, 0x10, 0x0C, 0x80, 0x28, 0x01, 0x40, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x7F, 0x8C, 0x04, 0x80, 0x28, 0x01, 0x40,
  0x0A, 0x00, 0x50, 0x02, 0x80, 0x34, 0x03, 0x98, 0x34, 0x7E, 0x10, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x8F, 0x85, 0x83, 0x30, 0x09, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x50, 0x02, 0x80, 0x16, 0x01, 0x2C, 0x11, 0x1F, 0x00, 0x0F, 0x81, 0x83,
  0x18, 0x0C, 0x80, 0x28, 0x01, 0x40, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x40,
  0x13, 0x00, 0x8C, 0x18, 0x1F, 0x00, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x0F, 0x89, 0x83, 0x48, 0x0E,
  0x80, 0x34, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x28, 0x01, 0x40, 0x19, 0x00,
  0xCC, 0x1A, 0x1F, 0x10, 0x0F, 0x81, 0x83, 0x18, 0x0C, 0x80, 0x28, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x84, 0x0C, 0x1F,
  0x80, 0x03, 0xC3, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0xFF,
  0x84, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x0F, 0x89, 0x83, 0x48, 0x0E, 0x80, 0x34, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x28, 0x01, 0x40, 0x19, 0x00, 0xCC, 0x1A, 0x1F, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x11, 0x00, 0x84, 0x08, 0x1F, 0x80, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x8F, 0x89,
  0x04, 0xA0, 0x2C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0xA0, 0x02, 0xAA, 0xAA, 0xAA, 0xAA, 0xA8, 0x04,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x0C, 0x13, 0xC0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x28, 0x04, 0x80, 0x88, 0x10,
  0x83, 0x08, 0x60, 0x8C, 0x08, 0x80, 0x90, 0x0A, 0x80, 0xC8, 0x08, 0x40,
  0x82, 0x08, 0x20, 0x81, 0x08, 0x08, 0x80, 0xC8, 0x04, 0x80, 0x28, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x8F, 0x81, 0xF1, 0x20, 0x84, 0x1A, 0x80, 0x90,
  0x16, 0x01, 0x40, 0x1C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x10, 0x8F, 0x89, 0x04, 0xA0, 0x2C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x0F, 0xC0, 0x41, 0x82,
  0x01, 0x10, 0x02, 0x40, 0x0B, 0x00, 0x28, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x90, 0x02,
  0x40, 0x08, 0x80, 0x41, 0x06, 0x03, 0xF0, 0x8F, 0x85, 0x83, 0x30, 0x09,
  0x80, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x50, 0x02, 0x80, 0x16, 0x01,
  0x2C, 0x11, 0x1F, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x00, 0x0F, 0x89, 0x83, 0x48, 0x0E, 0x80, 0x34,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0x00, 0x28, 0x01, 0x40, 0x09, 0x00, 0xCC, 0x1A,
  0x1F, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x8F, 0x22, 0x86, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x00, 0x1F, 0x82, 0x04,
  0x40, 0x28, 0x01, 0x80, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x01, 0x80, 0x14, 0x02,
  0x60, 0x61, 0xF8, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x08, 0x0F, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0xC0, 0x34, 0x05, 0x20, 0xD1, 0xF1, 0x80, 0x06,
  0x00, 0x24, 0x00, 0x90, 0x02, 0x40, 0x10, 0x80, 0x42, 0x01, 0x08, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x04, 0x02, 0x10, 0x08, 0x40, 0x22, 0x00, 0x48,
  0x01, 0x20, 0x05, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x80, 0x20, 0x1C,
  0x03, 0x00, 0xA0, 0x18, 0x05, 0x00, 0xA0, 0x24, 0x09, 0x01, 0x20, 0x48,
  0x11, 0x02, 0x40, 0x88, 0x11, 0x04, 0x21, 0x08, 0x21, 0x08, 0x42, 0x08,
  0x42, 0x10, 0x42, 0x08, 0x81, 0x20, 0x44, 0x09, 0x02, 0x40, 0x48, 0x12,
  0x02, 0x40, 0x50, 0x0C, 0x02, 0x80, 0x60, 0x14, 0x03, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x40, 0x09, 0x80, 0x42, 0x01, 0x04, 0x08, 0x10, 0x60, 0x21,
  0x00, 0x88, 0x01, 0x20, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x40, 0x04,
  0x80, 0x21, 0x01, 0x84, 0x04, 0x08, 0x20, 0x20, 0x80, 0x44, 0x01, 0xB0,
  0x02, 0x80, 0x06, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40, 0x10, 0x80, 0x42,
  0x01, 0x08, 0x08, 0x10, 0x20, 0x40, 0x81, 0x06, 0x02, 0x10, 0x08, 0x40,
  0x21, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x1C, 0x00, 0xFF, 0xF0, 0x01, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0xFF, 0xF0, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x0C, 0x0C, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0xFF, 0xFF,
  0xFF, 0xFE, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x01, 0x80, 0x20,
  0x60, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x0C, 0x04, 0x04, 0x0C, 0x00, 0x3C, 0x01, 0x42, 0x01,
  0x81, 0x01, 0x80, 0x81, 0x80, 0x42, 0x80, 0x3C,
};

const GFXglyph RobotoCondensed_Thin37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 1, 26, 7, 3, -26 },
  { 5, 5, 7, 10, 3, -28 },
  { 10, 17, 26, 18, 1, -26 },
  { 66, 14, 32, 18, 2, -29 },
  { 122, 20, 26, 24, 2, -26 },
  { 187, 17, 26, 20, 2, -26 },
  { 243, 2, 7, 6, 2, -28 },
  { 245, 6, 37, 10, 3, -29 },
  { 273, 7, 37, 10, 1, -29 },
  { 306, 14, 14, 16, 1, -26 },
  { 331, 16, 19, 18, 1, -22 },
  { 369, 2, 7, 7, 2, -3 },
  { 371, 7, 1, 10, 1, -13 },
  { 372, 2, 2, 8, 3, -2 },
  { 373, 10, 28, 13, 1, -26 },
  { 408, 14, 26, 18, 2, -26 },
  { 454, 8, 26, 18, 3, -26 },
  { 480, 14, 26, 18, 2, -26 },
  { 526, 14, 26, 18, 2, -26 },
  { 572, 15, 26, 18, 2, -26 },
  { 621, 13, 26, 18, 3, -26 },
  { 664, 14, 26, 18, 2, -26 },
  { 710, 14, 26, 18, 2, -26 },
  { 756, 14, 26, 18, 2, -26 },
  { 802, 14, 26, 18, 2, -26 },
  { 848, 2, 19, 6, 2, -19 },
  { 853, 3, 23, 6, 1, -19 },
  { 862, 12, 14, 17, 2, -19 },
  { 883, 12, 8, 18, 3, -16 },
  { 895, 13, 14, 17, 2, -19 },
  { 918, 11, 26, 14, 2, -26 },
  { 954, 26, 33, 30, 2, -25 },
  { 1062, 18, 26, 20, 1, -26 },
  { 1121, 15, 26, 20, 3, -26 },
  { 1170, 16, 26, 21, 3, -26 },
  { 1222, 16, 26, 21, 3, -26 },
  { 1274, 14, 26, 19, 3, -26 },
  { 1320, 14, 26, 19, 3, -26 },
  { 1366, 16, 26, 22, 3, -26 },
  { 1418, 16, 26, 23, 3, -26 },
  { 1470, 1, 26, 9, 4, -26 },
  { 1474, 13, 26, 18, 2, -26 },
  { 1517, 16, 26, 21, 3, -26 },
  { 1569, 13, 26, 17, 3, -26 },
  { 1612, 21, 26, 28, 3, -26 },
  { 1681, 17, 26, 23, 3, -26 },
  { 1737, 16, 26, 22, 3, -26 },
  { 1789, 15, 26, 20, 3, -26 },
  { 1838, 17, 31, 22, 2, -26 },
  { 1904, 16, 26, 21, 3, -26 },
  { 1956, 16, 26, 19, 2, -26 },
  { 2008, 17, 26, 19, 1, -26 },
  { 2064, 15, 26, 22, 3, -26 },
  { 2113, 18, 26, 20, 1, -26 },
  { 2172, 27, 26, 29, 1, -26 },
  { 2260, 17, 26, 19, 1, -26 },
  { 2316, 18, 26, 19, 1, -26 },
  { 2375, 16, 26, 19, 2, -26 },
  { 2427, 5, 36, 8, 3, -30 },
  { 2450, 11, 28, 13, 1, -26 },
  { 2489, 5, 36, 8, 0, -30 },
  { 2512, 10, 13, 14, 2, -26 },
  { 2529, 13, 1, 14, 0, 0 },
  { 2531, 4, 5, 10, 3, -28 },
  { 2534, 13, 20, 17, 2, -20 },
  { 2567, 13, 28, 18, 3, -28 },
  { 2613, 13, 20, 17, 2, -20 },
  { 2646, 13, 28, 18, 2, -28 },
  { 2692, 13, 20, 17, 2, -20 },
  { 2725, 10, 28, 11, 1, -28 },
  { 2760, 13, 28, 18, 2, -20 },
  { 2806, 12, 28, 18, 3, -28 },
  { 2848, 2, 27, 7, 3, -27 },
  { 2855, 7, 35, 8, -2, -27 },
  { 2886, 12, 28, 16, 3, -28 },
  { 2928, 1, 28, 7, 3, -28 },
  { 2932, 23, 20, 29, 3, -20 },
  { 2990, 12, 20, 18, 3, -20 },
  { 3020, 14, 20, 18, 2, -20 },
  { 3055, 13, 28, 18, 3, -20 },
  { 3101, 13, 28, 18, 2, -20 },
  { 3147, 7, 20, 11, 3, -20 },
  { 3165, 12, 20, 16, 2, -20 },
  { 3195, 8, 25, 11, 1, -25 },
  { 3220, 12, 20, 18, 3, -20 },
  { 3250, 14, 20, 16, 1, -20 },
  { 3285, 21, 20, 24, 2, -20 },
  { 3338, 14, 20, 16, 1, -20 },
  { 3373, 14, 28, 16, 1, -20 },
  { 3422, 13, 20, 16, 2, -20 },
  { 3455, 10, 37, 11, 1, -29 },
  { 3502, 1, 31, 7, 3, -26 },
  { 3506, 9, 37, 11, 0, -29 },
  { 3548, 16, 6, 22, 3, -14 },
};

const GFXfont RobotoCondensed_Thin37pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin37pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin37pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _ROBOTOCONDENSED_THIN37PT7B_H_
