#ifndef _ROBOTOCONDENSED_THIN23PT7B_H_
#define _ROBOTOCONDENSED_THIN23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF8, 0x80, 0xB6, 0xDA, 0x08, 0x82, 0x20, 0x88, 0x44, 0xFF,
  0xC4, 0x41, 0x10, 0x44, 0x11, 0x08, 0x82, 0x20, 0x88, 0xFF, 0xC8, 0x82,
  0x20, 0x88, 0x44, 0x00, 0x08, 0x04, 0x0F, 0x88, 0x24, 0x12, 0x05, 0x02,
  0x80, 0x40, 0x18, 0x03, 0x00, 0x40, 0x10, 0x06, 0x03, 0x01, 0x40, 0xA0,
  0x8F, 0x81, 0x00, 0x80, 0x30, 0x02, 0x40, 0x21, 0x11, 0x08, 0x88, 0x48,
  0x42, 0x41, 0x24, 0x06, 0x40, 0x02, 0x00, 0x23, 0x01, 0x24, 0x12, 0x10,
  0x90, 0x88, 0x84, 0x44, 0x20, 0x12, 0x00, 0x60, 0x1C, 0x04, 0x40, 0x88,
  0x21, 0x02, 0x20, 0x48, 0x0A, 0x00, 0x80, 0x28, 0x09, 0x01, 0x11, 0x41,
  0x28, 0x15, 0x02, 0xA0, 0x22, 0x0A, 0x3E, 0x40, 0xF8, 0x12, 0x44, 0x48,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x44, 0x42, 0x10, 0x82, 0x08, 0x41,
  0x08, 0x42, 0x08, 0x42, 0x10, 0x84, 0x21, 0x10, 0x84, 0x42, 0x22, 0x00,
  0x08, 0x04, 0x02, 0x19, 0x33, 0xE0, 0x60, 0x48, 0x44, 0x21, 0x00, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x55, 0x80, 0xF0, 0x80, 0x04, 0x10, 0x82, 0x08, 0x41, 0x04,
  0x20, 0x82, 0x10, 0x41, 0x04, 0x20, 0x82, 0x00, 0x1E, 0x10, 0x90, 0x48,
  0x28, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0A, 0x05,
  0x04, 0x42, 0x1E, 0x00, 0x1B, 0x62, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x3E, 0x20, 0x90, 0x50, 0x28, 0x10, 0x08, 0x04, 0x02,
  0x02, 0x02, 0x01, 0x01, 0x01, 0x00, 0x80, 0x80, 0x80, 0x7F, 0x80, 0x3E,
  0x20, 0x90, 0x50, 0x18, 0x08, 0x04, 0x04, 0x02, 0x1E, 0x01, 0x80, 0x20,
  0x18, 0x0C, 0x05, 0x02, 0x82, 0x3E, 0x00, 0x02, 0x00, 0x80, 0x60, 0x28,
  0x0A, 0x04, 0x81, 0x20, 0x88, 0x22, 0x10, 0x88, 0x23, 0xFF, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x7F, 0x40, 0x40, 0x40, 0x80, 0x80, 0xBC,
  0xC2, 0x01, 0x01, 0x01, 0x01, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x0E, 0x08,
  0x08, 0x08, 0x04, 0x02, 0x02, 0x79, 0x42, 0xC0, 0xC0, 0x60, 0x30, 0x18,
  0x0A, 0x05, 0x04, 0x42, 0x1E, 0x00, 0xFF, 0x80, 0x40, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20,
  0x20, 0x00, 0x3E, 0x20, 0x90, 0x50, 0x18, 0x0C, 0x05, 0x04, 0x82, 0x3E,
  0x11, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x82, 0x3E, 0x00, 0x3E, 0x20,
  0x90, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x41, 0xA1, 0x4F, 0x20, 0x10,
  0x10, 0x08, 0x08, 0x0C, 0x38, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x05,
  0x68, 0x01, 0x06, 0x18, 0x60, 0x80, 0x60, 0x18, 0x06, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x06, 0x18, 0x20,
  0xC0, 0x38, 0x8A, 0x0C, 0x10, 0x20, 0x40, 0x82, 0x08, 0x20, 0x40, 0x80,
  0x00, 0x00, 0x00, 0x10, 0x03, 0xF0, 0x0C, 0x08, 0x10, 0x04, 0x20, 0x02,
  0x20, 0x01, 0x41, 0xC1, 0x42, 0x21, 0x44, 0x21, 0x84, 0x21, 0x84, 0x21,
  0x84, 0x21, 0x88, 0x21, 0x88, 0x21, 0x84, 0x21, 0x44, 0x62, 0x43, 0x9C,
  0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x04, 0x01,
  0x80, 0x30, 0x09, 0x01, 0x20, 0x24, 0x04, 0x41, 0x08, 0x21, 0x04, 0x11,
  0x02, 0x3F, 0xC4, 0x09, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x20, 0xFE, 0x40,
  0xA0, 0x50, 0x28, 0x0C, 0x0A, 0x05, 0x02, 0xFE, 0x41, 0xA0, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x02, 0xFE, 0x00, 0x3E, 0x10, 0x68, 0x0A, 0x01, 0x80,
  0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18,
  0x09, 0x06, 0x3E, 0x00, 0xFE, 0x20, 0x48, 0x0A, 0x02, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x28, 0x0A, 0x04,
  0xFE, 0x00, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x3F, 0x10, 0x24, 0x0A, 0x01, 0x80,
  0x60, 0x08, 0x02, 0x00, 0x80, 0x21, 0xF8, 0x06, 0x01, 0x80, 0x60, 0x14,
  0x05, 0x82, 0x1F, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0xFF, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x40, 0xFF, 0xFF, 0x80, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x80, 0xA0,
  0x48, 0x12, 0x08, 0x84, 0x22, 0x09, 0x02, 0x80, 0xB0, 0x32, 0x08, 0x82,
  0x10, 0x82, 0x20, 0x48, 0x12, 0x02, 0x80, 0x40, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xFF, 0x80, 0x0C, 0x00, 0x70, 0x07, 0x80, 0x3A, 0x02, 0xD0, 0x16, 0x80,
  0xB2, 0x09, 0x90, 0x4C, 0x82, 0x62, 0x23, 0x11, 0x18, 0x48, 0xC2, 0x86,
  0x14, 0x30, 0x41, 0x82, 0x08, 0x80, 0x70, 0x1C, 0x06, 0x81, 0xA0, 0x64,
  0x18, 0x86, 0x21, 0x84, 0x61, 0x18, 0x26, 0x09, 0x81, 0x60, 0x58, 0x0E,
  0x01, 0x80, 0x40, 0x3E, 0x10, 0x48, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x09, 0x04, 0x3E,
  0x00, 0xFE, 0x40, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x7F,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x3E, 0x10, 0x48,
  0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x09, 0x04, 0x3E, 0x00, 0x40, 0x08, 0x01, 0xFE, 0x20,
  0x48, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x81, 0x3F, 0x88, 0x42,
  0x08, 0x82, 0x20, 0x48, 0x0A, 0x02, 0x80, 0x40, 0x3F, 0x10, 0x24, 0x06,
  0x01, 0x80, 0x10, 0x04, 0x00, 0xC0, 0x0E, 0x00, 0x40, 0x08, 0x01, 0x80,
  0x60, 0x18, 0x05, 0x02, 0x3F, 0x00, 0xFF, 0xC1, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x82, 0x3E, 0x00,
  0x80, 0x30, 0x0A, 0x01, 0x40, 0x24, 0x08, 0x81, 0x10, 0x21, 0x08, 0x21,
  0x04, 0x20, 0x44, 0x09, 0x01, 0x20, 0x24, 0x03, 0x00, 0x60, 0x04, 0x00,
  0x81, 0x01, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x42, 0x42, 0x42,
  0x42, 0x42, 0x42, 0x42, 0x44, 0x22, 0x24, 0x24, 0x24, 0x24, 0x24, 0x24,
  0x28, 0x14, 0x18, 0x14, 0x18, 0x18, 0x18, 0x08, 0x10, 0x08, 0x80, 0x50,
  0x24, 0x08, 0x84, 0x21, 0x04, 0x81, 0x20, 0x30, 0x04, 0x03, 0x01, 0x20,
  0x48, 0x21, 0x08, 0x24, 0x0A, 0x01, 0x80, 0x40, 0x80, 0x50, 0x09, 0x02,
  0x20, 0x42, 0x10, 0x42, 0x04, 0x80, 0x90, 0x0A, 0x01, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF, 0xC0, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x04, 0x02, 0x00, 0xFF, 0xC0, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x49, 0x38, 0x82, 0x08, 0x10, 0x41, 0x02, 0x08, 0x20, 0x41, 0x04,
  0x08, 0x20, 0x81, 0x04, 0x10, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x78, 0x10, 0xC2, 0x92, 0x49, 0x18, 0x61, 0xFF, 0x89, 0x00, 0x3E,
  0x41, 0x81, 0x81, 0x01, 0x3F, 0x41, 0x81, 0x81, 0x81, 0x83, 0x7D, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x82, 0xFC, 0x3E, 0x41, 0x81, 0x81, 0x80, 0x80, 0x80,
  0x80, 0x81, 0x81, 0x41, 0x3E, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x3F,
  0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x41, 0x3F, 0x3E,
  0x41, 0x81, 0x81, 0x81, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x41, 0x3E, 0x1C,
  0x82, 0x10, 0x41, 0x0F, 0x90, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x00, 0x3F, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x41,
  0x3F, 0x01, 0x01, 0x01, 0x41, 0x3E, 0x81, 0x02, 0x04, 0x08, 0x10, 0x2F,
  0x61, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x8F, 0xFF,
  0x10, 0x00, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x12, 0xC0, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0xC2, 0x89, 0x22, 0x87, 0x0A, 0x12, 0x22,
  0x42, 0x85, 0x04, 0xFF, 0xFF, 0xC0, 0xBC, 0x7B, 0x0A, 0x18, 0x30, 0x60,
  0x81, 0x82, 0x06, 0x08, 0x18, 0x20, 0x60, 0x81, 0x82, 0x06, 0x08, 0x18,
  0x20, 0x60, 0x81, 0xBD, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x10, 0x3E, 0x20, 0x90, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xA0, 0x90, 0x47, 0xC0, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x82, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3F, 0x41, 0x41,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x41, 0x3F, 0x01, 0x01, 0x01,
  0x01, 0x01, 0xBC, 0x88, 0x88, 0x88, 0x88, 0x88, 0x3C, 0x42, 0x81, 0x80,
  0x40, 0x38, 0x04, 0x02, 0x01, 0x81, 0x42, 0x3C, 0x42, 0x11, 0xE4, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x20, 0xE0, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0B, 0xF0, 0x81, 0x81, 0x81, 0x42, 0x42, 0x42, 0x24,
  0x24, 0x24, 0x18, 0x18, 0x10, 0x82, 0x0C, 0x10, 0x61, 0x42, 0x8A, 0x24,
  0x51, 0x22, 0x49, 0x22, 0x45, 0x14, 0x28, 0xA1, 0x83, 0x04, 0x10, 0x20,
  0x80, 0x81, 0x42, 0x44, 0x24, 0x18, 0x10, 0x18, 0x28, 0x24, 0x42, 0x82,
  0x81, 0x81, 0x81, 0x81, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x18, 0x18,
  0x10, 0x10, 0x10, 0x10, 0x20, 0xC0, 0xFF, 0x02, 0x04, 0x04, 0x08, 0x08,
  0x10, 0x20, 0x20, 0x40, 0x40, 0xFF, 0x08, 0x41, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x84, 0x20, 0x40, 0x82, 0x08, 0x20, 0x82, 0x08, 0x10, 0x40, 0x80,
  0xFF, 0xFF, 0xF0, 0xC0, 0x82, 0x08, 0x10, 0x41, 0x04, 0x10, 0x41, 0x03,
  0x18, 0x41, 0x04, 0x10, 0x41, 0x04, 0x20, 0x8C, 0x00, 0x70, 0x62, 0x18,
  0x46, 0x0E,
};

const GFXglyph RobotoCondensed_Thin23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 17, 4, 2, -17 },
  { 4, 3, 5, 6, 2, -17 },
  { 6, 10, 17, 11, 1, -17 },
  { 28, 9, 21, 11, 1, -19 },
  { 52, 13, 17, 15, 1, -17 },
  { 80, 11, 17, 12, 1, -17 },
  { 104, 1, 5, 4, 1, -17 },
  { 105, 4, 23, 6, 2, -18 },
  { 117, 5, 23, 6, 0, -18 },
  { 132, 9, 9, 10, 0, -17 },
  { 143, 9, 13, 11, 1, -14 },
  { 158, 2, 5, 4, 1, -2 },
  { 160, 4, 1, 6, 1, -8 },
  { 161, 1, 1, 5, 2, -1 },
  { 162, 6, 18, 8, 1, -17 },
  { 176, 9, 17, 11, 1, -17 },
  { 196, 5, 17, 11, 2, -17 },
  { 207, 9, 17, 11, 1, -17 },
  { 227, 9, 17, 11, 1, -17 },
  { 247, 10, 17, 11, 1, -17 },
  { 269, 8, 17, 11, 2, -17 },
  { 286, 9, 17, 11, 1, -17 },
  { 306, 9, 17, 11, 1, -17 },
  { 326, 9, 17, 11, 1, -17 },
  { 346, 9, 17, 11, 1, -17 },
  { 366, 2, 12, 4, 1, -12 },
  { 369, 2, 15, 4, 1, -12 },
  { 373, 8, 9, 10, 1, -12 },
  { 382, 8, 6, 11, 2, -10 },
  { 388, 8, 9, 10, 1, -12 },
  { 397, 7, 17, 9, 1, -17 },
  { 412, 16, 21, 19, 1, -16 },
  { 454, 11, 17, 12, 1, -17 },
  { 478, 9, 17, 12, 2, -17 },
  { 498, 10, 17, 13, 2, -17 },
  { 520, 10, 17, 13, 2, -17 },
  { 542, 9, 17, 12, 2, -17 },
  { 562, 9, 17, 12, 2, -17 },
  { 582, 10, 17, 14, 2, -17 },
  { 604, 10, 17, 14, 2, -17 },
  { 626, 1, 17, 6, 2, -17 },
  { 629, 8, 17, 11, 1, -17 },
  { 646, 10, 17, 13, 2, -17 },
  { 668, 8, 17, 11, 2, -17 },
  { 685, 13, 17, 17, 2, -17 },
  { 713, 10, 17, 14, 2, -17 },
  { 735, 10, 17, 13, 2, -17 },
  { 757, 9, 17, 12, 2, -17 },
  { 777, 10, 20, 13, 2, -17 },
  { 802, 10, 17, 13, 2, -17 },
  { 824, 10, 17, 12, 1, -17 },
  { 846, 10, 17, 12, 1, -17 },
  { 868, 9, 17, 13, 2, -17 },
  { 888, 11, 17, 12, 1, -17 },
  { 912, 16, 17, 18, 1, -17 },
  { 946, 10, 17, 12, 1, -17 },
  { 968, 11, 17, 12, 1, -17 },
  { 992, 10, 17, 12, 1, -17 },
  { 1014, 3, 23, 5, 2, -19 },
  { 1023, 6, 18, 8, 1, -17 },
  { 1037, 3, 23, 5, 0, -19 },
  { 1046, 6, 8, 9, 1, -17 },
  { 1052, 8, 1, 9, 0, 0 },
  { 1053, 3, 3, 6, 2, -17 },
  { 1055, 8, 12, 11, 1, -12 },
  { 1067, 8, 18, 11, 2, -18 },
  { 1085, 8, 12, 10, 1, -12 },
  { 1097, 8, 18, 11, 1, -18 },
  { 1115, 8, 12, 10, 1, -12 },
  { 1127, 6, 18, 7, 1, -18 },
  { 1141, 8, 17, 11, 1, -12 },
  { 1158, 7, 18, 11, 2, -18 },
  { 1174, 1, 16, 4, 2, -16 },
  { 1176, 4, 21, 5, -1, -16 },
  { 1187, 7, 18, 10, 2, -18 },
  { 1203, 1, 18, 4, 2, -18 },
  { 1206, 14, 12, 18, 2, -12 },
  { 1227, 7, 12, 11, 2, -12 },
  { 1238, 9, 12, 11, 1, -12 },
  { 1252, 8, 17, 11, 2, -12 },
  { 1269, 8, 17, 11, 1, -12 },
  { 1286, 4, 12, 7, 2, -12 },
  { 1292, 8, 12, 10, 1, -12 },
  { 1304, 5, 15, 7, 1, -15 },
  { 1314, 7, 12, 11, 2, -12 },
  { 1325, 8, 12, 10, 1, -12 },
  { 1337, 13, 12, 15, 1, -12 },
  { 1357, 8, 12, 10, 1, -12 },
  { 1369, 8, 17, 10, 1, -12 },
  { 1386, 8, 12, 10, 1, -12 },
  { 1398, 6, 23, 7, 1, -18 },
  { 1416, 1, 20, 5, 2, -17 },
  { 1419, 6, 23, 7, 0, -18 },
  { 1437, 10, 4, 14, 2, -9 },
};

const GFXfont RobotoCondensed_Thin23pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin23pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin23pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _ROBOTOCONDENSED_THIN23PT7B_H_
