#ifndef _ROBOTOCONDENSED_THIN46PT7B_H_
#define _ROBOTOCONDENSED_THIN46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Thin.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Thin46pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x55, 0x55, 0x00, 0x03, 0xC0, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC4, 0x00, 0x40, 0x40, 0x01, 0x01, 0x00, 0x04,
  0x04, 0x00, 0x10, 0x10, 0x00, 0x40, 0x40, 0x03, 0x03, 0x00, 0x08, 0x08,
  0x00, 0x20, 0x20, 0x00, 0x80, 0x80, 0x02, 0x02, 0x03, 0xFF, 0xFF, 0xC0,
  0x60, 0x60, 0x01, 0x01, 0x80, 0x04, 0x04, 0x00, 0x10, 0x10, 0x00, 0x40,
  0x40, 0x01, 0x01, 0x00, 0x04, 0x04, 0x00, 0x30, 0x30, 0x00, 0x80, 0x80,
  0x02, 0x02, 0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x3F, 0xFF, 0xFC, 0x06,
  0x06, 0x00, 0x18, 0x10, 0x00, 0x40, 0x40, 0x01, 0x01, 0x00, 0x04, 0x04,
  0x00, 0x10, 0x10, 0x00, 0x40, 0x40, 0x03, 0x03, 0x00, 0x08, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x7E, 0x00, 0x60,
  0xC0, 0xC0, 0x30, 0x40, 0x0C, 0x60, 0x02, 0x20, 0x01, 0x90, 0x00, 0x48,
  0x00, 0x24, 0x00, 0x12, 0x00, 0x09, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x50, 0x00, 0x28,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x05, 0x80, 0x02, 0x40, 0x03, 0x30, 0x01,
  0x0C, 0x01, 0x83, 0x83, 0x80, 0x7F, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x63, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x80, 0x80, 0x00, 0x80, 0x40, 0x20, 0x80, 0x40, 0x60, 0x80, 0x40,
  0x40, 0x80, 0x40, 0x80, 0x80, 0x40, 0x80, 0x80, 0x41, 0x00, 0x80, 0x41,
  0x00, 0x80, 0x82, 0x00, 0x40, 0x86, 0x00, 0x63, 0x04, 0x00, 0x1E, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x78, 0x00, 0x20, 0xC6, 0x00, 0x41, 0x02, 0x00, 0x41, 0x01, 0x00, 0x82,
  0x01, 0x00, 0x82, 0x01, 0x01, 0x02, 0x01, 0x03, 0x02, 0x01, 0x02, 0x02,
  0x01, 0x06, 0x02, 0x01, 0x04, 0x02, 0x01, 0x04, 0x01, 0x01, 0x00, 0x01,
  0x02, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0xC3, 0x00,
  0x18, 0x18, 0x01, 0x00, 0x80, 0x10, 0x08, 0x03, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x30, 0x08, 0x01, 0x01, 0x00, 0x10, 0x30, 0x01, 0x86,
  0x00, 0x08, 0xC0, 0x00, 0x58, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x09,
  0x00, 0x01, 0x18, 0x00, 0x20, 0xC0, 0x26, 0x04, 0x02, 0x40, 0x20, 0x2C,
  0x03, 0x02, 0x80, 0x18, 0x68, 0x00, 0x84, 0x80, 0x04, 0x48, 0x00, 0x6C,
  0x80, 0x02, 0x88, 0x00, 0x18, 0xC0, 0x01, 0x84, 0x00, 0x2C, 0x20, 0x0C,
  0x41, 0x83, 0x82, 0x07, 0xE0, 0x30, 0xFF, 0xAA, 0x80, 0x00, 0x80, 0x80,
  0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x18,
  0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x80, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04,
  0x04, 0x02, 0x02, 0x02, 0x02, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x18, 0x10, 0x20, 0x60, 0x40,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x0C, 0x08, 0x1D, 0xC2, 0x1C, 0x0E, 0x9C, 0x00, 0xF8, 0x00,
  0x1C, 0x00, 0x05, 0x80, 0x02, 0x30, 0x01, 0x84, 0x00, 0x40, 0x80, 0x20,
  0x30, 0x18, 0x06, 0x04, 0x00, 0x80, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x7F, 0xFF, 0xF0, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x24, 0x92, 0x5A, 0x80, 0xFF, 0x80, 0xEC, 0x00, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x00, 0x07, 0xE0, 0x0C, 0x30, 0x10,
  0x08, 0x20, 0x04, 0x60, 0x06, 0x40, 0x02, 0x40, 0x03, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40,
  0x03, 0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x10, 0x0C, 0x0C, 0x38, 0x03,
  0xE0, 0x00, 0x83, 0xC7, 0x2C, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x07, 0xE0, 0x0E, 0x1C, 0x0C, 0x03, 0x0C, 0x00, 0x84,
  0x00, 0x66, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x80, 0x03, 0x40, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xF0, 0x03, 0x87, 0x01, 0x80, 0x60, 0xC0, 0x0C, 0x20,
  0x01, 0x18, 0x00, 0x64, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x03, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0xD0, 0x00,
  0x34, 0x00, 0x09, 0x80, 0x02, 0x20, 0x01, 0x8C, 0x00, 0x41, 0x80, 0x20,
  0x38, 0x30, 0x03, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x4C, 0x00, 0x19, 0x80, 0x02, 0x30,
  0x00, 0xC6, 0x00, 0x10, 0xC0, 0x06, 0x18, 0x00, 0x83, 0x00, 0x20, 0x60,
  0x04, 0x0C, 0x01, 0x01, 0x80, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0xC0,
  0x40, 0x18, 0x18, 0x03, 0x02, 0x00, 0x60, 0x80, 0x0C, 0x30, 0x01, 0x87,
  0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x3F, 0xFF, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x47, 0xE0, 0x58, 0x30, 0x60, 0x0C, 0x40, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x40, 0x02, 0x40, 0x02, 0x60, 0x04,
  0x30, 0x0C, 0x1C, 0x38, 0x07, 0xE0, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x7E, 0x08, 0xC1, 0x84, 0x80, 0x22,
  0x80, 0x09, 0x80, 0x06, 0xC0, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x90, 0x00, 0x48, 0x00, 0x66, 0x00, 0x21, 0x80, 0x30, 0x60, 0x30,
  0x1C, 0x30, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x03, 0xF0, 0x03, 0x87,
  0x01, 0x80, 0x60, 0xC0, 0x0C, 0x20, 0x01, 0x18, 0x00, 0x24, 0x00, 0x09,
  0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x24, 0x00, 0x09, 0x80, 0x02, 0x20,
  0x01, 0x0C, 0x00, 0xC1, 0x80, 0x60, 0x38, 0x70, 0x03, 0xF0, 0x03, 0x03,
  0x01, 0x00, 0x30, 0x80, 0x06, 0x60, 0x00, 0x90, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x14, 0x00, 0x05, 0x00, 0x03, 0x60,
  0x00, 0x88, 0x00, 0x61, 0x00, 0x30, 0x38, 0x38, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x07, 0x0E, 0x06, 0x01, 0x82, 0x00, 0x42, 0x00, 0x33, 0x00, 0x09,
  0x00, 0x06, 0x80, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x60, 0x01, 0x90,
  0x00, 0xCC, 0x00, 0xA3, 0x00, 0x90, 0xC1, 0x88, 0x1F, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x0F, 0x80, 0x00, 0xD8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x66, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x22, 0x22, 0x64, 0xC8, 0x00, 0x01, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x61, 0x83, 0x01, 0x18, 0x06,
  0x40, 0x0B, 0x00, 0x38, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x02, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x03,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x02, 0x00, 0xC0,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x04, 0x10, 0x00,
  0x00, 0x0C, 0x60, 0x07, 0xC0, 0x08, 0x80, 0x18, 0xC0, 0x11, 0x00, 0x40,
  0x60, 0x26, 0x01, 0x00, 0x80, 0x68, 0x06, 0x01, 0x00, 0x50, 0x08, 0x02,
  0x00, 0xE0, 0x10, 0x04, 0x01, 0xC0, 0x60, 0x08, 0x03, 0x00, 0x80, 0x10,
  0x06, 0x01, 0x00, 0x20, 0x0C, 0x02, 0x00, 0x40, 0x18, 0x0C, 0x00, 0x80,
  0x30, 0x18, 0x01, 0x00, 0x60, 0x30, 0x02, 0x00, 0xC0, 0x40, 0x04, 0x01,
  0x80, 0x80, 0x18, 0x07, 0x01, 0x80, 0x30, 0x0A, 0x01, 0x00, 0x60, 0x14,
  0x02, 0x01, 0x40, 0x6C, 0x04, 0x02, 0x80, 0x88, 0x0C, 0x09, 0x02, 0x10,
  0x0C, 0x61, 0x8C, 0x20, 0x0F, 0x81, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x04, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00,
  0x01, 0x30, 0x00, 0x0C, 0x40, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x06,
  0x08, 0x00, 0x10, 0x20, 0x00, 0x40, 0x80, 0x03, 0x01, 0x00, 0x08, 0x04,
  0x00, 0x20, 0x10, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x0C, 0x03, 0x00, 0x10, 0x08, 0x00, 0x40, 0x20, 0x01, 0x81, 0xFF,
  0xFE, 0x04, 0x00, 0x08, 0x10, 0x00, 0x30, 0xC0, 0x00, 0x42, 0x00, 0x01,
  0x08, 0x00, 0x04, 0x60, 0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x00, 0xB0,
  0x00, 0x03, 0x80, 0x00, 0x04, 0xFF, 0xE0, 0x20, 0x06, 0x08, 0x00, 0x62,
  0x00, 0x08, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x06, 0x80,
  0x01, 0xA0, 0x00, 0x68, 0x00, 0x1A, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00,
  0x88, 0x00, 0x62, 0x00, 0x70, 0xFF, 0xF8, 0x20, 0x03, 0x88, 0x00, 0x32,
  0x00, 0x06, 0x80, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00,
  0x48, 0x00, 0x32, 0x00, 0x38, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x70,
  0x70, 0x08, 0x00, 0x81, 0x00, 0x04, 0x30, 0x00, 0x62, 0x00, 0x02, 0x40,
  0x00, 0x34, 0x00, 0x01, 0x40, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00,
  0x01, 0x60, 0x00, 0x32, 0x00, 0x02, 0x30, 0x00, 0x21, 0x00, 0x04, 0x0C,
  0x00, 0x80, 0x70, 0x70, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x10, 0x03, 0x82,
  0x00, 0x18, 0x40, 0x01, 0x88, 0x00, 0x19, 0x00, 0x01, 0xA0, 0x00, 0x14,
  0x00, 0x02, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0A, 0x00, 0x01, 0x40,
  0x00, 0x68, 0x00, 0x19, 0x00, 0x06, 0x20, 0x01, 0x84, 0x00, 0xE0, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0xFF, 0xFE, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xFF,
  0xFE, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0xE0, 0x70, 0x18, 0x01, 0x83, 0x00, 0x0C, 0x20, 0x00,
  0x64, 0x00, 0x02, 0x40, 0x00, 0x2C, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x3F, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x16, 0x00, 0x01, 0x20, 0x00,
  0x13, 0x00, 0x06, 0x18, 0x00, 0xC0, 0x70, 0x78, 0x01, 0xFC, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x02, 0x40,
  0x02, 0x60, 0x04, 0x30, 0x0C, 0x1C, 0x38, 0x07, 0xE0, 0x80, 0x00, 0x48,
  0x00, 0x0C, 0x80, 0x01, 0x88, 0x00, 0x30, 0x80, 0x02, 0x08, 0x00, 0x40,
  0x80, 0x08, 0x08, 0x01, 0x80, 0x80, 0x30, 0x08, 0x06, 0x00, 0x80, 0x40,
  0x08, 0x08, 0x00, 0x81, 0x00, 0x08, 0x30, 0x00, 0x86, 0x00, 0x08, 0xE0,
  0x00, 0x8B, 0x00, 0x09, 0x18, 0x00, 0xA0, 0x80, 0x0C, 0x04, 0x00, 0x80,
  0x60, 0x08, 0x03, 0x00, 0x80, 0x10, 0x08, 0x01, 0x80, 0x80, 0x0C, 0x08,
  0x00, 0x40, 0x80, 0x02, 0x08, 0x00, 0x30, 0x80, 0x01, 0x88, 0x00, 0x08,
  0x80, 0x00, 0x48, 0x00, 0x06, 0x80, 0x00, 0x30, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3A, 0x00, 0x00, 0x0E,
  0x80, 0x00, 0x05, 0xB0, 0x00, 0x01, 0x64, 0x00, 0x00, 0xD9, 0x00, 0x00,
  0x26, 0x60, 0x00, 0x09, 0x88, 0x00, 0x06, 0x62, 0x00, 0x01, 0x18, 0xC0,
  0x00, 0x46, 0x10, 0x00, 0x21, 0x84, 0x00, 0x08, 0x60, 0x80, 0x02, 0x18,
  0x20, 0x01, 0x06, 0x0C, 0x00, 0x41, 0x81, 0x00, 0x30, 0x60, 0x40, 0x08,
  0x18, 0x18, 0x02, 0x06, 0x02, 0x01, 0x81, 0x80, 0x80, 0x40, 0x60, 0x10,
  0x10, 0x18, 0x04, 0x08, 0x06, 0x01, 0x02, 0x01, 0x80, 0x21, 0x80, 0x60,
  0x08, 0x40, 0x18, 0x02, 0x10, 0x06, 0x00, 0x4C, 0x01, 0x80, 0x12, 0x00,
  0x60, 0x06, 0x80, 0x18, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04,
  0x00, 0x40, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xA0, 0x00, 0x1A, 0x00, 0x01,
  0x90, 0x00, 0x19, 0x80, 0x01, 0x88, 0x00, 0x18, 0xC0, 0x01, 0x84, 0x00,
  0x18, 0x20, 0x01, 0x83, 0x00, 0x18, 0x10, 0x01, 0x81, 0x80, 0x18, 0x08,
  0x01, 0x80, 0xC0, 0x18, 0x04, 0x01, 0x80, 0x20, 0x18, 0x03, 0x01, 0x80,
  0x10, 0x18, 0x01, 0x81, 0x80, 0x08, 0x18, 0x00, 0xC1, 0x80, 0x04, 0x18,
  0x00, 0x21, 0x80, 0x03, 0x18, 0x00, 0x11, 0x80, 0x01, 0x98, 0x00, 0x09,
  0x80, 0x00, 0x58, 0x00, 0x05, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x10, 0x01, 0xFC, 0x00, 0x38, 0x38, 0x03, 0x00, 0x60, 0x20, 0x00, 0x82,
  0x00, 0x06, 0x30, 0x00, 0x11, 0x00, 0x00, 0x48, 0x00, 0x02, 0xC0, 0x00,
  0x16, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x04,
  0xC0, 0x00, 0x42, 0x00, 0x02, 0x08, 0x00, 0x20, 0x30, 0x06, 0x00, 0xE0,
  0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x20, 0x03, 0x08, 0x00, 0x32, 0x00,
  0x04, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x28,
  0x00, 0x0A, 0x00, 0x04, 0x80, 0x03, 0x20, 0x03, 0x8F, 0xFF, 0x82, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x38, 0x38,
  0x02, 0x00, 0x60, 0x20, 0x00, 0x82, 0x00, 0x06, 0x30, 0x00, 0x11, 0x00,
  0x00, 0x48, 0x00, 0x02, 0xC0, 0x00, 0x16, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x12, 0x00, 0x00, 0x90, 0x00, 0x04, 0xC0, 0x00, 0x42, 0x00, 0x06, 0x08,
  0x00, 0x20, 0x20, 0x06, 0x00, 0xE0, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0xFF, 0xF0, 0x10, 0x01, 0x82, 0x00, 0x0C, 0x40, 0x00, 0x88,
  0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50,
  0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x05, 0x00, 0x01, 0x20,
  0x00, 0x24, 0x00, 0x08, 0x80, 0x03, 0x10, 0x01, 0xC3, 0xFF, 0xE0, 0x40,
  0x08, 0x08, 0x01, 0x81, 0x00, 0x10, 0x20, 0x01, 0x04, 0x00, 0x20, 0x80,
  0x02, 0x10, 0x00, 0x42, 0x00, 0x04, 0x40, 0x00, 0xC8, 0x00, 0x09, 0x00,
  0x01, 0xA0, 0x00, 0x14, 0x00, 0x03, 0x80, 0x00, 0x20, 0x01, 0xFC, 0x00,
  0xE0, 0x70, 0x18, 0x01, 0x83, 0x00, 0x0C, 0x20, 0x00, 0x66, 0x00, 0x02,
  0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x40, 0x00, 0x34, 0x00, 0x03, 0x20, 0x00, 0x23, 0x00, 0x06,
  0x18, 0x00, 0xC0, 0x70, 0x70, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x01, 0xA0, 0x00, 0x24, 0x00, 0x0C,
  0x40, 0x01, 0x0C, 0x00, 0xC0, 0x70, 0x70, 0x03, 0xF8, 0x00, 0xC0, 0x00,
  0x05, 0x00, 0x00, 0x34, 0x00, 0x00, 0x90, 0x00, 0x02, 0x60, 0x00, 0x18,
  0x80, 0x00, 0x42, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x10, 0x00, 0x30, 0x40,
  0x00, 0x81, 0x80, 0x02, 0x02, 0x00, 0x18, 0x08, 0x00, 0x40, 0x30, 0x01,
  0x00, 0x40, 0x0C, 0x01, 0x00, 0x20, 0x06, 0x00, 0x80, 0x08, 0x06, 0x00,
  0x20, 0x10, 0x00, 0x80, 0x40, 0x01, 0x01, 0x00, 0x04, 0x08, 0x00, 0x10,
  0x20, 0x00, 0x60, 0x80, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x40,
  0x00, 0x13, 0x00, 0x00, 0x48, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x80, 0x01, 0x80, 0x01, 0x40, 0x00, 0xC0,
  0x00, 0xA0, 0x00, 0x60, 0x00, 0x58, 0x00, 0x28, 0x00, 0x24, 0x00, 0x24,
  0x00, 0x32, 0x00, 0x12, 0x00, 0x11, 0x00, 0x09, 0x00, 0x08, 0xC0, 0x04,
  0x40, 0x04, 0x20, 0x04, 0x20, 0x06, 0x10, 0x02, 0x10, 0x02, 0x08, 0x01,
  0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x83, 0x00, 0x81, 0x00, 0x40, 0x80,
  0x40, 0x80, 0x60, 0x40, 0x20, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x18,
  0x10, 0x08, 0x08, 0x04, 0x08, 0x04, 0x0C, 0x02, 0x04, 0x02, 0x04, 0x01,
  0x06, 0x00, 0x82, 0x00, 0x82, 0x00, 0x41, 0x00, 0x61, 0x00, 0x21, 0x80,
  0x10, 0x80, 0x10, 0xC0, 0x08, 0xC0, 0x0C, 0x40, 0x04, 0x40, 0x02, 0x20,
  0x03, 0x20, 0x01, 0x10, 0x00, 0x90, 0x00, 0x98, 0x00, 0x58, 0x00, 0x68,
  0x00, 0x28, 0x00, 0x14, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x08, 0x80, 0x00, 0x63, 0x00, 0x03, 0x04, 0x00, 0x08, 0x18, 0x00, 0x60,
  0x20, 0x01, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x20, 0x02, 0x01, 0x00, 0x0C,
  0x0C, 0x00, 0x10, 0x20, 0x00, 0x21, 0x80, 0x00, 0x84, 0x00, 0x01, 0x20,
  0x00, 0x06, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x04, 0x80, 0x00, 0x31, 0x00, 0x00, 0x84, 0x00, 0x06, 0x08, 0x00, 0x10,
  0x30, 0x00, 0x80, 0x40, 0x06, 0x01, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x04,
  0x02, 0x00, 0x18, 0x10, 0x00, 0x20, 0x40, 0x00, 0xC2, 0x00, 0x01, 0x18,
  0x00, 0x06, 0x40, 0x00, 0x08, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x26, 0x00,
  0x01, 0x88, 0x00, 0x04, 0x30, 0x00, 0x30, 0x40, 0x00, 0x81, 0x80, 0x06,
  0x02, 0x00, 0x10, 0x0C, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x60, 0x18, 0x00,
  0x80, 0x40, 0x03, 0x03, 0x00, 0x04, 0x08, 0x00, 0x18, 0x60, 0x00, 0x21,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0x20, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFC,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0xF0, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x10, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x7F, 0x02,
  0x00, 0x30, 0x01, 0x40, 0x0A, 0x00, 0x98, 0x04, 0x40, 0x62, 0x02, 0x18,
  0x10, 0x41, 0x82, 0x08, 0x18, 0x40, 0x46, 0x02, 0x20, 0x19, 0x00, 0x58,
  0x02, 0xFF, 0xFF, 0x80, 0x41, 0x83, 0x04, 0x08, 0x30, 0x07, 0xF0, 0x0C,
  0x1C, 0x30, 0x06, 0x20, 0x02, 0x40, 0x02, 0x40, 0x03, 0x40, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x07, 0xFF, 0x1E, 0x01, 0x30,
  0x01, 0x60, 0x01, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0,
  0x03, 0x40, 0x05, 0x60, 0x09, 0x38, 0x71, 0x0F, 0xC1, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x87, 0xE0, 0x98, 0x30, 0xA0,
  0x08, 0xC0, 0x04, 0xC0, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0xC0,
  0x04, 0xA0, 0x08, 0x98, 0x30, 0x87, 0xE0, 0x03, 0xF0, 0x0C, 0x1C, 0x10,
  0x06, 0x20, 0x02, 0x60, 0x01, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x01, 0x60, 0x01, 0x20,
  0x02, 0x10, 0x06, 0x0C, 0x1C, 0x07, 0xF0, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x07, 0xE3, 0x18, 0x33, 0x20, 0x0B, 0x60,
  0x07, 0x40, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x07, 0x20,
  0x0F, 0x18, 0x3B, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0x0E, 0x04, 0x01, 0x84,
  0x00, 0x46, 0x00, 0x32, 0x00, 0x09, 0x00, 0x05, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x18, 0x38, 0x30, 0x07, 0xE0, 0x03, 0xE0, 0xC0, 0x30,
  0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x7F,
  0xE1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x00, 0x07, 0xE3, 0x18,
  0x33, 0x20, 0x0B, 0x60, 0x07, 0x40, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0x40,
  0x03, 0x60, 0x07, 0x20, 0x0F, 0x18, 0x3B, 0x07, 0xE3, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x60, 0x06, 0x30, 0x0C, 0x1C,
  0x18, 0x07, 0xE0, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x1F, 0x08, 0xC3, 0x12, 0x01, 0x28, 0x03, 0x70, 0x02, 0xC0, 0x05, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0xE8, 0x00, 0x00,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x03, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04,
  0x18, 0xF0, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x68, 0x01, 0x90, 0x06, 0x20, 0x18, 0x40, 0x60, 0x81, 0x81, 0x02, 0x02,
  0x08, 0x04, 0x20, 0x08, 0x80, 0x13, 0x00, 0x2B, 0x00, 0x62, 0x00, 0x82,
  0x01, 0x06, 0x02, 0x06, 0x04, 0x04, 0x08, 0x04, 0x10, 0x0C, 0x20, 0x08,
  0x40, 0x08, 0x80, 0x19, 0x00, 0x1A, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xC3, 0xF0, 0x0F, 0xC6, 0x30, 0xC1, 0xC3, 0x32, 0x01, 0x18, 0x0D,
  0xA0, 0x0D, 0x80, 0x3E, 0x00, 0x28, 0x00, 0xF0, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0x83, 0xE1, 0x18, 0x62, 0x40, 0x25, 0x00, 0x6E,
  0x00, 0x58, 0x00, 0xB0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x07, 0xE0, 0x0E, 0x1C, 0x0C, 0x03, 0x0C, 0x00, 0xC4, 0x00, 0x26,
  0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x02, 0x80,
  0x01, 0x40, 0x00, 0xB0, 0x00, 0x48, 0x00, 0x46, 0x00, 0x61, 0x80, 0x60,
  0x70, 0xE0, 0x0F, 0xC0, 0x87, 0xE0, 0x98, 0x30, 0xA0, 0x08, 0xC0, 0x04,
  0xC0, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0xC0, 0x04, 0xE0, 0x08,
  0x98, 0x30, 0x87, 0xE0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x07, 0xE3,
  0x18, 0x33, 0x20, 0x0B, 0x60, 0x07, 0x40, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03,
  0x40, 0x03, 0x60, 0x07, 0x20, 0x0F, 0x18, 0x3B, 0x0F, 0xE3, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x87, 0xCC, 0x2C, 0x14, 0x0C, 0x06, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x07, 0xE0, 0x30, 0x70, 0x80,
  0x33, 0x00, 0x34, 0x00, 0x28, 0x00, 0x50, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x07, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x24, 0x00,
  0x87, 0x06, 0x03, 0xF0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x83, 0xFF, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x3C, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x74, 0x00, 0xEC, 0x02,
  0xCC, 0x19, 0x87, 0xE3, 0xC0, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x4C, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x10, 0xC0, 0x08, 0x20, 0x04, 0x10, 0x04, 0x0C,
  0x02, 0x02, 0x01, 0x01, 0x01, 0x00, 0xC0, 0x80, 0x20, 0x40, 0x10, 0x40,
  0x0C, 0x20, 0x02, 0x10, 0x01, 0x10, 0x00, 0xC8, 0x00, 0x24, 0x00, 0x14,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x00, 0x80, 0x0C, 0x00, 0x70, 0x03,
  0x00, 0x34, 0x00, 0xC0, 0x0D, 0x00, 0x38, 0x02, 0x40, 0x12, 0x00, 0x98,
  0x04, 0x80, 0x62, 0x01, 0x20, 0x18, 0x80, 0xCC, 0x04, 0x20, 0x21, 0x01,
  0x0C, 0x08, 0x40, 0xC1, 0x02, 0x18, 0x30, 0x41, 0x82, 0x08, 0x10, 0x40,
  0x82, 0x06, 0x10, 0x21, 0x80, 0x84, 0x0C, 0x60, 0x22, 0x01, 0x10, 0x08,
  0x80, 0x44, 0x03, 0x20, 0x11, 0x00, 0x58, 0x02, 0xC0, 0x14, 0x00, 0xA0,
  0x05, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x20, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x60, 0x01, 0x10, 0x01, 0x8C, 0x00, 0x82, 0x00, 0xC0, 0x80, 0xC0,
  0x60, 0x40, 0x10, 0x60, 0x0C, 0x20, 0x02, 0x20, 0x00, 0xB0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0B, 0x00, 0x0C, 0x80, 0x04, 0x60, 0x04,
  0x10, 0x06, 0x04, 0x02, 0x03, 0x03, 0x00, 0x81, 0x00, 0x61, 0x00, 0x19,
  0x80, 0x04, 0x80, 0x03, 0xC0, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x6C, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x18, 0xC0, 0x08, 0x20, 0x04, 0x10, 0x06, 0x04,
  0x02, 0x02, 0x01, 0x01, 0x01, 0x80, 0x40, 0x80, 0x20, 0x40, 0x18, 0x60,
  0x04, 0x20, 0x02, 0x10, 0x01, 0x98, 0x00, 0x48, 0x00, 0x24, 0x00, 0x1E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x78, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x38, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x40, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xE0, 0x07,
  0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x04, 0x00, 0x1F, 0x00, 0x01,
  0x8C, 0x00, 0x58, 0x18, 0x02, 0x80, 0x60, 0x14, 0x01, 0x81, 0x20, 0x06,
  0x1B, 0x00, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_Thin46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 33, 9, 3, -33 },
  { 10, 6, 9, 12, 3, -35 },
  { 17, 22, 33, 22, 1, -33 },
  { 108, 17, 41, 22, 3, -37 },
  { 196, 24, 33, 30, 3, -33 },
  { 295, 20, 33, 25, 3, -33 },
  { 378, 2, 9, 8, 3, -35 },
  { 381, 9, 47, 13, 3, -36 },
  { 434, 8, 47, 13, 1, -36 },
  { 481, 18, 18, 19, 1, -33 },
  { 522, 19, 23, 23, 2, -27 },
  { 577, 3, 9, 9, 2, -4 },
  { 581, 9, 1, 12, 2, -15 },
  { 583, 3, 2, 10, 3, -2 },
  { 584, 13, 36, 16, 1, -33 },
  { 643, 16, 33, 22, 3, -33 },
  { 709, 9, 33, 22, 4, -33 },
  { 747, 17, 33, 22, 3, -33 },
  { 818, 18, 33, 22, 2, -33 },
  { 893, 19, 33, 22, 2, -33 },
  { 972, 16, 33, 22, 4, -33 },
  { 1038, 17, 33, 22, 3, -33 },
  { 1109, 18, 33, 22, 2, -33 },
  { 1184, 18, 33, 22, 2, -33 },
  { 1259, 17, 33, 22, 2, -33 },
  { 1330, 3, 23, 8, 3, -23 },
  { 1339, 4, 28, 8, 2, -23 },
  { 1353, 16, 18, 21, 2, -24 },
  { 1389, 16, 10, 23, 3, -20 },
  { 1409, 16, 18, 21, 3, -24 },
  { 1445, 14, 33, 18, 2, -33 },
  { 1503, 31, 42, 37, 3, -32 },
  { 1666, 22, 33, 24, 1, -33 },
  { 1757, 18, 33, 24, 4, -33 },
  { 1832, 20, 33, 26, 3, -33 },
  { 1915, 19, 33, 26, 4, -33 },
  { 1994, 17, 33, 23, 4, -33 },
  { 2065, 17, 33, 23, 4, -33 },
  { 2136, 20, 33, 28, 4, -33 },
  { 2219, 20, 33, 28, 4, -33 },
  { 2302, 1, 33, 11, 5, -33 },
  { 2307, 16, 33, 22, 2, -33 },
  { 2373, 20, 33, 26, 4, -33 },
  { 2456, 16, 33, 21, 4, -33 },
  { 2522, 26, 33, 34, 4, -33 },
  { 2630, 20, 33, 28, 4, -33 },
  { 2713, 21, 33, 27, 3, -33 },
  { 2800, 18, 33, 24, 4, -33 },
  { 2875, 21, 39, 27, 3, -33 },
  { 2978, 19, 33, 26, 4, -33 },
  { 3057, 20, 33, 24, 2, -33 },
  { 3140, 22, 33, 24, 1, -33 },
  { 3231, 19, 33, 27, 4, -33 },
  { 3310, 22, 33, 24, 1, -33 },
  { 3401, 33, 33, 36, 2, -33 },
  { 3538, 22, 33, 24, 1, -33 },
  { 3629, 22, 33, 24, 1, -33 },
  { 3720, 20, 33, 24, 2, -33 },
  { 3803, 5, 44, 9, 4, -37 },
  { 3831, 13, 36, 16, 1, -33 },
  { 3890, 6, 44, 9, 0, -37 },
  { 3923, 13, 16, 17, 2, -33 },
  { 3949, 17, 1, 17, 0, 0 },
  { 3952, 6, 6, 12, 3, -35 },
  { 3957, 16, 24, 22, 2, -24 },
  { 4005, 16, 35, 22, 4, -35 },
  { 4075, 16, 24, 21, 2, -24 },
  { 4123, 16, 35, 22, 3, -35 },
  { 4193, 17, 24, 21, 2, -24 },
  { 4244, 11, 35, 13, 2, -35 },
  { 4293, 16, 33, 22, 3, -24 },
  { 4359, 15, 35, 22, 4, -35 },
  { 4425, 3, 32, 9, 3, -32 },
  { 4437, 8, 41, 9, -2, -32 },
  { 4478, 15, 35, 19, 4, -35 },
  { 4544, 1, 35, 9, 4, -35 },
  { 4549, 29, 24, 36, 3, -24 },
  { 4636, 15, 24, 22, 4, -24 },
  { 4681, 17, 24, 22, 3, -24 },
  { 4732, 16, 33, 22, 4, -24 },
  { 4798, 16, 33, 22, 3, -24 },
  { 4864, 9, 24, 14, 4, -24 },
  { 4891, 15, 24, 20, 2, -24 },
  { 4936, 10, 31, 13, 1, -31 },
  { 4975, 15, 24, 22, 4, -24 },
  { 5020, 17, 24, 20, 1, -24 },
  { 5071, 26, 24, 30, 2, -24 },
  { 5149, 17, 24, 20, 1, -24 },
  { 5200, 17, 33, 19, 1, -24 },
  { 5271, 16, 24, 20, 2, -24 },
  { 5319, 11, 46, 13, 2, -36 },
  { 5383, 1, 39, 9, 4, -33 },
  { 5388, 12, 46, 13, 0, -36 },
  { 5457, 21, 7, 28, 3, -17 },
};

const GFXfont RobotoCondensed_Thin46pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Thin46pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Thin46pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOCONDENSED_THIN46PT7B_H_
