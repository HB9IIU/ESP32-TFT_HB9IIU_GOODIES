#ifndef _ROBOTOCONDENSED_MEDIUM25PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEC, 0x06, 0xF8, 0xCF, 0x3C, 0xF3, 0xCF,
  0x30, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC7, 0xFF, 0x7F, 0xF1,
  0x98, 0x19, 0x81, 0x98, 0x19, 0x8F, 0xFE, 0xFF, 0xE3, 0x30, 0x33, 0x03,
  0x30, 0x33, 0x03, 0x30, 0x04, 0x01, 0x00, 0x40, 0x7C, 0x3F, 0x9E, 0xF7,
  0x1D, 0xC7, 0x71, 0xDC, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x87,
  0xE1, 0xDC, 0x77, 0xBC, 0xFE, 0x1F, 0x03, 0x00, 0xC0, 0x38, 0x01, 0xF0,
  0x0C, 0x62, 0x31, 0x98, 0xC6, 0x43, 0x1B, 0x07, 0xD8, 0x0E, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x67, 0x01, 0xBE, 0x0D, 0xCC, 0x36, 0x31, 0x98, 0xC6,
  0x73, 0x00, 0xF8, 0x01, 0xC0, 0x1E, 0x01, 0xF8, 0x0E, 0xE0, 0xE3, 0x07,
  0x18, 0x39, 0xC0, 0xFC, 0x07, 0xC0, 0x1C, 0x01, 0xF3, 0x9F, 0xDD, 0xCE,
  0xEE, 0x3E, 0x71, 0xF3, 0x87, 0x0F, 0xFC, 0x7F, 0xF0, 0xF3, 0x80, 0xFF,
  0xF0, 0x08, 0xCE, 0x67, 0x33, 0x9C, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x39, 0xC6, 0x38, 0xC7, 0x18, 0x40, 0x83, 0x0E, 0x18, 0x70, 0xC3, 0x8E,
  0x18, 0x61, 0x86, 0x1C, 0x71, 0xC6, 0x18, 0x63, 0x8E, 0x31, 0xC6, 0x38,
  0xC2, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x23, 0x2F, 0xFE, 0x7F, 0x83, 0x80,
  0xD8, 0x3B, 0x86, 0x30, 0x44, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x3F, 0xFF, 0xFF, 0xFF, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x33,
  0x37, 0x76, 0x60, 0xFF, 0xF0, 0xFF, 0x80, 0x03, 0x07, 0x06, 0x06, 0x06,
  0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x70, 0x60,
  0x60, 0x60, 0xE0, 0x1E, 0x0F, 0xE7, 0xB9, 0xC7, 0x61, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xD8, 0x77, 0x1D, 0xEE, 0x3F,
  0x87, 0x80, 0x04, 0xFF, 0xFF, 0x9C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x70, 0x1F, 0x07, 0xF1, 0xFF, 0x70, 0xEE, 0x1D, 0xC3,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1E,
  0x03, 0x80, 0xFF, 0xFF, 0xFC, 0x1E, 0x1F, 0xE7, 0xFB, 0x87, 0xE1, 0xC0,
  0x70, 0x1C, 0x1E, 0x1F, 0x07, 0xE0, 0x3C, 0x07, 0x01, 0xF8, 0x7E, 0x1D,
  0xFE, 0x7F, 0x87, 0x80, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x3F,
  0x06, 0xE1, 0xDC, 0x33, 0x8E, 0x71, 0x8E, 0x71, 0xCF, 0xFF, 0xFF, 0xC0,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x3F, 0xCF, 0xF7, 0xFD, 0xC0, 0x70, 0x1C,
  0x07, 0xF1, 0xFE, 0x7B, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xF8, 0x77, 0x1D,
  0xEF, 0x3F, 0x87, 0xC0, 0x07, 0x07, 0xC3, 0xF0, 0xE0, 0x70, 0x1C, 0x06,
  0xF1, 0xFE, 0xFB, 0xFC, 0x7E, 0x1F, 0x83, 0xE0, 0xD8, 0x77, 0x1D, 0xEF,
  0x3F, 0x87, 0xC0, 0xFF, 0xFF, 0xF0, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38,
  0x0C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x60, 0x38,
  0x0E, 0x00, 0x1F, 0x0F, 0xE7, 0xB9, 0xC7, 0x61, 0xD8, 0x77, 0x1D, 0xEE,
  0x3F, 0x0F, 0xE7, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0xEF, 0x3F, 0x87,
  0xC0, 0x1E, 0x0F, 0xC7, 0xF9, 0xC6, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xDE, 0xF7, 0xFC, 0x77, 0x01, 0xC0, 0xE0, 0x38, 0x7C, 0x3E, 0x0F, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x7F, 0x60, 0x00, 0x00, 0x00, 0x77, 0x66,
  0xEE, 0xC0, 0x01, 0x07, 0x0F, 0x3E, 0xF8, 0xE0, 0xF8, 0x3E, 0x0F, 0x07,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x80, 0xE0, 0xF8,
  0x7E, 0x1F, 0x03, 0x1F, 0x7E, 0xF8, 0xE0, 0x80, 0x3E, 0x3F, 0xBF, 0xDC,
  0x7E, 0x38, 0x1C, 0x0E, 0x0E, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0x80, 0x00,
  0x00, 0x30, 0x1C, 0x0C, 0x00, 0x03, 0xF0, 0x03, 0xFE, 0x07, 0x03, 0x83,
  0x00, 0xE3, 0x00, 0x31, 0x87, 0x09, 0x8F, 0xC6, 0xC6, 0x63, 0x67, 0x31,
  0xE3, 0x18, 0xF1, 0x8C, 0x78, 0xC6, 0x3C, 0x63, 0x1E, 0x31, 0x8F, 0x19,
  0xCD, 0x8F, 0xFE, 0x63, 0x9E, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0xC1, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0xC0, 0x3B, 0x00, 0xEE, 0x03, 0x38, 0x1C, 0x60, 0x71, 0xC1,
  0xC7, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE7, 0x03, 0x9C, 0x07, 0x70, 0x1D,
  0xC0, 0x70, 0xFF, 0x1F, 0xF3, 0xFF, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0x77,
  0x1C, 0xFF, 0x1F, 0xF3, 0x87, 0x70, 0xEE, 0x0F, 0xC1, 0xF8, 0x77, 0x3E,
  0xFF, 0x9F, 0xE0, 0x0F, 0x83, 0xFE, 0x3D, 0xE7, 0x07, 0x70, 0x7E, 0x07,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x77, 0x07,
  0x70, 0x73, 0xFE, 0x3F, 0xE0, 0xF8, 0xFE, 0x1F, 0xF3, 0xFE, 0x70, 0xEE,
  0x1D, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC3, 0xB8, 0x77, 0x7C, 0xFF, 0x9F, 0xC0, 0xFF, 0xBF, 0xEF, 0xFB, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xBF, 0xEE, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xFF, 0x7F, 0xB8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x00, 0x0F, 0x83, 0xFE, 0x7D, 0xE7, 0x07, 0x70, 0x7E, 0x07,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x3F, 0xE3, 0xFE, 0x07, 0xF0, 0x77, 0x07,
  0x70, 0x73, 0xFF, 0x3F, 0xE0, 0xFC, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xF8, 0x7E, 0x3B, 0xFE,
  0x7F, 0x0F, 0x80, 0xE0, 0xEE, 0x1C, 0xE3, 0xCE, 0x38, 0xE7, 0x0E, 0xF0,
  0xEE, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFF, 0x0E, 0x70, 0xE7, 0x8E, 0x38,
  0xE3, 0xCE, 0x1C, 0xE1, 0xEE, 0x0E, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xFF, 0xFF, 0xC0, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x83,
  0xFF, 0x06, 0xF6, 0x0D, 0xEE, 0x3F, 0xDC, 0x6F, 0x98, 0xDF, 0xBB, 0xBF,
  0x77, 0x7E, 0x6C, 0xFC, 0xF9, 0xF9, 0xF3, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7,
  0x1C, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x7E,
  0xC7, 0xEE, 0x7E, 0x67, 0xE7, 0x7E, 0x37, 0xE3, 0xFE, 0x1F, 0xE1, 0xFE,
  0x0F, 0xE0, 0xFE, 0x07, 0x0F, 0x81, 0xFF, 0x0F, 0xF8, 0xE0, 0xE7, 0x07,
  0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xB8, 0x39, 0xC1, 0xC7, 0xFE, 0x3F, 0xE0, 0x7C, 0x00, 0xFF, 0x1F,
  0xFB, 0xFF, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE3, 0xDF, 0xFB,
  0xFC, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x0F,
  0x81, 0xFF, 0x0F, 0xF8, 0xE0, 0xE7, 0x07, 0x70, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xB8, 0x39, 0xC1, 0xC7,
  0xFC, 0x3F, 0xE0, 0x7F, 0x00, 0x3C, 0x00, 0xE0, 0x02, 0x00, 0xFF, 0x1F,
  0xF3, 0xFF, 0x70, 0xEE, 0x1D, 0xC1, 0xF8, 0x77, 0x0E, 0xE7, 0xDF, 0xF3,
  0xFC, 0x73, 0x8E, 0x39, 0xC7, 0x38, 0x77, 0x0E, 0xE1, 0xFC, 0x1C, 0x1F,
  0x07, 0xF9, 0xFF, 0xF8, 0x7E, 0x0F, 0xC0, 0x1C, 0x03, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0x80, 0x7E, 0x0F, 0xC1, 0xFC, 0x3B, 0xFF, 0x3F, 0xC3, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0x70, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0x70, 0x1D, 0xC0, 0xE7, 0x03, 0x9C,
  0x0E, 0x38, 0x38, 0xE1, 0xC3, 0x87, 0x07, 0x1C, 0x1C, 0xE0, 0x73, 0x81,
  0xCE, 0x03, 0xB8, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x76, 0x3E,
  0x33, 0x9F, 0x39, 0xCD, 0x9C, 0xE6, 0xCE, 0x73, 0x67, 0x3B, 0xBB, 0x8D,
  0xCD, 0x86, 0xC6, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x38, 0x38,
  0x1C, 0x1C, 0x0E, 0x0E, 0x00, 0xE0, 0x7F, 0x0E, 0x70, 0xE7, 0x9C, 0x39,
  0xC3, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x81, 0xF8, 0x3B,
  0xC3, 0x9C, 0x79, 0xE7, 0x0E, 0xF0, 0xFE, 0x07, 0xF0, 0x3B, 0x83, 0x9C,
  0x1C, 0x70, 0xE3, 0x8E, 0x0E, 0x70, 0x77, 0x03, 0xB8, 0x0F, 0x80, 0x7C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x00,
  0xFF, 0xFF, 0xFC, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCF, 0xF0, 0x60, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0,
  0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x70, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xF8, 0x18, 0x38, 0x3C, 0x3C, 0x6C,
  0x6E, 0x66, 0xE6, 0xC7, 0xFF, 0xFF, 0xF0, 0xE3, 0x8C, 0x30, 0x1E, 0x1F,
  0xE7, 0x3B, 0x8E, 0x01, 0x87, 0xE7, 0xFB, 0xC6, 0xE1, 0xB8, 0x6F, 0x79,
  0xFE, 0x3D, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0xF3,
  0xFE, 0xFB, 0xF8, 0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xFB,
  0xFF, 0xEE, 0xF0, 0x1E, 0x1F, 0xE7, 0xFB, 0x87, 0xE1, 0xF8, 0x0E, 0x03,
  0x80, 0xE1, 0xF8, 0x77, 0xF9, 0xFC, 0x1E, 0x00, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x73, 0xDD, 0xFF, 0x7F, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0x7F, 0xDF, 0xF3, 0xDC, 0x1F, 0x1F, 0xE7, 0xBB,
  0x87, 0xE1, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x27, 0xB9, 0xFE, 0x1F,
  0x00, 0x1E, 0x7C, 0xFB, 0x87, 0x0E, 0x3F, 0x7E, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x3D, 0xDF, 0xF7, 0xBF, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x77, 0xFD, 0xFF, 0x3D, 0xC0, 0x70,
  0x1D, 0xCF, 0x7F, 0x87, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0xF3, 0xFE, 0xFB, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0x6F, 0x60, 0x06, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x37, 0x30, 0x03, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x37,
  0x7F, 0xE0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0xF7,
  0x1C, 0xE7, 0x1D, 0xE3, 0xB8, 0x7E, 0x0F, 0xE1, 0xFC, 0x39, 0xC7, 0x3C,
  0xE3, 0x9C, 0x7B, 0x87, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xEF, 0x1E,
  0xFF, 0xFF, 0xFF, 0xEF, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7,
  0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7,
  0xEF, 0x3F, 0xEF, 0xBF, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x1F, 0x0F, 0xE7, 0xBF, 0x87, 0xE1, 0xF8,
  0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x77, 0xBD, 0xFE, 0x1F, 0x00, 0xEF, 0x3F,
  0xEF, 0xBF, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xF8, 0x7F, 0xBF,
  0xFE, 0xEF, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x3D, 0xDF, 0xF7,
  0xBF, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x77, 0xBD, 0xFF,
  0x3D, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0xEF, 0xFF, 0xFC, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE0, 0x3E, 0x3F, 0xBC, 0xFC, 0x7F, 0x03,
  0xE0, 0xFC, 0x1F, 0x03, 0xF0, 0xFC, 0xEF, 0xF3, 0xE0, 0x38, 0x70, 0xE7,
  0xFF, 0xE7, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xCF, 0x8F, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x77,
  0xFD, 0xFF, 0x3D, 0xC0, 0x71, 0xCE, 0x39, 0xC7, 0x38, 0xE3, 0x18, 0x77,
  0x0E, 0xE0, 0xD8, 0x1B, 0x03, 0xE0, 0x78, 0x07, 0x00, 0xE0, 0xC3, 0x0F,
  0x8C, 0x7E, 0x79, 0xF9, 0xE7, 0x67, 0x99, 0x9E, 0x67, 0xFF, 0x9F, 0x3E,
  0x7C, 0xF8, 0xF3, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xB8, 0xE7,
  0x71, 0xDC, 0x3E, 0x07, 0x81, 0xC0, 0xF8, 0x3E, 0x1D, 0xC7, 0x73, 0x8E,
  0xE3, 0x80, 0xF1, 0xDC, 0x77, 0x1D, 0xC6, 0x33, 0x8E, 0xE3, 0xB8, 0x6C,
  0x1F, 0x07, 0xC1, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0xF0, 0x78, 0x1C,
  0x00, 0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x38, 0x38,
  0x3C, 0x1F, 0xFF, 0xF8, 0x0C, 0x73, 0x8E, 0x30, 0xC3, 0x0C, 0x31, 0xC7,
  0x38, 0xE1, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x38, 0xE1, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x83, 0x86, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC3,
  0x87, 0x3C, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0x8E, 0x20, 0x3C, 0x37,
  0xE3, 0x7F, 0xFE, 0x3E, 0xE1, 0xC0,
};

const GFXglyph RobotoCondensed_Medium25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 18, 6, 2, -18 },
  { 8, 6, 6, 8, 1, -19 },
  { 13, 12, 18, 13, 1, -18 },
  { 40, 10, 23, 13, 1, -21 },
  { 69, 14, 18, 16, 1, -18 },
  { 101, 13, 18, 14, 1, -18 },
  { 131, 2, 6, 4, 1, -19 },
  { 133, 5, 26, 8, 2, -20 },
  { 150, 6, 26, 8, 1, -20 },
  { 170, 11, 11, 11, 0, -18 },
  { 186, 10, 13, 12, 1, -15 },
  { 203, 4, 7, 6, 0, -3 },
  { 207, 6, 2, 8, 1, -8 },
  { 209, 3, 3, 7, 2, -3 },
  { 211, 8, 20, 9, 0, -18 },
  { 231, 10, 18, 13, 1, -18 },
  { 254, 6, 18, 13, 2, -18 },
  { 268, 11, 18, 13, 1, -18 },
  { 293, 10, 18, 13, 1, -18 },
  { 316, 11, 18, 13, 1, -18 },
  { 341, 10, 18, 13, 1, -18 },
  { 364, 10, 18, 13, 1, -18 },
  { 387, 10, 18, 13, 1, -18 },
  { 410, 10, 18, 13, 1, -18 },
  { 433, 10, 18, 13, 1, -18 },
  { 456, 3, 13, 6, 2, -13 },
  { 461, 4, 17, 6, 1, -13 },
  { 470, 8, 11, 11, 1, -13 },
  { 481, 9, 7, 12, 2, -12 },
  { 489, 8, 11, 11, 2, -13 },
  { 500, 9, 18, 11, 1, -18 },
  { 521, 17, 23, 19, 1, -17 },
  { 570, 14, 18, 15, 0, -18 },
  { 602, 11, 18, 14, 2, -18 },
  { 627, 12, 18, 14, 1, -18 },
  { 654, 11, 18, 14, 2, -18 },
  { 679, 10, 18, 12, 2, -18 },
  { 702, 9, 18, 12, 2, -18 },
  { 723, 12, 18, 15, 1, -18 },
  { 750, 12, 18, 15, 2, -18 },
  { 777, 3, 18, 7, 2, -18 },
  { 784, 10, 18, 12, 1, -18 },
  { 807, 12, 18, 14, 2, -18 },
  { 834, 9, 18, 12, 2, -18 },
  { 855, 15, 18, 19, 2, -18 },
  { 889, 12, 18, 15, 2, -18 },
  { 916, 13, 18, 15, 1, -18 },
  { 946, 11, 18, 14, 2, -18 },
  { 971, 13, 21, 15, 1, -18 },
  { 1006, 11, 18, 14, 2, -18 },
  { 1031, 11, 18, 13, 1, -18 },
  { 1056, 12, 18, 13, 1, -18 },
  { 1083, 12, 18, 14, 1, -18 },
  { 1110, 14, 18, 14, 0, -18 },
  { 1142, 17, 18, 19, 1, -18 },
  { 1181, 12, 18, 14, 1, -18 },
  { 1208, 13, 18, 13, 0, -18 },
  { 1238, 11, 18, 13, 1, -18 },
  { 1263, 4, 25, 6, 2, -21 },
  { 1276, 9, 20, 9, 0, -18 },
  { 1299, 5, 25, 6, 0, -21 },
  { 1315, 8, 9, 10, 1, -18 },
  { 1324, 10, 2, 10, 0, 0 },
  { 1327, 5, 4, 8, 1, -19 },
  { 1330, 10, 13, 12, 1, -13 },
  { 1347, 10, 19, 12, 1, -19 },
  { 1371, 10, 13, 12, 1, -13 },
  { 1388, 10, 19, 12, 1, -19 },
  { 1412, 10, 13, 12, 1, -13 },
  { 1429, 7, 19, 8, 1, -19 },
  { 1446, 10, 18, 12, 1, -13 },
  { 1469, 10, 19, 12, 1, -19 },
  { 1493, 4, 18, 6, 1, -18 },
  { 1502, 4, 23, 6, 0, -18 },
  { 1514, 11, 19, 12, 1, -19 },
  { 1541, 2, 19, 6, 2, -19 },
  { 1546, 16, 13, 19, 1, -13 },
  { 1572, 10, 13, 12, 1, -13 },
  { 1589, 10, 13, 12, 1, -13 },
  { 1606, 10, 18, 12, 1, -13 },
  { 1629, 10, 18, 12, 1, -13 },
  { 1652, 6, 13, 8, 1, -13 },
  { 1662, 9, 13, 11, 1, -13 },
  { 1677, 7, 16, 8, 0, -16 },
  { 1691, 10, 13, 12, 1, -13 },
  { 1708, 11, 13, 11, 0, -13 },
  { 1726, 14, 13, 16, 1, -13 },
  { 1749, 10, 13, 11, 1, -13 },
  { 1766, 10, 18, 11, 0, -13 },
  { 1789, 9, 13, 11, 1, -13 },
  { 1804, 6, 24, 8, 1, -20 },
  { 1822, 2, 21, 6, 2, -18 },
  { 1828, 6, 24, 8, 1, -20 },
  { 1846, 12, 5, 14, 1, -10 },
};

const GFXfont RobotoCondensed_Medium25pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium25pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium25pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOCONDENSED_MEDIUM25PT7B_H_
