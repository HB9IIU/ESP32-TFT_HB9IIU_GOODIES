#ifndef _ROBOTOCONDENSED_MEDIUM46PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0xFB, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x00, 0x00, 0x1E, 0xFF, 0xFF,
  0xFF, 0x78, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8E, 0xF1, 0xDE, 0x3B, 0x87, 0x70, 0xE0, 0x00, 0xF1, 0xE0, 0x07, 0x0F,
  0x00, 0x38, 0x78, 0x01, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xF0, 0xE0, 0x07,
  0x8F, 0x00, 0x3C, 0x78, 0x01, 0xC3, 0xC1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x81, 0xE3, 0xC0, 0x0E, 0x1E, 0x00, 0x70,
  0xF0, 0x03, 0x87, 0x00, 0x3C, 0x38, 0x01, 0xE1, 0xC0, 0x0F, 0x1E, 0x0F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x0F, 0x0E,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xE0, 0x07,
  0x0E, 0x00, 0x78, 0x70, 0x03, 0xC3, 0x80, 0x1E, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xF0,
  0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFC, 0x3F,
  0x1F, 0x03, 0xE7, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x81, 0xFB, 0xF0, 0x3F,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFB,
  0xE0, 0x3E, 0x7E, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80,
  0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xBE, 0x00, 0x07, 0x0F, 0x07, 0x07, 0x87, 0x83, 0x83, 0xC1, 0xC3, 0xC1,
  0xE0, 0xE1, 0xC0, 0xF0, 0x71, 0xE0, 0x78, 0x78, 0xE0, 0x1C, 0x3C, 0xF0,
  0x0F, 0xBE, 0x70, 0x07, 0xFE, 0x78, 0x01, 0xFE, 0x38, 0x00, 0x3E, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x1F, 0x00, 0x0F, 0x3F, 0xC0, 0x07, 0x3F, 0xF0, 0x07, 0x9F, 0x7C, 0x03,
  0x8E, 0x1E, 0x03, 0xCF, 0x07, 0x01, 0xC7, 0x83, 0x81, 0xE3, 0xC1, 0xC0,
  0xE1, 0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x70, 0x38, 0x78, 0x18, 0x1F, 0x7C,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0,
  0x07, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x7C, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xF8, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0xF8, 0xFF, 0xE1, 0xE3, 0xF7, 0xE3, 0xC7, 0xC7, 0xE7, 0x9F, 0x8F,
  0xDF, 0x3E, 0x0F, 0xFE, 0x7C, 0x0F, 0xFC, 0xF8, 0x1F, 0xF1, 0xF0, 0x1F,
  0xE3, 0xF0, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xFB, 0xFF, 0x07, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0x7E, 0x03, 0xF0, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x40, 0x30, 0x1C, 0x0F, 0x07, 0x83, 0xE0, 0xF0,
  0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0,
  0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xC0,
  0x70, 0x04, 0x40, 0x0C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x1E,
  0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81,
  0xF0, 0x3C, 0x0F, 0x00, 0xC0, 0x10, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x81, 0xC0, 0xBE, 0x38, 0xF7,
  0xF7, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xF0, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x80, 0x1F, 0x78, 0x03, 0xCF, 0x80, 0xF0, 0xF8, 0x3E, 0x0F, 0x03,
  0x81, 0xC0, 0x00, 0x10, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9E, 0x7C, 0xF3, 0xE7,
  0x82, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFB, 0xF8, 0x7C, 0x1F, 0x1F, 0x83,
  0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xFB, 0xF0, 0x1F, 0x7E, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF8, 0x3F,
  0x1F, 0x07, 0xC3, 0xFB, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xE0,
  0x03, 0xF8, 0x00, 0x00, 0x20, 0x3C, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xC3, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFB,
  0xF8, 0xFC, 0x1F, 0xBF, 0x03, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0x3F, 0x9F, 0x83, 0xFF, 0xC0, 0xFF,
  0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0x7F,
  0x3F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0x7C, 0x00, 0x7B, 0xE0, 0x07, 0x9F, 0x00, 0x3C, 0xF8, 0x03, 0xE7, 0xC0,
  0x1E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0x83,
  0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F,
  0xFF, 0x9F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF7, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF1,
  0xF9, 0xFE, 0x38, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x03,
  0xFF, 0x80, 0xFB, 0xF0, 0x7E, 0x7F, 0x7F, 0x9F, 0xFF, 0xC3, 0xFF, 0xE0,
  0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE3, 0xE0, 0xFB, 0xFE, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFC, 0xFE, 0xFC, 0x1F, 0xBE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFF, 0x03, 0xF7, 0xC0, 0xF9, 0xF8, 0x7E, 0x3F, 0xFF, 0x8F, 0xFF,
  0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0xC3, 0xFB, 0xF8, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xE0, 0x3E, 0x7C, 0x07,
  0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3F, 0x07, 0xE3, 0xE0, 0xF8, 0x7F, 0x7F,
  0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFC, 0x7E,
  0x3F, 0x07, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0xBF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3F, 0x07, 0xE7, 0xFB, 0xFC,
  0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xBF, 0x1F, 0x87, 0xE7,
  0xC0, 0xF9, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7D, 0xF0, 0x1F, 0x7E, 0x0F,
  0xDF, 0xCF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xF7, 0xC1, 0xF1, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x80,
  0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0x78, 0x1E, 0x3F, 0x3F, 0x3F,
  0x3E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3C, 0x7C, 0x78, 0x78, 0x30, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x78, 0x03,
  0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0xFE, 0x3F, 0xF0, 0xFF, 0x81, 0xFC, 0x03,
  0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x30, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFE, 0x3F, 0xF8, 0xFF,
  0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x03,
  0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xF0, 0xFD,
  0xF0, 0x3E, 0xF8, 0x1F, 0xFC, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xF0,
  0xFE, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0x78, 0xF0, 0x07, 0xC0, 0x71, 0xE0, 0x3F, 0xE0, 0xE3, 0x80, 0xFF, 0xE1,
  0xEF, 0x03, 0xF7, 0xC3, 0xDE, 0x07, 0x87, 0x83, 0xBC, 0x1E, 0x0E, 0x07,
  0x70, 0x3C, 0x1C, 0x0E, 0xE0, 0xF0, 0x38, 0x1F, 0xC1, 0xE0, 0xF0, 0x3F,
  0x83, 0xC1, 0xE0, 0x7F, 0x07, 0x83, 0xC0, 0xFE, 0x1F, 0x07, 0x81, 0xFC,
  0x3E, 0x0F, 0x03, 0xF8, 0x78, 0x1E, 0x07, 0xF0, 0xF0, 0x3C, 0x1F, 0xE1,
  0xF0, 0x78, 0x3B, 0xC3, 0xE1, 0xF0, 0x77, 0x83, 0xC7, 0xE1, 0xE7, 0x07,
  0xFF, 0xE7, 0x8F, 0x07, 0xFB, 0xFE, 0x1E, 0x0F, 0xE7, 0xF8, 0x3C, 0x07,
  0x83, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x01,
  0x80, 0x00, 0xFF, 0x3F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0,
  0x00, 0x7D, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0x8F, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0,
  0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F,
  0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3,
  0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xC0, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFC, 0x07,
  0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0xFE, 0x07, 0xE3, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7C, 0x00,
  0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF8, 0x03, 0xF3,
  0xE0, 0x0F, 0xCF, 0xC0, 0x7E, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7E, 0x07, 0xF3, 0xF0,
  0x1F, 0x9F, 0x80, 0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0x7D,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x03,
  0xF7, 0xE0, 0x1F, 0xBF, 0x01, 0xF9, 0xF8, 0x1F, 0xCF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFC, 0x07, 0xE3, 0xE0, 0x0F, 0xDF,
  0x80, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7E, 0x00,
  0x7D, 0xF8, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0xE0, 0x3F, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xFF, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x80, 0xF9, 0xF0, 0x3F, 0x3F,
  0x07, 0xE7, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03,
  0xF0, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0x3F, 0x01,
  0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE0,
  0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x00, 0xFD,
  0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xDF, 0x80, 0xFE, 0x7E, 0x03,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xF0,
  0x3F, 0x0F, 0xC0, 0xFE, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xF3, 0xF0, 0x0F,
  0xCF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xBF, 0xF7, 0x80, 0x7D, 0xFF, 0xBE, 0x03, 0xEF, 0xFD,
  0xF0, 0x1E, 0x7F, 0xEF, 0x81, 0xF3, 0xFF, 0x3E, 0x0F, 0x9F, 0xF9, 0xF0,
  0x78, 0xFF, 0xCF, 0x83, 0xC7, 0xFE, 0x3E, 0x3E, 0x7F, 0xF1, 0xF1, 0xF3,
  0xFF, 0x8F, 0x8F, 0x1F, 0xFC, 0x3C, 0xF8, 0xFF, 0xE1, 0xF7, 0xC7, 0xFF,
  0x0F, 0xBC, 0x3F, 0xF8, 0x3F, 0xE1, 0xFF, 0xC1, 0xFF, 0x0F, 0xFE, 0x0F,
  0xF0, 0x7F, 0xF0, 0x3F, 0x83, 0xFF, 0x81, 0xFC, 0x1F, 0xFC, 0x0F, 0xE0,
  0xFF, 0xE0, 0x3E, 0x07, 0xFF, 0x01, 0xF0, 0x3F, 0xF8, 0x0F, 0x81, 0xF8,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x01, 0xFF, 0xBE, 0x07, 0xFE, 0xF8, 0x1F, 0xF9, 0xF0, 0x7F,
  0xE7, 0xC1, 0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x1F, 0xF8, 0x7C, 0x7F, 0xE1,
  0xF1, 0xFF, 0x83, 0xE7, 0xFE, 0x0F, 0x9F, 0xF8, 0x1F, 0x7F, 0xE0, 0x7D,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0xF8, 0x00, 0xFD,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00,
  0x0F, 0xBE, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xF8, 0xFC, 0x03,
  0xF1, 0xFC, 0x0F, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7E, 0x01, 0xFB, 0xF0, 0x07,
  0xDF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7E,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87,
  0xF0, 0x3F, 0x0F, 0xC0, 0x3F, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0xF8,
  0x00, 0xFD, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xDF, 0x00, 0x1F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0xF8,
  0xFC, 0x03, 0xF1, 0xFC, 0x0F, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x04, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x7E, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC,
  0x03, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0x7D, 0xF8, 0x07, 0xEF, 0xC0, 0x3F,
  0x7E, 0x01, 0xFB, 0xF0, 0x1F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0x83,
  0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x01,
  0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF,
  0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x03, 0xF1, 0xF0, 0x0F, 0xCF,
  0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0x9F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0xBF, 0x00, 0x7C, 0xFC, 0x07, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBF,
  0x00, 0xFD, 0xFC, 0x0F, 0xE7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x01, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F,
  0xBF, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE7, 0xE0, 0x07, 0xE3, 0xF0, 0x03,
  0xF0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0x80,
  0x7E, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x80, 0x7C,
  0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x03,
  0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0xBE, 0x01, 0xF0, 0x0F, 0x9F, 0x00,
  0xF8, 0x07, 0xCF, 0x80, 0x7C, 0x03, 0xE7, 0xC0, 0x7F, 0x01, 0xF3, 0xF0,
  0x3F, 0x81, 0xF9, 0xF8, 0x1F, 0xC0, 0xF8, 0x7C, 0x0F, 0xE0, 0x7C, 0x3E,
  0x07, 0xF0, 0x3E, 0x1F, 0x07, 0xFC, 0x1F, 0x0F, 0x83, 0xDE, 0x0F, 0x87,
  0xE1, 0xEF, 0x0F, 0xC1, 0xF0, 0xF7, 0x87, 0xC0, 0xF8, 0xFB, 0xC3, 0xE0,
  0x7C, 0x7D, 0xF1, 0xF0, 0x3E, 0x3C, 0x78, 0xF8, 0x1F, 0x1E, 0x3C, 0x7C,
  0x07, 0xCF, 0x1E, 0x7C, 0x03, 0xEF, 0x8F, 0x3E, 0x01, 0xF7, 0xC7, 0xDF,
  0x00, 0xFB, 0xC1, 0xEF, 0x80, 0x7D, 0xE0, 0xF7, 0xC0, 0x3E, 0xF0, 0x7B,
  0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x07,
  0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0,
  0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0xFC, 0x01,
  0xFC, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F,
  0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x07, 0xC7, 0xE0, 0x0F, 0xCF, 0xC0,
  0x0F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFB,
  0xF0, 0x03, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x87, 0xE0, 0x7E, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x1F, 0x9F, 0x80, 0x3F,
  0x3F, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7E,
  0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0xC1, 0xF0, 0x07, 0xC1, 0xF0,
  0x07, 0xC3, 0xF0, 0x07, 0xE3, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xE7, 0xC0,
  0x01, 0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0x78, 0x1E, 0x78, 0x3C,
  0xF0, 0xF1, 0xE1, 0xE1, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x07, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0x3F, 0x9F, 0x07, 0xE7, 0xC0, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F, 0x8F,
  0x9F, 0x83, 0xEF, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF,
  0xC1, 0xFB, 0xF9, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xE3, 0xFE, 0xFC, 0x3F,
  0x3F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE7, 0xE0, 0xFB, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFD,
  0xFE, 0xFC, 0x1F, 0xBE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x07, 0xEF, 0xF7, 0xFB, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3E, 0xFF, 0x8F, 0x9F, 0x80, 0x03, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xBF, 0x9F, 0x03, 0xEF, 0xC0, 0xFB,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x03,
  0xE7, 0xC0, 0xF9, 0xFE, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xC0,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x1F, 0x1F, 0x1F, 0xF7, 0xCF, 0xFF, 0xF7, 0xFF, 0xFD,
  0xFE, 0xFF, 0x7C, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xDF, 0x03, 0xF7, 0xFF, 0xFD,
  0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFD, 0xF0, 0x7C, 0x7C, 0x03, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xBF, 0x9F, 0x83, 0xE7, 0xC0,
  0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x47, 0xE0, 0x39, 0xFF, 0x7E, 0x3F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF,
  0xF0, 0x0F, 0xE0, 0x00, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC1, 0xFF, 0xEF, 0xFF,
  0x7F, 0xFB, 0xFF, 0xC3, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x07, 0xE3, 0xC7, 0xFD, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xBF, 0xDF,
  0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFF, 0x01, 0xF7, 0xE0, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF1, 0xFF, 0x7C, 0x1F, 0x9F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x60, 0x3F, 0x3E, 0x3F, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x1F, 0x0F, 0xBF, 0xE7, 0xFF, 0xF3, 0xFF, 0xFD, 0xFE,
  0xFE, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xE0, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0x07, 0xC7, 0xE3, 0xF0, 0xF8, 0x38, 0x00, 0x00,
  0x00, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xFF, 0xFF, 0xFD, 0xFE,
  0xFE, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x7E, 0xF8, 0x3F, 0x3E, 0x0F, 0xCF, 0x87,
  0xE3, 0xE3, 0xF0, 0xF9, 0xF8, 0x3E, 0x7E, 0x0F, 0xBF, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0x7E, 0x0F, 0x8F, 0x83, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x8F, 0x83,
  0xF3, 0xE0, 0xFC, 0xF8, 0x1F, 0xBE, 0x07, 0xEF, 0x80, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0xF8, 0x1F, 0x87,
  0xDF, 0xF1, 0xFE, 0x3F, 0xFF, 0xBF, 0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x0F, 0xE0, 0xFB, 0xE0, 0x7E, 0x07, 0xFF, 0x03, 0xF0,
  0x3F, 0xF8, 0x0F, 0x81, 0xFF, 0xC0, 0x7C, 0x0F, 0xFE, 0x03, 0xE0, 0x7F,
  0xF0, 0x1F, 0x03, 0xFF, 0x80, 0xF8, 0x1F, 0xFC, 0x07, 0xC0, 0xFF, 0xE0,
  0x3E, 0x07, 0xFF, 0x01, 0xF0, 0x3F, 0xF8, 0x0F, 0x81, 0xFF, 0xC0, 0x7C,
  0x0F, 0xFE, 0x03, 0xE0, 0x7F, 0xF0, 0x1F, 0x03, 0xFF, 0x80, 0xF8, 0x1F,
  0xFC, 0x07, 0xC0, 0xFF, 0xE0, 0x3E, 0x07, 0xFF, 0x01, 0xF0, 0x3F, 0xF8,
  0xF8, 0x7D, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xF7, 0xF7, 0xE0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7,
  0xFB, 0xFC, 0xFC, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xF9, 0xF8, 0x3F, 0x3F,
  0xDF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0xF1,
  0xF8, 0x3E, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0x7F, 0xBF, 0x07,
  0xEF, 0x80, 0xFB, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x03, 0xEF, 0xC1, 0xFB, 0xFD, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xBF, 0xE3, 0xE7, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC7, 0xC7, 0xFD, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F,
  0xBF, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0xFD, 0xFE, 0xFF, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0x7C, 0x1F, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xE3,
  0xF3, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0x7E, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xEF, 0xC7, 0xF7, 0xFF, 0xF1, 0xFF,
  0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F,
  0xF0, 0x3E, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFC, 0xFF, 0xBE, 0x3F, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0xFD,
  0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x83, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x07, 0x87, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x03, 0xCF,
  0x00, 0xFB, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0xF8,
  0x0F, 0x03, 0xEF, 0x81, 0xF0, 0x3E, 0x78, 0x1F, 0x03, 0xE7, 0xC1, 0xF8,
  0x3E, 0x7C, 0x1F, 0x83, 0xC7, 0xC3, 0xF8, 0x7C, 0x7C, 0x3F, 0x87, 0xC3,
  0xC3, 0xFC, 0x7C, 0x3E, 0x3F, 0xC7, 0xC3, 0xE7, 0xBC, 0x78, 0x3E, 0x7B,
  0xCF, 0x81, 0xE7, 0xBE, 0xF8, 0x1E, 0x79, 0xEF, 0x81, 0xFF, 0x1E, 0xF0,
  0x1F, 0xF1, 0xEF, 0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE,
  0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x03, 0xC0, 0xFC,
  0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3E, 0x1F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3F,
  0x7C, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x03, 0xF7, 0xC0, 0x7C, 0xFC, 0x1F, 0x8F, 0x83, 0xE1,
  0xF8, 0xFC, 0x1F, 0x1F, 0x03, 0xF7, 0xE0, 0x3E, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0xC0, 0xFD, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x87, 0xE3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F,
  0x3E, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x60, 0x0E, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xF0, 0xFE, 0x0F, 0xC0, 0xFC,
  0x0F, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xE0, 0x06, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x0E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C,
  0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x7C,
  0x1F, 0x01, 0xC0, 0x20, 0x00, 0x0F, 0x00, 0x01, 0xFE, 0x03, 0xDF, 0xF8,
  0x1E, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0x78, 0x7F, 0xFB, 0xC1, 0xFF, 0xDE,
  0x07, 0xFC, 0xF0, 0x1F, 0xC0, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_Medium46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 33, 12, 3, -33 },
  { 26, 11, 12, 15, 2, -35 },
  { 43, 21, 33, 25, 2, -33 },
  { 130, 19, 42, 23, 2, -38 },
  { 230, 25, 33, 29, 2, -33 },
  { 334, 23, 33, 26, 2, -33 },
  { 429, 4, 12, 8, 2, -35 },
  { 435, 10, 47, 15, 3, -37 },
  { 494, 11, 47, 15, 1, -37 },
  { 559, 19, 19, 20, 1, -33 },
  { 605, 19, 24, 22, 2, -27 },
  { 662, 7, 13, 10, 1, -5 },
  { 674, 10, 4, 14, 2, -16 },
  { 679, 6, 6, 13, 3, -6 },
  { 684, 15, 36, 16, 0, -33 },
  { 752, 19, 33, 23, 2, -33 },
  { 831, 11, 33, 23, 4, -33 },
  { 877, 19, 33, 23, 2, -33 },
  { 956, 18, 33, 23, 2, -33 },
  { 1031, 21, 33, 23, 1, -33 },
  { 1118, 18, 33, 23, 3, -33 },
  { 1193, 18, 33, 23, 3, -33 },
  { 1268, 19, 33, 23, 2, -33 },
  { 1347, 19, 33, 23, 2, -33 },
  { 1426, 18, 33, 23, 2, -33 },
  { 1501, 6, 25, 12, 3, -25 },
  { 1520, 8, 33, 11, 1, -25 },
  { 1553, 15, 21, 21, 2, -25 },
  { 1593, 17, 15, 23, 3, -22 },
  { 1625, 16, 21, 21, 3, -25 },
  { 1667, 17, 33, 20, 1, -33 },
  { 1738, 31, 42, 35, 2, -32 },
  { 1901, 25, 33, 27, 1, -33 },
  { 2005, 20, 33, 26, 3, -33 },
  { 2088, 22, 33, 26, 2, -33 },
  { 2179, 21, 33, 26, 3, -33 },
  { 2266, 18, 33, 23, 3, -33 },
  { 2341, 18, 33, 22, 3, -33 },
  { 2416, 22, 33, 27, 2, -33 },
  { 2507, 22, 33, 28, 3, -33 },
  { 2598, 6, 33, 12, 3, -33 },
  { 2623, 19, 33, 22, 1, -33 },
  { 2702, 22, 33, 25, 3, -33 },
  { 2793, 18, 33, 22, 3, -33 },
  { 2868, 29, 33, 35, 3, -33 },
  { 2988, 22, 33, 28, 3, -33 },
  { 3079, 23, 33, 28, 2, -33 },
  { 3174, 21, 33, 26, 3, -33 },
  { 3261, 23, 39, 28, 2, -33 },
  { 3374, 21, 33, 25, 3, -33 },
  { 3461, 21, 33, 24, 2, -33 },
  { 3548, 22, 33, 25, 1, -33 },
  { 3639, 21, 33, 26, 3, -33 },
  { 3726, 25, 33, 26, 1, -33 },
  { 3830, 33, 33, 35, 1, -33 },
  { 3967, 23, 33, 26, 1, -33 },
  { 4062, 24, 33, 25, 0, -33 },
  { 4161, 21, 33, 24, 2, -33 },
  { 4248, 8, 45, 12, 3, -38 },
  { 4293, 16, 36, 17, 1, -33 },
  { 4365, 8, 45, 12, 1, -38 },
  { 4410, 15, 16, 18, 1, -33 },
  { 4440, 17, 4, 19, 1, 0 },
  { 4449, 11, 7, 15, 1, -35 },
  { 4459, 18, 24, 22, 2, -24 },
  { 4513, 18, 35, 23, 3, -35 },
  { 4592, 18, 24, 21, 2, -24 },
  { 4646, 18, 35, 23, 2, -35 },
  { 4725, 18, 24, 22, 2, -24 },
  { 4779, 13, 35, 15, 1, -35 },
  { 4836, 18, 33, 23, 2, -24 },
  { 4911, 17, 35, 22, 3, -35 },
  { 4986, 5, 33, 11, 3, -33 },
  { 5007, 9, 42, 11, -1, -33 },
  { 5055, 18, 35, 21, 3, -35 },
  { 5134, 5, 35, 11, 3, -35 },
  { 5156, 29, 24, 34, 3, -24 },
  { 5243, 17, 24, 22, 3, -24 },
  { 5294, 19, 24, 23, 2, -24 },
  { 5351, 18, 33, 23, 3, -24 },
  { 5426, 18, 33, 23, 2, -24 },
  { 5501, 11, 24, 15, 3, -24 },
  { 5534, 17, 24, 21, 2, -24 },
  { 5585, 12, 30, 14, 1, -30 },
  { 5630, 17, 24, 22, 3, -24 },
  { 5681, 18, 24, 20, 1, -24 },
  { 5735, 28, 24, 29, 1, -24 },
  { 5819, 19, 24, 21, 1, -24 },
  { 5876, 18, 33, 20, 1, -24 },
  { 5951, 17, 24, 21, 2, -24 },
  { 6002, 12, 44, 14, 1, -36 },
  { 6068, 4, 39, 11, 4, -33 },
  { 6088, 11, 44, 14, 1, -36 },
  { 6149, 21, 10, 26, 3, -19 },
};

const GFXfont RobotoCondensed_Medium46pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium46pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium46pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOCONDENSED_MEDIUM46PT7B_H_
