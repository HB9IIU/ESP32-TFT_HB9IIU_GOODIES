#ifndef _ROBOTOCONDENSED_MEDIUM27PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0xEF, 0xDF, 0xB6,
  0x6C, 0xD9, 0xB3, 0x00, 0x06, 0x60, 0x33, 0x01, 0x98, 0x18, 0xC0, 0xC6,
  0x3F, 0xFD, 0xFF, 0xE1, 0x98, 0x0C, 0xC0, 0xE6, 0x06, 0x30, 0x33, 0x0F,
  0xFF, 0x7F, 0xF8, 0x66, 0x03, 0x30, 0x31, 0x81, 0x9C, 0x0C, 0xC0, 0x06,
  0x00, 0xC0, 0x18, 0x07, 0x83, 0xFC, 0x7F, 0x9C, 0x7B, 0x87, 0x70, 0xEE,
  0x01, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xE0, 0xFE, 0x1D,
  0xC3, 0xBF, 0xF3, 0xFC, 0x3E, 0x01, 0x80, 0x30, 0x06, 0x00, 0x3C, 0x00,
  0xFC, 0x01, 0x98, 0x46, 0x31, 0x8C, 0x66, 0x18, 0xCC, 0x19, 0xB0, 0x3F,
  0x60, 0x3D, 0x80, 0x03, 0x00, 0x0C, 0xE0, 0x1B, 0xE0, 0x6C, 0xE1, 0xD8,
  0xC3, 0x31, 0x8C, 0x63, 0x18, 0xE6, 0x00, 0xF8, 0x00, 0xE0, 0x0F, 0x00,
  0xFE, 0x03, 0xFC, 0x0E, 0x70, 0x71, 0xC0, 0xE7, 0x03, 0xB8, 0x0F, 0xE0,
  0x1E, 0x00, 0xF8, 0x07, 0xF3, 0x9D, 0xCE, 0xE3, 0xBB, 0x8F, 0xCE, 0x1F,
  0x3C, 0x38, 0x7F, 0xF0, 0xFF, 0xE1, 0xF3, 0x80, 0xFF, 0x6D, 0xB0, 0x04,
  0x31, 0x8E, 0x31, 0xC6, 0x38, 0xE3, 0x8E, 0x30, 0xC3, 0x0C, 0x30, 0xE3,
  0x8E, 0x38, 0x61, 0xC3, 0x0E, 0x18, 0x30, 0x40, 0x83, 0x0E, 0x1C, 0x70,
  0xE3, 0x86, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC6, 0x38,
  0xE3, 0x1C, 0xE3, 0x08, 0x00, 0x06, 0x00, 0x60, 0x06, 0x06, 0x62, 0x7F,
  0xE3, 0xFC, 0x0F, 0x01, 0xF8, 0x19, 0x83, 0x9C, 0x10, 0x80, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x39, 0xCE, 0x67, 0x39, 0x80, 0xFF,
  0xFF, 0xC0, 0x4E, 0xEE, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x38,
  0x1C, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38,
  0x18, 0x0C, 0x0E, 0x00, 0x1F, 0x07, 0xF1, 0xFF, 0x38, 0xE7, 0x0E, 0xE1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0xE1, 0xDC,
  0x3B, 0x8E, 0x7F, 0xC7, 0xF0, 0x7C, 0x00, 0x06, 0x3D, 0xFF, 0xFC, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x1F, 0x07, 0xF9, 0xFF, 0x38, 0xFE, 0x0F, 0xC1, 0xC0, 0x38, 0x0E, 0x01,
  0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0x07, 0xF1, 0xFF, 0x78, 0xEE, 0x0E, 0x01, 0xC0,
  0x78, 0x0E, 0x0F, 0xC1, 0xF0, 0x3F, 0x00, 0xE0, 0x0E, 0x01, 0xF8, 0x3F,
  0x8F, 0x7F, 0xCF, 0xF8, 0x7C, 0x00, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0xDC, 0x1D, 0xC1, 0x9C, 0x39, 0xC3, 0x1C, 0x71, 0xC6, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x7F,
  0xDF, 0xF7, 0xFD, 0x80, 0xE0, 0x38, 0x0E, 0xF3, 0xFE, 0xFF, 0xC8, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x7E, 0x1F, 0x87, 0xFF, 0x9F, 0xE3, 0xE0, 0x07,
  0x07, 0xC3, 0xF1, 0xE0, 0x70, 0x38, 0x0E, 0xF3, 0xFE, 0xFF, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x7F, 0x9F, 0xE1, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80,
  0xE0, 0x00, 0x1F, 0x07, 0xF9, 0xFF, 0x38, 0xF7, 0x0E, 0xE1, 0xDC, 0x71,
  0xFE, 0x1F, 0x87, 0xF9, 0xC7, 0x38, 0x7F, 0x0F, 0xC1, 0xFC, 0x3B, 0x8F,
  0x7F, 0xC7, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xF1, 0xFF, 0x38, 0xEF, 0x1F,
  0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0xEE, 0x3D, 0xFF, 0x9F, 0xF1, 0xEE, 0x03,
  0x80, 0x70, 0x1E, 0x1F, 0x83, 0xE0, 0x70, 0x00, 0x5F, 0xF0, 0x00, 0x00,
  0x2F, 0xF8, 0x27, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x77, 0x77, 0x6E, 0xC0,
  0x00, 0x80, 0xC1, 0xE3, 0xF7, 0xE7, 0xC3, 0x81, 0xF0, 0x7E, 0x0F, 0xC1,
  0xE0, 0x70, 0x08, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x70, 0x3C, 0x1F, 0x83, 0xF0, 0x7C, 0x0E, 0x1F,
  0x3F, 0x7E, 0x3C, 0x1C, 0x08, 0x00, 0x3E, 0x1F, 0xEF, 0xFB, 0x8F, 0xE1,
  0xC0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x07, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x38,
  0x1C, 0x0E, 0x01, 0xC3, 0x80, 0x18, 0x60, 0x01, 0x9C, 0x3C, 0x33, 0x0F,
  0xE6, 0x63, 0x98, 0xCC, 0x63, 0x1B, 0x8C, 0x61, 0x73, 0x8C, 0x3C, 0x71,
  0x85, 0x8E, 0x31, 0xB1, 0x86, 0x37, 0x39, 0xC6, 0xE7, 0x39, 0x8C, 0x7F,
  0xF1, 0x87, 0x3C, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x82,
  0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0x98, 0x07, 0x38, 0x0E, 0x70, 0x38,
  0xE0, 0x70, 0xE0, 0xE1, 0xC3, 0xFF, 0x87, 0xFF, 0x8F, 0xFF, 0x1C, 0x0E,
  0x70, 0x1E, 0xE0, 0x1D, 0xC0, 0x38, 0xFF, 0x8F, 0xFC, 0xFF, 0xEE, 0x0E,
  0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x3C, 0xFF, 0x8F, 0xFC, 0xE1, 0xEE, 0x0E,
  0xE0, 0xFE, 0x0F, 0xE0, 0xEE, 0x0E, 0xFF, 0xEF, 0xFC, 0xFF, 0x00, 0x0F,
  0xC0, 0xFF, 0x0F, 0xFC, 0xF0, 0xF7, 0x03, 0xB8, 0x1F, 0xC0, 0xFE, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x03, 0xB8, 0x1D, 0xC0, 0xEF,
  0x0F, 0x3F, 0xF0, 0xFF, 0x03, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0xCE, 0x1E,
  0xE0, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0xEE, 0x1E, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xBF, 0xEF,
  0xFB, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xBF, 0xEF,
  0xFB, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x0F,
  0xC0, 0xFF, 0x8F, 0xFC, 0xF0, 0xF7, 0x03, 0xB8, 0x1F, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x03, 0xB8, 0x1D, 0xC0, 0xEF,
  0x07, 0x3F, 0xF8, 0xFF, 0x83, 0xF8, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xF8, 0x7E, 0x1F, 0x87, 0xFF, 0xDF, 0xE1, 0xE0, 0xE0, 0xF7, 0x07,
  0xB8, 0x79, 0xC7, 0x8E, 0x38, 0x73, 0xC3, 0xBC, 0x1D, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0xC1, 0xEF, 0x0E, 0x38, 0x71, 0xE3, 0x87, 0x1C, 0x3C, 0xE0,
  0xE7, 0x07, 0xB8, 0x1E, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x6F, 0xF8, 0x77, 0xEC, 0x3B, 0xF7,
  0x19, 0xFB, 0x9C, 0xFC, 0xCE, 0x7E, 0x76, 0x7F, 0x3F, 0x3F, 0x8F, 0x9F,
  0xC7, 0xCF, 0xE3, 0xC7, 0xF0, 0xE3, 0xF8, 0x71, 0xE0, 0xE0, 0x3F, 0x81,
  0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0xFD, 0xC7, 0xEE, 0x3F,
  0x39, 0xF9, 0xCF, 0xC7, 0x7E, 0x3B, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0,
  0xFF, 0x03, 0xF8, 0x1E, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70,
  0x39, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1D, 0xC0, 0xF7, 0x03, 0x9E, 0x1E, 0x3F, 0xF0, 0x7F, 0xC0,
  0xFC, 0x00, 0xFF, 0x8F, 0xFC, 0xFF, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0xFF, 0xFE, 0xFF, 0xEF, 0xF8, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0xFF,
  0x1E, 0x1E, 0x70, 0x39, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3D, 0xC0, 0xF7, 0x03, 0x9E, 0x1E, 0x3F,
  0xF0, 0x7F, 0x80, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x40, 0xFF, 0x0F,
  0xFC, 0xFF, 0xEE, 0x0E, 0xE0, 0xEE, 0x0F, 0xE0, 0xFE, 0x0E, 0xE0, 0xEF,
  0xFE, 0xFF, 0xCF, 0xF8, 0xE3, 0x8E, 0x3C, 0xE1, 0xCE, 0x1E, 0xE0, 0xEE,
  0x0F, 0xE0, 0x70, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x0F, 0xF0, 0x7F, 0x07,
  0x70, 0x07, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0x00, 0x7E, 0x07,
  0xE0, 0x7F, 0x07, 0x7F, 0xF3, 0xFE, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFE, 0x0E, 0xFF, 0xE7, 0xFC, 0x1F, 0x00, 0x70, 0x1E, 0xE0, 0x3D,
  0xE0, 0x73, 0xC0, 0xE3, 0x83, 0xC7, 0x07, 0x0F, 0x0E, 0x0E, 0x1C, 0x1C,
  0x70, 0x38, 0xE0, 0x39, 0xC0, 0x77, 0x80, 0xEE, 0x01, 0xDC, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0xE0, 0xE1, 0xFC, 0x1C,
  0x3B, 0x87, 0x87, 0x70, 0xF0, 0xE7, 0x1F, 0x1C, 0xE3, 0xE3, 0x9C, 0x7C,
  0x73, 0x9D, 0x9C, 0x73, 0xB3, 0x86, 0x77, 0x70, 0xEC, 0xEE, 0x1D, 0x9D,
  0xC3, 0xF1, 0xB0, 0x7E, 0x3E, 0x07, 0x87, 0xC0, 0xF0, 0xF8, 0x1E, 0x0F,
  0x03, 0xC1, 0xC0, 0x78, 0x38, 0x00, 0xF0, 0x7B, 0x83, 0xDE, 0x1C, 0x71,
  0xE3, 0xCE, 0x0E, 0xE0, 0x77, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x03, 0xE0,
  0x3F, 0x81, 0xDC, 0x1E, 0xF0, 0xE3, 0x8F, 0x1E, 0x70, 0x77, 0x83, 0xFC,
  0x1E, 0x70, 0x3D, 0xC0, 0xE7, 0x83, 0x8E, 0x1E, 0x3C, 0x70, 0x71, 0xC1,
  0xCE, 0x03, 0xB8, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07,
  0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEF, 0xFF, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E,
  0x03, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70,
  0x1C, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0xFF, 0xFE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xFF,
  0xC0, 0x18, 0x0E, 0x0F, 0x07, 0x83, 0xE3, 0xB1, 0x98, 0xCE, 0xE3, 0x61,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF1, 0xC3, 0x87, 0x1F, 0x07, 0xF1,
  0xFF, 0x38, 0xE0, 0x1C, 0x03, 0x87, 0xF3, 0xFE, 0x71, 0xDC, 0x3B, 0x87,
  0x70, 0xEF, 0xFC, 0xFF, 0x8F, 0x78, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0xF3, 0xFE, 0xFF, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0xFE, 0xCF, 0x00, 0x1F, 0x07, 0xF1,
  0xFF, 0x38, 0xEE, 0x0F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x83,
  0xB8, 0xE7, 0xFC, 0x7F, 0x07, 0xC0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC7, 0xBB, 0xFF, 0x7F, 0xFE, 0x3F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x3D, 0xFF, 0xBF, 0xF1, 0xEE, 0x1F,
  0x07, 0xF1, 0xFF, 0x38, 0xFE, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C,
  0x03, 0xC0, 0x38, 0x27, 0xFC, 0x7F, 0x87, 0xE0, 0x0E, 0x3C, 0xF9, 0xC7,
  0x8F, 0x3F, 0xFF, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x80, 0x1E, 0xE7, 0xFD, 0xFF, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xB8, 0x77, 0xFE, 0x7F, 0xC7, 0xB8,
  0x07, 0x21, 0xEF, 0xF9, 0xFF, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3D, 0xE7, 0xFE, 0xFF, 0xDE, 0x3B, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0E,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0xF1, 0x80, 0x00,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x7F, 0xBE, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x3F,
  0x9E, 0xE7, 0x3B, 0xCF, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xE3, 0xB8, 0xE7,
  0x39, 0xEE, 0x3B, 0x8F, 0xE1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xCF, 0x1E, 0x7F, 0xFF, 0xBF, 0xFF, 0xDC, 0x78, 0xEE, 0x3C,
  0x7F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8,
  0x70, 0xFC, 0x38, 0x7E, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0E, 0xE7, 0x9D,
  0xFB, 0xFF, 0x78, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x38, 0x1F, 0x07, 0xF9, 0xFF, 0x38,
  0xFF, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xB8, 0x77,
  0xFC, 0x7F, 0x87, 0xC0, 0xCF, 0x37, 0xEF, 0xFF, 0x8F, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xFF, 0xBF, 0xEE, 0xF3, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0x1E, 0xEF, 0xFD, 0xFF, 0xF8, 0xFE, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0xF7, 0xFE, 0xFF,
  0xC7, 0xB8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xEF, 0xFF, 0xFC,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x00, 0x1F, 0x1F, 0xE7,
  0xFF, 0xC7, 0xE0, 0x1C, 0x07, 0xE0, 0xFC, 0x0F, 0x80, 0xFE, 0x1F, 0x87,
  0x7F, 0xDF, 0xE1, 0xF0, 0x38, 0x70, 0xE7, 0xFF, 0xE7, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0x1E, 0x1C, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1D, 0xC3, 0xB8,
  0xF7, 0xFE, 0xFF, 0xC7, 0xB8, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0xE3, 0x9C,
  0x73, 0x8E, 0x70, 0xCC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0xE3, 0x87, 0xE3, 0x8E, 0xE3, 0x8E, 0xE3, 0xCE, 0x67, 0xCE,
  0x77, 0xCE, 0x76, 0xCC, 0x76, 0xFC, 0x7E, 0xFC, 0x3E, 0x7C, 0x3C, 0x7C,
  0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x38, 0x18, 0x38, 0xE1, 0xDE, 0x79, 0xCE,
  0x3D, 0xC3, 0xF0, 0x7E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xE0, 0xFC, 0x39,
  0xC7, 0x39, 0xE7, 0xB8, 0x70, 0xF0, 0xEE, 0x1D, 0xC7, 0xB8, 0xE3, 0x9C,
  0x73, 0x8E, 0xE0, 0xDC, 0x1F, 0x83, 0xF0, 0x7C, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x03, 0x81, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x04, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xC3, 0x8E, 0x1E, 0x1C, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x0E, 0x1C, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x83, 0x8E, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC3, 0x8F, 0x1C, 0x73, 0x8C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x38, 0xE2, 0x00, 0x3C, 0x1B, 0xF1, 0xDF, 0xCE, 0xC7, 0xEE,
  0x3F, 0x00, 0x70,
};

const GFXglyph RobotoCondensed_Medium27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 19, 7, 2, -19 },
  { 9, 7, 7, 9, 1, -20 },
  { 16, 13, 19, 15, 1, -19 },
  { 47, 11, 25, 14, 1, -22 },
  { 82, 15, 19, 17, 1, -19 },
  { 118, 14, 19, 15, 1, -19 },
  { 152, 3, 7, 5, 1, -20 },
  { 155, 6, 27, 9, 2, -21 },
  { 176, 6, 27, 9, 1, -21 },
  { 197, 12, 11, 12, 0, -19 },
  { 214, 11, 14, 13, 1, -16 },
  { 234, 5, 7, 6, 0, -3 },
  { 239, 6, 3, 8, 1, -10 },
  { 242, 4, 4, 8, 2, -4 },
  { 244, 9, 21, 9, 0, -19 },
  { 268, 11, 19, 14, 1, -19 },
  { 295, 7, 19, 14, 2, -19 },
  { 312, 11, 19, 14, 1, -19 },
  { 339, 11, 19, 14, 1, -19 },
  { 366, 12, 19, 14, 1, -19 },
  { 395, 10, 19, 14, 2, -19 },
  { 419, 10, 19, 14, 2, -19 },
  { 443, 11, 19, 14, 1, -19 },
  { 470, 11, 19, 14, 1, -19 },
  { 497, 11, 19, 14, 1, -19 },
  { 524, 3, 15, 7, 2, -15 },
  { 530, 4, 19, 6, 1, -15 },
  { 540, 9, 13, 12, 1, -15 },
  { 555, 10, 9, 13, 2, -13 },
  { 567, 9, 13, 12, 2, -15 },
  { 582, 10, 19, 12, 1, -19 },
  { 606, 19, 25, 21, 1, -19 },
  { 666, 15, 19, 16, 0, -19 },
  { 702, 12, 19, 15, 2, -19 },
  { 731, 13, 19, 15, 1, -19 },
  { 762, 12, 19, 15, 2, -19 },
  { 791, 10, 19, 13, 2, -19 },
  { 815, 10, 19, 13, 2, -19 },
  { 839, 13, 19, 16, 1, -19 },
  { 870, 13, 19, 17, 2, -19 },
  { 901, 3, 19, 7, 2, -19 },
  { 909, 10, 19, 13, 1, -19 },
  { 933, 13, 19, 15, 2, -19 },
  { 964, 10, 19, 13, 2, -19 },
  { 988, 17, 19, 20, 2, -19 },
  { 1029, 13, 19, 17, 2, -19 },
  { 1060, 14, 19, 16, 1, -19 },
  { 1094, 12, 19, 15, 2, -19 },
  { 1123, 14, 22, 16, 1, -19 },
  { 1162, 12, 19, 15, 2, -19 },
  { 1191, 12, 19, 14, 1, -19 },
  { 1220, 13, 19, 14, 1, -19 },
  { 1251, 12, 19, 15, 2, -19 },
  { 1280, 15, 19, 15, 0, -19 },
  { 1316, 19, 19, 20, 1, -19 },
  { 1362, 13, 19, 15, 1, -19 },
  { 1393, 14, 19, 14, 0, -19 },
  { 1427, 12, 19, 14, 1, -19 },
  { 1456, 4, 26, 7, 2, -22 },
  { 1469, 10, 21, 10, 0, -19 },
  { 1496, 5, 26, 7, 0, -22 },
  { 1513, 9, 10, 10, 1, -19 },
  { 1525, 11, 3, 11, 0, 0 },
  { 1530, 6, 4, 9, 1, -20 },
  { 1533, 11, 15, 13, 1, -15 },
  { 1554, 10, 21, 13, 2, -21 },
  { 1581, 11, 15, 12, 1, -15 },
  { 1602, 11, 21, 13, 1, -21 },
  { 1631, 11, 15, 13, 1, -15 },
  { 1652, 7, 21, 9, 1, -21 },
  { 1671, 11, 20, 13, 1, -15 },
  { 1699, 11, 21, 13, 1, -21 },
  { 1728, 3, 20, 7, 2, -20 },
  { 1736, 6, 25, 6, -1, -20 },
  { 1755, 10, 21, 13, 2, -21 },
  { 1782, 3, 21, 7, 2, -21 },
  { 1790, 17, 15, 20, 2, -15 },
  { 1822, 11, 15, 13, 1, -15 },
  { 1843, 11, 15, 13, 1, -15 },
  { 1864, 10, 20, 13, 2, -15 },
  { 1889, 11, 20, 13, 1, -15 },
  { 1917, 6, 15, 9, 2, -15 },
  { 1929, 10, 15, 12, 1, -15 },
  { 1948, 7, 18, 8, 0, -18 },
  { 1964, 11, 15, 13, 1, -15 },
  { 1985, 11, 15, 12, 0, -15 },
  { 2006, 16, 15, 17, 1, -15 },
  { 2036, 11, 15, 12, 1, -15 },
  { 2057, 11, 20, 12, 0, -15 },
  { 2085, 10, 15, 12, 1, -15 },
  { 2104, 7, 26, 8, 1, -21 },
  { 2127, 2, 23, 7, 2, -19 },
  { 2133, 6, 26, 8, 1, -21 },
  { 2153, 13, 6, 15, 1, -11 },
};

const GFXfont RobotoCondensed_Medium27pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium27pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOCONDENSED_MEDIUM27PT7B_H_
