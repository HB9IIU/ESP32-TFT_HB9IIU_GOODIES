#ifndef _ROBOTOCONDENSED_MEDIUM9PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium9pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xB4, 0x31, 0x9E, 0xAF, 0x31, 0x80, 0x27, 0x54, 0x61, 0xD7,
  0x20, 0x65, 0x9C, 0x43, 0xAC, 0x60, 0x62, 0x98, 0xCE, 0xC9, 0xE0, 0xC0,
  0x6A, 0xAA, 0x40, 0x95, 0x55, 0x80, 0x2B, 0x66, 0x22, 0xF2, 0x20, 0x60,
  0xC0, 0x80, 0x25, 0x24, 0xA4, 0x65, 0x99, 0x95, 0x60, 0x75, 0x54, 0x69,
  0x13, 0x24, 0xF0, 0x69, 0x12, 0x19, 0x60, 0x33, 0x55, 0xF1, 0x10, 0xF3,
  0x93, 0x70, 0x24, 0x75, 0x55, 0x60, 0xF1, 0x22, 0x26, 0x40, 0x65, 0x56,
  0x5D, 0x70, 0x65, 0x95, 0x71, 0x60, 0x88, 0x40, 0x60, 0x3B, 0x10, 0xE3,
  0x80, 0x8D, 0xC0, 0x69, 0x22, 0x40, 0x40, 0x38, 0x89, 0x6D, 0x5A, 0xB7,
  0x90, 0x1C, 0x21, 0x94, 0xA7, 0x26, 0x20, 0xEA, 0xAE, 0xAA, 0xE0, 0x72,
  0x71, 0x8C, 0x25, 0xC0, 0xEA, 0x99, 0x9A, 0xE0, 0xF2, 0x79, 0x38, 0xF2,
  0x79, 0x20, 0x72, 0x71, 0xBC, 0xA5, 0xC0, 0x99, 0x9F, 0x99, 0x90, 0xFE,
  0x11, 0x11, 0x19, 0x60, 0xBA, 0xCC, 0xEA, 0xB0, 0x92, 0x49, 0x38, 0x8C,
  0xF7, 0xBD, 0xD6, 0xA0, 0x99, 0xDD, 0xBB, 0x90, 0x72, 0x73, 0x9C, 0xA5,
  0xC0, 0xE9, 0x9E, 0x88, 0x80, 0x72, 0x73, 0x9C, 0xA5, 0xC1, 0xEA, 0xAE,
  0xAA, 0xB0, 0x75, 0x47, 0x19, 0x70, 0xF9, 0x08, 0x42, 0x10, 0x80, 0x99,
  0x99, 0x9B, 0xE0, 0x8A, 0xD4, 0xA5, 0x10, 0x80, 0x96, 0xA9, 0x53, 0x66,
  0xCD, 0x9A, 0x00, 0xDA, 0x9C, 0x45, 0x2B, 0x60, 0x9A, 0x94, 0xC2, 0x10,
  0x80, 0xF1, 0x22, 0x44, 0xF0, 0xFF, 0x89, 0x24, 0x49, 0xD5, 0x57, 0x4E,
  0x80, 0xF0, 0x50, 0x61, 0x79, 0x70, 0x93, 0xDB, 0x78, 0x69, 0x89, 0x60,
  0x11, 0x79, 0x99, 0x70, 0x69, 0xF8, 0x70, 0x6B, 0xA4, 0x90, 0x79, 0x99,
  0x71, 0x60, 0xCC, 0xFD, 0xDD, 0xD0, 0xBE, 0xC5, 0x55, 0x80, 0x93, 0xED,
  0xA8, 0xFE, 0xFD, 0x6B, 0x5A, 0x80, 0xBD, 0xDD, 0xD0, 0x7D, 0x99, 0x70,
  0xF6, 0xDF, 0x20, 0x79, 0x99, 0x71, 0x10, 0xEA, 0x80, 0x68, 0x69, 0x60,
  0x75, 0x50, 0xDD, 0xD5, 0x70, 0x96, 0x66, 0x60, 0xAA, 0xE7, 0x96, 0x48,
  0xF6, 0x66, 0xF0, 0x96, 0x66, 0x64, 0xC0, 0xF2, 0x64, 0xF0, 0x49, 0x28,
  0x92, 0x40, 0xFF, 0x95, 0x55, 0x80, 0x6D, 0x80,
};

const GFXglyph RobotoCondensed_Medium9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 2, 1, -7 },
  { 2, 3, 2, 3, 0, -7 },
  { 3, 5, 7, 5, 0, -7 },
  { 8, 4, 9, 5, 0, -8 },
  { 13, 5, 7, 6, 0, -7 },
  { 18, 5, 7, 5, 0, -7 },
  { 23, 1, 2, 2, 0, -7 },
  { 24, 2, 9, 3, 1, -7 },
  { 27, 2, 9, 3, 0, -7 },
  { 30, 4, 4, 4, 0, -7 },
  { 32, 4, 5, 4, 0, -6 },
  { 35, 2, 2, 2, 0, -1 },
  { 36, 2, 1, 3, 0, -3 },
  { 37, 1, 1, 3, 1, -1 },
  { 38, 3, 8, 3, 0, -7 },
  { 41, 4, 7, 5, 0, -7 },
  { 45, 2, 7, 5, 1, -7 },
  { 47, 4, 7, 5, 0, -7 },
  { 51, 4, 7, 5, 0, -7 },
  { 55, 4, 7, 5, 0, -7 },
  { 59, 3, 7, 5, 1, -7 },
  { 62, 4, 7, 5, 0, -7 },
  { 66, 4, 7, 5, 0, -7 },
  { 70, 4, 7, 5, 0, -7 },
  { 74, 4, 7, 5, 0, -7 },
  { 78, 1, 5, 2, 1, -5 },
  { 79, 2, 6, 2, 0, -5 },
  { 81, 3, 4, 4, 0, -5 },
  { 83, 3, 3, 4, 1, -4 },
  { 85, 3, 4, 4, 1, -5 },
  { 87, 4, 7, 4, 0, -7 },
  { 91, 7, 8, 7, 0, -6 },
  { 98, 5, 7, 5, 0, -7 },
  { 103, 4, 7, 5, 1, -7 },
  { 107, 5, 7, 5, 0, -7 },
  { 112, 4, 7, 5, 1, -7 },
  { 116, 3, 7, 4, 1, -7 },
  { 119, 3, 7, 4, 1, -7 },
  { 122, 5, 7, 5, 0, -7 },
  { 127, 4, 7, 6, 1, -7 },
  { 131, 1, 7, 2, 1, -7 },
  { 132, 4, 7, 4, 0, -7 },
  { 136, 4, 7, 5, 1, -7 },
  { 140, 3, 7, 4, 1, -7 },
  { 143, 5, 7, 7, 1, -7 },
  { 148, 4, 7, 6, 1, -7 },
  { 152, 5, 7, 5, 0, -7 },
  { 157, 4, 7, 5, 1, -7 },
  { 161, 5, 8, 5, 0, -7 },
  { 166, 4, 7, 5, 1, -7 },
  { 170, 4, 7, 5, 0, -7 },
  { 174, 5, 7, 5, 0, -7 },
  { 179, 4, 7, 5, 1, -7 },
  { 183, 5, 7, 5, 0, -7 },
  { 188, 7, 7, 7, 0, -7 },
  { 195, 5, 7, 5, 0, -7 },
  { 200, 5, 7, 5, 0, -7 },
  { 205, 4, 7, 5, 0, -7 },
  { 209, 1, 8, 2, 1, -7 },
  { 210, 3, 8, 3, 0, -7 },
  { 213, 2, 8, 2, 0, -7 },
  { 215, 3, 3, 3, 0, -7 },
  { 217, 4, 1, 4, 0, 0 },
  { 218, 2, 2, 3, 0, -7 },
  { 219, 4, 5, 4, 0, -5 },
  { 222, 3, 7, 4, 1, -7 },
  { 225, 4, 5, 4, 0, -5 },
  { 228, 4, 7, 4, 0, -7 },
  { 232, 4, 5, 4, 0, -5 },
  { 235, 3, 7, 3, 0, -7 },
  { 238, 4, 7, 4, 0, -5 },
  { 242, 4, 7, 4, 0, -7 },
  { 246, 1, 7, 2, 1, -7 },
  { 247, 2, 9, 2, 0, -7 },
  { 250, 3, 7, 4, 1, -7 },
  { 253, 1, 7, 2, 1, -7 },
  { 254, 5, 5, 7, 1, -5 },
  { 258, 4, 5, 4, 0, -5 },
  { 261, 4, 5, 5, 0, -5 },
  { 264, 3, 7, 4, 1, -5 },
  { 267, 4, 7, 4, 0, -5 },
  { 271, 2, 5, 3, 1, -5 },
  { 273, 4, 5, 4, 0, -5 },
  { 276, 2, 6, 3, 0, -6 },
  { 278, 4, 5, 4, 0, -5 },
  { 281, 4, 5, 4, 0, -5 },
  { 284, 6, 5, 6, 0, -5 },
  { 288, 4, 5, 4, 0, -5 },
  { 291, 4, 7, 4, 0, -5 },
  { 295, 4, 5, 4, 0, -5 },
  { 298, 3, 9, 3, 0, -7 },
  { 302, 1, 8, 2, 1, -7 },
  { 303, 2, 9, 3, 0, -7 },
  { 306, 5, 2, 5, 0, -4 },
};

const GFXfont RobotoCondensed_Medium9pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium9pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOCONDENSED_MEDIUM9PT7B_H_
