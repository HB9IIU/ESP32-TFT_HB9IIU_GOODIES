#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/RobotoCondensed_Medium
// Headers: 67

#include "RobotoCondensed_Medium6pt7b.h"
#include "RobotoCondensed_Medium7pt7b.h"
#include "RobotoCondensed_Medium8pt7b.h"
#include "RobotoCondensed_Medium9pt7b.h"
#include "RobotoCondensed_Medium10pt7b.h"
#include "RobotoCondensed_Medium11pt7b.h"
#include "RobotoCondensed_Medium12pt7b.h"
#include "RobotoCondensed_Medium13pt7b.h"
#include "RobotoCondensed_Medium14pt7b.h"
#include "RobotoCondensed_Medium15pt7b.h"
#include "RobotoCondensed_Medium16pt7b.h"
#include "RobotoCondensed_Medium17pt7b.h"
#include "RobotoCondensed_Medium18pt7b.h"
#include "RobotoCondensed_Medium19pt7b.h"
#include "RobotoCondensed_Medium20pt7b.h"
#include "RobotoCondensed_Medium21pt7b.h"
#include "RobotoCondensed_Medium22pt7b.h"
#include "RobotoCondensed_Medium23pt7b.h"
#include "RobotoCondensed_Medium24pt7b.h"
#include "RobotoCondensed_Medium25pt7b.h"
#include "RobotoCondensed_Medium26pt7b.h"
#include "RobotoCondensed_Medium27pt7b.h"
#include "RobotoCondensed_Medium28pt7b.h"
#include "RobotoCondensed_Medium29pt7b.h"
#include "RobotoCondensed_Medium30pt7b.h"
#include "RobotoCondensed_Medium31pt7b.h"
#include "RobotoCondensed_Medium32pt7b.h"
#include "RobotoCondensed_Medium33pt7b.h"
#include "RobotoCondensed_Medium34pt7b.h"
#include "RobotoCondensed_Medium35pt7b.h"
#include "RobotoCondensed_Medium36pt7b.h"
#include "RobotoCondensed_Medium37pt7b.h"
#include "RobotoCondensed_Medium38pt7b.h"
#include "RobotoCondensed_Medium39pt7b.h"
#include "RobotoCondensed_Medium40pt7b.h"
#include "RobotoCondensed_Medium41pt7b.h"
#include "RobotoCondensed_Medium42pt7b.h"
#include "RobotoCondensed_Medium43pt7b.h"
#include "RobotoCondensed_Medium44pt7b.h"
#include "RobotoCondensed_Medium45pt7b.h"
#include "RobotoCondensed_Medium46pt7b.h"
#include "RobotoCondensed_Medium47pt7b.h"
#include "RobotoCondensed_Medium48pt7b.h"
#include "RobotoCondensed_Medium49pt7b.h"
#include "RobotoCondensed_Medium50pt7b.h"
#include "RobotoCondensed_Medium51pt7b.h"
#include "RobotoCondensed_Medium52pt7b.h"
#include "RobotoCondensed_Medium53pt7b.h"
#include "RobotoCondensed_Medium54pt7b.h"
#include "RobotoCondensed_Medium55pt7b.h"
#include "RobotoCondensed_Medium56pt7b.h"
#include "RobotoCondensed_Medium57pt7b.h"
#include "RobotoCondensed_Medium58pt7b.h"
#include "RobotoCondensed_Medium59pt7b.h"
#include "RobotoCondensed_Medium60pt7b.h"
#include "RobotoCondensed_Medium61pt7b.h"
#include "RobotoCondensed_Medium62pt7b.h"
#include "RobotoCondensed_Medium63pt7b.h"
#include "RobotoCondensed_Medium64pt7b.h"
#include "RobotoCondensed_Medium65pt7b.h"
#include "RobotoCondensed_Medium66pt7b.h"
#include "RobotoCondensed_Medium67pt7b.h"
#include "RobotoCondensed_Medium68pt7b.h"
#include "RobotoCondensed_Medium69pt7b.h"
#include "RobotoCondensed_Medium70pt7b.h"
#include "RobotoCondensed_Medium71pt7b.h"
#include "RobotoCondensed_Medium72pt7b.h"
