#ifndef _ROBOTOCONDENSED_MEDIUM52PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium52pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBE, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFD, 0xFB, 0xF7, 0xC2, 0x00, 0xF8,
  0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xEF, 0x8F, 0x7C, 0x7B, 0xE3, 0xDF, 0x1E,
  0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x00, 0x00, 0xF0, 0x78,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE1, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x87, 0x83, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x81, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87,
  0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF0, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x03,
  0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7,
  0xF0, 0x7E, 0x7E, 0x07, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F,
  0x7E, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x0F, 0x81, 0x80, 0xF0, 0x78, 0x1E, 0x0F,
  0x07, 0x83, 0xC0, 0xF0, 0x78, 0x38, 0x0F, 0x07, 0x87, 0x80, 0xF0, 0x78,
  0xF0, 0x0F, 0x07, 0x8F, 0x00, 0xF0, 0xF9, 0xE0, 0x0F, 0x9F, 0x1E, 0x00,
  0x7F, 0xF3, 0xC0, 0x07, 0xFE, 0x3C, 0x00, 0x1F, 0xC7, 0x80, 0x00, 0x20,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x7F, 0x80, 0x03, 0xCF, 0xFC, 0x00,
  0x78, 0xFF, 0xE0, 0x07, 0x9F, 0x3E, 0x00, 0xF1, 0xE1, 0xE0, 0x0F, 0x3E,
  0x0F, 0x01, 0xE3, 0xC0, 0xF0, 0x3C, 0x3C, 0x0F, 0x03, 0xC3, 0xC0, 0xF0,
  0x78, 0x3C, 0x0F, 0x07, 0x83, 0xE0, 0xF0, 0x70, 0x1E, 0x1E, 0x03, 0x01,
  0xF3, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x7C, 0x00,
  0x3F, 0x1F, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x3F, 0x0F, 0xDF, 0xC7, 0xE3, 0xF1, 0xF8,
  0xF8, 0x7E, 0x3F, 0x9F, 0x1F, 0x83, 0xFB, 0xE3, 0xF0, 0x3F, 0xFC, 0x7E,
  0x07, 0xFF, 0x8F, 0xC0, 0x7F, 0xE1, 0xF8, 0x07, 0xFC, 0x3F, 0x80, 0x7F,
  0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xF9, 0xFC, 0x07, 0xFC, 0x3F,
  0x80, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF,
  0x00, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0,
  0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x00, 0x20, 0x40, 0x03, 0x80,
  0x1E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x1E, 0x00, 0xE0, 0x04, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x06, 0x07, 0x81, 0x1E, 0x1E, 0x3E, 0xFF, 0x7B,
  0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xF7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E,
  0x3E, 0x01, 0xF0, 0x7C, 0x07, 0x80, 0xF8, 0x0E, 0x03, 0x80, 0x10, 0x04,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0xF8,
  0xF8, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x7E,
  0xFF, 0xFF, 0x7E, 0x7E, 0x10, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0x0F, 0xE7,
  0xE0, 0x7E, 0x7C, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xE7,
  0xE0, 0x7E, 0x7F, 0x0F, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x18, 0x03, 0xC0,
  0x7E, 0x1F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC7, 0xF0, 0x7F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xFB, 0xF0, 0x07,
  0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xEF, 0xF1, 0xFC, 0x1F,
  0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x7F, 0x7F, 0x07, 0xF3, 0xFE, 0xFF, 0x8F,
  0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0x7E, 0x00, 0x7D, 0xF8, 0x03, 0xE7,
  0xE0, 0x0F, 0x9F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF8, 0x0F, 0x87, 0xE0,
  0x3E, 0x1F, 0x81, 0xF0, 0x7E, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xE1, 0xF8,
  0x1F, 0x87, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x3F, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0x83, 0xFC, 0x38, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xE0, 0xFE, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x10, 0x00, 0x00,
  0x1F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x3F, 0x03,
  0xF7, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xC3,
  0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xF7, 0xE0, 0x1F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE,
  0x7F, 0x0F, 0xE7, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE3, 0xF0,
  0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC7, 0xF0, 0xFE, 0x7E, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0xFC, 0x1F, 0x8F, 0xE0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0,
  0x1F, 0x9F, 0x80, 0x7E, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xEF, 0x80, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80,
  0xFE, 0xFE, 0x07, 0xF3, 0xF8, 0x7F, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x07, 0xFD, 0xF0, 0x1F, 0x8F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x7E, 0xFE, 0xFF, 0x7E, 0x7E, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x7E, 0xFF, 0xFF, 0x7E, 0x7E, 0x10, 0x1F, 0x1F, 0xCF, 0xE7,
  0xF3, 0xF8, 0xF8, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC, 0x7C, 0x7E, 0x3E, 0x1E, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F,
  0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F,
  0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x1F,
  0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x38,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F,
  0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0xBF, 0x87, 0xF7, 0xE0, 0x7E, 0xFC,
  0x0F, 0xDF, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x20,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x03, 0xC1, 0xF0, 0x07, 0xE0, 0x3C, 0x1E, 0x01, 0xFF, 0x01, 0xC3,
  0xE0, 0x3F, 0xFC, 0x1E, 0x3C, 0x07, 0xFF, 0xC1, 0xE3, 0xC0, 0x7C, 0x3C,
  0x1E, 0x3C, 0x0F, 0x87, 0xC0, 0xE7, 0x80, 0xF0, 0x7C, 0x0E, 0x78, 0x1F,
  0x07, 0xC0, 0xE7, 0x81, 0xE0, 0x78, 0x0F, 0x78, 0x1E, 0x07, 0x80, 0xF7,
  0x83, 0xE0, 0x78, 0x0F, 0x78, 0x3E, 0x07, 0x80, 0xF7, 0x83, 0xE0, 0x78,
  0x0F, 0xF8, 0x3C, 0x07, 0x80, 0xEF, 0x83, 0xC0, 0x78, 0x0E, 0xF8, 0x3C,
  0x07, 0x81, 0xEF, 0x83, 0xC0, 0x78, 0x1E, 0x78, 0x3C, 0x0F, 0x81, 0xE7,
  0x83, 0xE0, 0xF8, 0x1C, 0x78, 0x3E, 0x0F, 0x83, 0xC7, 0x83, 0xE1, 0xF8,
  0x3C, 0x78, 0x3F, 0xFF, 0xCF, 0x87, 0x81, 0xFF, 0xFF, 0xF0, 0x7C, 0x0F,
  0xF3, 0xFE, 0x03, 0xC0, 0x7E, 0x1F, 0xC0, 0x3C, 0x01, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x80, 0x00, 0x3F, 0x80, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F, 0x9F, 0x80,
  0x00, 0xFC, 0x7C, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x03,
  0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0xC0,
  0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x83, 0xF8, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFD, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xC0, 0x7F, 0xBF, 0x80, 0x7F,
  0x7F, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7,
  0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0xFE, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xCF, 0xE0, 0x1F, 0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0x7F, 0x01, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFE, 0x03,
  0xF8, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x80,
  0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF3, 0xF0, 0x01,
  0xF9, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xF8, 0xFE,
  0x01, 0xFC, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFC, 0xFE,
  0x01, 0xFC, 0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xCF, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0xFE, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x03, 0xFB, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x3F,
  0xC0, 0x7F, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x30, 0x00, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x01, 0xFD, 0xF8, 0x0F, 0xCF,
  0xE0, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x3F, 0xE0, 0x00, 0x10, 0x00, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x1F,
  0xCF, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F,
  0x87, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x00,
  0x3F, 0x9F, 0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xF9, 0xF8, 0x03, 0xFC, 0x7F, 0x00,
  0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x07, 0xF3,
  0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xDF, 0x00, 0x7F, 0xFF, 0xEF, 0x80,
  0x3E, 0xFF, 0xF7, 0xE0, 0x1F, 0x7F, 0xF9, 0xF0, 0x1F, 0xBF, 0xFC, 0xF8,
  0x0F, 0x9F, 0xFE, 0x7E, 0x07, 0xCF, 0xFF, 0x3F, 0x07, 0xE7, 0xFF, 0x8F,
  0x83, 0xE3, 0xFF, 0xC7, 0xE1, 0xF1, 0xFF, 0xE3, 0xF0, 0xF8, 0xFF, 0xF0,
  0xF8, 0xF8, 0x7F, 0xF8, 0x7C, 0x7C, 0x3F, 0xFC, 0x3F, 0x3E, 0x1F, 0xFE,
  0x0F, 0xBF, 0x0F, 0xFF, 0x07, 0xDF, 0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF,
  0xC0, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F,
  0xF8, 0x0F, 0xF0, 0x3F, 0xFC, 0x07, 0xF0, 0x1F, 0xFE, 0x03, 0xF8, 0x0F,
  0xFF, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0xC0, 0x3E, 0x01,
  0xF8, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFD, 0xF8, 0x0F, 0xFF, 0x3E, 0x03, 0xFF, 0xCF,
  0xC0, 0xFF, 0xF1, 0xF0, 0x3F, 0xFC, 0x7E, 0x0F, 0xFF, 0x0F, 0x83, 0xFF,
  0xC3, 0xF0, 0xFF, 0xF0, 0x7C, 0x3F, 0xFC, 0x1F, 0x8F, 0xFF, 0x03, 0xE3,
  0xFF, 0xC0, 0xFC, 0xFF, 0xF0, 0x1F, 0x3F, 0xFC, 0x07, 0xEF, 0xFF, 0x00,
  0xFB, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFC, 0x0F,
  0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xEF, 0xE0,
  0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x1F,
  0x9F, 0x80, 0x0F, 0xE7, 0xE0, 0x03, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0xC0,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE,
  0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xF8, 0x0F, 0xE1, 0xFC,
  0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFB,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01,
  0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0,
  0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x9F, 0x80,
  0x0F, 0xE7, 0xE0, 0x03, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x9F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFC, 0xFE,
  0x01, 0xFC, 0xFE, 0x07, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xC0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE,
  0x00, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0x81, 0xFC, 0x7F,
  0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7F, 0x80, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFE, 0x00,
  0x7E, 0x7E, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8,
  0x1F, 0x80, 0x3F, 0x81, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x9F,
  0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x00,
  0x7E, 0xFC, 0x01, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0xC0, 0x3F, 0x3F, 0x00,
  0xFE, 0x01, 0xF8, 0xFC, 0x07, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0xC0, 0x7E,
  0x3F, 0x03, 0xFE, 0x03, 0xE1, 0xF8, 0x1F, 0xF0, 0x3F, 0x0F, 0xC0, 0xFF,
  0xC1, 0xF8, 0x3E, 0x07, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0xF0, 0x7E, 0x0F,
  0xC3, 0xEF, 0x83, 0xF0, 0x7E, 0x1F, 0x7C, 0x1F, 0x03, 0xF0, 0xF9, 0xF1,
  0xF8, 0x0F, 0x87, 0xCF, 0x8F, 0xC0, 0x7C, 0x3E, 0x7C, 0x7E, 0x03, 0xF3,
  0xE3, 0xE3, 0xF0, 0x1F, 0x9F, 0x1F, 0x1F, 0x00, 0xFC, 0xF8, 0x7C, 0xF8,
  0x03, 0xE7, 0xC3, 0xEF, 0xC0, 0x1F, 0x3C, 0x1F, 0x7E, 0x00, 0xFB, 0xE0,
  0xFB, 0xF0, 0x07, 0xFF, 0x03, 0xDF, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x3F,
  0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFB, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0xFE, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0xFC, 0x00,
  0xFE, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xF7, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x07,
  0xE1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF8,
  0x0F, 0x3C, 0x0F, 0x9E, 0x07, 0xCF, 0x83, 0xC3, 0xC3, 0xE1, 0xE1, 0xF0,
  0xF8, 0xF0, 0x7C, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x03,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F,
  0xCF, 0xF1, 0xFC, 0x1F, 0x8F, 0xC0, 0x7E, 0x7E, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0x83, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFD,
  0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF8, 0x1F, 0xCF, 0xF7,
  0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFE, 0xFC, 0x1F, 0xE7, 0xF0,
  0x18, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xCF,
  0xF0, 0x7E, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7,
  0xF0, 0x3F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F,
  0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xF0, 0x3F, 0xBF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0x7E, 0xFF, 0xC3, 0xE3, 0xFC, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x7F, 0x07, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x1F, 0x7E, 0x01, 0xF7, 0xE0, 0x3F, 0x7F, 0x03, 0xF3, 0xFD, 0xFE,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x20,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x83, 0xF0, 0x7F, 0x9F, 0x8F,
  0xFE, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xF8, 0x3F,
  0xDF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x3F, 0x7E, 0x03, 0xFB, 0xF8, 0x3F, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x87, 0xFE, 0xFC, 0x1F, 0xE7, 0xE0, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x01, 0xF3, 0xF0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x31, 0xFC, 0x03, 0x87, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x01, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F,
  0xE1, 0xFF, 0xC3, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF,
  0xF8, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x40, 0x00, 0x3F, 0xC7, 0xC3,
  0xFF, 0x7E, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFC, 0x0F,
  0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xE0,
  0x1F, 0xBF, 0x00, 0xFD, 0xFC, 0x0F, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0x7E, 0x0F, 0xF3, 0xF0, 0x04, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x18, 0x03, 0xF0, 0xF0, 0x3F, 0x8F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xCF, 0xF1, 0xFB, 0xFF, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xF8, 0x30, 0xFB,
  0xF7, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0x07, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0x80, 0x00, 0x03, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x7F, 0xFF, 0xFF, 0xEF, 0xF3, 0xFC, 0xFC, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0x7E, 0x07, 0xF3, 0xF0,
  0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0x3F, 0x87, 0xE3, 0xF8, 0x3F, 0x1F, 0x81,
  0xF9, 0xFC, 0x0F, 0xDF, 0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xE7, 0xE0, 0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x1F,
  0x87, 0xE0, 0xFE, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0xCF, 0xC0, 0x7F, 0x7E,
  0x03, 0xFB, 0xF0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x08, 0x00, 0x40, 0x7E, 0x7F, 0x83, 0xFC, 0x3F, 0x7F, 0xE3, 0xFF, 0x9F,
  0xFF, 0xFB, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB,
  0xF8, 0x3F, 0xE0, 0xFD, 0xF8, 0x0F, 0xE0, 0x7F, 0xFC, 0x07, 0xF0, 0x1F,
  0xFE, 0x03, 0xF0, 0x0F, 0xFF, 0x01, 0xF8, 0x07, 0xFF, 0x80, 0xFC, 0x03,
  0xFF, 0xC0, 0x7E, 0x01, 0xFF, 0xE0, 0x3F, 0x00, 0xFF, 0xF0, 0x1F, 0x80,
  0x7F, 0xF8, 0x0F, 0xC0, 0x3F, 0xFC, 0x07, 0xE0, 0x1F, 0xFE, 0x03, 0xF0,
  0x0F, 0xFF, 0x01, 0xF8, 0x07, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0xC0, 0x7E,
  0x01, 0xFF, 0xE0, 0x3F, 0x00, 0xFF, 0xF0, 0x1F, 0x80, 0x7F, 0xF8, 0x0F,
  0xC0, 0x3F, 0xFC, 0x07, 0xE0, 0x1F, 0xFE, 0x03, 0xF0, 0x0F, 0xFF, 0x01,
  0xF8, 0x07, 0xFF, 0x80, 0xFC, 0x03, 0xF0, 0x00, 0x08, 0x1F, 0x1F, 0xE3,
  0xF7, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xF0, 0x3F, 0x9F, 0x80, 0x7E,
  0x7E, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0x7E, 0x01, 0xF9,
  0xF8, 0x07, 0xE7, 0xF0, 0x3F, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x07, 0xC7, 0xF8, 0x3F, 0x7F, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xF8, 0x1F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F,
  0xBF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF8, 0x1F, 0xDF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0x7F, 0xE1, 0xF9, 0xFE, 0x0F,
  0xC1, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xC7, 0xFF,
  0x7E, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFC, 0x0F, 0xEF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F,
  0xBF, 0x00, 0xFD, 0xFC, 0x0F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC7, 0xFF, 0x7E, 0x0F, 0xF3, 0xF0, 0x0C, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0x3F,
  0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x81, 0xFB, 0xFC, 0x7F, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8,
  0x7F, 0xFE, 0x03, 0xFF, 0x00, 0x04, 0x00, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x07,
  0xF8, 0x1F, 0xC0, 0x10, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0x7C, 0x3F, 0xCF, 0x80, 0x80, 0x00, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F,
  0x1F, 0x03, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x7E, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x07,
  0xC0, 0x7F, 0xF8, 0x0F, 0x80, 0xFD, 0xF0, 0x1F, 0x01, 0xFB, 0xE0, 0x3F,
  0x03, 0xE7, 0xE0, 0xFE, 0x07, 0xCF, 0xC1, 0xFC, 0x1F, 0x8F, 0x83, 0xF8,
  0x3F, 0x1F, 0x07, 0xF8, 0x7E, 0x3E, 0x1F, 0xF0, 0xF8, 0x7E, 0x3F, 0xE1,
  0xF0, 0xFC, 0x7B, 0xE7, 0xE0, 0xF9, 0xF7, 0xCF, 0xC1, 0xF3, 0xEF, 0x9F,
  0x03, 0xE7, 0xCF, 0x3E, 0x07, 0xEF, 0x1F, 0x7C, 0x07, 0xFE, 0x3F, 0xF8,
  0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80,
  0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x01,
  0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07,
  0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x7E, 0x03, 0xFB, 0xF0, 0x1F,
  0x8F, 0xC1, 0xFC, 0x7E, 0x0F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0x3F,
  0x3E, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x00,
  0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x03,
  0xF3, 0xF0, 0x1F, 0xBF, 0x80, 0xFE, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xBF,
  0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x1F,
  0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x3F,
  0x1F, 0x01, 0xF9, 0xF8, 0x07, 0xCF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x20, 0x0F, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0,
  0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x01, 0xF8,
  0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x03,
  0xC0, 0x1F, 0x01, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x1F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0xE0,
  0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F,
  0x03, 0xF8, 0x0F, 0x80, 0x70, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xE0, 0x1F, 0x3F, 0xF0, 0x1F, 0x7F, 0xF8, 0x1F, 0x7F, 0xFC, 0x1F, 0xFC,
  0xFE, 0x3E, 0xF8, 0x3F, 0xFE, 0xF8, 0x1F, 0xFC, 0xF8, 0x0F, 0xFC, 0xF0,
  0x07, 0xF8, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoCondensed_Medium52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 38, 13, 3, -37 },
  { 35, 13, 13, 17, 2, -39 },
  { 57, 23, 37, 28, 3, -37 },
  { 164, 20, 49, 26, 3, -43 },
  { 287, 28, 39, 33, 3, -38 },
  { 424, 27, 39, 29, 2, -38 },
  { 556, 5, 13, 9, 2, -39 },
  { 565, 12, 53, 17, 3, -41 },
  { 645, 13, 53, 17, 1, -41 },
  { 732, 22, 22, 23, 1, -37 },
  { 793, 21, 27, 25, 2, -31 },
  { 864, 8, 14, 12, 1, -6 },
  { 878, 12, 5, 16, 2, -18 },
  { 886, 8, 7, 14, 3, -6 },
  { 893, 17, 40, 18, 0, -37 },
  { 978, 20, 39, 26, 3, -38 },
  { 1076, 13, 37, 26, 4, -37 },
  { 1137, 22, 38, 26, 2, -38 },
  { 1242, 21, 39, 26, 2, -38 },
  { 1345, 22, 37, 26, 2, -37 },
  { 1447, 21, 38, 26, 3, -37 },
  { 1547, 21, 38, 26, 3, -37 },
  { 1647, 22, 37, 26, 2, -37 },
  { 1749, 20, 39, 26, 3, -38 },
  { 1847, 21, 38, 26, 2, -38 },
  { 1947, 8, 29, 13, 3, -28 },
  { 1976, 9, 36, 12, 1, -28 },
  { 2017, 18, 24, 23, 2, -28 },
  { 2071, 18, 16, 26, 4, -25 },
  { 2107, 19, 24, 24, 3, -28 },
  { 2164, 19, 39, 23, 2, -38 },
  { 2257, 36, 48, 40, 2, -36 },
  { 2473, 29, 37, 31, 1, -37 },
  { 2608, 23, 37, 29, 3, -37 },
  { 2715, 25, 39, 30, 3, -38 },
  { 2837, 24, 37, 30, 3, -37 },
  { 2948, 21, 37, 26, 3, -37 },
  { 3046, 20, 37, 25, 3, -37 },
  { 3139, 25, 39, 31, 3, -38 },
  { 3261, 26, 37, 32, 3, -37 },
  { 3382, 6, 37, 14, 4, -37 },
  { 3410, 21, 38, 25, 1, -37 },
  { 3510, 26, 37, 29, 3, -37 },
  { 3631, 20, 37, 25, 3, -37 },
  { 3724, 33, 37, 39, 3, -37 },
  { 3877, 26, 37, 32, 3, -37 },
  { 3998, 26, 39, 31, 3, -38 },
  { 4125, 24, 37, 29, 3, -37 },
  { 4236, 26, 44, 31, 3, -38 },
  { 4379, 24, 37, 28, 3, -37 },
  { 4490, 24, 39, 28, 2, -38 },
  { 4607, 25, 37, 28, 1, -37 },
  { 4723, 24, 38, 29, 3, -37 },
  { 4837, 28, 37, 30, 1, -37 },
  { 4967, 37, 37, 39, 1, -37 },
  { 5139, 27, 37, 29, 1, -37 },
  { 5264, 26, 37, 28, 1, -37 },
  { 5385, 24, 37, 27, 2, -37 },
  { 5496, 9, 51, 13, 3, -43 },
  { 5554, 19, 40, 20, 1, -37 },
  { 5649, 9, 51, 13, 1, -43 },
  { 5707, 17, 18, 20, 1, -37 },
  { 5746, 19, 5, 21, 1, 0 },
  { 5758, 12, 8, 17, 1, -39 },
  { 5770, 21, 29, 25, 2, -28 },
  { 5847, 21, 40, 26, 3, -39 },
  { 5952, 20, 29, 24, 2, -28 },
  { 6025, 21, 40, 26, 2, -39 },
  { 6130, 21, 29, 25, 2, -28 },
  { 6207, 15, 40, 17, 1, -40 },
  { 6282, 21, 39, 26, 2, -28 },
  { 6385, 19, 39, 25, 3, -39 },
  { 6478, 7, 38, 13, 3, -38 },
  { 6512, 10, 49, 12, -1, -38 },
  { 6574, 21, 39, 24, 3, -39 },
  { 6677, 6, 39, 13, 3, -39 },
  { 6707, 33, 28, 39, 3, -28 },
  { 6823, 19, 28, 25, 3, -28 },
  { 6890, 22, 29, 26, 2, -28 },
  { 6970, 21, 39, 26, 3, -28 },
  { 7073, 21, 39, 26, 2, -28 },
  { 7176, 13, 28, 17, 3, -28 },
  { 7222, 19, 29, 24, 2, -28 },
  { 7291, 13, 35, 16, 1, -34 },
  { 7348, 19, 28, 25, 3, -27 },
  { 7415, 21, 27, 23, 1, -27 },
  { 7486, 31, 27, 33, 1, -27 },
  { 7591, 21, 27, 23, 1, -27 },
  { 7662, 21, 38, 22, 1, -27 },
  { 7762, 19, 27, 23, 2, -27 },
  { 7827, 12, 50, 16, 2, -41 },
  { 7902, 5, 44, 13, 4, -37 },
  { 7930, 13, 50, 16, 1, -41 },
  { 8012, 24, 11, 30, 3, -21 },
};

const GFXfont RobotoCondensed_Medium52pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium52pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium52pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOCONDENSED_MEDIUM52PT7B_H_
