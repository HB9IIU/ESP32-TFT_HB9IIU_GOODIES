#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &RobotoCondensed_Medium6pt7b, 6, "RobotoCondensed_Medium6pt7b" },
  { &RobotoCondensed_Medium7pt7b, 7, "RobotoCondensed_Medium7pt7b" },
  { &RobotoCondensed_Medium8pt7b, 8, "RobotoCondensed_Medium8pt7b" },
  { &RobotoCondensed_Medium9pt7b, 9, "RobotoCondensed_Medium9pt7b" },
  { &RobotoCondensed_Medium10pt7b, 10, "RobotoCondensed_Medium10pt7b" },
  { &RobotoCondensed_Medium11pt7b, 11, "RobotoCondensed_Medium11pt7b" },
  { &RobotoCondensed_Medium12pt7b, 12, "RobotoCondensed_Medium12pt7b" },
  { &RobotoCondensed_Medium13pt7b, 13, "RobotoCondensed_Medium13pt7b" },
  { &RobotoCondensed_Medium14pt7b, 14, "RobotoCondensed_Medium14pt7b" },
  { &RobotoCondensed_Medium15pt7b, 15, "RobotoCondensed_Medium15pt7b" },
  { &RobotoCondensed_Medium16pt7b, 16, "RobotoCondensed_Medium16pt7b" },
  { &RobotoCondensed_Medium17pt7b, 17, "RobotoCondensed_Medium17pt7b" },
  { &RobotoCondensed_Medium18pt7b, 18, "RobotoCondensed_Medium18pt7b" },
  { &RobotoCondensed_Medium19pt7b, 19, "RobotoCondensed_Medium19pt7b" },
  { &RobotoCondensed_Medium20pt7b, 20, "RobotoCondensed_Medium20pt7b" },
  { &RobotoCondensed_Medium21pt7b, 21, "RobotoCondensed_Medium21pt7b" },
  { &RobotoCondensed_Medium22pt7b, 22, "RobotoCondensed_Medium22pt7b" },
  { &RobotoCondensed_Medium23pt7b, 23, "RobotoCondensed_Medium23pt7b" },
  { &RobotoCondensed_Medium24pt7b, 24, "RobotoCondensed_Medium24pt7b" },
  { &RobotoCondensed_Medium25pt7b, 25, "RobotoCondensed_Medium25pt7b" },
  { &RobotoCondensed_Medium26pt7b, 26, "RobotoCondensed_Medium26pt7b" },
  { &RobotoCondensed_Medium27pt7b, 27, "RobotoCondensed_Medium27pt7b" },
  { &RobotoCondensed_Medium28pt7b, 28, "RobotoCondensed_Medium28pt7b" },
  { &RobotoCondensed_Medium29pt7b, 29, "RobotoCondensed_Medium29pt7b" },
  { &RobotoCondensed_Medium30pt7b, 30, "RobotoCondensed_Medium30pt7b" },
  { &RobotoCondensed_Medium31pt7b, 31, "RobotoCondensed_Medium31pt7b" },
  { &RobotoCondensed_Medium32pt7b, 32, "RobotoCondensed_Medium32pt7b" },
  { &RobotoCondensed_Medium33pt7b, 33, "RobotoCondensed_Medium33pt7b" },
  { &RobotoCondensed_Medium34pt7b, 34, "RobotoCondensed_Medium34pt7b" },
  { &RobotoCondensed_Medium35pt7b, 35, "RobotoCondensed_Medium35pt7b" },
  { &RobotoCondensed_Medium36pt7b, 36, "RobotoCondensed_Medium36pt7b" },
  { &RobotoCondensed_Medium37pt7b, 37, "RobotoCondensed_Medium37pt7b" },
  { &RobotoCondensed_Medium38pt7b, 38, "RobotoCondensed_Medium38pt7b" },
  { &RobotoCondensed_Medium39pt7b, 39, "RobotoCondensed_Medium39pt7b" },
  { &RobotoCondensed_Medium40pt7b, 40, "RobotoCondensed_Medium40pt7b" },
  { &RobotoCondensed_Medium41pt7b, 41, "RobotoCondensed_Medium41pt7b" },
  { &RobotoCondensed_Medium42pt7b, 42, "RobotoCondensed_Medium42pt7b" },
  { &RobotoCondensed_Medium43pt7b, 43, "RobotoCondensed_Medium43pt7b" },
  { &RobotoCondensed_Medium44pt7b, 44, "RobotoCondensed_Medium44pt7b" },
  { &RobotoCondensed_Medium45pt7b, 45, "RobotoCondensed_Medium45pt7b" },
  { &RobotoCondensed_Medium46pt7b, 46, "RobotoCondensed_Medium46pt7b" },
  { &RobotoCondensed_Medium47pt7b, 47, "RobotoCondensed_Medium47pt7b" },
  { &RobotoCondensed_Medium48pt7b, 48, "RobotoCondensed_Medium48pt7b" },
  { &RobotoCondensed_Medium49pt7b, 49, "RobotoCondensed_Medium49pt7b" },
  { &RobotoCondensed_Medium50pt7b, 50, "RobotoCondensed_Medium50pt7b" },
  { &RobotoCondensed_Medium51pt7b, 51, "RobotoCondensed_Medium51pt7b" },
  { &RobotoCondensed_Medium52pt7b, 52, "RobotoCondensed_Medium52pt7b" },
  { &RobotoCondensed_Medium53pt7b, 53, "RobotoCondensed_Medium53pt7b" },
  { &RobotoCondensed_Medium54pt7b, 54, "RobotoCondensed_Medium54pt7b" },
  { &RobotoCondensed_Medium55pt7b, 55, "RobotoCondensed_Medium55pt7b" },
  { &RobotoCondensed_Medium56pt7b, 56, "RobotoCondensed_Medium56pt7b" },
  { &RobotoCondensed_Medium57pt7b, 57, "RobotoCondensed_Medium57pt7b" },
  { &RobotoCondensed_Medium58pt7b, 58, "RobotoCondensed_Medium58pt7b" },
  { &RobotoCondensed_Medium59pt7b, 59, "RobotoCondensed_Medium59pt7b" },
  { &RobotoCondensed_Medium60pt7b, 60, "RobotoCondensed_Medium60pt7b" },
  { &RobotoCondensed_Medium61pt7b, 61, "RobotoCondensed_Medium61pt7b" },
  { &RobotoCondensed_Medium62pt7b, 62, "RobotoCondensed_Medium62pt7b" },
  { &RobotoCondensed_Medium63pt7b, 63, "RobotoCondensed_Medium63pt7b" },
  { &RobotoCondensed_Medium64pt7b, 64, "RobotoCondensed_Medium64pt7b" },
  { &RobotoCondensed_Medium65pt7b, 65, "RobotoCondensed_Medium65pt7b" },
  { &RobotoCondensed_Medium66pt7b, 66, "RobotoCondensed_Medium66pt7b" },
  { &RobotoCondensed_Medium67pt7b, 67, "RobotoCondensed_Medium67pt7b" },
  { &RobotoCondensed_Medium68pt7b, 68, "RobotoCondensed_Medium68pt7b" },
  { &RobotoCondensed_Medium69pt7b, 69, "RobotoCondensed_Medium69pt7b" },
  { &RobotoCondensed_Medium70pt7b, 70, "RobotoCondensed_Medium70pt7b" },
  { &RobotoCondensed_Medium71pt7b, 71, "RobotoCondensed_Medium71pt7b" },
  { &RobotoCondensed_Medium72pt7b, 72, "RobotoCondensed_Medium72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
