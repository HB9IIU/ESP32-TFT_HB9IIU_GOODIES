#ifndef _ROBOTOCONDENSED_MEDIUM37PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium37pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xC0, 0x00, 0x39, 0xFF, 0x7B, 0x80, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xC7, 0xC7, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x00, 0x63, 0x80,
  0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF,
  0xC1, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C,
  0x60, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC3, 0x8E, 0x01, 0xC7, 0x00,
  0xE3, 0x00, 0x63, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x7C, 0x03, 0xFE, 0x0F, 0xFE,
  0x3F, 0xFE, 0x7C, 0x7C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xF7, 0x80, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x79,
  0xFF, 0xF3, 0xFF, 0xC3, 0xFF, 0x01, 0xFC, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0E, 0x38, 0x20, 0xE3,
  0x87, 0x0E, 0x18, 0x60, 0xE1, 0x8E, 0x0E, 0x38, 0xC0, 0xE3, 0x9C, 0x0F,
  0xFB, 0x80, 0x7F, 0x38, 0x03, 0xE7, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xC7, 0x80, 0x1C, 0xFE, 0x01, 0x9F, 0xE0, 0x39, 0xC7, 0x07, 0x38,
  0x70, 0x73, 0x87, 0x0E, 0x38, 0x70, 0xE3, 0x87, 0x1C, 0x1C, 0x70, 0x41,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x07, 0xC0, 0x07, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x3C, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0,
  0x3C, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0xE1, 0xE7, 0xFC, 0x7B, 0xEF, 0x9E, 0xF1, 0xF7, 0xBC, 0x3D, 0xCF, 0x0F,
  0xF3, 0xC1, 0xFC, 0xF0, 0x3E, 0x3E, 0x0F, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE,
  0x3F, 0xFF, 0x83, 0xF1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x01, 0x01,
  0x81, 0xE1, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x07,
  0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0,
  0xE0, 0x70, 0x3C, 0x1E, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x07,
  0x81, 0xE0, 0x70, 0x10, 0x40, 0x70, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x70,
  0x3C, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x1C, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC1,
  0xE0, 0xF0, 0x70, 0x78, 0x38, 0x38, 0x3C, 0x1C, 0x04, 0x00, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x41, 0xC0, 0x79, 0xCE, 0x7F, 0xFF,
  0x7F, 0xFF, 0x0F, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x70, 0x1E, 0x78,
  0x1C, 0x3C, 0x1C, 0x18, 0x08, 0x10, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x7B, 0xDE, 0xF7, 0xBD,
  0xFE, 0xE3, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x31, 0xEF, 0xDE, 0x78, 0x00,
  0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF,
  0xC7, 0x87, 0xDF, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xE7, 0x83, 0xCF, 0x0F, 0x9F, 0xFE,
  0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0x80, 0x00, 0x83, 0xC7, 0xFF, 0xFF, 0xFF,
  0xBF, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3E, 0x78, 0x1E,
  0x78, 0x1E, 0xF8, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7,
  0xC3, 0xEF, 0x03, 0xDE, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x03,
  0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7F, 0xC0, 0xF7, 0x81, 0xEF, 0x87, 0xDF, 0xFF, 0x1F,
  0xFE, 0x1F, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xBC, 0x07, 0xBC, 0x07, 0x3C, 0x0F,
  0x3C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x3C, 0x78,
  0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x3F, 0xFC, 0x7F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF7, 0xC1, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xC7, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x7F, 0x81, 0xF7, 0x83,
  0xEF, 0x07, 0x9F, 0xFF, 0x1F, 0xFC, 0x1F, 0xF0, 0x0F, 0x80, 0x01, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xF0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF7, 0xC3, 0xDF, 0xE7, 0xFF, 0xCF, 0xFF, 0xDF, 0x07,
  0xBE, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xF7,
  0x83, 0xEF, 0x87, 0x8F, 0xFF, 0x1F, 0xFC, 0x1F, 0xF0, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xC7, 0x87,
  0xDF, 0x07, 0xBE, 0x0F, 0x7C, 0x1E, 0x78, 0x3C, 0xF0, 0xF9, 0xFF, 0xE1,
  0xFF, 0x81, 0xFE, 0x07, 0xFF, 0x1F, 0x1E, 0x7C, 0x1E, 0xF0, 0x3D, 0xE0,
  0x7B, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xDF, 0x0F, 0x9F, 0xFF, 0x3F, 0xFC,
  0x3F, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0x78,
  0x7B, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF8, 0x7D, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x0F, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0x80,
  0x78, 0x00, 0x71, 0xEF, 0x9E, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x7B, 0xE7, 0x9E, 0x39, 0xF7, 0xDF, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xF3, 0xCF, 0x3D, 0xE7, 0x9C, 0xF1,
  0x80, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0xFF, 0x8F, 0xF1, 0xFE,
  0x1F, 0xC0, 0xF0, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFC,
  0x03, 0xE0, 0x07, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x00, 0x7C, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0x83,
  0xF8, 0x0F, 0x80, 0x38, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF,
  0x9F, 0xFE, 0xF8, 0x7B, 0xE1, 0xFF, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xF0,
  0x70, 0x00, 0x38, 0x70, 0x00, 0x0C, 0x38, 0x1F, 0x07, 0x38, 0x1F, 0xC3,
  0x9C, 0x1F, 0xF0, 0xCE, 0x1E, 0x38, 0x6E, 0x0E, 0x1C, 0x3F, 0x0F, 0x0E,
  0x1F, 0x87, 0x0F, 0x0F, 0xC3, 0x87, 0x07, 0xE3, 0xC3, 0x83, 0xF1, 0xE1,
  0xC1, 0xF8, 0xF0, 0xE0, 0xFC, 0x78, 0x70, 0x6E, 0x3C, 0x38, 0x77, 0x1E,
  0x3C, 0x3B, 0x87, 0x9E, 0x39, 0xC3, 0xFF, 0xFC, 0xE0, 0xFD, 0xFC, 0x38,
  0x38, 0x7C, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x02, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7B, 0xC0,
  0x07, 0x9E, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0xF1, 0xF0, 0x0F, 0x0F,
  0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0x78, 0x1F, 0xFF, 0x83, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7C, 0x03, 0xC7, 0x80, 0x3E, 0x78,
  0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x3D,
  0xF0, 0x1E, 0xF8, 0x0F, 0x7C, 0x0F, 0xBE, 0x1F, 0x9F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xFF, 0xF3, 0xE0, 0x7D, 0xF0, 0x1E, 0xF8, 0x0F, 0x7C, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xF7, 0xC0, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC,
  0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1E, 0x78, 0x07, 0x9F, 0x03, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F,
  0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF,
  0xCF, 0x83, 0xF7, 0xC0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xEF, 0x81,
  0xF7, 0xC1, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF,
  0xDF, 0xFF, 0xBE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xCF,
  0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x7C,
  0x0F, 0x9E, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x1F, 0xFF, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x7C,
  0x07, 0xDF, 0x81, 0xF3, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0x00, 0xFE,
  0x00, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x83, 0xDF, 0x0F, 0x9F, 0xFF, 0x1F, 0xFC, 0x1F, 0xF0,
  0x1F, 0x80, 0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0x81, 0xF3, 0xE0, 0xFC, 0xF8,
  0x3E, 0x3E, 0x1F, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF9, 0xF0, 0x3E, 0xF8,
  0x0F, 0xBE, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFC, 0xF8, 0x3E, 0x1E, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0xF8,
  0x3E, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xEF, 0xF7, 0x81, 0xEF, 0xF7, 0x81, 0xFF, 0xFF, 0x81, 0xDF, 0xFB,
  0xC3, 0xDF, 0xFB, 0xC3, 0xDF, 0xFB, 0xC3, 0xDF, 0xF9, 0xC7, 0x9F, 0xF9,
  0xE7, 0x9F, 0xF9, 0xE7, 0x9F, 0xF8, 0xE7, 0x1F, 0xF8, 0xFF, 0x1F, 0xF8,
  0xFF, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8,
  0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xBC, 0x3F, 0xEF, 0x8F, 0xF9,
  0xE3, 0xFE, 0x3C, 0xFF, 0x8F, 0x3F, 0xE1, 0xEF, 0xF8, 0x7B, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x0F, 0x9F, 0x01, 0xEF, 0x80, 0x7F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x1F, 0x7C, 0x07, 0x9F, 0x83, 0xE3, 0xFF, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF,
  0x9F, 0xFF, 0xEF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFB,
  0xFF, 0xF9, 0xFF, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7C,
  0x0F, 0x9E, 0x01, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x78,
  0x07, 0x9F, 0x03, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x10,
  0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x81, 0xF7, 0xC0,
  0x7B, 0xE0, 0x3D, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xBE, 0x03, 0xDF,
  0x03, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0xF8, 0x78,
  0x7C, 0x3E, 0x3E, 0x0F, 0x1F, 0x07, 0xCF, 0x83, 0xE7, 0xC0, 0xFB, 0xE0,
  0x7D, 0xF0, 0x1E, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xFE,
  0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xC1, 0xF3, 0xE0, 0x7D, 0xE0, 0x3E, 0xF0,
  0x0F, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFE, 0x01,
  0xEF, 0x00, 0xF7, 0x80, 0xFB, 0xE0, 0x7C, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F,
  0xFE, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFB,
  0xE0, 0xF9, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0xF0,
  0x01, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xE7, 0x80, 0x3C, 0x78, 0x03, 0xC7,
  0xC0, 0x7C, 0x3C, 0x07, 0xC3, 0xC0, 0x78, 0x3E, 0x07, 0x83, 0xE0, 0xF8,
  0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E,
  0x00, 0xF1, 0xE0, 0x07, 0xBE, 0x00, 0x7B, 0xC0, 0x07, 0xBC, 0x00, 0x7B,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x1E, 0x03, 0xFE, 0x07, 0x81, 0xF7, 0x81,
  0xE0, 0x7D, 0xE0, 0x7C, 0x1E, 0x78, 0x3F, 0x07, 0x9E, 0x0F, 0xC1, 0xE7,
  0x83, 0xF0, 0x79, 0xF0, 0xFC, 0x3E, 0x3C, 0x7F, 0x8F, 0x0F, 0x1F, 0xE3,
  0xC3, 0xC7, 0xB8, 0xF0, 0xF1, 0xCE, 0x3C, 0x3C, 0x73, 0x8F, 0x07, 0xBC,
  0xF3, 0xC1, 0xEF, 0x3D, 0xE0, 0x7B, 0xC7, 0x78, 0x1E, 0xE1, 0xDE, 0x07,
  0xB8, 0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC,
  0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC0,
  0x78, 0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3E,
  0x1F, 0x07, 0xC3, 0xE0, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0x80, 0x7D, 0xF0,
  0x0F, 0xBC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xF7, 0x80,
  0x3C, 0xF8, 0x0F, 0x8F, 0x01, 0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE3,
  0xE0, 0x7C, 0x7C, 0x07, 0xDF, 0x00, 0xF8, 0x78, 0x03, 0xEF, 0x80, 0x7D,
  0xF0, 0x0F, 0x1F, 0x03, 0xE3, 0xE0, 0x78, 0x3C, 0x1F, 0x07, 0xC3, 0xC0,
  0x78, 0x78, 0x0F, 0x1F, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xFF, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x3D, 0xC3, 0x9C, 0x39, 0xE7,
  0x8E, 0x70, 0xE7, 0x0F, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x1F, 0x7E,
  0xF8, 0x7B, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xF8, 0xFF, 0xE7, 0xFF,
  0xBE, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xFF, 0xFB, 0xFF,
  0xF7, 0xFF, 0xC7, 0x8F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF3, 0xE1, 0xEF, 0xF3, 0xFF,
  0xE7, 0xFF, 0xEF, 0x83, 0xDE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xFC,
  0x1E, 0xFF, 0xFD, 0xFF, 0xF3, 0xDF, 0xE7, 0x9F, 0x00, 0x07, 0xE0, 0x3F,
  0xF0, 0xFF, 0xF1, 0xFF, 0xE7, 0xC3, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x03, 0xDE,
  0x07, 0xBE, 0x1E, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xC0, 0x3F, 0x00, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x0F, 0x9E, 0x3F, 0xBC, 0xFF, 0xFB, 0xFF, 0xF7, 0xC3, 0xEF,
  0x03, 0xDE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBE, 0x1F, 0x7F, 0xFE, 0x7F, 0xFC,
  0x7F, 0x78, 0x7C, 0xF0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0xF8,
  0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x06, 0x7F, 0xFD, 0xFF, 0xF3,
  0xFF, 0x83, 0xF8, 0x03, 0xE1, 0xFC, 0x7F, 0x8F, 0xE1, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0xFF, 0xDF, 0xFB, 0xFF, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x0F, 0x9E, 0x3F, 0xFC, 0xFF, 0xF9,
  0xFF, 0xF7, 0xC3, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBE, 0x0F,
  0x3F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x3C, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x88, 0x1F, 0x3E, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF3, 0xE3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0x7F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0x77, 0xFF, 0xF7, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x1E, 0x1F, 0x1F, 0x0E, 0x00,
  0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1E, 0x1E, 0xFE, 0xFE, 0xFC, 0xF8, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x7D, 0xE1,
  0xF3, 0xC3, 0xE7, 0x8F, 0x8F, 0x3E, 0x1E, 0x7C, 0x3D, 0xF0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xBE, 0x1E, 0x3C, 0x3C,
  0x7C, 0x78, 0x7C, 0xF0, 0xF9, 0xE0, 0xFB, 0xC1, 0xF7, 0x81, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF3, 0xE0, 0xF9, 0xEF, 0xE7, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xE1, 0xFE, 0x07, 0x83, 0xFC, 0x0F,
  0x07, 0xF8, 0x1E, 0x0F, 0xF0, 0x3C, 0x1F, 0xE0, 0x78, 0x3F, 0xC0, 0xF0,
  0x7F, 0x81, 0xE0, 0xFF, 0x03, 0xC1, 0xFE, 0x07, 0x83, 0xFC, 0x0F, 0x07,
  0xF8, 0x1E, 0x0F, 0xF0, 0x3C, 0x1F, 0xE0, 0x78, 0x3F, 0xC0, 0xF0, 0x7F,
  0x81, 0xE0, 0xF0, 0xF3, 0xE3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0x7F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0x07, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3E,
  0x78, 0x1E, 0x78, 0x1F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x78, 0x1F, 0x7C, 0x1E, 0x3F, 0xFE,
  0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xE0, 0xF3, 0xE1, 0xEF, 0xF3, 0xFF, 0xE7,
  0xFF, 0xEF, 0x87, 0xDE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0x7C, 0x1E,
  0xFF, 0xFD, 0xFF, 0xF3, 0xDF, 0xE7, 0x9F, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F,
  0x9E, 0x3F, 0xFC, 0xFF, 0xFB, 0xFF, 0xF7, 0xC3, 0xEF, 0x03, 0xDE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xF7, 0x81, 0xEF,
  0x03, 0xDE, 0x07, 0xBE, 0x1F, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x7C,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0xF3, 0xFB, 0xFF, 0xFF, 0xFF, 0xC7, 0xC3, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xBF, 0x78, 0x3D,
  0xE0, 0xF7, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFE,
  0x00, 0x7C, 0x00, 0xFF, 0x83, 0xDE, 0x0F, 0x7E, 0xFC, 0xFF, 0xE1, 0xFF,
  0x03, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0xFF, 0xFF, 0xFF, 0xFC, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1F, 0xC7, 0xF0, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x1F,
  0x7F, 0xFD, 0xFF, 0xF3, 0xFB, 0xC7, 0xCF, 0xF0, 0x3D, 0xE0, 0x7B, 0xE0,
  0xF3, 0xC3, 0xE7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x1E, 0x38, 0x3C, 0xF0,
  0x79, 0xE0, 0x73, 0xC0, 0xF7, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x78, 0x3F,
  0xC1, 0xE0, 0xFF, 0x07, 0x87, 0x9E, 0x3E, 0x1E, 0x78, 0xFC, 0x79, 0xE3,
  0xF1, 0xE7, 0x8F, 0xC7, 0x9E, 0x7F, 0x3C, 0x39, 0xDC, 0xF0, 0xF7, 0x7B,
  0xC3, 0xDC, 0xEF, 0x0F, 0xF3, 0xB8, 0x1F, 0x8E, 0xE0, 0x7E, 0x3F, 0x81,
  0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x07, 0xC0, 0x3C, 0x1F, 0x00, 0xF0,
  0x3C, 0x03, 0xC0, 0xF0, 0xF8, 0x3C, 0xF0, 0xF9, 0xF1, 0xE1, 0xE7, 0xC3,
  0xEF, 0x03, 0xDE, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xBC, 0x1E, 0x78, 0x3C, 0x78,
  0xF8, 0xF9, 0xE1, 0xF7, 0xC1, 0xF0, 0x78, 0x1E, 0xF0, 0x3D, 0xF0, 0xFB,
  0xE1, 0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x0F, 0x3C, 0x1E, 0x78, 0x3C,
  0xF0, 0x79, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x81, 0xC1, 0xE1,
  0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x78, 0x7C, 0x7C, 0x3C, 0x1F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xE0,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x3C, 0x1F, 0x07, 0xC1, 0xE1, 0xF1,
  0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x78, 0x7C, 0x38, 0x08, 0x00, 0x1E, 0x00, 0x1F, 0xC1, 0xDF, 0xE0,
  0xEF, 0xF8, 0xFF, 0x1F, 0xFF, 0x07, 0xFB, 0x81, 0xF8, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_Medium37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 26, 9, 2, -26 },
  { 18, 8, 9, 12, 2, -28 },
  { 27, 17, 26, 20, 2, -26 },
  { 83, 15, 33, 19, 2, -30 },
  { 145, 20, 26, 24, 2, -26 },
  { 210, 18, 26, 21, 2, -26 },
  { 269, 4, 9, 6, 1, -28 },
  { 274, 9, 37, 12, 2, -29 },
  { 316, 9, 37, 12, 1, -29 },
  { 358, 16, 16, 16, 0, -26 },
  { 390, 16, 19, 18, 1, -21 },
  { 428, 5, 10, 8, 1, -4 },
  { 435, 8, 4, 11, 2, -13 },
  { 439, 6, 5, 10, 2, -5 },
  { 443, 12, 28, 13, 0, -26 },
  { 485, 15, 26, 19, 2, -26 },
  { 534, 9, 26, 19, 3, -26 },
  { 564, 16, 26, 19, 1, -26 },
  { 616, 15, 26, 19, 1, -26 },
  { 665, 16, 26, 19, 1, -26 },
  { 717, 15, 26, 19, 2, -26 },
  { 766, 15, 26, 19, 2, -26 },
  { 815, 16, 26, 19, 1, -26 },
  { 867, 15, 26, 19, 2, -26 },
  { 916, 14, 26, 19, 2, -26 },
  { 962, 6, 20, 9, 2, -20 },
  { 977, 6, 26, 9, 1, -20 },
  { 997, 13, 17, 17, 1, -20 },
  { 1025, 13, 12, 18, 3, -18 },
  { 1045, 14, 17, 17, 2, -20 },
  { 1075, 14, 26, 16, 1, -26 },
  { 1121, 25, 34, 28, 2, -26 },
  { 1228, 20, 26, 22, 1, -26 },
  { 1293, 17, 26, 21, 2, -26 },
  { 1349, 18, 26, 21, 2, -26 },
  { 1408, 17, 26, 21, 2, -26 },
  { 1464, 15, 26, 18, 2, -26 },
  { 1513, 15, 26, 18, 2, -26 },
  { 1562, 18, 26, 22, 2, -26 },
  { 1621, 18, 26, 23, 2, -26 },
  { 1680, 4, 26, 10, 3, -26 },
  { 1693, 15, 26, 18, 1, -26 },
  { 1742, 18, 26, 20, 2, -26 },
  { 1801, 15, 26, 18, 2, -26 },
  { 1850, 24, 26, 28, 2, -26 },
  { 1928, 18, 26, 23, 2, -26 },
  { 1987, 18, 26, 22, 2, -26 },
  { 2046, 17, 26, 21, 2, -26 },
  { 2102, 18, 31, 22, 2, -26 },
  { 2172, 17, 26, 20, 2, -26 },
  { 2228, 17, 26, 20, 1, -26 },
  { 2284, 18, 26, 20, 1, -26 },
  { 2343, 17, 26, 21, 2, -26 },
  { 2399, 20, 26, 21, 1, -26 },
  { 2464, 26, 26, 28, 1, -26 },
  { 2549, 19, 26, 21, 1, -26 },
  { 2611, 19, 26, 20, 0, -26 },
  { 2673, 16, 26, 20, 2, -26 },
  { 2725, 7, 36, 10, 2, -30 },
  { 2757, 13, 28, 14, 1, -26 },
  { 2803, 6, 36, 10, 1, -30 },
  { 2830, 12, 13, 14, 1, -26 },
  { 2850, 14, 3, 15, 0, 0 },
  { 2856, 8, 5, 12, 1, -27 },
  { 2861, 14, 20, 18, 2, -20 },
  { 2896, 15, 28, 18, 2, -28 },
  { 2949, 15, 20, 17, 1, -20 },
  { 2987, 15, 28, 18, 1, -28 },
  { 3040, 14, 20, 18, 2, -20 },
  { 3075, 11, 28, 12, 1, -28 },
  { 3114, 15, 28, 18, 1, -20 },
  { 3167, 14, 28, 18, 2, -28 },
  { 3216, 5, 28, 9, 2, -28 },
  { 3234, 8, 36, 9, -1, -28 },
  { 3270, 15, 28, 17, 2, -28 },
  { 3323, 5, 28, 9, 2, -28 },
  { 3341, 23, 20, 28, 2, -20 },
  { 3399, 14, 20, 18, 2, -20 },
  { 3434, 16, 20, 18, 1, -20 },
  { 3474, 15, 28, 18, 2, -20 },
  { 3527, 15, 28, 18, 1, -20 },
  { 3580, 9, 20, 12, 2, -20 },
  { 3603, 14, 20, 17, 1, -20 },
  { 3638, 10, 24, 11, 0, -24 },
  { 3668, 14, 20, 18, 2, -20 },
  { 3703, 15, 20, 16, 1, -20 },
  { 3741, 22, 20, 24, 1, -20 },
  { 3796, 15, 20, 17, 1, -20 },
  { 3834, 15, 28, 16, 0, -20 },
  { 3887, 13, 20, 17, 2, -20 },
  { 3920, 9, 36, 11, 1, -29 },
  { 3961, 3, 31, 9, 3, -26 },
  { 3973, 9, 36, 11, 1, -29 },
  { 4014, 17, 8, 21, 2, -15 },
};

const GFXfont RobotoCondensed_Medium37pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium37pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium37pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _ROBOTOCONDENSED_MEDIUM37PT7B_H_
