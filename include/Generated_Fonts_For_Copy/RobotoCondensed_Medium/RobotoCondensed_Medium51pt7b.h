#ifndef _ROBOTOCONDENSED_MEDIUM51PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium51pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBE, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x1F, 0x7F, 0xFE, 0xFD, 0xF1, 0xC0, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0E, 0xF0, 0xE0, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC1, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x07, 0x00, 0x1E, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x3C, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0x83, 0x80, 0x0F, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x1F, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0x0F, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x3F,
  0x7C, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFE, 0x07, 0xF7, 0xF0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x0F, 0x01,
  0x01, 0xE1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xC0, 0xF0,
  0x78, 0x78, 0x1E, 0x0F, 0x1E, 0x03, 0xC1, 0xE3, 0x80, 0x78, 0x7C, 0xF0,
  0x0F, 0x0F, 0x3C, 0x01, 0xFF, 0xE7, 0x80, 0x1F, 0xF9, 0xE0, 0x01, 0xFE,
  0x3C, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x1F, 0x00, 0x03, 0xCF, 0xF8, 0x00, 0x73, 0xFF, 0x80, 0x1E,
  0x7F, 0xF0, 0x07, 0x9F, 0x1F, 0x00, 0xF3, 0xC1, 0xE0, 0x3C, 0x78, 0x3C,
  0x07, 0x8F, 0x07, 0x81, 0xE1, 0xE0, 0xF0, 0x3C, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1F, 0x1F, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x1F,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x7C, 0x3F, 0xFE, 0x1F, 0x0F, 0xDF, 0xC7, 0xC7, 0xE3, 0xF1,
  0xF1, 0xF0, 0xFE, 0x7C, 0xFC, 0x1F, 0xFF, 0x3F, 0x03, 0xFF, 0x8F, 0xC0,
  0x7F, 0xE3, 0xF0, 0x1F, 0xF8, 0xFC, 0x03, 0xFC, 0x1F, 0x80, 0x7F, 0x07,
  0xF0, 0x3F, 0xC1, 0xFF, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFB, 0xF8, 0x1F, 0xF8, 0x7F, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x00, 0x00, 0x20, 0x06, 0x00,
  0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x06, 0x00, 0x20, 0x40, 0x06, 0x00, 0x70, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01,
  0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x70, 0x06, 0x00, 0x40, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x01, 0x81, 0xC0, 0x5F, 0x0E, 0x1E, 0xFF, 0x77, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xC0, 0x0F, 0x9F, 0x00, 0xF8, 0x7C, 0x07,
  0xC1, 0xF0, 0x3C, 0x0F, 0x80, 0xE0, 0x38, 0x02, 0x01, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF8, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x38, 0xFD, 0xFF, 0xFF, 0xEF, 0xCF,
  0x00, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC7, 0xF0, 0xFC, 0x7E, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0,
  0x3E, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x7E, 0x7C, 0x07,
  0xE7, 0xE0, 0x7E, 0x7F, 0x0F, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x18, 0x03, 0xC0, 0xFE, 0x1F,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF1, 0xFE, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0x83, 0xF9, 0xF8, 0x0F, 0xCF,
  0xC0, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0x7D, 0xF8, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x83, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0,
  0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xEF, 0xC0, 0x3F, 0x3F, 0x01, 0xF9, 0xFC,
  0x1F, 0xCF, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0xF9, 0xF0,
  0x03, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xE1, 0xF0, 0x0F,
  0x87, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC1, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE7, 0xE0, 0xFE, 0x0C, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x7E, 0x7F, 0x0F, 0xE3,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x7E, 0x0F, 0xDF, 0xF0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF0, 0xFE, 0xFE, 0x07, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x03,
  0xF7, 0xE0, 0x7E, 0x3F, 0x0F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xF0, 0xFC, 0x7E, 0x07, 0xEF, 0xC0,
  0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0x7C,
  0x07, 0xE7, 0xE0, 0x7C, 0x3F, 0x0F, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0x0F, 0xC7, 0xE0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0xFF, 0x0F, 0xE7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xC7, 0xF1, 0xFC, 0x1F, 0x8F, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xE0,
  0x1F, 0xBF, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x7E, 0x00, 0xFD,
  0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x03, 0xFB, 0xF0, 0x1F, 0xCF, 0xC1,
  0xFE, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFE, 0xF8, 0x3F, 0xE7, 0xC0,
  0x7E, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x38, 0xFF,
  0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x1F, 0xFF, 0xFF, 0xFD, 0xF9, 0xE0, 0x0E,
  0x0F, 0x8F, 0xE7, 0xF3, 0xF9, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x7C,
  0x3E, 0x1E, 0x02, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F,
  0xE0, 0x3F, 0xC0, 0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x1C, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x00,
  0xF8, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x83,
  0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x3E, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xC0,
  0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x3E,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x7C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x3E, 0x01, 0xE3, 0xE0, 0x1F, 0xF0,
  0x3C, 0x78, 0x07, 0xFF, 0x07, 0x8F, 0x01, 0xFF, 0xE0, 0x71, 0xE0, 0x7C,
  0x3C, 0x0E, 0x78, 0x0F, 0x07, 0x81, 0xEF, 0x03, 0xE0, 0xF0, 0x3D, 0xE0,
  0x78, 0x1E, 0x07, 0xBC, 0x1F, 0x03, 0xC0, 0xF7, 0x83, 0xE0, 0x78, 0x1E,
  0xF0, 0x78, 0x0F, 0x03, 0xFE, 0x0F, 0x03, 0xE0, 0x7F, 0xC1, 0xE0, 0x7C,
  0x0F, 0xF0, 0x7C, 0x0F, 0x81, 0xFE, 0x0F, 0x81, 0xE0, 0x3B, 0xE1, 0xF0,
  0x3C, 0x07, 0x7C, 0x3E, 0x07, 0x81, 0xE7, 0x87, 0xC0, 0xF0, 0x3C, 0xF0,
  0x7C, 0x3E, 0x07, 0x1E, 0x0F, 0x8F, 0xE1, 0xE3, 0xC1, 0xFF, 0xFC, 0x78,
  0x78, 0x1F, 0xF7, 0xFF, 0x0F, 0x83, 0xFC, 0xFF, 0xC0, 0xF0, 0x3F, 0x0F,
  0xF0, 0x1E, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x1F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7E, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x80,
  0x7F, 0x3F, 0x00, 0x7F, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8, 0x01,
  0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F,
  0x3F, 0x00, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x1F, 0xBF,
  0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0xBF, 0x00,
  0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xC1, 0xFE, 0x7F, 0x00,
  0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0xC1,
  0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x81, 0xFF, 0x3F, 0x00, 0xFE,
  0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x7F, 0x3F, 0x03, 0xFE, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xC1, 0xFE, 0x7F,
  0x00, 0xFE, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x3F,
  0xC0, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF,
  0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x03, 0xF9, 0xFE, 0x3F, 0x87, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xBF, 0x00, 0x3F, 0x9F, 0x80, 0x3F,
  0x8F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87,
  0xF0, 0x0F, 0xC7, 0xF0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xFB,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFD, 0xFC, 0x03, 0xFC, 0x7E, 0x01,
  0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xFC,
  0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x07,
  0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0xBF, 0x00,
  0x1F, 0xDF, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xDF, 0xFF, 0xF0, 0x07, 0xDF, 0xFF,
  0xF0, 0x07, 0xDF, 0xFD, 0xF0, 0x0F, 0xDF, 0xFD, 0xF0, 0x0F, 0x9F, 0xFD,
  0xF8, 0x0F, 0x9F, 0xFC, 0xF8, 0x1F, 0xBF, 0xFC, 0xF8, 0x1F, 0x3F, 0xFC,
  0xFC, 0x1F, 0x3F, 0xFC, 0x7C, 0x1F, 0x3F, 0xFC, 0x7C, 0x3E, 0x3F, 0xFC,
  0x7E, 0x3E, 0x3F, 0xFC, 0x3E, 0x3E, 0x3F, 0xFC, 0x3E, 0x7C, 0x3F, 0xFC,
  0x3F, 0x7C, 0x3F, 0xFC, 0x1F, 0x7C, 0x3F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xFC, 0x0F, 0xF8, 0x3F, 0xFC, 0x0F, 0xF8, 0x3F, 0xFC,
  0x0F, 0xF0, 0x3F, 0xFC, 0x07, 0xF0, 0x3F, 0xFC, 0x07, 0xF0, 0x3F, 0xFC,
  0x07, 0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xDF, 0x81, 0xFF, 0xEF, 0xC0, 0xFF, 0xF3, 0xF0, 0x7F, 0xF9, 0xF8,
  0x3F, 0xFC, 0x7E, 0x1F, 0xFE, 0x1F, 0x0F, 0xFF, 0x0F, 0xC7, 0xFF, 0x83,
  0xE3, 0xFF, 0xC1, 0xF9, 0xFF, 0xE0, 0x7C, 0xFF, 0xF0, 0x3F, 0x7F, 0xF8,
  0x0F, 0xBF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFE, 0x1F, 0xF1, 0xFC,
  0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xF3, 0xF8,
  0x07, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFC, 0x03, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE,
  0xFC, 0x01, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC1, 0xFE, 0x1F, 0xF1, 0xFC, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0xFE, 0x00,
  0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0xC0, 0x07,
  0xE7, 0xE0, 0x07, 0xF3, 0xF8, 0x07, 0xF0, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xFC, 0x03, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0,
  0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87,
  0xF0, 0x7F, 0x9F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0xFC,
  0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xE0, 0x1F, 0xCF,
  0xE0, 0x7F, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F,
  0x9F, 0xE0, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFE,
  0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x1F,
  0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7C, 0x7E, 0x00,
  0x0F, 0x8F, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0xF8, 0x03,
  0xF7, 0xE0, 0x0F, 0x80, 0x3F, 0x7E, 0x01, 0xF8, 0x03, 0xF7, 0xE0, 0x1F,
  0xC0, 0x3F, 0x7E, 0x01, 0xFC, 0x03, 0xE7, 0xE0, 0x1F, 0xC0, 0x7E, 0x3E,
  0x01, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0xC0, 0x7E, 0x3F, 0x03, 0xFE, 0x07,
  0xE3, 0xF0, 0x3F, 0xE0, 0x7E, 0x3F, 0x03, 0xFE, 0x07, 0xC1, 0xF0, 0x3F,
  0xE0, 0xFC, 0x1F, 0x07, 0xDE, 0x0F, 0xC1, 0xF8, 0x7D, 0xF0, 0xFC, 0x1F,
  0x87, 0xDF, 0x0F, 0xC1, 0xF8, 0x7D, 0xF0, 0xF8, 0x0F, 0x8F, 0x8F, 0x0F,
  0x80, 0xF8, 0xF8, 0xF9, 0xF8, 0x0F, 0x8F, 0x8F, 0x9F, 0x80, 0xFC, 0xF8,
  0xF9, 0xF8, 0x0F, 0xCF, 0x0F, 0x9F, 0x00, 0x7D, 0xF0, 0x79, 0xF0, 0x07,
  0xDF, 0x07, 0xDF, 0x00, 0x7D, 0xF0, 0x7F, 0xF0, 0x07, 0xDF, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8,
  0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x0F,
  0xE0, 0x3F, 0x83, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0x3F,
  0x3F, 0x80, 0x0F, 0xEF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xF3, 0xF0, 0x00,
  0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x0F, 0xE0, 0xFC,
  0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x3F, 0x80,
  0x3F, 0x0F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xE7, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x87, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x3E, 0x00,
  0x0F, 0xDF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1E, 0xF0, 0x0F, 0x7C, 0x0F, 0x9E, 0x07,
  0xCF, 0x03, 0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0xF0, 0x7C, 0xF8, 0x3E,
  0x7C, 0x0F, 0xBC, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF0, 0xFE, 0x7E, 0x07, 0xE7, 0xE0,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0xFE, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xF0, 0x7E, 0x7E, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xE0, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFB, 0xF1, 0xFF, 0x3F, 0x07, 0xE3,
  0xF0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0xFD, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xC0, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0x0F, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xBF, 0xFC, 0xF9, 0xFF, 0x8F, 0x87, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE7, 0xF0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF7,
  0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xF0, 0x7E, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x3F, 0x3F, 0x0F, 0xFB, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0x07, 0xF7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE,
  0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x07, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1,
  0xFF, 0xDF, 0x0F, 0xF9, 0xF0, 0x3F, 0x1F, 0x01, 0xFC, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xF0, 0x7E, 0x7E, 0x03,
  0xF7, 0xE0, 0x3F, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x04, 0x7E, 0x00, 0xC7,
  0xF8, 0x1E, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xF8,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE1, 0xFF, 0xC3, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x7F, 0xEF, 0xC7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0x83, 0xFD, 0xF8, 0x0F, 0xEF,
  0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x3F,
  0xBF, 0x83, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x1F, 0xFD, 0xF8, 0x7F,
  0xCF, 0xC0, 0xFC, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x60, 0x0F, 0xC3, 0xC0, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x3F, 0x0F,
  0xDF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xFF, 0xFB,
  0xFE, 0xFF, 0x3F, 0xCF, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x1F,
  0xCF, 0xC0, 0xFE, 0x7E, 0x0F, 0xE3, 0xF0, 0xFE, 0x1F, 0x87, 0xE0, 0xFC,
  0x7F, 0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x01, 0xFD, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x83,
  0xF0, 0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x03,
  0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F, 0x7E, 0x01, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x7E, 0x03, 0xF0, 0xF9, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF,
  0x9F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x0F,
  0xF8, 0x7F, 0xFC, 0x0F, 0xF0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xF8, 0x7E, 0x1F, 0x3F, 0xE3, 0xEF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x83, 0xF9, 0xF8,
  0x0F, 0xCF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x03, 0xF7,
  0xE0, 0x3F, 0x3F, 0x83, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0x00, 0xF8, 0x7E, 0x0F, 0x9F, 0xF8, 0xFB,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE0, 0xFE, 0xFC, 0x07, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xE0,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xDF, 0xF0, 0xFC,
  0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF1, 0xF0, 0xFF, 0x9F, 0x1F, 0xFD, 0xF3, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xF0, 0x7F, 0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xF0, 0x7F, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xBF, 0x03, 0xF3, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0xF8, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F, 0x9F, 0x01, 0xFB, 0xE0, 0x3F,
  0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xDF, 0xFF, 0xF1,
  0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xFC, 0x3F,
  0xE1, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xDF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFE, 0x7C, 0x3F, 0x00, 0x00, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x3E, 0x7E, 0x07, 0xE7,
  0xE0, 0x7E, 0x3E, 0x07, 0xE3, 0xF0, 0x7C, 0x3F, 0x0F, 0xC1, 0xF0, 0xFC,
  0x1F, 0x0F, 0x81, 0xF8, 0xF8, 0x1F, 0x8F, 0x80, 0xF9, 0xF8, 0x0F, 0x9F,
  0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x7D, 0xF8,
  0x0F, 0x80, 0xF9, 0xF0, 0x1F, 0x03, 0xF3, 0xE0, 0x7E, 0x07, 0xE7, 0xE0,
  0xFE, 0x0F, 0xCF, 0xC1, 0xFC, 0x1F, 0x0F, 0x83, 0xF8, 0x3E, 0x1F, 0x0F,
  0xF0, 0x7C, 0x3E, 0x1F, 0xF1, 0xF8, 0x7C, 0x3F, 0xE3, 0xE0, 0xFC, 0x7F,
  0xC7, 0xC0, 0xF9, 0xF7, 0x8F, 0x81, 0xF3, 0xEF, 0x9F, 0x03, 0xE7, 0x9F,
  0x7E, 0x07, 0xCF, 0x1E, 0xF8, 0x07, 0xFE, 0x3D, 0xF0, 0x0F, 0xFC, 0x7F,
  0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF0,
  0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x3F, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x8F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x7E, 0x01, 0xFB,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xBF, 0x01, 0xF9, 0xF8, 0x0F,
  0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF0, 0x1F,
  0xBF, 0x80, 0xFE, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0,
  0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x3E, 0x07, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF9, 0xF8, 0x1F, 0x9F, 0x80,
  0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x20, 0x0F, 0x01, 0xF0, 0x3F, 0x07,
  0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x03, 0xF0, 0xFE, 0x0F, 0xE0, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x03, 0x80, 0x3F, 0x01, 0xFC, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x1F, 0xC1,
  0xFE, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x7F, 0x01, 0xF0, 0x0F, 0x00, 0x60,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x3C, 0xFF, 0xC0, 0x7B, 0xFF, 0xC0,
  0xF7, 0xFF, 0xC3, 0xFF, 0x9F, 0xCF, 0xFE, 0x0F, 0xFF, 0x7C, 0x1F, 0xFE,
  0xF0, 0x1F, 0xF9, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoCondensed_Medium51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 36, 13, 3, -36 },
  { 33, 12, 13, 16, 2, -38 },
  { 53, 23, 36, 27, 3, -36 },
  { 157, 20, 46, 26, 3, -41 },
  { 272, 27, 36, 32, 3, -36 },
  { 394, 26, 37, 29, 2, -36 },
  { 515, 5, 13, 9, 2, -38 },
  { 524, 12, 53, 16, 3, -41 },
  { 604, 12, 53, 16, 1, -41 },
  { 684, 21, 22, 23, 1, -36 },
  { 742, 21, 27, 25, 2, -30 },
  { 813, 8, 14, 11, 1, -6 },
  { 827, 11, 5, 16, 2, -18 },
  { 834, 7, 7, 14, 3, -7 },
  { 841, 17, 39, 18, 0, -36 },
  { 924, 20, 36, 26, 3, -36 },
  { 1014, 13, 36, 26, 4, -36 },
  { 1073, 21, 36, 26, 2, -36 },
  { 1168, 21, 36, 26, 2, -36 },
  { 1263, 22, 36, 26, 2, -36 },
  { 1362, 20, 36, 26, 3, -36 },
  { 1452, 20, 36, 26, 3, -36 },
  { 1542, 21, 36, 26, 2, -36 },
  { 1637, 20, 36, 26, 3, -36 },
  { 1727, 21, 36, 26, 2, -36 },
  { 1822, 7, 28, 13, 3, -28 },
  { 1847, 9, 36, 12, 1, -28 },
  { 1888, 17, 23, 23, 2, -27 },
  { 1937, 18, 15, 25, 4, -24 },
  { 1971, 18, 23, 23, 3, -27 },
  { 2023, 18, 36, 22, 2, -36 },
  { 2104, 35, 46, 39, 2, -35 },
  { 2306, 28, 36, 30, 1, -36 },
  { 2432, 23, 36, 28, 3, -36 },
  { 2536, 24, 36, 29, 3, -36 },
  { 2644, 23, 36, 29, 3, -36 },
  { 2748, 21, 36, 25, 3, -36 },
  { 2843, 20, 36, 24, 3, -36 },
  { 2933, 24, 36, 30, 3, -36 },
  { 3041, 25, 36, 31, 3, -36 },
  { 3154, 6, 36, 13, 4, -36 },
  { 3181, 21, 36, 25, 1, -36 },
  { 3276, 25, 36, 28, 3, -36 },
  { 3389, 20, 36, 24, 3, -36 },
  { 3479, 32, 36, 39, 3, -36 },
  { 3623, 25, 36, 31, 3, -36 },
  { 3736, 25, 36, 31, 3, -36 },
  { 3849, 24, 36, 29, 3, -36 },
  { 3957, 25, 42, 31, 3, -36 },
  { 4089, 24, 36, 28, 3, -36 },
  { 4197, 23, 36, 27, 2, -36 },
  { 4301, 25, 36, 27, 1, -36 },
  { 4414, 23, 36, 29, 3, -36 },
  { 4518, 27, 36, 29, 1, -36 },
  { 4640, 36, 36, 39, 1, -36 },
  { 4802, 26, 36, 28, 1, -36 },
  { 4919, 26, 36, 27, 1, -36 },
  { 5036, 23, 36, 27, 2, -36 },
  { 5140, 9, 50, 13, 3, -42 },
  { 5197, 18, 39, 19, 1, -36 },
  { 5285, 9, 50, 13, 1, -42 },
  { 5342, 17, 18, 19, 1, -36 },
  { 5381, 19, 5, 21, 1, 0 },
  { 5393, 12, 8, 16, 1, -39 },
  { 5405, 20, 27, 24, 2, -27 },
  { 5473, 20, 38, 25, 3, -38 },
  { 5568, 20, 27, 24, 2, -27 },
  { 5636, 20, 38, 25, 2, -38 },
  { 5731, 20, 27, 24, 2, -27 },
  { 5799, 15, 39, 16, 1, -39 },
  { 5873, 21, 37, 25, 2, -27 },
  { 5971, 19, 38, 25, 3, -38 },
  { 6062, 6, 37, 12, 3, -37 },
  { 6090, 10, 47, 12, -1, -37 },
  { 6149, 21, 38, 24, 3, -38 },
  { 6249, 6, 38, 12, 3, -38 },
  { 6278, 32, 27, 38, 3, -27 },
  { 6386, 19, 27, 25, 3, -27 },
  { 6451, 21, 27, 25, 2, -27 },
  { 6522, 20, 37, 25, 3, -27 },
  { 6615, 20, 37, 25, 2, -27 },
  { 6708, 12, 27, 16, 3, -27 },
  { 6749, 19, 27, 23, 2, -27 },
  { 6814, 13, 34, 15, 1, -34 },
  { 6870, 19, 27, 25, 3, -27 },
  { 6935, 20, 27, 22, 1, -27 },
  { 7003, 31, 27, 33, 1, -27 },
  { 7108, 21, 27, 23, 1, -27 },
  { 7179, 20, 37, 22, 1, -27 },
  { 7272, 19, 27, 23, 2, -27 },
  { 7337, 12, 49, 15, 2, -40 },
  { 7411, 4, 43, 13, 4, -36 },
  { 7433, 13, 49, 15, 1, -40 },
  { 7513, 23, 11, 29, 3, -21 },
};

const GFXfont RobotoCondensed_Medium51pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium51pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium51pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _ROBOTOCONDENSED_MEDIUM51PT7B_H_
