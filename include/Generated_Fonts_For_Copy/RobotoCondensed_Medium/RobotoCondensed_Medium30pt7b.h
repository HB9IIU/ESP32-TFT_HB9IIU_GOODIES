#ifndef _ROBOTOCONDENSED_MEDIUM30PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0xE0, 0x00, 0x6F, 0xF6,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0x03, 0x38, 0x1C, 0xC0, 0x73,
  0x01, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0x67, 0x1F, 0xFF, 0x7F, 0xFC, 0x31,
  0x80, 0xC6, 0x03, 0x18, 0x0C, 0xE3, 0xFF, 0xEF, 0xFF, 0x87, 0x30, 0x18,
  0xC0, 0x63, 0x01, 0x8C, 0x06, 0x70, 0x19, 0xC0, 0xE6, 0x00, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x1F, 0x01, 0xFE, 0x1F, 0xF0, 0xE3, 0xCF, 0x0E, 0x78,
  0x73, 0xC3, 0x9E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xF0, 0x03, 0xBC, 0x1C, 0xE0, 0xF7, 0x07, 0x3C, 0x78, 0xFF, 0xC7,
  0xFC, 0x0F, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x3F, 0x00,
  0x19, 0xC0, 0x0C, 0x63, 0x8E, 0x31, 0x87, 0x19, 0xC1, 0x8C, 0xC0, 0xCE,
  0xE0, 0x7E, 0x60, 0x1E, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x19, 0xE0,
  0x19, 0xF8, 0x0D, 0xCC, 0x0C, 0xC7, 0x06, 0x63, 0x86, 0x31, 0xC3, 0x18,
  0xE1, 0x0E, 0x60, 0x03, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x3F, 0x80, 0xFF,
  0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1E, 0xF0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF9, 0xCE, 0x7B, 0xBC, 0xF7, 0x78,
  0xFE, 0xF0, 0xFD, 0xE0, 0xF1, 0xE3, 0xE3, 0xFF, 0xE3, 0xFF, 0xC1, 0xF3,
  0xC0, 0xFF, 0xFF, 0xFF, 0x04, 0x1C, 0x30, 0xE3, 0x87, 0x1C, 0x38, 0x71,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x1C,
  0x38, 0x70, 0x70, 0xE0, 0xE0, 0xC1, 0xC1, 0x00, 0x81, 0x83, 0x83, 0x87,
  0x07, 0x0E, 0x0E, 0x1C, 0x38, 0x70, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0xF1, 0xC3, 0x87, 0x0E, 0x38, 0x70, 0xC3, 0x8E, 0x18, 0x20, 0x00,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x07, 0x33, 0xBF, 0xFC, 0xFF, 0xC0,
  0xE0, 0x0F, 0x80, 0xEE, 0x0E, 0x38, 0x71, 0xC1, 0x04, 0x00, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x39, 0xCE, 0x73,
  0xB9, 0xCC, 0xFF, 0xFF, 0xF8, 0x6F, 0xF6, 0x01, 0xC0, 0x60, 0x38, 0x0E,
  0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07,
  0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03,
  0x80, 0x1F, 0x07, 0xF1, 0xFF, 0x78, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFE, 0x1F, 0xC7, 0xBF, 0xE3, 0xF8, 0x3E, 0x00, 0x03, 0x0F, 0x3F, 0xFF,
  0xF7, 0xC7, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x81, 0xFF, 0x1F, 0xF8, 0xF1,
  0xE7, 0x0F, 0x78, 0x3B, 0xC1, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x8F,
  0xF0, 0xFF, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0xFE, 0x0F, 0x80, 0xFE,
  0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0xF0, 0x7F, 0x07, 0x78, 0xF7, 0xFE,
  0x3F, 0xC0, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03,
  0x70, 0x3B, 0x81, 0xDC, 0x1C, 0xE0, 0xE7, 0x0E, 0x38, 0x71, 0xC7, 0x0E,
  0x38, 0x73, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0xF8, 0xFF, 0xCF, 0xFE, 0x71, 0xE0, 0x0E, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0xE0, 0xFE, 0x0E, 0xF1, 0xE7, 0xFC, 0x3F, 0xC1, 0xF0,
  0x07, 0x80, 0xF8, 0x3F, 0x83, 0xC0, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x78,
  0xFF, 0xCF, 0xFE, 0xF1, 0xEE, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFF, 0x0E, 0x71, 0xE7, 0xFC, 0x3F, 0xC1, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0x1F, 0x07, 0xF1,
  0xFF, 0x78, 0xFF, 0x1F, 0xC1, 0xF8, 0x3F, 0x8F, 0x71, 0xCF, 0xF8, 0xFE,
  0x3F, 0xEF, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC7, 0xBF,
  0xE7, 0xFC, 0x3E, 0x00, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0x8E, 0x70, 0xF7,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x77, 0x07, 0x70, 0x77, 0x8F, 0x7F, 0xF3,
  0xFF, 0x0E, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC1, 0xFC, 0x1F, 0x01,
  0xC0, 0x6F, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xF6, 0x73, 0xDE, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x39, 0xCE, 0x73, 0x9D, 0xC4, 0x00, 0x00,
  0x40, 0x30, 0x3C, 0x3F, 0x3F, 0xBF, 0x0F, 0x03, 0xC0, 0xFC, 0x0F, 0xE0,
  0xFC, 0x0F, 0x00, 0xC0, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x1C, 0x03, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x0F, 0xE7, 0xF3, 0xF8, 0x7C, 0x0E, 0x01,
  0x00, 0x00, 0x1F, 0x07, 0xF1, 0xFF, 0x78, 0xFF, 0x1F, 0xC3, 0xC0, 0x78,
  0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70,
  0x00, 0x00, 0x00, 0x30, 0x0F, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xF8, 0x01, 0xE1, 0xE0, 0x1C, 0x03, 0x81, 0xC0, 0x0E, 0x0C, 0x00,
  0x30, 0xE0, 0xF0, 0xC6, 0x1F, 0xC6, 0x70, 0xE6, 0x33, 0x0E, 0x71, 0x98,
  0x63, 0x8E, 0xC7, 0x1C, 0x76, 0x38, 0xE1, 0xF1, 0xC7, 0x1F, 0x8C, 0x38,
  0xFC, 0x61, 0xC6, 0xE3, 0x0C, 0x33, 0x1C, 0xE1, 0x98, 0xFF, 0x98, 0xC3,
  0xEF, 0xC7, 0x0E, 0x38, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x7C, 0x70, 0x01, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1D, 0xC0, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x9C, 0x03, 0x8F, 0x01, 0xC3,
  0x81, 0xE1, 0xC0, 0xF0, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x3F, 0xFF, 0x1C,
  0x07, 0x8E, 0x01, 0xCF, 0x00, 0xE7, 0x80, 0x7B, 0x80, 0x3C, 0xFF, 0x87,
  0xFF, 0x3F, 0xFD, 0xE1, 0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0E, 0xF0,
  0xF7, 0xFF, 0x3F, 0xF1, 0xFF, 0xEF, 0x0F, 0x78, 0x3F, 0xC1, 0xFE, 0x07,
  0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xFF, 0xEF, 0xFE, 0x7F, 0xE0, 0x0F, 0xC0,
  0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x87, 0x9F, 0xFE, 0x3F, 0xF0, 0x3F,
  0x00, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xE1, 0xEF, 0x07, 0xF8, 0x3F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x3D, 0xFF, 0xCF, 0xFC, 0x7F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xFF, 0x7F, 0xEF, 0xFD, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E,
  0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0xF7, 0x83, 0xDF, 0xFF, 0x3F, 0xF8, 0x3F, 0x80, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x70, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xE0, 0xFF,
  0x0E, 0xF1, 0xE7, 0xFE, 0x7F, 0xC1, 0xF0, 0xF0, 0x3D, 0xE0, 0xF3, 0xC3,
  0xE7, 0x87, 0x8F, 0x1E, 0x1E, 0x7C, 0x3C, 0xF0, 0x7B, 0xC0, 0xF7, 0x81,
  0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0x78, 0x3C, 0xF0, 0x78,
  0xF0, 0xF1, 0xE1, 0xE1, 0xE3, 0xC3, 0xE7, 0x83, 0xCF, 0x03, 0xDE, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0x70, 0x7F, 0xEE, 0x0F, 0xFD, 0xC3, 0xBF, 0xBC, 0x77, 0xF3, 0x8E,
  0xFE, 0x73, 0xDF, 0xCF, 0x73, 0xF8, 0xEE, 0x7F, 0x1D, 0xCF, 0xE3, 0xF1,
  0xFC, 0x3E, 0x3F, 0x87, 0xC7, 0xF0, 0xF0, 0xFE, 0x0E, 0x1F, 0xC1, 0xC3,
  0xC0, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xE1, 0xFB, 0x87, 0xEF, 0x1F, 0x9C, 0x7E, 0x79, 0xF8, 0xE7, 0xE3, 0xDF,
  0x87, 0x7E, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0x70, 0x0F, 0xC0, 0xFF, 0xC3, 0xFF, 0x9E, 0x1E, 0xF0,
  0x3F, 0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xF7,
  0x87, 0x9F, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF,
  0x3C, 0x1E, 0xF0, 0x3B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xEF, 0x07, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0xC0,
  0x7F, 0xE1, 0xFF, 0xC3, 0xC3, 0xCF, 0x03, 0xDE, 0x07, 0xB8, 0x07, 0x70,
  0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x00, 0xEE, 0x01, 0xDC, 0x03,
  0xB8, 0x07, 0x70, 0x0E, 0xF0, 0x3D, 0xE0, 0x79, 0xE1, 0xE3, 0xFF, 0xC3,
  0xFF, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x10, 0xFF,
  0x83, 0xFF, 0x8F, 0xFF, 0x3C, 0x3C, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC,
  0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x0F,
  0x1C, 0x3C, 0x78, 0xF0, 0xE3, 0xC3, 0xCF, 0x0F, 0x3C, 0x1E, 0xF0, 0x7B,
  0xC0, 0xF0, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x39, 0xC0,
  0xE7, 0x03, 0xDE, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x01, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x87, 0x8F,
  0xFE, 0x1F, 0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3F,
  0x83, 0xFE, 0x1E, 0xFF, 0xE3, 0xFE, 0x0F, 0xC0, 0x70, 0x07, 0xBC, 0x07,
  0x9E, 0x03, 0xCF, 0x01, 0xE3, 0x80, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x38,
  0x3C, 0x1C, 0x1C, 0x0F, 0x1E, 0x07, 0x8F, 0x01, 0xC7, 0x00, 0xE3, 0x80,
  0x7B, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0xE0, 0x70, 0x7F, 0x83, 0x83,
  0xFC, 0x3C, 0x1F, 0xE1, 0xF0, 0xE7, 0x0F, 0x87, 0x38, 0x7C, 0x39, 0xC3,
  0xE3, 0xCF, 0x3B, 0x1E, 0x79, 0xDC, 0xE1, 0xCE, 0xE7, 0x0E, 0x77, 0x38,
  0x73, 0x39, 0xC3, 0xB8, 0xDE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x03, 0xF1,
  0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x00,
  0xF0, 0x78, 0x07, 0x03, 0xC0, 0xF0, 0x1E, 0xF0, 0x79, 0xE0, 0xF1, 0xE3,
  0xC3, 0xC7, 0x83, 0x9E, 0x07, 0xBC, 0x07, 0x70, 0x0F, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xB8, 0x0F, 0x78, 0x3C,
  0xF0, 0x78, 0xF1, 0xE1, 0xE3, 0xC1, 0xEF, 0x03, 0xDE, 0x03, 0xC0, 0x70,
  0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x38, 0x1E,
  0x78, 0x0E, 0x78, 0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xFF, 0xFC, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80,
  0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0,
  0x78, 0x07, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xFF,
  0xF0, 0x1C, 0x07, 0x01, 0xE0, 0xF8, 0x3E, 0x0D, 0xC7, 0x71, 0xCC, 0x63,
  0xB8, 0xEE, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xE0,
  0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x0E, 0x70, 0xE0, 0x0E, 0x0F, 0xE3, 0xFE,
  0x78, 0xE7, 0x0E, 0xF0, 0xEF, 0x0E, 0xF1, 0xE7, 0xFF, 0x7F, 0xF1, 0xEF,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0xF8,
  0xFF, 0xCF, 0xFE, 0xF1, 0xEE, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xEF, 0x1E, 0xFF, 0xEF, 0xFC, 0xEF, 0x80, 0x0F,
  0x83, 0xFC, 0x7F, 0xE7, 0x8E, 0x70, 0xFF, 0x07, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x77, 0x0F, 0x70, 0xE7, 0xFE, 0x3F, 0xC0, 0xF8, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x71, 0xE7, 0x3F,
  0xF7, 0xFF, 0x78, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x77, 0x8F, 0x7F, 0xF3, 0xFF, 0x1E, 0x70, 0x0F, 0x83,
  0xFC, 0x7F, 0xE7, 0x8F, 0x70, 0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x67, 0xFF, 0x3F, 0xE0, 0xF8, 0x0F, 0x1F,
  0x3F, 0x3C, 0x38, 0x38, 0x38, 0xFF, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1F, 0x73, 0xFF,
  0x7F, 0xF7, 0x8F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0x78, 0xF7, 0xFF, 0x3F, 0xF1, 0xF7, 0x00, 0x70, 0x07,
  0x20, 0xF3, 0xFE, 0x3F, 0xE1, 0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x3C, 0xFF, 0xDF, 0xFB, 0xC7, 0xF0, 0xFE, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x38, 0x6E, 0xEE, 0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0x1C, 0x71, 0xC7, 0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xBC, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x1E, 0xE3, 0xCE,
  0x3C, 0xE7, 0x8E, 0xF0, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xF7, 0x0E,
  0x78, 0xE3, 0x8E, 0x3C, 0xE1, 0xCE, 0x1E, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE7, 0x8F, 0x1F, 0xFB, 0xFB, 0xFF,
  0xFF, 0x78, 0xF8, 0xEE, 0x1E, 0x1F, 0xC3, 0xC3, 0xF8, 0x78, 0x7F, 0x0F,
  0x0F, 0xE1, 0xE1, 0xFC, 0x3C, 0x3F, 0x87, 0x87, 0xF0, 0xF0, 0xFE, 0x1E,
  0x1F, 0xC3, 0xC3, 0xF8, 0x78, 0x7F, 0x0F, 0x0F, 0xE7, 0x9F, 0xFB, 0xFF,
  0x78, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0x0F, 0x81, 0xFF, 0x1F, 0xF8, 0xF1,
  0xE7, 0x07, 0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E,
  0xE0, 0xE7, 0x8F, 0x3F, 0xF8, 0xFF, 0x81, 0xF0, 0xEF, 0x8F, 0xFC, 0xFF,
  0xEF, 0x1E, 0xE0, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0E, 0xF1, 0xEF, 0xFE, 0xFF, 0xCE, 0xF8, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x1E, 0x73, 0xFF, 0x7F, 0xF7, 0x8F, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x78,
  0xF7, 0xFF, 0x3F, 0xF1, 0xE7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0xEF, 0xFF, 0xFF, 0xDF, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0x1F, 0x87, 0xF9, 0xFF, 0xB8, 0xF7, 0x0E, 0xE0,
  0x1F, 0x01, 0xFC, 0x1F, 0xC0, 0x7C, 0x07, 0xF8, 0x7F, 0x0E, 0xFF, 0xCF,
  0xF0, 0xFC, 0x3C, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1F, 0x1F, 0x0F, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0xFF, 0x1F, 0xFF, 0xDF, 0xB9, 0xE7, 0xE0, 0xEE, 0x0E, 0xF1,
  0xE7, 0x1E, 0x71, 0xC7, 0x1C, 0x79, 0xC3, 0xB8, 0x3B, 0x83, 0xB8, 0x3B,
  0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xE0, 0xE1, 0xC3, 0xB8, 0x70,
  0xEE, 0x1C, 0x3B, 0xCF, 0x8E, 0x73, 0xE7, 0x9C, 0xF9, 0xC7, 0x36, 0x71,
  0xDD, 0xDC, 0x7F, 0x77, 0x0F, 0xCD, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x3E, 0x07, 0x87, 0x81, 0xC1, 0xC0, 0x70, 0x70, 0xF0, 0xE7, 0x1E, 0x79,
  0xC3, 0xBC, 0x3F, 0x81, 0xF8, 0x1F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x3F,
  0x83, 0xB8, 0x7B, 0xC7, 0x9C, 0xF1, 0xEF, 0x0F, 0x70, 0x73, 0x83, 0x9E,
  0x3C, 0xF1, 0xE3, 0x8E, 0x1C, 0x70, 0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0xEE,
  0x07, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x7C, 0x03, 0xC0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1C,
  0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x1C, 0x78, 0xE3, 0xC7, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xCF, 0x1C, 0x3C, 0x3C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC1, 0xC3, 0xC3, 0x87, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC1, 0xE1, 0xC7, 0x9E, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x3C, 0x71,
  0xE3, 0x86, 0x00, 0x3C, 0x1D, 0xF8, 0x6F, 0xF3, 0xB9, 0xFE, 0xC3, 0xF0,
  0x07, 0x80,
};

const GFXglyph RobotoCondensed_Medium30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 22, 8, 2, -22 },
  { 12, 7, 8, 10, 1, -23 },
  { 19, 14, 22, 16, 1, -22 },
  { 58, 13, 28, 15, 1, -25 },
  { 104, 17, 22, 19, 1, -22 },
  { 151, 15, 22, 17, 1, -22 },
  { 193, 3, 8, 5, 1, -23 },
  { 196, 7, 31, 10, 2, -24 },
  { 224, 7, 31, 10, 1, -24 },
  { 252, 13, 13, 13, 0, -22 },
  { 274, 12, 15, 15, 1, -17 },
  { 297, 5, 8, 7, 0, -3 },
  { 302, 7, 3, 9, 1, -11 },
  { 305, 4, 4, 8, 2, -4 },
  { 307, 10, 24, 10, 0, -22 },
  { 337, 11, 22, 15, 2, -22 },
  { 368, 8, 22, 15, 2, -22 },
  { 390, 13, 22, 15, 1, -22 },
  { 426, 12, 22, 15, 1, -22 },
  { 459, 13, 22, 15, 1, -22 },
  { 495, 12, 22, 15, 2, -22 },
  { 528, 12, 22, 15, 2, -22 },
  { 561, 13, 22, 15, 1, -22 },
  { 597, 11, 22, 15, 2, -22 },
  { 628, 12, 22, 15, 1, -22 },
  { 661, 4, 16, 8, 2, -16 },
  { 669, 5, 21, 7, 1, -16 },
  { 683, 10, 14, 13, 1, -16 },
  { 701, 11, 9, 15, 2, -14 },
  { 714, 11, 14, 14, 2, -16 },
  { 734, 11, 22, 13, 1, -22 },
  { 765, 21, 28, 23, 1, -21 },
  { 839, 17, 22, 18, 0, -22 },
  { 886, 13, 22, 17, 2, -22 },
  { 922, 14, 22, 17, 2, -22 },
  { 961, 13, 22, 17, 2, -22 },
  { 997, 12, 22, 15, 2, -22 },
  { 1030, 11, 22, 14, 2, -22 },
  { 1061, 14, 22, 18, 2, -22 },
  { 1100, 14, 22, 19, 2, -22 },
  { 1139, 4, 22, 8, 2, -22 },
  { 1150, 12, 22, 15, 1, -22 },
  { 1183, 15, 22, 17, 2, -22 },
  { 1225, 11, 22, 14, 2, -22 },
  { 1256, 19, 22, 23, 2, -22 },
  { 1309, 14, 22, 18, 2, -22 },
  { 1348, 14, 22, 18, 2, -22 },
  { 1387, 14, 22, 17, 2, -22 },
  { 1426, 15, 26, 18, 2, -22 },
  { 1475, 14, 22, 16, 2, -22 },
  { 1514, 14, 22, 16, 1, -22 },
  { 1553, 14, 22, 16, 1, -22 },
  { 1592, 13, 22, 17, 2, -22 },
  { 1628, 17, 22, 17, 0, -22 },
  { 1675, 21, 22, 23, 1, -22 },
  { 1733, 15, 22, 17, 1, -22 },
  { 1775, 16, 22, 16, 0, -22 },
  { 1819, 14, 22, 16, 1, -22 },
  { 1858, 5, 30, 8, 2, -25 },
  { 1877, 11, 24, 11, 0, -22 },
  { 1910, 6, 30, 8, 0, -25 },
  { 1933, 10, 11, 11, 1, -22 },
  { 1947, 12, 3, 12, 0, 0 },
  { 1952, 7, 4, 10, 1, -22 },
  { 1956, 12, 16, 14, 1, -16 },
  { 1980, 12, 23, 15, 2, -23 },
  { 2015, 12, 16, 14, 1, -16 },
  { 2039, 12, 23, 15, 1, -23 },
  { 2074, 12, 16, 14, 1, -16 },
  { 2098, 8, 23, 10, 1, -23 },
  { 2121, 12, 22, 15, 1, -16 },
  { 2154, 11, 23, 15, 2, -23 },
  { 2186, 4, 22, 7, 2, -22 },
  { 2197, 6, 28, 7, -1, -22 },
  { 2218, 12, 23, 14, 2, -23 },
  { 2253, 3, 23, 7, 2, -23 },
  { 2262, 19, 16, 22, 2, -16 },
  { 2300, 11, 16, 15, 2, -16 },
  { 2322, 13, 16, 15, 1, -16 },
  { 2348, 12, 22, 15, 2, -16 },
  { 2381, 12, 22, 15, 1, -16 },
  { 2414, 7, 16, 10, 2, -16 },
  { 2428, 11, 16, 14, 1, -16 },
  { 2450, 8, 20, 9, 0, -20 },
  { 2470, 11, 16, 15, 2, -16 },
  { 2492, 12, 16, 13, 1, -16 },
  { 2516, 18, 16, 19, 1, -16 },
  { 2552, 12, 16, 13, 1, -16 },
  { 2576, 13, 22, 13, 0, -16 },
  { 2612, 11, 16, 13, 1, -16 },
  { 2634, 7, 28, 9, 1, -23 },
  { 2659, 2, 26, 7, 3, -22 },
  { 2666, 7, 28, 9, 1, -23 },
  { 2691, 14, 6, 17, 2, -12 },
};

const GFXfont RobotoCondensed_Medium30pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium30pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium30pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _ROBOTOCONDENSED_MEDIUM30PT7B_H_
