#ifndef _ROBOTOCONDENSED_MEDIUM42PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xBF, 0xFF, 0xB8, 0xF3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xE3, 0xF8, 0xEE, 0x3B, 0x8E, 0xE3, 0xB8, 0xEE, 0x38, 0x01, 0xC3,
  0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE3, 0xC0, 0x1C, 0x70, 0x07, 0x8E,
  0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF0, 0x78, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70,
  0x07, 0x1E, 0x00, 0xE3, 0x83, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC,
  0x1C, 0x38, 0x03, 0x8F, 0x00, 0x71, 0xE0, 0x1E, 0x38, 0x03, 0xC7, 0x00,
  0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x7F,
  0xF8, 0x7F, 0xFC, 0x3E, 0x3F, 0x3E, 0x0F, 0x9F, 0x03, 0xCF, 0x81, 0xF7,
  0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF7, 0xC1, 0xFB,
  0xF1, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0x8E, 0x04, 0x0F, 0x1E, 0x0C, 0x1C, 0x1C, 0x38,
  0x38, 0x38, 0x70, 0x70, 0x71, 0xC0, 0xE0, 0xE7, 0x81, 0xE3, 0xCE, 0x01,
  0xC7, 0x3C, 0x03, 0xFE, 0x70, 0x03, 0xF9, 0xC0, 0x03, 0xE3, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x71, 0xF0, 0x00, 0xE7, 0xF0, 0x03,
  0x9F, 0xF0, 0x0F, 0x78, 0xE0, 0x1C, 0xF1, 0xE0, 0x79, 0xC1, 0xC0, 0xE3,
  0x83, 0x83, 0xC7, 0x07, 0x07, 0x0E, 0x0E, 0x1C, 0x1E, 0x3C, 0x18, 0x3C,
  0x70, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xE3, 0xE0, 0x1F,
  0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xF1, 0xF0,
  0x0F, 0x9F, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xFC, 0x3C, 0x3F, 0xF1, 0xE3, 0xEF, 0x8F, 0x3E, 0x3E, 0x79,
  0xF1, 0xFB, 0xCF, 0x87, 0xFE, 0x7C, 0x1F, 0xF3, 0xE0, 0xFF, 0x1F, 0x03,
  0xF8, 0xF8, 0x0F, 0x83, 0xE1, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1,
  0xFF, 0x9F, 0x03, 0xF0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x81,
  0xC1, 0xE0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x07,
  0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0x80, 0x40, 0x40, 0x18,
  0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF0,
  0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0E, 0x07, 0x83, 0xC0,
  0x60, 0x10, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x07, 0x0E, 0x0B, 0xE7, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0xFC,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0xF7, 0x00, 0xF3, 0xC0, 0x78, 0xF0, 0x78,
  0x7C, 0x18, 0x1C, 0x04, 0x04, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0xF3, 0xCF, 0x3C, 0xF7, 0xDE, 0x7B,
  0xCF, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x23, 0xEF, 0xBF, 0xF9, 0xC0,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xE3, 0xE3, 0xE0, 0xF9, 0xF0,
  0x7C, 0xF0, 0x1E, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7D, 0xE0, 0x3C, 0xF8,
  0x3E, 0x7C, 0x1F, 0x1F, 0x1F, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80,
  0x1F, 0x00, 0x00, 0x60, 0x3C, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x07, 0xF0, 0x0F, 0xFE,
  0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xE3, 0xF7, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0,
  0x1E, 0xF8, 0x0F, 0x7C, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xC3, 0xF7, 0xC0,
  0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x1E, 0xF8, 0x1F, 0x7E, 0x1F, 0x9F, 0xFF, 0x87, 0xFF, 0x81,
  0xFF, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03,
  0xDF, 0x00, 0x7B, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x80, 0xF1, 0xF0, 0x1E,
  0x3E, 0x07, 0x87, 0xC0, 0xF0, 0xF8, 0x3C, 0x1F, 0x07, 0x83, 0xE1, 0xE0,
  0x7C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xE3, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x7C, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF9, 0xF0, 0xFC,
  0x10, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xFF, 0xC0, 0x7D, 0xE0, 0x3E, 0xF8, 0x1F, 0x7C, 0x1F, 0xBF, 0x1F, 0x8F,
  0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x78, 0x00, 0xFC,
  0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x3E, 0x0F, 0x7F, 0x87, 0xFF, 0xE7,
  0xFF, 0xFB, 0xF8, 0xFD, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFB, 0xC0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C,
  0x1F, 0x1F, 0x1F, 0x8F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0xC7, 0xE3, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E,
  0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE3, 0xE3, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0,
  0x3F, 0xF8, 0x3F, 0xFE, 0x3F, 0x1F, 0x9F, 0x07, 0xDF, 0x01, 0xEF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0x7C, 0x1F, 0x3F, 0x1F, 0x9F,
  0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x07, 0xFC,
  0x07, 0xFF, 0x07, 0xFF, 0x87, 0xE3, 0xE3, 0xE0, 0xF3, 0xE0, 0x7D, 0xF0,
  0x3E, 0xF8, 0x0F, 0x7C, 0x07, 0xBE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7D, 0xF0, 0x7E, 0xFC, 0x7F, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xFB,
  0xC0, 0xF9, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00,
  0x23, 0xEF, 0xBE, 0xF9, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x8F, 0xBE, 0xFF, 0xE7, 0x00, 0x00, 0x7D, 0xFB, 0xF3, 0xE7, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF9, 0xF3,
  0xE7, 0xCF, 0x1E, 0x3C, 0xF9, 0xE3, 0xCF, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x1C, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0,
  0xFF, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x80, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xF0, 0x7F,
  0xC3, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xFC, 0x01, 0xE0, 0x03, 0x00, 0x04,
  0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E,
  0x7C, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x00, 0x38, 0x0E,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x7C,
  0x0E, 0x38, 0x0F, 0xF0, 0x77, 0x81, 0xFF, 0x87, 0x70, 0x3C, 0x70, 0x77,
  0x07, 0x87, 0x07, 0x70, 0x78, 0x70, 0x7F, 0x0F, 0x07, 0x07, 0xF0, 0xF0,
  0x70, 0x7E, 0x0F, 0x07, 0x07, 0xE0, 0xE0, 0x70, 0x7E, 0x0E, 0x0F, 0x07,
  0xE1, 0xE0, 0xF0, 0x7E, 0x1E, 0x0F, 0x07, 0xE1, 0xE0, 0xF0, 0x7E, 0x1E,
  0x0F, 0x0E, 0xF0, 0xF1, 0xF0, 0xEF, 0x0F, 0xBF, 0x1E, 0x70, 0xFF, 0x7F,
  0xC7, 0x07, 0xF7, 0xF8, 0x78, 0x3C, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x01,
  0x00, 0x07, 0xE0, 0x70, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07, 0xDF, 0x00, 0x0F, 0x3E, 0x00, 0x3E,
  0x3C, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0xF8, 0x01, 0xE0, 0xF0, 0x07, 0xC1,
  0xE0, 0x0F, 0x83, 0xE0, 0x1E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF,
  0x80, 0x07, 0xFF, 0x00, 0x07, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF3, 0xFF, 0xFE, 0xF8, 0x3F, 0xBE, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7E, 0xFF, 0xFF, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x1F, 0xBE, 0x03, 0xEF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x07, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x3F, 0x87, 0xE3, 0xE0, 0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xF7,
  0xC0, 0x1F, 0x7E, 0x03, 0xE3, 0xF0, 0x7E, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8,
  0x7F, 0xFF, 0x8F, 0x87, 0xF1, 0xF0, 0x1F, 0x3E, 0x03, 0xF7, 0xC0, 0x3E,
  0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x0F, 0x7C, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7,
  0xC0, 0x7E, 0xF8, 0x0F, 0x9F, 0x07, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F,
  0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x3F, 0x87, 0xE7, 0xE0, 0x3E, 0x7C, 0x01, 0xF7, 0xC0,
  0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF,
  0x81, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F,
  0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x3E, 0x01, 0xF3, 0xF8, 0x7F, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xE0, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xFC, 0x1F, 0x3F,
  0x1F, 0x9F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x80, 0xF8, 0x07,
  0xEF, 0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0x81, 0xF8, 0xF8, 0x1F, 0x8F, 0x83,
  0xF0, 0xF8, 0x7E, 0x0F, 0x87, 0xE0, 0xF8, 0xFC, 0x0F, 0x8F, 0x80, 0xF9,
  0xF0, 0x0F, 0xBF, 0x00, 0xFB, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xEF, 0x80, 0xFC, 0xFC, 0x0F, 0xC7, 0xC0,
  0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x8F, 0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80,
  0x3F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0x78, 0x07,
  0xFF, 0xDF, 0x03, 0xDF, 0xF7, 0xC0, 0xF7, 0xFC, 0xF0, 0x3D, 0xFF, 0x3C,
  0x1F, 0x7F, 0xEF, 0x87, 0x9F, 0xF9, 0xE1, 0xE7, 0xFE, 0x78, 0xF9, 0xFF,
  0x9F, 0x3C, 0x7F, 0xE3, 0xCF, 0x1F, 0xF8, 0xF7, 0xC7, 0xFE, 0x3F, 0xE1,
  0xFF, 0x87, 0xF8, 0x7F, 0xE1, 0xFE, 0x1F, 0xF8, 0x7F, 0x07, 0xFE, 0x0F,
  0xC1, 0xFF, 0x83, 0xF0, 0x7F, 0xE0, 0xFC, 0x1F, 0xF8, 0x1E, 0x07, 0xFE,
  0x07, 0x81, 0xF0, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xBC, 0x1F, 0xFB, 0xE1, 0xFF,
  0x9E, 0x1F, 0xF9, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF9, 0xFF, 0x87, 0x9F,
  0xF8, 0x7D, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xF8, 0xFE, 0x1F, 0x01, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0x7C, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x3E, 0x03, 0xF1,
  0xFC, 0x7F, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFE,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x81,
  0xFD, 0xF0, 0x0F, 0xBE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xBE, 0x03,
  0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83,
  0xF8, 0xFE, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7D, 0xF0,
  0x07, 0xCF, 0x80, 0x3E, 0x7E, 0x03, 0xF1, 0xFC, 0x7F, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x18, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x81, 0xF9, 0xF0, 0x1F, 0xBE,
  0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C,
  0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x7F, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xE1, 0xF0,
  0x7E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x9F, 0x01, 0xF3, 0xE0,
  0x3F, 0x7C, 0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x07, 0xC0, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xE1, 0xF8, 0xF8, 0x1F, 0xBE,
  0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7D, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xCF, 0xC3, 0xF9, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xEF,
  0xE1, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xF0, 0x00,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0x3E, 0x7C,
  0x00, 0xF9, 0xF0, 0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x3C, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1F,
  0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xF8,
  0x07, 0x80, 0x7F, 0xE0, 0x1E, 0x01, 0xE7, 0xC0, 0xFC, 0x0F, 0x9F, 0x03,
  0xF0, 0x3E, 0x7C, 0x0F, 0xC0, 0xF9, 0xF0, 0x3F, 0x03, 0xE7, 0xC0, 0xFC,
  0x0F, 0x8F, 0x07, 0xF8, 0x3C, 0x3C, 0x1F, 0xE1, 0xF0, 0xF8, 0x7F, 0x87,
  0xC3, 0xE1, 0xFE, 0x1F, 0x0F, 0x87, 0xF8, 0x7C, 0x1E, 0x3C, 0xF1, 0xE0,
  0x78, 0xF3, 0xC7, 0x81, 0xE3, 0xCF, 0x3E, 0x07, 0xCF, 0x3C, 0xF8, 0x1F,
  0x38, 0x73, 0xE0, 0x7D, 0xE1, 0xEF, 0x00, 0xF7, 0x87, 0xBC, 0x03, 0xDE,
  0x1E, 0xF0, 0x0F, 0x78, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03,
  0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE,
  0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0x9F, 0x80, 0xFC,
  0x7E, 0x07, 0xC3, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x7E, 0x1F, 0x01, 0xF1,
  0xF0, 0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF8, 0x07,
  0xE7, 0xC0, 0x3E, 0x3F, 0x03, 0xF0, 0xF8, 0x1F, 0x07, 0xE1, 0xF8, 0x1F,
  0x0F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xC0, 0x1F, 0xFE, 0x00, 0xFC, 0x7C,
  0x00, 0xFD, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x3F, 0x01,
  0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xC0,
  0x1E, 0x1F, 0x00, 0x7C, 0x78, 0x01, 0xF3, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0xFF, 0xFF, 0xFE, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0xFF, 0xFF, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0x80, 0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x81, 0xFE,
  0x07, 0x38, 0x3C, 0xF0, 0xF3, 0xC3, 0xC7, 0x1E, 0x1E, 0x78, 0x79, 0xE1,
  0xEF, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C,
  0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7F, 0xFE, 0x7C, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x07, 0xFE, 0x1F, 0xFE, 0x7F, 0xFE, 0x7E, 0x1E, 0xF8, 0x1E, 0xF8,
  0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x7E, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F,
  0xDF, 0x1F, 0x9F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x7E, 0x1F, 0x7F, 0x8F, 0xFF, 0xE7, 0xFF, 0xFB, 0xF8, 0xFD, 0xF8,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0xC3, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xEF, 0xF1, 0xF3, 0xF0, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7F,
  0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x0F, 0x8F, 0x3F, 0xEF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFC,
  0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0x7C, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xEF, 0x0F, 0x8F, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xC3, 0xF7, 0xC0, 0xFB,
  0xE0, 0x3D, 0xF0, 0x1E, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x06, 0x3F,
  0x07, 0x1F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0x80, 0x01, 0xF0,
  0x7F, 0x0F, 0xF0, 0xFF, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0xCF,
  0x8F, 0xF7, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xE3, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xBF, 0x1F,
  0xDF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFE, 0xF8, 0x7E, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x10, 0x0F, 0x8E, 0x0F, 0xC7, 0xFF, 0xC7, 0xFF, 0xE0,
  0xFF, 0xC0, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x3F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x79, 0xFF, 0xDF, 0x78,
  0x00, 0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79,
  0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x0F, 0x0F, 0x87, 0xE3, 0xE0,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0xDF, 0xEF,
  0xE7, 0xF3, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x07, 0xDF, 0x07, 0xEF, 0x87, 0xE7, 0xC3, 0xE3, 0xE3, 0xE1, 0xF3,
  0xF0, 0xF9, 0xF0, 0x7D, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0xC1, 0xFB, 0xE0, 0xF8, 0xF8, 0x7C, 0x7E, 0x3E, 0x1F,
  0x1F, 0x0F, 0xCF, 0x83, 0xE7, 0xC0, 0xFB, 0xE0, 0x7F, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x3E, 0x1F, 0x7F, 0x8F, 0xF3, 0xFF, 0xFB,
  0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xE3, 0xFC, 0x7F, 0xF8, 0x3F, 0x07, 0xFE,
  0x07, 0xC0, 0xFF, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0x03, 0xFF, 0x03, 0xE0,
  0x7F, 0xE0, 0x7C, 0x0F, 0xFC, 0x0F, 0x81, 0xFF, 0x81, 0xF0, 0x3F, 0xF0,
  0x3E, 0x07, 0xFE, 0x07, 0xC0, 0xFF, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0x03,
  0xFF, 0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0xFC, 0x0F, 0x81, 0xFF, 0x81,
  0xF0, 0x3F, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xE3,
  0xF7, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xFC, 0x1F, 0xBF, 0x1F, 0x9F, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F,
  0x80, 0xF9, 0xF8, 0x7D, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xE3, 0xF7,
  0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xFE, 0x1F, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xBF, 0xC7, 0xCF, 0xC3,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x0F, 0xCF, 0x3F, 0xEF, 0x7F,
  0xFF, 0x7F, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F,
  0xEF, 0x0F, 0xCF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xF9, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xEF,
  0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF0, 0x7D, 0xFF, 0xFB, 0xFF, 0xE3, 0xFF, 0x81, 0xFC, 0x00, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0xE1, 0xFC, 0x1F, 0x81,
  0xF0, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7C,
  0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xEF, 0x0F, 0x8F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xBE, 0x07, 0xCF, 0x03, 0xE7, 0xC1, 0xE3, 0xE1, 0xF0, 0xF0, 0xF8,
  0x78, 0x7C, 0x3E, 0x3C, 0x1F, 0x1E, 0x07, 0x9F, 0x03, 0xCF, 0x01, 0xF7,
  0x80, 0x7B, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0xF8, 0x1C, 0x0F, 0xFC,
  0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xCF, 0x07, 0xC1, 0xE7, 0x83, 0xE0, 0xF3,
  0xE3, 0xF8, 0xF9, 0xF1, 0xFC, 0x7C, 0x78, 0xFE, 0x3C, 0x3C, 0xF7, 0x1E,
  0x1E, 0x7B, 0xCF, 0x0F, 0xBD, 0xEF, 0x87, 0xDC, 0xF7, 0x81, 0xFE, 0x3B,
  0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0x87, 0xF8, 0x0F, 0xC1,
  0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x3F, 0x00, 0x78,
  0x0F, 0x00, 0x3C, 0x07, 0x80, 0xFC, 0x1F, 0x3E, 0x0F, 0x9F, 0x0F, 0x87,
  0xC7, 0xC3, 0xE7, 0xC0, 0xFB, 0xE0, 0x7D, 0xE0, 0x1F, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x3E, 0xF0, 0x1F, 0x7C, 0x1F, 0x1E, 0x0F, 0x8F, 0x8F, 0x87, 0xE7,
  0xC1, 0xF7, 0xC0, 0xFC, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xCF, 0x83,
  0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x78, 0x3E, 0x7C, 0x1F,
  0x3E, 0x07, 0x9F, 0x03, 0xCF, 0x01, 0xF7, 0x80, 0xFF, 0xC0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x38, 0x0F, 0x83, 0xE0, 0xF8, 0x1E,
  0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x07, 0xC3, 0xF8, 0x7E, 0x0F, 0x81, 0xF8, 0x0F, 0x80,
  0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x70, 0x06, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x40, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x03, 0xC0,
  0xFC, 0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x3E,
  0x0F, 0x01, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x0F, 0x3F, 0xE0, 0xF7, 0xFF,
  0x0F, 0x79, 0xF9, 0xE7, 0x0F, 0xFE, 0xF0, 0x7F, 0xCF, 0x03, 0xF8, 0x00,
  0x0F, 0x00,
};

const GFXglyph RobotoCondensed_Medium42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 30, 11, 3, -30 },
  { 20, 10, 11, 13, 2, -32 },
  { 34, 19, 30, 23, 2, -30 },
  { 106, 17, 38, 21, 2, -34 },
  { 187, 23, 30, 27, 2, -30 },
  { 274, 21, 30, 24, 2, -30 },
  { 353, 3, 11, 7, 2, -32 },
  { 358, 9, 42, 13, 3, -33 },
  { 406, 10, 42, 14, 1, -33 },
  { 459, 17, 18, 19, 1, -30 },
  { 498, 17, 22, 20, 2, -25 },
  { 545, 6, 12, 9, 1, -5 },
  { 554, 9, 4, 13, 2, -15 },
  { 559, 6, 6, 12, 3, -6 },
  { 564, 14, 33, 15, 0, -30 },
  { 622, 17, 30, 21, 2, -30 },
  { 686, 11, 30, 21, 3, -30 },
  { 728, 17, 30, 21, 2, -30 },
  { 792, 17, 30, 21, 2, -30 },
  { 856, 19, 30, 21, 1, -30 },
  { 928, 17, 30, 21, 2, -30 },
  { 992, 17, 30, 21, 2, -30 },
  { 1056, 17, 30, 21, 2, -30 },
  { 1120, 17, 30, 21, 2, -30 },
  { 1184, 17, 30, 21, 2, -30 },
  { 1248, 6, 23, 11, 3, -23 },
  { 1266, 7, 30, 10, 1, -23 },
  { 1293, 15, 20, 19, 1, -23 },
  { 1331, 15, 13, 21, 3, -20 },
  { 1356, 15, 20, 19, 3, -23 },
  { 1394, 16, 30, 18, 1, -30 },
  { 1454, 28, 38, 32, 2, -29 },
  { 1587, 23, 30, 25, 1, -30 },
  { 1674, 18, 30, 23, 3, -30 },
  { 1742, 20, 30, 24, 2, -30 },
  { 1817, 19, 30, 24, 3, -30 },
  { 1889, 16, 30, 21, 3, -30 },
  { 1949, 16, 30, 20, 3, -30 },
  { 2009, 20, 30, 25, 2, -30 },
  { 2084, 20, 30, 26, 3, -30 },
  { 2159, 5, 30, 11, 3, -30 },
  { 2178, 17, 30, 20, 1, -30 },
  { 2242, 20, 30, 23, 3, -30 },
  { 2317, 16, 30, 20, 3, -30 },
  { 2377, 26, 30, 32, 3, -30 },
  { 2475, 20, 30, 26, 3, -30 },
  { 2550, 21, 30, 25, 2, -30 },
  { 2629, 19, 30, 24, 3, -30 },
  { 2701, 21, 35, 25, 2, -30 },
  { 2793, 19, 30, 23, 3, -30 },
  { 2865, 19, 30, 22, 2, -30 },
  { 2937, 20, 30, 22, 1, -30 },
  { 3012, 19, 30, 24, 2, -30 },
  { 3084, 22, 30, 24, 1, -30 },
  { 3167, 30, 30, 32, 1, -30 },
  { 3280, 21, 30, 23, 1, -30 },
  { 3359, 22, 30, 22, 0, -30 },
  { 3442, 19, 30, 22, 2, -30 },
  { 3514, 7, 41, 11, 3, -34 },
  { 3550, 15, 33, 16, 1, -30 },
  { 3612, 7, 41, 11, 1, -34 },
  { 3648, 14, 15, 16, 1, -30 },
  { 3675, 16, 4, 17, 0, 0 },
  { 3683, 10, 6, 13, 1, -31 },
  { 3691, 16, 22, 20, 2, -22 },
  { 3735, 17, 32, 21, 2, -32 },
  { 3803, 16, 22, 19, 2, -22 },
  { 3847, 16, 32, 21, 2, -32 },
  { 3911, 17, 22, 20, 2, -22 },
  { 3958, 12, 32, 14, 1, -32 },
  { 4006, 17, 31, 21, 2, -22 },
  { 4072, 16, 32, 20, 2, -32 },
  { 4136, 6, 30, 10, 2, -30 },
  { 4159, 9, 39, 10, -1, -30 },
  { 4203, 17, 32, 20, 2, -32 },
  { 4271, 4, 32, 10, 3, -32 },
  { 4287, 27, 22, 31, 2, -22 },
  { 4362, 16, 22, 21, 2, -22 },
  { 4406, 17, 22, 21, 2, -22 },
  { 4453, 17, 31, 21, 2, -22 },
  { 4519, 16, 31, 21, 2, -22 },
  { 4581, 11, 22, 13, 2, -22 },
  { 4612, 15, 22, 19, 2, -22 },
  { 4654, 11, 28, 13, 0, -28 },
  { 4693, 16, 22, 20, 2, -22 },
  { 4737, 17, 22, 18, 1, -22 },
  { 4784, 25, 22, 27, 1, -22 },
  { 4853, 17, 22, 19, 1, -22 },
  { 4900, 17, 31, 18, 1, -22 },
  { 4966, 15, 22, 19, 2, -22 },
  { 5008, 11, 40, 13, 1, -33 },
  { 5063, 3, 36, 10, 4, -30 },
  { 5077, 10, 40, 13, 1, -33 },
  { 5127, 20, 9, 24, 2, -17 },
};

const GFXfont RobotoCondensed_Medium42pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium42pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium42pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOCONDENSED_MEDIUM42PT7B_H_
