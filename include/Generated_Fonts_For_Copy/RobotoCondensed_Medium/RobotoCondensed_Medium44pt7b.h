#ifndef _ROBOTOCONDENSED_MEDIUM44PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF7, 0x80, 0x00, 0x03, 0xBF, 0xFF, 0xFD, 0xC0, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0x00,
  0xE1, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xC3, 0x80,
  0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x83, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x03, 0x87, 0x00, 0x38, 0x70, 0x07, 0x8F,
  0x00, 0x78, 0xF0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x0F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0x1E, 0x00, 0xE1, 0xC0, 0x0E,
  0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01,
  0xC3, 0x80, 0x1C, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFF, 0x0F, 0xCF, 0xE3, 0xE0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0xDF, 0x01,
  0xF7, 0xC0, 0x7D, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xDF, 0x03,
  0xF7, 0xC0, 0xF9, 0xFC, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0,
  0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x1F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0xF0,
  0xE0, 0x60, 0xF0, 0xE0, 0xE0, 0xF0, 0xF1, 0xE0, 0xF0, 0xF1, 0xC0, 0xF0,
  0xF3, 0xC0, 0xF0, 0xE3, 0x80, 0xF0, 0xE7, 0x80, 0x79, 0xE7, 0x00, 0x7F,
  0xCE, 0x00, 0x3F, 0xCE, 0x00, 0x1F, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0xF8, 0x00, 0x79, 0xFC, 0x00, 0x73, 0xFE, 0x00, 0xF7, 0x9E, 0x00,
  0xE7, 0x8F, 0x01, 0xE7, 0x07, 0x01, 0xC7, 0x07, 0x03, 0x87, 0x07, 0x03,
  0x87, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x07, 0x8F, 0x02, 0x07, 0x9E, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0x3F, 0x00, 0xF8, 0x7C,
  0x03, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x78, 0x01,
  0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0xF8, 0xFF, 0xE3, 0xC7, 0xCF, 0x8F,
  0x3F, 0x3F, 0x3C, 0xF8, 0x7E, 0xF3, 0xE0, 0xFF, 0xCF, 0x83, 0xFF, 0x3E,
  0x07, 0xF8, 0xF8, 0x0F, 0xE3, 0xF0, 0x3F, 0x07, 0xE3, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xF7, 0xE0, 0x7F, 0x0F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xEE, 0xEE, 0xE0, 0x00, 0x80, 0x60, 0x3C, 0x1E, 0x07, 0x83, 0xC1,
  0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0xC0,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x06, 0x00,
  0x80, 0x40, 0x0C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0,
  0x30, 0x04, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x10, 0x78, 0x2F, 0x9E, 0x3B, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xDE, 0x01, 0xF3,
  0xC0, 0x78, 0xF8, 0x3C, 0x1F, 0x07, 0x03, 0x80, 0x80, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xC7, 0x8F, 0x3E, 0x79, 0xF3, 0xC1,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x73, 0xFF, 0xFF, 0xFD, 0xE0, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x3F, 0x1F, 0x87,
  0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xF7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x87, 0xE3, 0xF3, 0xF0,
  0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x30, 0x1F,
  0x07, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x1F, 0x81, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x3F, 0x9F, 0x07, 0xEF, 0x80, 0xFB,
  0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x7E, 0x3F, 0x1F, 0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x3E,
  0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x3E,
  0xF8, 0x0F, 0xBF, 0x07, 0xE7, 0xE3, 0xF9, 0xFF, 0xFC, 0x3F, 0xFE, 0x07,
  0xFF, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1E, 0xF8,
  0x01, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0x8F,
  0x80, 0xF8, 0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3C, 0x0F, 0x87, 0xC0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0xFF,
  0x1F, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xE7, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x3E, 0x07,
  0xFF, 0xC3, 0xFF, 0xF3, 0xFF, 0xFD, 0xF8, 0xFE, 0x38, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xFE, 0x0F, 0x9F, 0x9F, 0xCF, 0xFF, 0xC3, 0xFF, 0xE0,
  0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xCF, 0x81, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7,
  0xF1, 0xFB, 0xF8, 0x3E, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x0F,
  0xCF, 0x83, 0xE3, 0xF3, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x00,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x3F, 0x1F,
  0x87, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0,
  0xF9, 0xF8, 0x7C, 0x3F, 0x3F, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xFF, 0x0F, 0x87, 0xC7, 0xC0, 0xF9, 0xF0, 0x3E, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0x9F, 0x03, 0xE7, 0xF3,
  0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xF3, 0xF3, 0xE0, 0xF9, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7D, 0xF0, 0x3E, 0xF8, 0x3F, 0x7E, 0x3F, 0x9F, 0xFF,
  0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0x7C, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x00,
  0x7F, 0x00, 0x3C, 0x00, 0x73, 0xEF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x3E, 0xFF, 0xFF, 0xDE, 0x1C, 0x7D,
  0xFB, 0xF3, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0xF3, 0xE7, 0x9E,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF,
  0x07, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xFC, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x03,
  0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFE, 0x00, 0x7C, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8,
  0x7F, 0xC0, 0xFE, 0x01, 0xF0, 0x03, 0x80, 0x04, 0x00, 0x00, 0x07, 0xF0,
  0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0x7F, 0x7C, 0x1F, 0xFC, 0x1F,
  0xF8, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7E, 0x0F, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x70, 0x70, 0x0F,
  0x81, 0xC3, 0xC0, 0xFF, 0x83, 0x8E, 0x07, 0xFF, 0x0E, 0x78, 0x1E, 0x3C,
  0x39, 0xE0, 0xF0, 0xE0, 0xE7, 0x03, 0x83, 0x83, 0xDC, 0x1E, 0x0E, 0x07,
  0xF0, 0x78, 0x38, 0x1F, 0xC3, 0xC0, 0xE0, 0x7F, 0x0F, 0x07, 0x81, 0xFC,
  0x3C, 0x1E, 0x07, 0xF0, 0xF0, 0x78, 0x1F, 0xC3, 0xC1, 0xE0, 0xFF, 0x0F,
  0x07, 0x83, 0xBC, 0x3C, 0x1E, 0x0E, 0xF0, 0xF0, 0x78, 0x3B, 0xC3, 0xC3,
  0xE1, 0xEF, 0x0F, 0x8F, 0x87, 0x3C, 0x1F, 0xFE, 0x3C, 0x70, 0x7F, 0xBF,
  0xE1, 0xE0, 0xFC, 0xFF, 0x07, 0x81, 0xE0, 0xF8, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x08, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xE7, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xC7,
  0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0x81,
  0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3E, 0x00,
  0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0x83, 0xFD, 0xF0, 0x1F, 0xBE, 0x01, 0xF7,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF,
  0x81, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F,
  0x01, 0xFB, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0x7F,
  0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFC, 0xFF, 0x1F, 0x80,
  0xF9, 0xF8, 0x07, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F,
  0x7E, 0x01, 0xF9, 0xF8, 0x0F, 0x8F, 0xF3, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xF8, 0x7F, 0x8F, 0x80, 0xFC, 0xF8, 0x07,
  0xCF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x80, 0xFC,
  0xF8, 0x7F, 0x8F, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFF, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3,
  0xFC, 0xFF, 0x1F, 0x80, 0xF9, 0xF8, 0x07, 0xEF, 0x80, 0x1F, 0x7C, 0x00,
  0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0,
  0x03, 0xEF, 0x80, 0x1F, 0x7E, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0xF9, 0xFE,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC,
  0x0F, 0x9F, 0x07, 0xE7, 0xF3, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF,
  0x00, 0x7F, 0x00, 0xF8, 0x03, 0xF7, 0xC0, 0x3F, 0xBE, 0x01, 0xF9, 0xF0,
  0x1F, 0x8F, 0x80, 0xFC, 0x7C, 0x0F, 0xC3, 0xE0, 0xFC, 0x1F, 0x07, 0xE0,
  0xF8, 0x7E, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x01, 0xF3, 0xF0, 0x0F, 0xBF,
  0x00, 0x7D, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xBF, 0x01, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x1F,
  0x83, 0xE0, 0xFC, 0x1F, 0x03, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7E, 0x3E,
  0x01, 0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x7C, 0x01, 0xFB, 0xE0, 0x07,
  0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xBF, 0xFF, 0x00, 0xF7, 0xFF, 0xE0, 0x3E, 0xFF,
  0xBC, 0x07, 0x9F, 0xF7, 0xC0, 0xF7, 0xFE, 0xF8, 0x3E, 0xFF, 0xCF, 0x07,
  0x9F, 0xF9, 0xF0, 0xF3, 0xFF, 0x3E, 0x3E, 0x7F, 0xE3, 0xC7, 0xCF, 0xFC,
  0x7C, 0xF1, 0xFF, 0x8F, 0xBE, 0x3F, 0xF0, 0xF7, 0xC7, 0xFE, 0x1E, 0xF0,
  0xFF, 0xC3, 0xFE, 0x1F, 0xF8, 0x3F, 0xC3, 0xFF, 0x07, 0xF0, 0x7F, 0xE0,
  0xFE, 0x0F, 0xFC, 0x0F, 0xC1, 0xFF, 0x81, 0xF0, 0x3F, 0xF0, 0x3E, 0x07,
  0xFE, 0x03, 0xC0, 0xF8, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xF7, 0xC1, 0xFF,
  0x9E, 0x0F, 0xFC, 0xF8, 0x7F, 0xE3, 0xC3, 0xFF, 0x1F, 0x1F, 0xF8, 0x78,
  0xFF, 0xC3, 0xE7, 0xFE, 0x0F, 0xBF, 0xF0, 0x7D, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x03, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xEF, 0xF0, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x00, 0x3E,
  0x7C, 0x00, 0xFD, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7D,
  0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x3E, 0x7E, 0x00, 0xF8, 0xFC,
  0x07, 0xE3, 0xFE, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0xF8, 0x1F, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x7E, 0xF8, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xEF, 0xF0,
  0xFC, 0x0F, 0xE7, 0xE0, 0x1F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF7, 0xC0,
  0x0F, 0xDF, 0x00, 0x3E, 0x7E, 0x01, 0xF8, 0xFC, 0x0F, 0xE3, 0xFE, 0xFF,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x0C, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xF8,
  0x3F, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0xFC,
  0xF8, 0x3F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0xF8,
  0x07, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0x1F, 0xC7, 0xE0, 0x7E, 0xFC, 0x07,
  0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xE7, 0xE0, 0x7E,
  0x7F, 0x8F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0xC0, 0x7E, 0x7F, 0xBF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81,
  0xFF, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0xC0, 0x1F, 0x8F, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x07,
  0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8,
  0x07, 0xC1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00,
  0x1E, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x00,
  0xF7, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0xF8, 0x0F, 0x80, 0x7D, 0xF0, 0x1F, 0x00, 0xFB, 0xE0,
  0x3F, 0x03, 0xF7, 0xC0, 0x7E, 0x07, 0xCF, 0x81, 0xFC, 0x0F, 0x9F, 0x03,
  0xF8, 0x1F, 0x1F, 0x07, 0xF0, 0x3E, 0x3E, 0x0F, 0xF0, 0x7C, 0x7C, 0x1F,
  0xE1, 0xF0, 0xF8, 0x7F, 0xC3, 0xE1, 0xF0, 0xF7, 0x87, 0xC1, 0xE1, 0xEF,
  0x0F, 0x83, 0xE3, 0xCF, 0x1F, 0x07, 0xC7, 0x9E, 0x3C, 0x0F, 0x9F, 0x3C,
  0xF8, 0x1F, 0x3C, 0x79, 0xF0, 0x1E, 0x78, 0xFB, 0xE0, 0x3C, 0xF0, 0xF7,
  0xC0, 0x7D, 0xE1, 0xEF, 0x80, 0xFF, 0x83, 0xDE, 0x01, 0xFF, 0x07, 0xBC,
  0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0,
  0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0xFD, 0xF8, 0x03, 0xF3, 0xE0, 0x1F, 0x8F, 0xC0, 0x7C, 0x1F,
  0x03, 0xF0, 0x7E, 0x0F, 0x80, 0xF8, 0x7E, 0x03, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x1F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0x3F,
  0x00, 0xFC, 0xFC, 0x03, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0xC3,
  0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x03, 0xFF, 0xC0,
  0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF8,
  0x07, 0xC3, 0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x07, 0xE0, 0x7C, 0x07, 0xC1,
  0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x1F, 0x3E,
  0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7F, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0xFF, 0xFF, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFE, 0x01,
  0xFC, 0x07, 0xB8, 0x0F, 0x78, 0x1E, 0xF0, 0x78, 0xE0, 0xF1, 0xE1, 0xE3,
  0xC7, 0x87, 0x8F, 0x07, 0x9E, 0x0F, 0x7C, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81,
  0xF0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xE3, 0xF3,
  0xE0, 0xFB, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x03, 0xFF, 0x87, 0xFF,
  0xC7, 0xFF, 0xE7, 0xF1, 0xF7, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8,
  0x1F, 0x7C, 0x0F, 0xBF, 0x1F, 0xCF, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0x7C,
  0x3E, 0x3E, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x7C, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xFB, 0xF9, 0xFD, 0xF0, 0x3E,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x03, 0xEF, 0xE7, 0xF7, 0xFF, 0xFB, 0xDF, 0xF9, 0xEF, 0xF8, 0xF1, 0xF0,
  0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xE3, 0xF7,
  0xE0, 0xFB, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x0F, 0xDF, 0x8F, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0,
  0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC3,
  0xF3, 0xE3, 0xFD, 0xF3, 0xFF, 0xFB, 0xFF, 0xFD, 0xFC, 0xFF, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x81, 0xF7, 0xF3, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xCF, 0x0F, 0xC7,
  0x80, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE3, 0xF3,
  0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x01, 0x9F, 0xC3, 0xC7, 0xFF, 0xF3, 0xFF, 0xF0, 0x7F, 0xF0,
  0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFC, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F,
  0xF8, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC7, 0x8F, 0xFB,
  0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xF3, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xDF, 0xCF,
  0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC4, 0x03, 0xE7, 0x87, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0,
  0x7F, 0xF0, 0x0F, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x3E, 0x1F, 0x7F, 0xCF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFC, 0xFF,
  0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0x80, 0x27, 0xFF, 0xFF, 0xB8, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x04,
  0x07, 0x87, 0xE3, 0xF0, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE3, 0xF3, 0xF7, 0xFB, 0xFD, 0xFC, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x0F, 0xDF, 0x07, 0xCF,
  0x87, 0xE7, 0xC7, 0xE3, 0xE3, 0xE1, 0xF3, 0xF0, 0xFB, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xE0, 0xF9, 0xF0, 0x7C, 0x7C, 0x3E, 0x3F, 0x1F, 0x0F, 0x8F, 0x87, 0xE7,
  0xC1, 0xF3, 0xE0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF1, 0xF0, 0x3F, 0x1E, 0xFF, 0x8F,
  0xF3, 0xFF, 0xFB, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFC, 0xFF, 0xF0,
  0x7F, 0x07, 0xFE, 0x07, 0xC0, 0xFF, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0x03,
  0xFF, 0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0xFC, 0x0F, 0x81, 0xFF, 0x81,
  0xF0, 0x3F, 0xF0, 0x3E, 0x07, 0xFE, 0x07, 0xC0, 0xFF, 0xC0, 0xF8, 0x1F,
  0xF8, 0x1F, 0x03, 0xFF, 0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0xFC, 0x0F,
  0x81, 0xFF, 0x81, 0xF0, 0x3F, 0xF0, 0x3E, 0x07, 0xFE, 0x07, 0xC0, 0xF8,
  0xF8, 0xF8, 0x7C, 0xFF, 0x3E, 0xFF, 0xDF, 0xFF, 0xEF, 0xF3, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3E, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0x3F,
  0x9F, 0x03, 0xEF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xFC, 0x0F, 0xDF, 0x03, 0xE7, 0xF3, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0x00, 0x3F, 0x00, 0xF1, 0xF0, 0x7B, 0xFE, 0x3F, 0xFF, 0x9F,
  0xFF, 0xEF, 0xE7, 0xF7, 0xC0, 0xFB, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xBF, 0x1F, 0xDF, 0xFF, 0xEF,
  0xFF, 0xE7, 0xFF, 0xE3, 0xE7, 0xC1, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x0F, 0xC7, 0x8F, 0xFB, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xE3, 0xFF,
  0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x07, 0xDF, 0x8F, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC,
  0x1F, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xF1, 0xFD, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x3F, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0x01, 0xF0, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xBE, 0x0F, 0xDF, 0x8F,
  0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0x7C, 0x3F, 0x3E, 0xF8, 0x0F, 0xFC,
  0x07, 0xFF, 0x03, 0xEF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF8, 0xF0, 0x7C,
  0x7C, 0x3C, 0x3E, 0x3E, 0x0F, 0x1F, 0x07, 0x8F, 0x03, 0xE7, 0x81, 0xF7,
  0xC0, 0x7B, 0xE0, 0x3D, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x1E,
  0x07, 0xFE, 0x07, 0x81, 0xFF, 0x81, 0xF0, 0x7D, 0xE0, 0xFC, 0x1E, 0x7C,
  0x3F, 0x07, 0x9F, 0x0F, 0xC3, 0xE7, 0xC3, 0xF8, 0xF8, 0xF1, 0xFE, 0x3E,
  0x3C, 0x7F, 0x8F, 0x0F, 0x9F, 0xE3, 0xC3, 0xE7, 0x3D, 0xF0, 0x7B, 0xCF,
  0x7C, 0x1E, 0xF3, 0xDE, 0x07, 0xBC, 0xF7, 0x81, 0xFE, 0x1F, 0xE0, 0x7F,
  0x87, 0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x0F, 0xC0,
  0x3F, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x07,
  0x80, 0xFC, 0x0F, 0x9F, 0x07, 0xE7, 0xE1, 0xF0, 0xF8, 0xFC, 0x3F, 0x3E,
  0x07, 0xCF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x1F, 0x7C, 0x07, 0xCF, 0x83, 0xF3, 0xE0, 0xF8, 0x7C, 0x7E, 0x1F,
  0x1F, 0x03, 0xEF, 0xC0, 0xFC, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xEF,
  0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF8, 0x7C, 0x7C, 0x7C, 0x3E, 0x3E,
  0x1F, 0x1F, 0x07, 0x8F, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0x7B, 0xC0, 0x3D,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x03, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x40, 0x3C, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0,
  0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x40,
  0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x3E, 0x07, 0xF0, 0x7E, 0x07, 0xC1, 0xF8, 0x7C, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F,
  0x03, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0x70, 0x08, 0x00, 0x0F, 0x80, 0x00,
  0xFE, 0x03, 0xCF, 0xF8, 0x1E, 0xFF, 0xE1, 0xF7, 0xDF, 0xDF, 0x3C, 0x3F,
  0xFB, 0xC0, 0xFF, 0x9E, 0x03, 0xF8, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoCondensed_Medium44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 31, 11, 3, -31 },
  { 21, 10, 11, 14, 2, -33 },
  { 35, 20, 31, 24, 2, -31 },
  { 113, 18, 40, 22, 2, -36 },
  { 203, 24, 31, 28, 2, -31 },
  { 296, 22, 31, 25, 2, -31 },
  { 382, 4, 11, 7, 2, -33 },
  { 388, 10, 45, 14, 3, -35 },
  { 445, 11, 45, 14, 1, -35 },
  { 507, 18, 19, 20, 1, -31 },
  { 550, 18, 23, 21, 2, -26 },
  { 602, 7, 12, 10, 1, -5 },
  { 613, 10, 4, 14, 2, -15 },
  { 618, 6, 6, 12, 3, -6 },
  { 623, 14, 34, 15, 0, -31 },
  { 683, 18, 31, 22, 2, -31 },
  { 753, 12, 31, 22, 3, -31 },
  { 800, 18, 31, 22, 2, -31 },
  { 870, 18, 31, 22, 2, -31 },
  { 940, 20, 31, 22, 1, -31 },
  { 1018, 17, 31, 22, 3, -31 },
  { 1084, 18, 31, 22, 2, -31 },
  { 1154, 18, 31, 22, 2, -31 },
  { 1224, 18, 31, 22, 2, -31 },
  { 1294, 17, 31, 22, 2, -31 },
  { 1360, 6, 24, 11, 3, -24 },
  { 1378, 7, 31, 10, 1, -24 },
  { 1406, 16, 20, 20, 1, -24 },
  { 1446, 16, 13, 22, 3, -21 },
  { 1472, 15, 20, 20, 3, -24 },
  { 1510, 16, 31, 19, 1, -31 },
  { 1572, 30, 41, 34, 2, -31 },
  { 1726, 24, 31, 26, 1, -31 },
  { 1819, 19, 31, 24, 3, -31 },
  { 1893, 21, 31, 25, 2, -31 },
  { 1975, 20, 31, 25, 3, -31 },
  { 2053, 17, 31, 22, 3, -31 },
  { 2119, 17, 31, 21, 3, -31 },
  { 2185, 21, 31, 26, 2, -31 },
  { 2267, 21, 31, 27, 3, -31 },
  { 2349, 5, 31, 11, 3, -31 },
  { 2369, 18, 31, 21, 1, -31 },
  { 2439, 21, 31, 24, 3, -31 },
  { 2521, 17, 31, 21, 3, -31 },
  { 2587, 27, 31, 33, 3, -31 },
  { 2692, 21, 31, 27, 3, -31 },
  { 2774, 22, 31, 27, 2, -31 },
  { 2860, 20, 31, 25, 3, -31 },
  { 2938, 22, 36, 27, 2, -31 },
  { 3037, 20, 31, 24, 3, -31 },
  { 3115, 20, 31, 23, 2, -31 },
  { 3193, 21, 31, 23, 1, -31 },
  { 3275, 20, 31, 25, 3, -31 },
  { 3353, 23, 31, 25, 1, -31 },
  { 3443, 31, 31, 33, 1, -31 },
  { 3564, 22, 31, 24, 1, -31 },
  { 3650, 23, 31, 24, 0, -31 },
  { 3740, 20, 31, 23, 2, -31 },
  { 3818, 7, 43, 11, 3, -36 },
  { 3856, 16, 34, 17, 1, -31 },
  { 3924, 7, 43, 11, 1, -36 },
  { 3962, 15, 16, 17, 1, -31 },
  { 3992, 17, 4, 18, 0, 0 },
  { 4001, 10, 6, 14, 1, -33 },
  { 4009, 17, 23, 21, 2, -23 },
  { 4058, 17, 33, 22, 3, -33 },
  { 4129, 17, 23, 20, 2, -23 },
  { 4178, 17, 33, 22, 2, -33 },
  { 4249, 17, 23, 21, 2, -23 },
  { 4298, 13, 33, 14, 1, -33 },
  { 4352, 17, 32, 22, 2, -23 },
  { 4420, 17, 33, 21, 2, -33 },
  { 4491, 5, 32, 11, 3, -32 },
  { 4511, 9, 41, 10, -1, -32 },
  { 4558, 17, 33, 20, 3, -33 },
  { 4629, 5, 33, 11, 3, -33 },
  { 4650, 27, 23, 33, 3, -23 },
  { 4728, 17, 23, 22, 2, -23 },
  { 4777, 18, 23, 22, 2, -23 },
  { 4829, 17, 32, 22, 3, -23 },
  { 4897, 17, 32, 22, 2, -23 },
  { 4965, 10, 23, 14, 3, -23 },
  { 4994, 16, 23, 20, 2, -23 },
  { 5040, 12, 29, 13, 0, -29 },
  { 5084, 17, 23, 21, 2, -23 },
  { 5133, 17, 23, 19, 1, -23 },
  { 5182, 26, 23, 28, 1, -23 },
  { 5257, 18, 23, 20, 1, -23 },
  { 5309, 17, 32, 19, 1, -23 },
  { 5377, 16, 23, 20, 2, -23 },
  { 5423, 11, 42, 13, 1, -34 },
  { 5481, 3, 37, 11, 4, -31 },
  { 5495, 11, 42, 13, 1, -34 },
  { 5553, 21, 9, 25, 2, -17 },
};

const GFXfont RobotoCondensed_Medium44pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium44pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium44pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _ROBOTOCONDENSED_MEDIUM44PT7B_H_
