#ifndef _ROBOTOCONDENSED_MEDIUM33PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x77, 0x77, 0x00, 0x07, 0xFF,
  0x70, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0x07, 0x38, 0x0E, 0x70,
  0x18, 0xE0, 0x31, 0x80, 0x63, 0x01, 0xC6, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFE, 0x18, 0xE0, 0x31, 0x80, 0xE3, 0x01, 0xC6, 0x03, 0x9C, 0x3F, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFC, 0x31, 0x80, 0xE3, 0x01, 0xCE, 0x03, 0x9C, 0x06,
  0x38, 0x0C, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x1F, 0x03, 0xFE,
  0x3F, 0xF1, 0xF7, 0xCE, 0x1E, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xF8, 0x1F, 0xC0,
  0xFF, 0x07, 0xF8, 0x3F, 0xE7, 0xCF, 0xFE, 0x3F, 0xE0, 0x7C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0E, 0xF0, 0x03, 0x1C,
  0x30, 0xC3, 0x1C, 0x30, 0xC6, 0x0C, 0x33, 0x83, 0x1C, 0xC0, 0xEF, 0x70,
  0x1F, 0xB8, 0x03, 0xCC, 0x00, 0x07, 0x00, 0x01, 0x9E, 0x00, 0xEF, 0xC0,
  0x37, 0xB8, 0x1D, 0xC6, 0x06, 0x71, 0xC3, 0x9C, 0x71, 0xC7, 0x1C, 0x61,
  0xC6, 0x08, 0x7B, 0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xF0,
  0x07, 0xFC, 0x07, 0x9E, 0x03, 0xC7, 0x01, 0xE3, 0x80, 0xF1, 0xC0, 0x79,
  0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0xE3, 0xFC, 0x73,
  0xDE, 0x79, 0xE7, 0xBD, 0xE3, 0xFC, 0xF0, 0xFE, 0x78, 0x3F, 0x1E, 0x0F,
  0x0F, 0x9F, 0xC3, 0xFF, 0xE1, 0xFF, 0x78, 0x3E, 0x3E, 0xFF, 0xFF, 0xFF,
  0x02, 0x06, 0x0E, 0x0E, 0x1C, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0xF0,
  0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x70,
  0x70, 0x38, 0x38, 0x38, 0x1C, 0x0E, 0x0E, 0x06, 0x02, 0x80, 0xC0, 0xE0,
  0x70, 0x38, 0x38, 0x3C, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x38, 0x38, 0x70, 0xE0, 0xC0, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x63, 0x8D, 0xFF, 0xF7, 0xFF, 0xC3, 0xF8, 0x07, 0xC0, 0x3F, 0x01,
  0xEE, 0x07, 0x1C, 0x38, 0x70, 0x20, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x7B, 0xDE, 0xF7, 0x3B, 0xDC, 0x40, 0xFF, 0xFF, 0xFF,
  0x77, 0xFE, 0xE0, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0xE0, 0x00, 0x0F, 0x81, 0xFE, 0x1F, 0xF8, 0xF3, 0xEF, 0x0F, 0x78, 0x3B,
  0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xBC, 0x3C, 0xF3, 0xE7, 0xFE,
  0x1F, 0xE0, 0x3E, 0x00, 0x03, 0x0F, 0x7F, 0xFF, 0xFF, 0xCF, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x3E, 0x78, 0x7B,
  0xC0, 0xEF, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0x83,
  0xFF, 0x1F, 0x3E, 0x78, 0x7B, 0xC0, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0xF0, 0x3F, 0xC0, 0xF7, 0x87, 0x9F, 0x3E, 0x3F, 0xF0, 0x7F, 0x80, 0xFC,
  0x00, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0,
  0x7F, 0x03, 0xBC, 0x0E, 0xF0, 0x73, 0xC1, 0xCF, 0x0E, 0x3C, 0x38, 0xF1,
  0xC3, 0xC7, 0x0F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xF3, 0xFF, 0x9F, 0xFC, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x77, 0xC3, 0xFF, 0x1F, 0xFC,
  0xF1, 0xE1, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1E, 0xF1, 0xE7, 0xFF, 0x1F, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x7E, 0x07,
  0xF0, 0x7E, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF7, 0xC7, 0xFF,
  0x3F, 0xFD, 0xF1, 0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xDE, 0x1E, 0xF1, 0xE3, 0xFF, 0x0F, 0xF0, 0x3E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x0F, 0x81, 0xFE, 0x1F, 0xF8, 0xF3, 0xEF, 0x0F, 0x78,
  0x3B, 0xC1, 0xDE, 0x0E, 0xF0, 0xF3, 0xCF, 0x8F, 0xF8, 0x3F, 0x87, 0xFE,
  0x3C, 0x7B, 0xC1, 0xDE, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xF3, 0xE7,
  0xFF, 0x1F, 0xF0, 0x7E, 0x00, 0x0F, 0x81, 0xFE, 0x1F, 0xF9, 0xF3, 0xCF,
  0x0F, 0x78, 0x7B, 0x81, 0xDC, 0x0E, 0xE0, 0x7F, 0x03, 0xFC, 0x3F, 0xF3,
  0xF7, 0xFF, 0x9F, 0xF8, 0x79, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x0F, 0x83, 0xFC, 0x1F, 0x80, 0xF0, 0x00, 0x77, 0xFE, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xDF, 0xFB, 0x80, 0x7B, 0xDE, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xEF, 0x7B, 0xDE, 0xE7, 0x71, 0x00, 0x00, 0x10,
  0x07, 0x01, 0xF0, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x0F, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF0, 0x07, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F,
  0x03, 0xF0, 0xFE, 0x3F, 0x8F, 0xE0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0x1F,
  0x83, 0xFC, 0x7F, 0xEF, 0x9F, 0xF0, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0xFF, 0x80, 0x0F, 0x8F, 0x80, 0x38, 0x03, 0x80, 0xE0, 0x03,
  0x83, 0x80, 0x03, 0x06, 0x00, 0x07, 0x1C, 0x0F, 0x06, 0x38, 0x7F, 0x0C,
  0xE1, 0xFF, 0x1D, 0xC3, 0x8E, 0x3B, 0x8E, 0x1C, 0x76, 0x1C, 0x30, 0xEC,
  0x38, 0x61, 0xD8, 0x70, 0xC3, 0xB1, 0xC3, 0x87, 0x63, 0x87, 0x0E, 0xC7,
  0x0E, 0x19, 0x8E, 0x1C, 0x33, 0x0E, 0x78, 0xE7, 0x1F, 0xFB, 0x8E, 0x3F,
  0x7E, 0x1C, 0x3C, 0x78, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7F, 0x78, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x77, 0x80, 0x1D, 0xE0, 0x0F, 0x38, 0x03, 0x8F, 0x00,
  0xE3, 0xC0, 0x78, 0x70, 0x1E, 0x1C, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0x80, 0x71, 0xE0, 0x1E, 0xF0, 0x07,
  0xBC, 0x01, 0xEF, 0x00, 0x3C, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x87,
  0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0xF3,
  0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x9E, 0x07, 0xBC, 0x0F, 0x78, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0xF7, 0x83, 0xEF, 0xFF, 0x9F, 0xFF, 0x3F, 0xF8,
  0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x7C, 0x78, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0,
  0x1E, 0x78, 0x1E, 0x7E, 0x7C, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF,
  0x81, 0xFF, 0xC3, 0xFF, 0xE7, 0x8F, 0xCF, 0x03, 0xDE, 0x07, 0xBC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7B, 0xC0, 0xF7, 0x87,
  0xCF, 0xFF, 0x9F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F,
  0xFD, 0xFF, 0xEF, 0xFF, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x7C, 0x78, 0x1E, 0xF0, 0x1E, 0xF0,
  0x0E, 0xF0, 0x0E, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78,
  0x0F, 0x7E, 0x3F, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x3F, 0xFB, 0xE7, 0xFF, 0x1F, 0xF0, 0x3E, 0x00, 0xF0, 0x1E, 0xF0,
  0x3E, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xF8, 0xF1, 0xF0, 0xF1, 0xE0, 0xF3,
  0xE0, 0xF7, 0xC0, 0xF7, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xE0, 0xF9, 0xE0, 0xF1, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x7C, 0xF0,
  0x3C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xB8, 0x3B, 0xFD,
  0xC1, 0xDF, 0xEF, 0x1E, 0xFF, 0x38, 0xE7, 0xF9, 0xC7, 0x3F, 0xCF, 0x79,
  0xFE, 0x3B, 0x8F, 0xF1, 0xDC, 0x7F, 0x8F, 0xE3, 0xFC, 0x3E, 0x1F, 0xE1,
  0xF0, 0xFF, 0x0F, 0x87, 0xF8, 0x38, 0x3F, 0xC1, 0xC1, 0xE0, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFF, 0x0F, 0xF7, 0x0F, 0xF7, 0x8F, 0xF3, 0x8F, 0xF3, 0xCF, 0xF1, 0xEF,
  0xF1, 0xEF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7E, 0x7E, 0x78, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x7E, 0x7E,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7,
  0x83, 0xEF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC1, 0xFF, 0xFF, 0xEF, 0xFF, 0x9F, 0xFC, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x7E, 0x78, 0x1E,
  0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1E, 0x78, 0x1E, 0x7E, 0x7E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x04, 0xFF, 0xE1, 0xFF, 0xE3,
  0xFF, 0xE7, 0x87, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0,
  0x3D, 0xE0, 0x7B, 0xC3, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3C, 0x3C,
  0x78, 0x78, 0xF0, 0xF9, 0xE0, 0xF3, 0xC1, 0xE7, 0x81, 0xEF, 0x03, 0xDE,
  0x07, 0xFC, 0x07, 0x80, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xF3, 0xE7,
  0x83, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3D, 0xE0, 0x7B, 0xE3, 0xF3, 0xFF, 0xC3, 0xFF, 0x01, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFB, 0xE3, 0xE7,
  0xFF, 0x87, 0xFE, 0x03, 0xF8, 0x00, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x80,
  0x7C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0x80, 0xE1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x01,
  0xCF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x03, 0xB8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0xF0, 0x38,
  0x1F, 0xE0, 0x78, 0x3F, 0xC1, 0xF0, 0x7B, 0x83, 0xE0, 0xF7, 0x87, 0xC1,
  0xCF, 0x0F, 0x87, 0x9E, 0x1F, 0x8F, 0x3C, 0x7F, 0x1E, 0x38, 0xEE, 0x3C,
  0x71, 0xDC, 0x70, 0xF3, 0xB8, 0xE1, 0xE7, 0x3B, 0xC3, 0xDC, 0x77, 0x83,
  0xB8, 0xEF, 0x07, 0x71, 0xDC, 0x0E, 0xE3, 0xB8, 0x1F, 0xC3, 0xF0, 0x3F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x78, 0x00, 0xF8, 0x0F, 0x3C, 0x0F, 0x9F, 0x07, 0x87,
  0x87, 0xC3, 0xE3, 0xC0, 0xF1, 0xE0, 0x79, 0xE0, 0x1E, 0xF0, 0x0F, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x1E, 0xF0, 0x1E, 0x78, 0x0F, 0x3E, 0x0F, 0x0F, 0x07, 0x87, 0xC7,
  0x81, 0xE3, 0xC0, 0xFB, 0xE0, 0x3C, 0x78, 0x07, 0xBC, 0x07, 0xDF, 0x03,
  0xC7, 0x81, 0xE3, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0xF0, 0x1E, 0x78, 0x0F,
  0x38, 0x03, 0xBC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xFF, 0xFF, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x0F, 0x00, 0x70, 0xFF, 0xFE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xFF,
  0xFF, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x83, 0xF0, 0x77, 0x0E, 0xE3, 0x9C,
  0x71, 0xCE, 0x3B, 0xC7, 0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8,
  0xF0, 0xF0, 0xF0, 0xE0, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xF1, 0xF7, 0x87,
  0x80, 0x3C, 0x01, 0xE1, 0xFF, 0x3F, 0xFB, 0xF3, 0xDE, 0x1E, 0xE0, 0xFF,
  0x07, 0xBC, 0x7D, 0xFF, 0xE7, 0xFF, 0x1F, 0x78, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF7, 0xC7, 0xFF,
  0x3F, 0xFD, 0xF1, 0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x7B, 0xFF, 0xDD, 0xFC, 0xE7,
  0xC0, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xF9, 0xF7, 0x87, 0xF8, 0x3F, 0xC0,
  0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x77, 0x87, 0xBC, 0x7C,
  0xFF, 0xC7, 0xFC, 0x0F, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x0F, 0x39, 0xFD, 0xDF, 0xFE, 0xF9,
  0xF7, 0x87, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x77, 0x87, 0xBE, 0x7D, 0xFF, 0xE7, 0xF7, 0x0F, 0x38, 0x0F, 0xC0,
  0x7F, 0x83, 0xFF, 0x1F, 0x3E, 0x78, 0x79, 0xC0, 0xEF, 0x03, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x78, 0x11, 0xF1, 0xE3, 0xFF,
  0x87, 0xFC, 0x0F, 0xC0, 0x07, 0x87, 0xC7, 0xE7, 0xC3, 0xC1, 0xE0, 0xF0,
  0x78, 0xFF, 0xFF, 0xFF, 0xE7, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x00, 0x0F, 0x3C, 0xFF,
  0xF7, 0xFF, 0xDF, 0x1F, 0x78, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x78, 0x3D, 0xF3, 0xF3, 0xFF, 0xCF,
  0xFF, 0x0F, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x38, 0xF8, 0xFF, 0xC3,
  0xFF, 0x03, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF7, 0xCF, 0xFE, 0xFF, 0xFF, 0x9F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0xFF, 0xF6, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x0F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x79, 0xFF, 0xDF, 0xBC, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0xF7,
  0x8F, 0xBC, 0xF9, 0xE7, 0x8F, 0x78, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xFC, 0x3D, 0xE1, 0xE7, 0x8F, 0x3E, 0x78, 0xF3, 0xC3, 0xDE, 0x1E,
  0xF0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE7, 0xC3, 0xC7, 0xFF, 0x7F, 0x3F, 0xFF, 0xFD, 0xF3,
  0xF9, 0xEF, 0x0F, 0x87, 0xF8, 0x78, 0x3F, 0xC3, 0xC1, 0xFE, 0x1E, 0x0F,
  0xF0, 0xF0, 0x7F, 0x87, 0x83, 0xFC, 0x3C, 0x1F, 0xE1, 0xE0, 0xFF, 0x0F,
  0x07, 0xF8, 0x78, 0x3F, 0xC3, 0xC1, 0xFE, 0x1E, 0x0F, 0xF0, 0xF0, 0x78,
  0xE7, 0xCE, 0xFE, 0xFF, 0xFF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xF0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x1E, 0x78, 0x3D, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDC, 0x0F, 0x78,
  0x3D, 0xF1, 0xE3, 0xFF, 0x87, 0xFC, 0x0F, 0xC0, 0xE7, 0xC7, 0x7F, 0x3F,
  0xFD, 0xF1, 0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x7B, 0xFF, 0xDF, 0xFC, 0xF7, 0xC7,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x0F,
  0x39, 0xFF, 0xDF, 0xFE, 0xF8, 0xF7, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x77, 0x83, 0xBE, 0x7D, 0xFF, 0xE7,
  0xF7, 0x0F, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0xF7, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x0F, 0x81, 0xFF, 0x1F, 0xFC,
  0xF1, 0xE7, 0x07, 0x3C, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7D, 0xE0, 0xFF, 0x07, 0xBC, 0x79, 0xFF, 0xC7, 0xFC, 0x0F, 0xC0, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC7, 0xFF, 0xFF, 0xFF, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x83, 0xF1, 0xF8, 0x3C,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0xFF, 0xF7, 0xF7,
  0x3E, 0x70, 0xF0, 0x7F, 0x83, 0xBC, 0x3C, 0xE1, 0xE7, 0x8F, 0x3C, 0x71,
  0xE7, 0x87, 0x3C, 0x39, 0xC1, 0xEE, 0x07, 0x70, 0x3F, 0x81, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xE0, 0xE0, 0xFE, 0x1C, 0x3F, 0xC3,
  0xC7, 0xF8, 0xF8, 0xF7, 0x1F, 0x1C, 0xE3, 0xE3, 0x9E, 0xEE, 0x73, 0xDD,
  0xDE, 0x3B, 0xBB, 0xC7, 0x77, 0x70, 0xFC, 0x7E, 0x1F, 0x8F, 0xC1, 0xF1,
  0xF8, 0x3E, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x00, 0xF0,
  0x7B, 0xC7, 0x9E, 0x3C, 0x7B, 0xC3, 0xDC, 0x0F, 0xE0, 0x7E, 0x01, 0xF0,
  0x0F, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0x83, 0xDE, 0x1C, 0xF1, 0xE3, 0xDF,
  0x1E, 0xF0, 0x78, 0x78, 0x3D, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x3C, 0x78,
  0xF3, 0xC3, 0xCF, 0x07, 0x3C, 0x1E, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0xF8, 0x03, 0xE0, 0x0E, 0x00, 0x7F, 0xF7, 0xFF,
  0x7F, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0,
  0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0x07, 0x0F, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C,
  0x38, 0xF8, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x3C, 0x1C, 0x1F, 0x0F, 0x1F, 0x1C, 0x3C, 0x3C, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0xF0, 0xE0, 0xC0, 0x3C, 0x0E,
  0xFE, 0x1D, 0xFC, 0x3F, 0xBE, 0xFE, 0x3F, 0xDC, 0x3F, 0x00, 0x1C, 0x00,
};

const GFXglyph RobotoCondensed_Medium33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 23, 8, 2, -23 },
  { 13, 7, 8, 11, 2, -25 },
  { 20, 15, 23, 18, 2, -23 },
  { 64, 13, 29, 17, 2, -26 },
  { 112, 18, 23, 21, 2, -23 },
  { 164, 17, 23, 19, 1, -23 },
  { 213, 3, 8, 6, 1, -25 },
  { 216, 8, 33, 11, 2, -26 },
  { 249, 8, 33, 11, 1, -26 },
  { 282, 14, 14, 15, 0, -23 },
  { 307, 14, 18, 16, 1, -20 },
  { 339, 5, 9, 7, 1, -4 },
  { 345, 8, 3, 10, 1, -11 },
  { 348, 5, 4, 9, 2, -4 },
  { 351, 11, 25, 12, 0, -23 },
  { 386, 13, 23, 17, 2, -23 },
  { 424, 8, 23, 17, 3, -23 },
  { 447, 14, 23, 17, 1, -23 },
  { 488, 14, 23, 17, 1, -23 },
  { 529, 14, 23, 17, 1, -23 },
  { 570, 13, 23, 17, 2, -23 },
  { 608, 13, 23, 17, 2, -23 },
  { 646, 14, 23, 17, 1, -23 },
  { 687, 13, 23, 17, 2, -23 },
  { 725, 13, 23, 17, 2, -23 },
  { 763, 5, 18, 8, 2, -18 },
  { 775, 5, 23, 8, 1, -18 },
  { 790, 12, 15, 15, 1, -18 },
  { 813, 12, 10, 16, 2, -16 },
  { 828, 12, 15, 15, 2, -18 },
  { 851, 12, 23, 14, 1, -23 },
  { 886, 23, 30, 25, 1, -23 },
  { 973, 18, 23, 19, 1, -23 },
  { 1025, 15, 23, 18, 2, -23 },
  { 1069, 16, 23, 19, 2, -23 },
  { 1115, 15, 23, 19, 2, -23 },
  { 1159, 13, 23, 16, 2, -23 },
  { 1197, 13, 23, 16, 2, -23 },
  { 1235, 16, 23, 19, 2, -23 },
  { 1281, 16, 23, 20, 2, -23 },
  { 1327, 4, 23, 9, 2, -23 },
  { 1339, 13, 23, 16, 1, -23 },
  { 1377, 16, 23, 18, 2, -23 },
  { 1423, 13, 23, 16, 2, -23 },
  { 1461, 21, 23, 25, 2, -23 },
  { 1522, 16, 23, 20, 2, -23 },
  { 1568, 16, 23, 20, 2, -23 },
  { 1614, 15, 23, 19, 2, -23 },
  { 1658, 16, 27, 20, 2, -23 },
  { 1712, 15, 23, 18, 2, -23 },
  { 1756, 15, 23, 17, 1, -23 },
  { 1800, 16, 23, 18, 1, -23 },
  { 1846, 15, 23, 19, 2, -23 },
  { 1890, 18, 23, 19, 0, -23 },
  { 1942, 23, 23, 25, 1, -23 },
  { 2009, 17, 23, 18, 1, -23 },
  { 2058, 17, 23, 18, 0, -23 },
  { 2107, 15, 23, 17, 1, -23 },
  { 2151, 6, 32, 8, 2, -27 },
  { 2175, 12, 25, 12, 0, -23 },
  { 2213, 5, 32, 8, 1, -27 },
  { 2233, 11, 12, 13, 1, -23 },
  { 2250, 13, 3, 13, 0, 0 },
  { 2255, 7, 5, 11, 1, -25 },
  { 2260, 13, 17, 16, 1, -17 },
  { 2288, 13, 25, 16, 2, -25 },
  { 2329, 13, 17, 15, 1, -17 },
  { 2357, 13, 25, 16, 1, -25 },
  { 2398, 14, 17, 16, 1, -17 },
  { 2428, 9, 25, 11, 1, -25 },
  { 2457, 14, 24, 16, 1, -17 },
  { 2499, 12, 25, 16, 2, -25 },
  { 2537, 4, 24, 8, 2, -24 },
  { 2549, 7, 31, 8, -1, -24 },
  { 2577, 13, 25, 15, 2, -25 },
  { 2618, 4, 25, 8, 2, -25 },
  { 2631, 21, 17, 25, 2, -17 },
  { 2676, 12, 17, 16, 2, -17 },
  { 2702, 14, 17, 16, 1, -17 },
  { 2732, 13, 24, 16, 2, -17 },
  { 2771, 13, 24, 16, 1, -17 },
  { 2810, 8, 17, 11, 2, -17 },
  { 2827, 13, 17, 15, 1, -17 },
  { 2855, 9, 22, 10, 0, -22 },
  { 2880, 12, 17, 16, 2, -17 },
  { 2906, 13, 17, 14, 1, -17 },
  { 2934, 19, 17, 21, 1, -17 },
  { 2975, 13, 17, 15, 1, -17 },
  { 3003, 14, 24, 14, 0, -17 },
  { 3045, 12, 17, 15, 1, -17 },
  { 3071, 8, 32, 10, 1, -26 },
  { 3103, 2, 27, 8, 3, -23 },
  { 3110, 8, 32, 10, 1, -26 },
  { 3142, 15, 7, 19, 2, -13 },
};

const GFXfont RobotoCondensed_Medium33pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium33pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium33pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _ROBOTOCONDENSED_MEDIUM33PT7B_H_
