#ifndef _ROBOTOCONDENSED_MEDIUM59PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium59pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x40, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x03, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3E, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00,
  0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1F, 0x07,
  0x80, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x3E, 0x03, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE0, 0x3E, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x1E,
  0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x07, 0x80,
  0x03, 0xE1, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x3F, 0xE7, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7F,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x81, 0xFE, 0x7F,
  0xE3, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7C, 0x7E,
  0x03, 0x00, 0xF8, 0x3E, 0x03, 0x80, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3E,
  0x07, 0x80, 0xF8, 0x1E, 0x0F, 0x80, 0xF8, 0x1E, 0x0F, 0x00, 0xF8, 0x1E,
  0x1F, 0x00, 0xF8, 0x3E, 0x1E, 0x00, 0xF8, 0x3E, 0x3E, 0x00, 0xF8, 0x3E,
  0x3C, 0x00, 0x7C, 0x7E, 0x7C, 0x00, 0x7F, 0xFC, 0x78, 0x00, 0x3F, 0xFC,
  0xF8, 0x00, 0x3F, 0xF8, 0xF0, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x01, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x80, 0x00, 0x0F, 0x8F, 0xF0, 0x00, 0x0F, 0x1F, 0xF8, 0x00, 0x1F,
  0x3F, 0xFC, 0x00, 0x1E, 0x3F, 0xFE, 0x00, 0x3E, 0x7C, 0x3E, 0x00, 0x3C,
  0x7C, 0x1F, 0x00, 0x7C, 0x78, 0x1F, 0x00, 0x78, 0x78, 0x1F, 0x00, 0xF8,
  0x78, 0x1F, 0x00, 0xF0, 0x78, 0x1F, 0x01, 0xF0, 0x78, 0x1F, 0x01, 0xE0,
  0x78, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x7C, 0x1F, 0x01, 0xC0,
  0x7E, 0x3E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x3F, 0xC0,
  0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x01,
  0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0x83, 0xF0, 0xFF, 0x7F, 0x0F, 0xC3,
  0xF9, 0xFE, 0x3F, 0x1F, 0xC3, 0xFC, 0xFC, 0x7F, 0x07, 0xF3, 0xF1, 0xF8,
  0x1F, 0xFF, 0xC7, 0xE0, 0x3F, 0xFE, 0x3F, 0x80, 0x7F, 0xF8, 0x7E, 0x01,
  0xFF, 0xE1, 0xF8, 0x03, 0xFF, 0x07, 0xF0, 0x07, 0xFC, 0x1F, 0xC0, 0x1F,
  0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x8F, 0xE0,
  0x1F, 0xF8, 0x3F, 0xC0, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0x80, 0x00, 0x10, 0x01, 0x80, 0x1E,
  0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xC0, 0x0C, 0x00, 0x20, 0x40, 0x07, 0x00,
  0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0,
  0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0x80, 0x38, 0x00, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xE0, 0x7C, 0x0C,
  0x7C, 0x3C, 0x1F, 0x7F, 0xDE, 0x7F, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xF3, 0xE0, 0x01, 0xF9, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3C, 0x03, 0xE0, 0x0E,
  0x01, 0xC0, 0x02, 0x00, 0x40, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x9F, 0x8F,
  0xCF, 0xC7, 0xE7, 0xE1, 0xE0, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xC0,
  0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x01, 0xF9, 0xF8, 0x03, 0xFB, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0x7E, 0x00,
  0xFE, 0xFC, 0x01, 0xFD, 0xFC, 0x03, 0xF3, 0xF8, 0x0F, 0xE3, 0xF8, 0x1F,
  0xC7, 0xF8, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x7C, 0x03, 0xF8, 0x1F, 0xF1, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0x83, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF,
  0x8F, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0x9F,
  0xC0, 0x1F, 0xCF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x3F, 0xC3, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0x7E, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFE, 0x7F, 0xC3,
  0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xF7, 0xF0, 0x00, 0xFD,
  0xFC, 0x00, 0x3E, 0x7F, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xC7, 0xF0, 0x03,
  0xF1, 0xFC, 0x00, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x07, 0xF0,
  0x0F, 0xC1, 0xFC, 0x03, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07,
  0xF0, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x7F, 0x03, 0xFE, 0x06, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x81, 0xFE,
  0x3F, 0xC3, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x7E, 0x7F, 0xE0, 0x7E, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xC1, 0xFE,
  0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFE, 0x1F, 0xE3, 0xFC,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F,
  0xF1, 0xFF, 0x3F, 0xC0, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x01, 0xF9, 0xFC,
  0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0,
  0x3F, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x3F, 0xC3, 0xF8, 0xFE, 0x03, 0xF9, 0xFC, 0x03, 0xFB,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFB, 0xF8,
  0x07, 0xF7, 0xF0, 0x1F, 0xEF, 0xF8, 0x7F, 0x8F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF1, 0xFE, 0x3F, 0xC1, 0xFC,
  0x7F, 0x01, 0xFC, 0xFC, 0x03, 0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xEF, 0xE0, 0x3F, 0xDF, 0xE0, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xE7, 0xE0, 0x1F, 0x8F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x10, 0x0F, 0x87, 0xF3, 0xFC, 0xFF, 0x3F, 0xC7, 0xF1, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F,
  0x83, 0xC0, 0x60, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00,
  0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF9, 0xFF, 0x3F, 0xDF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x1F,
  0x00, 0x7F, 0xE0, 0x3C, 0x3E, 0x00, 0xFF, 0xF0, 0x3C, 0x3E, 0x01, 0xFF,
  0xF8, 0x3E, 0x3C, 0x03, 0xFB, 0xF8, 0x1E, 0x7C, 0x07, 0xE0, 0xF8, 0x1E,
  0x7C, 0x07, 0xC0, 0xF0, 0x1E, 0x7C, 0x0F, 0xC0, 0xF0, 0x1E, 0x78, 0x0F,
  0x81, 0xF0, 0x1E, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xF0,
  0x1F, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0xF8, 0x3F, 0x01, 0xF0, 0x1F, 0xF8, 0x3F, 0x01,
  0xF0, 0x1F, 0xF8, 0x3F, 0x01, 0xF0, 0x1E, 0xF8, 0x3F, 0x01, 0xF0, 0x1E,
  0xF8, 0x3F, 0x01, 0xF0, 0x1E, 0xF8, 0x3F, 0x01, 0xE0, 0x1E, 0xF8, 0x3F,
  0x03, 0xE0, 0x3E, 0xF8, 0x3F, 0x03, 0xE0, 0x3C, 0xF8, 0x3F, 0x03, 0xE0,
  0x3C, 0xF8, 0x1F, 0x87, 0xF0, 0x7C, 0xF8, 0x1F, 0xCF, 0xF0, 0xF8, 0x78,
  0x1F, 0xFF, 0xFF, 0xF0, 0x7C, 0x0F, 0xFC, 0xFF, 0xF0, 0x7C, 0x07, 0xFC,
  0xFF, 0xE0, 0x7C, 0x03, 0xF0, 0x3F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x60, 0x00, 0x01,
  0xFF, 0xC7, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07,
  0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xCF, 0xE0, 0x1F, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0xBF,
  0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00,
  0xFF, 0x3F, 0x80, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xF8, 0x03, 0xFC,
  0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00,
  0xFE, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xFB,
  0xF8, 0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0xFF, 0xC3,
  0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0xFF, 0x7F, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x80,
  0x0F, 0xF3, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xE1, 0xFF, 0x8F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xE0, 0x3F, 0xF3, 0xF8, 0x03, 0xFC, 0xFE,
  0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xEF,
  0xE0, 0x0F, 0xF3, 0xF8, 0x0F, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0xFF, 0xE3,
  0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x7F, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x7F, 0x3F, 0x80,
  0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x3F, 0xE0, 0x0F, 0xF1, 0xFF, 0xC7, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F, 0x81,
  0xFE, 0x3F, 0xE7, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFE, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xF8,
  0xFE, 0x00, 0xFF, 0x8F, 0xE0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0,
  0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF8,
  0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE,
  0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xEF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xDF,
  0xE0, 0x0F, 0xFD, 0xFE, 0x00, 0xFF, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xE0,
  0x1F, 0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF,
  0x0F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0xFE,
  0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0xFC, 0x00, 0x7F, 0xFF, 0xF7, 0xE0, 0x07, 0xEF, 0xFF,
  0xBF, 0x00, 0x3F, 0x7F, 0xFC, 0xFC, 0x01, 0xFB, 0xFF, 0xE7, 0xE0, 0x0F,
  0x9F, 0xFF, 0x3F, 0x00, 0xFC, 0xFF, 0xF8, 0xFC, 0x07, 0xE7, 0xFF, 0xE7,
  0xE0, 0x3F, 0x3F, 0xFF, 0x3F, 0x03, 0xF1, 0xFF, 0xF9, 0xFC, 0x1F, 0x8F,
  0xFF, 0xC7, 0xE0, 0xFC, 0x7F, 0xFE, 0x3F, 0x0F, 0xC3, 0xFF, 0xF1, 0xFC,
  0x7E, 0x1F, 0xFF, 0x87, 0xE3, 0xF0, 0xFF, 0xFC, 0x3F, 0x3F, 0x07, 0xFF,
  0xE1, 0xF9, 0xF8, 0x3F, 0xFF, 0x07, 0xEF, 0xC1, 0xFF, 0xF8, 0x3F, 0x7C,
  0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xEF, 0xE0,
  0x3F, 0xFE, 0x7E, 0x03, 0xFF, 0xE7, 0xF0, 0x3F, 0xFE, 0x3F, 0x03, 0xFF,
  0xE3, 0xF8, 0x3F, 0xFE, 0x1F, 0x83, 0xFF, 0xE1, 0xFC, 0x3F, 0xFE, 0x0F,
  0xC3, 0xFF, 0xE0, 0xFE, 0x3F, 0xFE, 0x07, 0xE3, 0xFF, 0xE0, 0x7F, 0x3F,
  0xFE, 0x03, 0xF3, 0xFF, 0xE0, 0x3F, 0xBF, 0xFE, 0x01, 0xFB, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0x07, 0xFC, 0x03,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC,
  0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0x8F,
  0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xFE, 0x01, 0xFE, 0x0F, 0xFE,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0x80, 0x1F, 0xE7,
  0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xDF, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0xC7,
  0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x03,
  0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0xF7, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x8F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFE, 0x3F, 0x80, 0x3F, 0xC7, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0x3F,
  0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xEF, 0xE0,
  0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC,
  0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xF3, 0xF8, 0x01, 0xFE, 0x7F, 0x00,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xF8, 0x1F,
  0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF8, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x1F,
  0xC3, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF9, 0xFC,
  0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xF7, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x1F,
  0xDF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFC, 0x7F, 0xE1, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xCF, 0xF0,
  0x03, 0xF9, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC,
  0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0xF1, 0xFF,
  0x87, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0x7F,
  0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0x3F, 0xC0,
  0x1F, 0xE3, 0xFF, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x1F,
  0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xE0,
  0x07, 0xF0, 0x03, 0xF3, 0xF0, 0x07, 0xF8, 0x03, 0xF9, 0xFC, 0x03, 0xFE,
  0x01, 0xFC, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0x80, 0x7F,
  0x3F, 0x80, 0x7F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7F, 0xF0, 0x1F, 0x87, 0xE0,
  0x3F, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xBE,
  0x07, 0xF0, 0xFE, 0x07, 0xDF, 0x03, 0xF0, 0x3F, 0x07, 0xEF, 0xC1, 0xF8,
  0x1F, 0x83, 0xF7, 0xE0, 0xFC, 0x0F, 0xC1, 0xFB, 0xF0, 0xFE, 0x07, 0xF0,
  0xF8, 0xF8, 0x7F, 0x03, 0xF8, 0x7C, 0x7C, 0x3F, 0x80, 0xFC, 0x7E, 0x3F,
  0x1F, 0x80, 0x7E, 0x3F, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x0F, 0xC7, 0xE0,
  0x1F, 0x8F, 0x83, 0xE7, 0xF0, 0x0F, 0xE7, 0xC1, 0xF3, 0xF8, 0x07, 0xF7,
  0xE0, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x7E, 0xFC, 0x00, 0xFD, 0xF0, 0x1F,
  0x7E, 0x00, 0x7E, 0xF8, 0x0F, 0xBF, 0x00, 0x3F, 0x7C, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x7F, 0x8F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0xC0,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x01,
  0xFC, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x01,
  0xFE, 0xFF, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0xFF, 0x01,
  0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFD,
  0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x81, 0xF1, 0xF0,
  0x7E, 0x3E, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0x81, 0xF9,
  0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0x80, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7E, 0x01, 0xF8, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F,
  0x81, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xE3, 0xF9, 0xFC, 0x07, 0xF7, 0xF0, 0x0F,
  0xEF, 0xE0, 0x1F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0xFE,
  0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xFB, 0xFC, 0x3F, 0xF7, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0x7F, 0x07, 0xFC, 0x7F, 0x00,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0xFE, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xC3, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7E, 0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0xC3, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFE, 0xFF, 0xF0, 0xFE,
  0x3F, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF0,
  0xFF, 0x1F, 0xC0, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFD, 0xF8, 0x01,
  0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0xBF,
  0x80, 0x3F, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFC, 0xFF, 0x0F, 0xF0, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xFE, 0x7F, 0x07, 0xFF,
  0x7F, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xE3,
  0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0xFF, 0x3F, 0xE3,
  0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0x3F, 0x03, 0xFC, 0x3F, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x1F, 0xF1, 0xFE, 0x3F, 0x80, 0xFE, 0x7E, 0x01, 0xFD, 0xFC, 0x01, 0xFB,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x10, 0xFE, 0x00, 0x71, 0xFF, 0x07,
  0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x3F, 0x07, 0xFF, 0x3F, 0x0F, 0xFF, 0xBF,
  0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xE3, 0xFF, 0x7F, 0x80, 0xFF,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x80, 0xFF, 0x3F, 0xE3, 0xFF, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0x7F, 0x03, 0xFE, 0x7F,
  0x00, 0x20, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x0C, 0x00, 0xFE, 0x0F, 0x01, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC7, 0xF8, 0x3F, 0xBF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0x1F, 0xF7, 0xF8, 0x0F, 0xEF, 0xF0, 0x1F,
  0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xF0, 0x3E, 0x7E, 0xFF, 0xFF, 0x7F,
  0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x07, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7E, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0,
  0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0xCF, 0xF8, 0xFF, 0x0F, 0xC0, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x07,
  0xF8, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F,
  0xC0, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xBF, 0x80, 0xFF, 0x3F,
  0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x01,
  0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x03,
  0xF8, 0xFF, 0x01, 0xFE, 0x0F, 0xEF, 0xFF, 0x1F, 0xFE, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFC, 0x7F, 0xF8, 0xFF, 0xBF, 0xC0, 0x7F, 0xC0, 0xFE, 0xFE, 0x01, 0xFE,
  0x03, 0xFB, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0x00, 0x7F, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xFE,
  0x00, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x00,
  0x7F, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xFE, 0x00, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0x02, 0x01, 0xFC, 0x7F, 0x83, 0xFB, 0xFF, 0xC7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xF1, 0xFF, 0x7F,
  0xC0, 0xFE, 0xFF, 0x01, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xF0,
  0x07, 0xEF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0x8F, 0xF8, 0x7F, 0x01, 0xFE,
  0x7F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xEF, 0xC0, 0x07,
  0xF7, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x1F, 0xC0, 0x7F, 0x8F, 0xF8, 0x7F, 0x83,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x3F,
  0xC0, 0xFE, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xC7, 0xFE, 0xFF, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFF, 0x01,
  0xFE, 0xFF, 0xC3, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFE, 0xFF, 0xF0, 0xFE, 0x3F, 0xC0, 0xFE, 0x04, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x3F, 0x0F, 0xFF, 0x3F, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xE3, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80,
  0xFF, 0x3F, 0xC1, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0x7F, 0x03, 0xFE, 0x7F, 0x00, 0x20, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x09, 0xFC, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0x81,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3,
  0xF8, 0x3F, 0xDF, 0xC0, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFD, 0xFC, 0x07, 0xF7, 0xF8, 0x3F, 0xCF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0x10, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0x7F, 0xC0, 0x7F, 0x80, 0x18, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0x7F,
  0x03, 0xFD, 0xFE, 0x3F, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFB, 0xF0, 0x7F, 0x8F, 0xC0, 0x20, 0x00, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0,
  0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xF0, 0x07, 0xE7, 0xE0,
  0x1F, 0x80, 0x7E, 0x7E, 0x01, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x80, 0xFE,
  0x7F, 0x03, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0xC0, 0xFC, 0x3F, 0x03, 0xFC,
  0x0F, 0xC3, 0xF0, 0x7F, 0xC0, 0xFC, 0x3F, 0x07, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0xE1, 0xF8, 0x1F, 0x87, 0xFE, 0x1F, 0x81, 0xF8, 0xFF, 0xE1, 0xF8,
  0x1F, 0x8F, 0xBF, 0x1F, 0x81, 0xF8, 0xFB, 0xF3, 0xF8, 0x1F, 0xCF, 0x9F,
  0x3F, 0x00, 0xFD, 0xF9, 0xF3, 0xF0, 0x0F, 0xDF, 0x1F, 0xBF, 0x00, 0xFD,
  0xF0, 0xFB, 0xF0, 0x0F, 0xDF, 0x0F, 0xBE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0,
  0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x01, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFE, 0x3F, 0x81, 0xFE, 0x3F,
  0x81, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE3, 0xF0, 0x0F,
  0xE7, 0xF0, 0x07, 0xF7, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xF7, 0xF0, 0x0F,
  0xE7, 0xF0, 0x0F, 0xE3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F,
  0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F,
  0xC3, 0xF0, 0x0F, 0xC7, 0xF0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE7, 0xE0, 0x07,
  0xE7, 0xE0, 0x07, 0xEF, 0xE0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x08,
  0x00, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFC,
  0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xC0, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07,
  0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFC, 0x07, 0xF0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0x1E, 0x00, 0x10, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0x1F, 0xFC, 0x03, 0xE3, 0xFF, 0xE0, 0x3E, 0x3F, 0xFF, 0x03, 0xE7, 0xFF,
  0xF8, 0x7E, 0x7E, 0x1F, 0xFF, 0xE7, 0xC0, 0xFF, 0xFC, 0xFC, 0x07, 0xFF,
  0x8F, 0xC0, 0x3F, 0xF8, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_Medium59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 7, 43, 15, 4, -42 },
  { 39, 13, 15, 19, 3, -44 },
  { 64, 27, 42, 32, 3, -42 },
  { 206, 24, 56, 30, 3, -49 },
  { 374, 32, 44, 38, 3, -43 },
  { 550, 30, 44, 33, 2, -43 },
  { 715, 6, 15, 10, 2, -44 },
  { 727, 13, 60, 19, 4, -47 },
  { 825, 13, 60, 19, 2, -47 },
  { 923, 25, 25, 26, 1, -42 },
  { 1002, 24, 30, 29, 2, -35 },
  { 1092, 9, 16, 13, 1, -7 },
  { 1110, 13, 6, 18, 3, -21 },
  { 1120, 8, 8, 16, 4, -7 },
  { 1128, 19, 46, 21, 0, -42 },
  { 1238, 23, 44, 30, 3, -43 },
  { 1365, 15, 42, 30, 5, -42 },
  { 1444, 25, 43, 30, 2, -43 },
  { 1579, 24, 44, 30, 2, -43 },
  { 1711, 26, 42, 30, 2, -42 },
  { 1848, 24, 43, 30, 3, -42 },
  { 1977, 24, 43, 30, 3, -42 },
  { 2106, 25, 42, 30, 2, -42 },
  { 2238, 23, 44, 30, 3, -43 },
  { 2365, 23, 43, 30, 3, -43 },
  { 2489, 8, 32, 15, 4, -31 },
  { 2521, 10, 40, 14, 1, -31 },
  { 2571, 20, 27, 26, 2, -32 },
  { 2639, 21, 18, 29, 4, -28 },
  { 2687, 21, 27, 27, 4, -32 },
  { 2758, 21, 44, 26, 2, -43 },
  { 2874, 40, 54, 45, 3, -41 },
  { 3144, 33, 42, 35, 1, -42 },
  { 3318, 26, 42, 33, 4, -42 },
  { 3455, 28, 44, 34, 3, -43 },
  { 3609, 26, 42, 34, 4, -42 },
  { 3746, 23, 42, 29, 4, -42 },
  { 3867, 22, 42, 28, 4, -42 },
  { 3983, 28, 44, 35, 3, -43 },
  { 4137, 28, 42, 36, 4, -42 },
  { 4284, 7, 42, 15, 4, -42 },
  { 4321, 24, 43, 29, 1, -42 },
  { 4450, 28, 42, 32, 4, -42 },
  { 4597, 23, 42, 28, 4, -42 },
  { 4718, 37, 42, 45, 4, -42 },
  { 4913, 28, 42, 36, 4, -42 },
  { 5060, 29, 44, 36, 3, -43 },
  { 5220, 27, 42, 33, 4, -42 },
  { 5362, 30, 50, 36, 3, -43 },
  { 5550, 27, 42, 32, 4, -42 },
  { 5692, 27, 44, 31, 2, -43 },
  { 5841, 28, 42, 31, 2, -42 },
  { 5988, 27, 43, 33, 3, -42 },
  { 6134, 32, 42, 34, 1, -42 },
  { 6302, 41, 42, 45, 2, -42 },
  { 6518, 30, 42, 33, 1, -42 },
  { 6676, 30, 42, 32, 1, -42 },
  { 6834, 27, 42, 31, 2, -42 },
  { 6976, 10, 57, 15, 4, -48 },
  { 7048, 21, 46, 22, 1, -42 },
  { 7169, 10, 57, 15, 1, -48 },
  { 7241, 19, 21, 23, 2, -42 },
  { 7291, 22, 6, 24, 1, 0 },
  { 7308, 13, 9, 19, 2, -45 },
  { 7323, 23, 33, 28, 3, -32 },
  { 7418, 24, 45, 29, 3, -44 },
  { 7553, 23, 33, 27, 2, -32 },
  { 7648, 24, 45, 29, 2, -44 },
  { 7783, 23, 33, 28, 3, -32 },
  { 7878, 16, 45, 19, 2, -45 },
  { 7968, 24, 44, 29, 2, -32 },
  { 8100, 23, 44, 29, 3, -44 },
  { 8227, 8, 42, 14, 3, -42 },
  { 8269, 12, 54, 14, -1, -42 },
  { 8350, 24, 44, 27, 3, -44 },
  { 8482, 6, 44, 14, 4, -44 },
  { 8515, 38, 32, 44, 3, -32 },
  { 8667, 23, 32, 29, 3, -32 },
  { 8759, 25, 33, 29, 2, -32 },
  { 8863, 24, 44, 29, 3, -32 },
  { 8995, 24, 44, 29, 2, -32 },
  { 9127, 15, 32, 19, 3, -32 },
  { 9187, 22, 33, 27, 2, -32 },
  { 9278, 15, 40, 18, 1, -39 },
  { 9353, 22, 32, 29, 3, -31 },
  { 9441, 24, 31, 26, 1, -31 },
  { 9534, 36, 31, 38, 1, -31 },
  { 9674, 24, 31, 26, 1, -31 },
  { 9767, 24, 43, 26, 1, -31 },
  { 9896, 22, 31, 26, 2, -31 },
  { 9982, 14, 56, 18, 2, -46 },
  { 10080, 5, 50, 15, 5, -42 },
  { 10112, 15, 56, 18, 1, -46 },
  { 10217, 28, 12, 34, 3, -23 },
};

const GFXfont RobotoCondensed_Medium59pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium59pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium59pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOCONDENSED_MEDIUM59PT7B_H_
