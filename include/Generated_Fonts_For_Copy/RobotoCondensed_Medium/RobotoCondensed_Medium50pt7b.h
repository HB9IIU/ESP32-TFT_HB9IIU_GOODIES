#ifndef _ROBOTOCONDENSED_MEDIUM50PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8,
  0x00, 0x00, 0x00, 0x0E, 0x3E, 0xFF, 0xFD, 0xF1, 0xC0, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xEF, 0x0E,
  0xF0, 0xEF, 0x0E, 0xF0, 0xE0, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01,
  0xE1, 0xC0, 0x03, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0, 0x01, 0xC3, 0xC0, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x78, 0x78,
  0x00, 0xF0, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x70, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x1E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87,
  0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x38, 0x00, 0x70, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x0F, 0xE1, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0x01, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFB, 0xF0, 0x07, 0xCF, 0x80,
  0x3F, 0x7C, 0x01, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFE, 0x0F, 0xE3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFC,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x78, 0x78, 0x18, 0x07, 0x87, 0x81, 0xE0, 0x70,
  0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x78, 0x0F, 0x07, 0x87,
  0x80, 0x70, 0x78, 0xF0, 0x07, 0x87, 0x8E, 0x00, 0x78, 0x79, 0xE0, 0x07,
  0xFF, 0x9C, 0x00, 0x3F, 0xF3, 0xC0, 0x01, 0xFE, 0x38, 0x00, 0x0F, 0xC7,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x1E, 0x7F, 0x80, 0x03, 0xCF, 0xFC, 0x00, 0x3C, 0xFF, 0xE0, 0x07,
  0x9E, 0x1E, 0x00, 0x79, 0xE1, 0xE0, 0x0F, 0x1E, 0x0F, 0x00, 0xE1, 0xE0,
  0xF0, 0x1E, 0x1E, 0x0F, 0x01, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03,
  0x81, 0xE1, 0xE0, 0x38, 0x1E, 0x1E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0xFC, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0,
  0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF9, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x83, 0xE3, 0xFF,
  0xE1, 0xF3, 0xFB, 0xF1, 0xF9, 0xF8, 0xFC, 0xF8, 0xF8, 0x7F, 0x7C, 0xFC,
  0x1F, 0xBE, 0x7E, 0x07, 0xFF, 0x3F, 0x03, 0xFF, 0x1F, 0x80, 0xFF, 0x8F,
  0xC0, 0x3F, 0xC7, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xF0, 0xFF, 0x1F, 0xF8,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xCF, 0xC0, 0xFF, 0xC3,
  0xF0, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF,
  0x00, 0x00, 0x20, 0x06, 0x00, 0xE0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x80,
  0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03,
  0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xE0, 0x06, 0x00, 0x20, 0x40, 0x06, 0x00, 0x70, 0x07, 0x80,
  0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0,
  0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0x70, 0x06, 0x00, 0x40, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x01, 0xC3, 0xC1, 0xDF, 0x9E, 0x3E, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xC7, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00,
  0x1F, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x7C, 0x0F, 0x81,
  0xF0, 0x18, 0x07, 0x00, 0x40, 0x20, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8,
  0xF0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x10, 0xFB, 0xFF,
  0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFC, 0x1F,
  0x9F, 0x83, 0xF7, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x1F, 0x9F, 0x83, 0xF1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00,
  0x00, 0x18, 0x07, 0xC0, 0xFE, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xF1, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE,
  0x3F, 0x87, 0xF1, 0xF8, 0x1F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0,
  0x1F, 0xBF, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x01, 0xF8,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF0,
  0xFE, 0x7E, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0,
  0x7F, 0x7F, 0x0F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7B, 0xF0, 0x07, 0xDF, 0x80,
  0x3C, 0xFC, 0x03, 0xE7, 0xE0, 0x1E, 0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0x8F,
  0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0xFC, 0x3E,
  0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE3, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0xFC, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xE0, 0xFE,
  0x0C, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xE7, 0xE0, 0x7E, 0x7F, 0x0F, 0xE7, 0xFF, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x7C, 0x0F, 0xDF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xF0, 0xFE, 0xFE, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7E, 0x07, 0xE7, 0xE0, 0x7E,
  0x3F, 0x0F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7,
  0xFF, 0xFC, 0xFE, 0x3F, 0x9F, 0x83, 0xF7, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xF7, 0xC0, 0x7C, 0xFC, 0x1F, 0x9F,
  0xC3, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC7, 0xF1, 0xFC, 0xF8, 0x1F, 0xBF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x83, 0xFB, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F,
  0xF8, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF0, 0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x7E,
  0x7C, 0x03, 0xE7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0,
  0x7F, 0x7F, 0x0F, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F,
  0xFB, 0xF0, 0x3E, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x10, 0xFB,
  0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x1F, 0x7F, 0xFF, 0xFD, 0xF9, 0xE0, 0x04,
  0x0F, 0x8F, 0xC7, 0xF3, 0xF9, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x7C,
  0x3E, 0x1E, 0x02, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07,
  0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F,
  0xE0, 0x3F, 0x80, 0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x00,
  0xF8, 0x00, 0x1C, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x00,
  0xF8, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x03,
  0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0x87, 0xEF, 0xC1, 0xFF, 0xF0,
  0x3F, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0x78, 0x78, 0x03, 0xF0, 0x1E, 0x3E, 0x01, 0xFE, 0x07, 0x8F,
  0x01, 0xFF, 0xE0, 0xE3, 0xC0, 0x7F, 0xF8, 0x3D, 0xF0, 0x3E, 0x1E, 0x0F,
  0x78, 0x1F, 0x07, 0x83, 0xDE, 0x07, 0x83, 0xE0, 0xF7, 0x81, 0xE0, 0xF0,
  0x3D, 0xE0, 0xF8, 0x3C, 0x07, 0x78, 0x3C, 0x0F, 0x01, 0xFE, 0x0F, 0x03,
  0xC0, 0x7F, 0x07, 0xC0, 0xF0, 0x3F, 0xC1, 0xF0, 0x3C, 0x0F, 0xF0, 0x7C,
  0x0F, 0x03, 0xFC, 0x1F, 0x03, 0xC0, 0xFF, 0x07, 0xC0, 0xF0, 0x3F, 0xC1,
  0xF0, 0x3C, 0x0E, 0x78, 0x7C, 0x1F, 0x07, 0x9E, 0x1F, 0x07, 0xC1, 0xE7,
  0x83, 0xE3, 0xF0, 0xF1, 0xE0, 0xFF, 0xFE, 0x3C, 0x78, 0x3F, 0xFF, 0xFE,
  0x1F, 0x07, 0xF9, 0xFF, 0x03, 0xC0, 0xFC, 0x3F, 0x80, 0xF0, 0x00, 0x02,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x01, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x1F,
  0x9F, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF1, 0xF8,
  0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07,
  0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x07,
  0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC,
  0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xF0, 0x1F, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E,
  0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC,
  0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFC, 0x03, 0xFB,
  0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x3F, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x7F,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x81, 0xFE, 0x3F, 0x00,
  0xFE, 0x7E, 0x00, 0xFC, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03,
  0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7D, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0,
  0x07, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x7F, 0x3F, 0x03, 0xFC, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x3F, 0x81, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7F, 0x00, 0x7F, 0x3F, 0xC0, 0xFF, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7E, 0x03,
  0xF7, 0xE0, 0x7E, 0x7F, 0x0F, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFE,
  0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0,
  0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0,
  0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x00,
  0xFC, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xBF, 0x00,
  0xFF, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0,
  0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xBF,
  0xFD, 0xF0, 0x0F, 0xBF, 0xFD, 0xF0, 0x0F, 0xBF, 0xFD, 0xF0, 0x1F, 0x3F,
  0xFC, 0xF8, 0x1F, 0x3F, 0xFC, 0xF8, 0x1F, 0x3F, 0xFC, 0xF8, 0x3E, 0x3F,
  0xFC, 0xFC, 0x3E, 0x3F, 0xFC, 0x7C, 0x3E, 0x3F, 0xFC, 0x7C, 0x3E, 0x3F,
  0xFC, 0x7E, 0x7C, 0x3F, 0xFC, 0x3E, 0x7C, 0x3F, 0xFC, 0x3E, 0x7C, 0x3F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xF8, 0x3F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xF0, 0x3F, 0xFC, 0x0F, 0xF0, 0x3F, 0xFC, 0x0F, 0xF0, 0x3F,
  0xFC, 0x0F, 0xF0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x03, 0xC0, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFD, 0xF0, 0x1F, 0xFD,
  0xF8, 0x1F, 0xFC, 0xF8, 0x1F, 0xFC, 0xFC, 0x1F, 0xFC, 0x7C, 0x1F, 0xFC,
  0x7E, 0x1F, 0xFC, 0x3E, 0x1F, 0xFC, 0x3F, 0x1F, 0xFC, 0x1F, 0x1F, 0xFC,
  0x1F, 0x9F, 0xFC, 0x0F, 0x9F, 0xFC, 0x0F, 0xDF, 0xFC, 0x07, 0xDF, 0xFC,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F,
  0xC3, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7F,
  0x00, 0xFE, 0x3F, 0xC1, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x80,
  0x7F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xFB,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFE, 0x1F, 0xE1, 0xFC,
  0x03, 0xF8, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xC0, 0x01, 0xFB,
  0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F,
  0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x01,
  0xFB, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00,
  0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF8,
  0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x04, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x80, 0x7F, 0x3F, 0x00, 0x7E,
  0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7,
  0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x7F, 0x7E,
  0x00, 0xFC, 0xFC, 0x07, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F,
  0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xFC, 0x01, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7E,
  0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xEF, 0xE0, 0x0F, 0xCF,
  0xC0, 0x1F, 0x9F, 0xE0, 0x7F, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0xC0,
  0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFB, 0xF8,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x03, 0xF0,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x07, 0xC0,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x01, 0xF0, 0xFC, 0x00,
  0x3E, 0x1F, 0x80, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0x9F,
  0x80, 0x01, 0xF3, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF7, 0xE0,
  0x1F, 0x80, 0x7E, 0x7E, 0x01, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x80, 0x7E,
  0x7E, 0x01, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0xC0, 0x7E, 0x3E, 0x03, 0xFC,
  0x07, 0xC3, 0xE0, 0x3F, 0xC0, 0x7C, 0x3F, 0x03, 0xFC, 0x0F, 0xC3, 0xF0,
  0x3F, 0xC0, 0xFC, 0x3F, 0x07, 0xFE, 0x0F, 0xC1, 0xF0, 0x7F, 0xE0, 0xF8,
  0x1F, 0x07, 0xFE, 0x0F, 0x81, 0xF0, 0x7D, 0xE0, 0xF8, 0x1F, 0x87, 0x9E,
  0x1F, 0x81, 0xF8, 0xF9, 0xF1, 0xF8, 0x1F, 0x8F, 0x9F, 0x1F, 0x80, 0xF8,
  0xF9, 0xF1, 0xF0, 0x0F, 0x8F, 0x8F, 0x1F, 0x00, 0xF8, 0xF0, 0xF1, 0xF0,
  0x0F, 0xDF, 0x0F, 0xBF, 0x00, 0xFD, 0xF0, 0xFB, 0xF0, 0x07, 0xDF, 0x0F,
  0xBE, 0x00, 0x7D, 0xE0, 0x7B, 0xE0, 0x07, 0xDE, 0x07, 0xBE, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xF0, 0xFE, 0x01,
  0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F,
  0x87, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x00,
  0x0F, 0xCF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF3, 0xF0, 0x01, 0xFC, 0xFC,
  0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xC1, 0xFC, 0x07, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x7F, 0x1F,
  0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xE7, 0xF0, 0x07,
  0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x81,
  0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xEF, 0x80, 0x01,
  0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1E, 0xF0, 0x0F,
  0x78, 0x0F, 0xBE, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE3, 0xE1, 0xF0, 0xF0,
  0xF0, 0x78, 0xF8, 0x3E, 0x7C, 0x0F, 0x3C, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xE0, 0xFC, 0x7E,
  0x07, 0xE7, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xFF, 0xE0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0x07, 0xE7, 0xE0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFE, 0x0F,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xF7, 0xE0, 0x7E,
  0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0xFC, 0x0F, 0xDF, 0xF0,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xE0, 0xFE, 0xFC, 0x07,
  0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x7E, 0xFE, 0x0F, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xBF, 0xF8, 0xF9, 0xFF, 0x0F, 0x8F, 0xC0,
  0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0xFE, 0x1F, 0xDF, 0x81, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0xF0, 0x0F, 0xBF, 0x01, 0xF7,
  0xE0, 0x7E, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE3, 0xF0, 0xFF,
  0xBF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF0, 0x7F, 0x7E,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x07,
  0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xF9, 0xF0, 0x3E,
  0x1F, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE7, 0xF0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x0C, 0x7F, 0x01, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE1, 0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFC, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x03, 0xF1, 0xF0, 0xFF,
  0x9F, 0x1F, 0xFD, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF0, 0x7F, 0x7E,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x07,
  0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFB, 0xF0, 0x3F,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF1, 0x00, 0x3F, 0x1C,
  0x07, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x1F, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x87, 0xC1, 0xF3, 0xFE, 0x3E,
  0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xDF, 0xC1, 0xFB, 0xF0, 0x3F, 0x7E,
  0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xC0, 0x7B, 0xFF, 0xFF,
  0xFD, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x1F, 0xFF, 0xEF, 0xFB, 0xFC, 0xFE, 0x3F, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xEF, 0xC1, 0xFC, 0xFC, 0x1F, 0x8F,
  0xC3, 0xF8, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0xFC, 0x0F, 0xDF, 0xC0,
  0xFD, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xEF, 0xC0, 0xFC, 0xFE, 0x0F, 0xC7,
  0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC,
  0x0F, 0xCF, 0xC0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x7C, 0x07, 0xE1, 0xF3, 0xFE, 0x3F, 0xF3, 0xEF, 0xFE,
  0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFE,
  0x1F, 0xFF, 0x03, 0xF8, 0x1F, 0xFE, 0x03, 0xF0, 0x1F, 0xFC, 0x07, 0xE0,
  0x3F, 0xF8, 0x0F, 0xC0, 0x7F, 0xF0, 0x1F, 0x80, 0xFF, 0xE0, 0x3F, 0x01,
  0xFF, 0xC0, 0x7E, 0x03, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0x01, 0xF8, 0x0F,
  0xFE, 0x03, 0xF0, 0x1F, 0xFC, 0x07, 0xE0, 0x3F, 0xF8, 0x0F, 0xC0, 0x7F,
  0xF0, 0x1F, 0x80, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xC0, 0x7E, 0x03, 0xFF,
  0x80, 0xFC, 0x07, 0xFF, 0x01, 0xF8, 0x0F, 0xFE, 0x03, 0xF0, 0x1F, 0xFC,
  0x07, 0xE0, 0x3F, 0xF8, 0x0F, 0xC0, 0x7C, 0xF8, 0x7C, 0x1F, 0x3F, 0xE3,
  0xEF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x1F, 0xBF, 0x03, 0xF7,
  0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x83,
  0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x7C, 0xFC,
  0x07, 0xE7, 0xF0, 0x7F, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0xFC, 0x0F, 0x9F, 0xF0, 0xFB,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xE0, 0xFE, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFE, 0x0F, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFD, 0xFF, 0x0F, 0xCF, 0xC0, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE1, 0xF0, 0xFF, 0x9F, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xF0, 0x7F, 0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7,
  0xE0, 0x3F, 0x7F, 0x07, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x0F, 0xFB, 0xF0, 0x3E, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF8, 0xFF, 0x9F, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F, 0x9F,
  0x01, 0xF3, 0xE0, 0x3E, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xDF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFF, 0x87, 0xFC,
  0x3F, 0xE0, 0xFF, 0x03, 0xF0, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x3F, 0xF7, 0xE1, 0xF8, 0xFC, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7C, 0x3E, 0x07,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF1,
  0xF8, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0xFC, 0x07, 0x80, 0xFF, 0xF0, 0x3E, 0x03, 0xF7, 0xC0, 0xFC, 0x0F, 0x9F,
  0x03, 0xF0, 0x3E, 0x7C, 0x0F, 0xC0, 0xF9, 0xF8, 0x7F, 0x87, 0xE3, 0xE1,
  0xFE, 0x1F, 0x8F, 0x87, 0xF8, 0x7C, 0x3E, 0x1F, 0xE1, 0xF0, 0xF8, 0xFF,
  0xC7, 0xC3, 0xF3, 0xFF, 0x3F, 0x07, 0xCF, 0x3C, 0xF8, 0x1F, 0x3C, 0xF3,
  0xE0, 0x7D, 0xF3, 0xEF, 0x81, 0xF7, 0xCF, 0xBE, 0x03, 0xFE, 0x1F, 0xF0,
  0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03,
  0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F,
  0x03, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x7E, 0x03, 0xF7, 0xE0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0xFC,
  0x1F, 0x8F, 0xC1, 0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x01, 0xF9, 0xF8, 0x1F, 0x9F, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7,
  0xE0, 0x7E, 0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7C, 0x3E, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x1F, 0x81, 0xF9,
  0xF8, 0x1F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0xBF, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x60, 0x0E, 0x03, 0xF0, 0x3F, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8,
  0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x0F, 0xE0, 0xFE, 0x0F, 0x80,
  0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x3F, 0x00, 0xE0, 0x06,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x03,
  0x80, 0x3F, 0x01, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x3F, 0x03, 0xF8, 0x3F, 0xC1, 0xF8, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x7E,
  0x01, 0xC0, 0x0C, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x3C, 0xFF, 0xC0,
  0xFB, 0xFF, 0xC1, 0xF7, 0xFF, 0xC7, 0xDF, 0x1F, 0xFF, 0xBE, 0x0F, 0xFF,
  0x78, 0x0F, 0xFC, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoCondensed_Medium50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 36, 13, 3, -36 },
  { 33, 12, 13, 16, 2, -38 },
  { 53, 23, 36, 27, 2, -36 },
  { 157, 21, 46, 25, 2, -41 },
  { 278, 28, 36, 32, 2, -36 },
  { 404, 25, 37, 28, 2, -36 },
  { 520, 5, 13, 8, 2, -38 },
  { 529, 12, 51, 16, 3, -40 },
  { 606, 12, 51, 16, 1, -40 },
  { 683, 21, 21, 22, 1, -36 },
  { 739, 20, 26, 24, 2, -29 },
  { 804, 8, 14, 11, 1, -6 },
  { 818, 11, 5, 15, 2, -18 },
  { 825, 7, 7, 14, 3, -7 },
  { 832, 16, 39, 17, 0, -36 },
  { 910, 19, 36, 25, 3, -36 },
  { 996, 13, 36, 25, 4, -36 },
  { 1055, 21, 36, 25, 2, -36 },
  { 1150, 20, 36, 25, 2, -36 },
  { 1240, 21, 36, 25, 2, -36 },
  { 1335, 20, 36, 25, 3, -36 },
  { 1425, 20, 36, 25, 3, -36 },
  { 1515, 21, 36, 25, 2, -36 },
  { 1610, 19, 36, 25, 3, -36 },
  { 1696, 20, 36, 25, 2, -36 },
  { 1786, 7, 28, 13, 3, -28 },
  { 1811, 9, 36, 12, 1, -28 },
  { 1852, 17, 23, 22, 2, -27 },
  { 1901, 18, 15, 25, 3, -24 },
  { 1935, 18, 23, 23, 3, -27 },
  { 1987, 18, 36, 22, 2, -36 },
  { 2068, 34, 46, 38, 2, -35 },
  { 2264, 28, 36, 29, 1, -36 },
  { 2390, 22, 36, 28, 3, -36 },
  { 2489, 24, 36, 28, 3, -36 },
  { 2597, 23, 36, 28, 3, -36 },
  { 2701, 20, 36, 25, 3, -36 },
  { 2791, 19, 36, 24, 3, -36 },
  { 2877, 24, 36, 29, 3, -36 },
  { 2985, 24, 36, 31, 3, -36 },
  { 3093, 6, 36, 13, 4, -36 },
  { 3120, 20, 36, 24, 1, -36 },
  { 3210, 24, 36, 27, 3, -36 },
  { 3318, 19, 36, 24, 3, -36 },
  { 3404, 32, 36, 38, 3, -36 },
  { 3548, 24, 36, 31, 3, -36 },
  { 3656, 24, 36, 30, 3, -36 },
  { 3764, 23, 36, 28, 3, -36 },
  { 3868, 25, 42, 30, 3, -36 },
  { 4000, 23, 36, 27, 3, -36 },
  { 4104, 23, 36, 26, 2, -36 },
  { 4208, 24, 36, 27, 1, -36 },
  { 4316, 23, 36, 28, 3, -36 },
  { 4420, 27, 36, 28, 1, -36 },
  { 4542, 36, 36, 38, 1, -36 },
  { 4704, 26, 36, 28, 1, -36 },
  { 4821, 25, 36, 27, 1, -36 },
  { 4934, 23, 36, 26, 2, -36 },
  { 5038, 9, 49, 13, 3, -41 },
  { 5094, 18, 39, 19, 1, -36 },
  { 5182, 9, 49, 13, 1, -41 },
  { 5238, 17, 18, 19, 1, -36 },
  { 5277, 19, 5, 20, 1, 0 },
  { 5289, 12, 7, 16, 1, -37 },
  { 5300, 20, 26, 24, 2, -26 },
  { 5365, 20, 38, 25, 3, -38 },
  { 5460, 19, 26, 23, 2, -26 },
  { 5522, 20, 38, 25, 2, -38 },
  { 5617, 20, 26, 24, 2, -26 },
  { 5682, 15, 39, 16, 1, -39 },
  { 5756, 20, 36, 25, 2, -26 },
  { 5846, 19, 38, 24, 3, -38 },
  { 5937, 6, 36, 12, 3, -36 },
  { 5964, 10, 46, 12, -1, -36 },
  { 6022, 20, 38, 23, 3, -38 },
  { 6117, 6, 38, 12, 3, -38 },
  { 6146, 31, 26, 37, 3, -26 },
  { 6247, 19, 26, 24, 3, -26 },
  { 6309, 21, 26, 25, 2, -26 },
  { 6378, 20, 36, 25, 3, -26 },
  { 6468, 20, 36, 25, 2, -26 },
  { 6558, 12, 26, 16, 3, -26 },
  { 6597, 19, 26, 23, 2, -26 },
  { 6659, 13, 33, 15, 1, -33 },
  { 6713, 19, 26, 24, 3, -26 },
  { 6775, 20, 26, 22, 1, -26 },
  { 6840, 30, 26, 32, 1, -26 },
  { 6938, 20, 26, 22, 1, -26 },
  { 7003, 20, 36, 22, 1, -26 },
  { 7093, 18, 26, 22, 2, -26 },
  { 7152, 12, 48, 15, 2, -39 },
  { 7224, 4, 43, 12, 4, -36 },
  { 7246, 13, 48, 15, 1, -39 },
  { 7324, 23, 10, 29, 3, -19 },
};

const GFXfont RobotoCondensed_Medium50pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium50pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium50pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOCONDENSED_MEDIUM50PT7B_H_
