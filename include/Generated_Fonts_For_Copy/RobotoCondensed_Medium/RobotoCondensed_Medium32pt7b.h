#ifndef _ROBOTOCONDENSED_MEDIUM32PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x00, 0x07, 0xFF,
  0x70, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE6, 0x06, 0x30, 0x18, 0xC0,
  0x63, 0x01, 0x8C, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x1F, 0xFF, 0x7F, 0xFC,
  0x31, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x63, 0x8F, 0xFF, 0xBF, 0xFE,
  0x18, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x31, 0x80, 0xC6, 0x03, 0x18,
  0x00, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF8, 0x3F, 0xC7, 0xFE, 0x79, 0xFF,
  0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0xC0,
  0x7E, 0x01, 0xF0, 0x0F, 0x00, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0xF8, 0xF7,
  0xFE, 0x3F, 0xE1, 0xF8, 0x06, 0x00, 0x60, 0x06, 0x00, 0x3C, 0x00, 0x3F,
  0x00, 0x3B, 0x80, 0x18, 0xE3, 0x8C, 0x71, 0x86, 0x39, 0xC3, 0x1C, 0xC1,
  0x8E, 0xE0, 0xEE, 0x60, 0x3F, 0x70, 0x0F, 0x30, 0x00, 0x38, 0x00, 0x19,
  0xE0, 0x19, 0xF8, 0x1D, 0xDC, 0x0C, 0xC7, 0x0E, 0x63, 0x86, 0x31, 0xC7,
  0x18, 0xE3, 0x0C, 0x70, 0x87, 0x70, 0x01, 0xF8, 0x00, 0x78, 0x07, 0x80,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0x9E, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xE1,
  0xC0, 0x79, 0xC0, 0x1D, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0xE3, 0xDE, 0x71, 0xC7, 0xB9, 0xE3, 0xDC, 0xF0, 0xFE, 0x78, 0x3E,
  0x1C, 0x1F, 0x0F, 0x1F, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3E, 0x3C, 0xFF,
  0xFF, 0xFF, 0x02, 0x0C, 0x38, 0xE1, 0xC7, 0x0E, 0x38, 0x70, 0xE3, 0xC7,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x1C, 0x38, 0x70,
  0x70, 0xE0, 0xE1, 0xC1, 0xC1, 0x81, 0x81, 0x83, 0x83, 0x83, 0x87, 0x0F,
  0x0E, 0x1C, 0x3C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC7, 0x8E, 0x1C, 0x38, 0xE1, 0xC7, 0x1C, 0x30, 0x40, 0x03, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x63, 0x19, 0xFD, 0xF7, 0xFF, 0xC3, 0xF8,
  0x07, 0x80, 0x3F, 0x01, 0xCE, 0x07, 0x3C, 0x38, 0x70, 0x00, 0x80, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x77, 0x77, 0x77, 0xEE, 0x40, 0xFF, 0xFF, 0xF8, 0x77, 0xBC, 0xE0,
  0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80,
  0xE0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x00, 0x1F, 0x03, 0xFC, 0x7F,
  0xE7, 0x9E, 0xF0, 0xFF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0xF0,
  0xF7, 0x9E, 0x7F, 0xE3, 0xFC, 0x0F, 0x80, 0x01, 0x83, 0xCF, 0xFF, 0xFF,
  0xFF, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xC0, 0x7F,
  0x83, 0xFF, 0x1E, 0x3E, 0x70, 0x7B, 0xC1, 0xEF, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xC0, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xE7, 0x07, 0xF8, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x83, 0xF8, 0x1F, 0x80, 0xFF, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3F, 0x83, 0xFC, 0x1E, 0xF1, 0xF7, 0xFF,
  0x1F, 0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xBC, 0x0E, 0xF0, 0x73, 0xC1, 0xCF, 0x0E,
  0x3C, 0x38, 0xF1, 0xC3, 0xC7, 0x0F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7F, 0xF3, 0xFF,
  0x9F, 0xFC, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x77, 0x83,
  0xFF, 0x1F, 0xF9, 0xE3, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00,
  0x7F, 0x03, 0xBC, 0x3D, 0xF1, 0xE7, 0xFE, 0x1F, 0xE0, 0x3E, 0x00, 0x03,
  0xC0, 0x7E, 0x07, 0xF0, 0x7C, 0x07, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x00,
  0xF7, 0x87, 0xFF, 0x3F, 0xF9, 0xF1, 0xEF, 0x0F, 0x70, 0x3B, 0x81, 0xFC,
  0x0F, 0xF0, 0x7F, 0x83, 0xBC, 0x3C, 0xF1, 0xE3, 0xFE, 0x1F, 0xE0, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x9E,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x9E, 0x3F, 0xC1, 0xF8,
  0x7F, 0xEF, 0x1E, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xFF, 0x9F,
  0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0x1F, 0x03, 0xFC, 0x7F, 0xCF, 0x9E, 0xF0,
  0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0xFF, 0x1F, 0x7F,
  0xF7, 0xFF, 0x1E, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x7C, 0x3F,
  0x83, 0xF0, 0x3C, 0x00, 0x7F, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x70, 0x7B, 0xDE, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xEF, 0x7B,
  0xDC, 0xEE, 0x20, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xF3, 0xF9, 0xFC, 0x3E,
  0x07, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF0, 0x0E, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x1C, 0x03, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x78, 0x0F,
  0x0F, 0xE7, 0xF3, 0xF8, 0x7C, 0x0E, 0x01, 0x00, 0x00, 0x1F, 0x83, 0xFC,
  0x7F, 0xEF, 0x9E, 0xF0, 0xFF, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3E,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x07,
  0xFE, 0x00, 0x7C, 0x3E, 0x03, 0xC0, 0x38, 0x0E, 0x00, 0x70, 0x70, 0x00,
  0xE3, 0x80, 0x01, 0x8E, 0x0F, 0x86, 0x30, 0x7F, 0x1D, 0xC3, 0xDC, 0x37,
  0x0C, 0x70, 0xD8, 0x71, 0xC3, 0x61, 0xC7, 0x0D, 0x8E, 0x1C, 0x36, 0x38,
  0x70, 0xF8, 0xE1, 0xC3, 0x63, 0x87, 0x1D, 0x8E, 0x18, 0x76, 0x38, 0xF1,
  0x98, 0x7F, 0xCE, 0x71, 0xFB, 0xF1, 0xC3, 0xC7, 0x83, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x07, 0xBC,
  0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x3C, 0x78, 0x0E, 0x1E, 0x07, 0x83, 0x81,
  0xE0, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xE3, 0xC0, 0x78, 0xE0,
  0x1E, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3C, 0xFF, 0xC3, 0xFF, 0xCF,
  0xFF, 0xBC, 0x3E, 0xF0, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3B,
  0xC1, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0xFB, 0xC1, 0xEF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xFB, 0xFF, 0xCF, 0xFC,
  0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xDE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x0F, 0xF0, 0x1F, 0xE0, 0x3D, 0xE0,
  0xF3, 0xE3, 0xE3, 0xFF, 0x83, 0xFE, 0x01, 0xF8, 0x00, 0xFF, 0x83, 0xFF,
  0x8F, 0xFF, 0x3C, 0x3E, 0xF0, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xBC, 0x3E, 0xFF, 0xF3, 0xFF, 0x8F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE3, 0xEF, 0x81,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3D, 0xE0, 0x7B, 0xE1, 0xF3, 0xFF, 0xE3, 0xFF, 0x01, 0xF8, 0x00, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xF0,
  0x7F, 0x83, 0xBC, 0x3D, 0xF3, 0xE7, 0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0xF0,
  0x3E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xF0, 0xF1,
  0xE0, 0xF3, 0xC0, 0xF7, 0x80, 0xF7, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xC0, 0xF9, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xFF, 0xE0, 0x77, 0xFE, 0x07, 0x7F, 0xF0, 0xF7, 0xF7, 0x0E, 0xFF,
  0x70, 0xEF, 0xF7, 0x8E, 0xFF, 0x39, 0xCF, 0xF3, 0x9C, 0xFF, 0x3D, 0xCF,
  0xF1, 0xFC, 0xFF, 0x1F, 0x8F, 0xF1, 0xF8, 0xFF, 0x0F, 0x8F, 0xF0, 0xF0,
  0xFF, 0x0F, 0x0F, 0xF0, 0x70, 0xF0, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xF7, 0x0F,
  0xF7, 0x8F, 0xF3, 0x8F, 0xF3, 0xCF, 0xF1, 0xCF, 0xF1, 0xEF, 0xF0, 0xEF,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7C, 0x7C,
  0x78, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0E,
  0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x1E, 0x7C, 0x7C, 0x3F, 0xFC, 0x1F, 0xF0,
  0x07, 0xE0, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xEF, 0x03, 0xDE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7B, 0xC1, 0xF7, 0xFF,
  0xCF, 0xFF, 0x9F, 0xFC, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0,
  0x1F, 0xF0, 0x3F, 0xF8, 0x7C, 0x7C, 0x78, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x3E,
  0x7C, 0x7C, 0x3F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0E, 0x00, 0x04, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x87, 0xCF,
  0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC3,
  0xE7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3C, 0x78, 0x78, 0x78, 0xF0, 0xF1,
  0xE1, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x03, 0xDE, 0x07, 0xBC, 0x07, 0x80,
  0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xCF, 0x03, 0x9E,
  0x07, 0xBC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x3D, 0xE0, 0x73,
  0xE3, 0xE3, 0xFF, 0xC3, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF,
  0x03, 0xDE, 0x1F, 0x7F, 0xF8, 0xFF, 0xC0, 0xFC, 0x00, 0x78, 0x03, 0xDE,
  0x01, 0xE7, 0x80, 0x78, 0xE0, 0x1E, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0,
  0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x07, 0x87, 0x80, 0xE1, 0xE0, 0x3C, 0x70,
  0x0F, 0x3C, 0x03, 0xCF, 0x00, 0x73, 0xC0, 0x1E, 0xE0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0xF0, 0x78, 0x1F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xDC, 0x1E, 0x0F,
  0x70, 0x7C, 0x3D, 0xE3, 0xF0, 0xE7, 0x8F, 0xC3, 0x9E, 0x3F, 0x1E, 0x78,
  0xFC, 0x78, 0xE3, 0xB9, 0xE3, 0x9E, 0xE7, 0x0F, 0x73, 0x9C, 0x3D, 0xCE,
  0x70, 0xF7, 0x1B, 0xC1, 0xDC, 0x7F, 0x07, 0xE1, 0xFC, 0x1F, 0x87, 0xE0,
  0x7E, 0x1F, 0x81, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x03, 0xE0, 0x3C,
  0x0F, 0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E,
  0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x3E, 0x78,
  0x1E, 0xF0, 0x1F, 0x78, 0x0F, 0xBC, 0x07, 0x9E, 0x03, 0xC7, 0x83, 0xC3,
  0xC1, 0xE0, 0xF0, 0xE0, 0x78, 0xF0, 0x1C, 0x78, 0x0F, 0x78, 0x07, 0xBC,
  0x01, 0xDC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFF, 0xC0,
  0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0,
  0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78,
  0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0xF0, 0xFF, 0xFE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0xFF, 0xE0, 0x0E, 0x07,
  0x81, 0xE0, 0x7C, 0x3F, 0x0E, 0xC3, 0x39, 0xCE, 0x71, 0xB8, 0x7E, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0x0F, 0xC1,
  0xFF, 0x0F, 0xFC, 0xF1, 0xE7, 0x07, 0x00, 0x38, 0x01, 0xC1, 0xFE, 0x3F,
  0xF3, 0xE3, 0x9E, 0x1D, 0xE0, 0xEF, 0x07, 0x3C, 0x79, 0xFF, 0xC7, 0xFF,
  0x1E, 0x78, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0xF8, 0xEF, 0xE7, 0xFF, 0xBE, 0x3D, 0xE1, 0xEE, 0x07, 0x70,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1D, 0xE1, 0xEF, 0x8F,
  0x7F, 0xFB, 0xBF, 0x9C, 0xF8, 0x0F, 0xC1, 0xFF, 0x0F, 0xFC, 0xF1, 0xE7,
  0x07, 0xF8, 0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0xF7, 0x07, 0xBC, 0x78, 0xFF, 0xC7, 0xFC, 0x0F, 0x80, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE3, 0xEF, 0x3F, 0xFB,
  0xFF, 0xDE, 0x3E, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1E, 0xE0, 0xF7, 0x8F, 0xBF, 0xFC, 0xFE, 0xE3, 0xE7,
  0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xF1, 0xE7, 0x87, 0xB8, 0x3F, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x07, 0x80, 0x3E, 0x18, 0xFF,
  0xE3, 0xFE, 0x0F, 0xC0, 0x07, 0x8F, 0xC7, 0xE7, 0xC3, 0xC1, 0xE0, 0xF1,
  0xFE, 0xFF, 0x7F, 0x8F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x0F, 0x39, 0xFD, 0xDF, 0xFE,
  0xF1, 0xF7, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xF7, 0x07, 0xBC, 0x7D, 0xFF, 0xE7, 0xFF, 0x0F, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF3, 0x0F, 0x9F, 0xF8, 0xFF, 0x81, 0xF8, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x78, 0xEF, 0xEF,
  0xFE, 0xF9, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xEF, 0xF6,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x3C,
  0x78, 0xE0, 0x00, 0x07, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0xF7, 0xEF, 0xDE,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x1E, 0xE1, 0xE7, 0x1E, 0x38, 0xF1, 0xCF, 0x0E, 0xF0, 0x77, 0x83,
  0xF8, 0x1F, 0xE0, 0xFF, 0x87, 0xBC, 0x38, 0xF1, 0xC7, 0x8E, 0x1E, 0x70,
  0xF3, 0x83, 0xDC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0x87, 0xCE, 0xFE, 0xFE, 0xFF, 0xFF, 0xEF,
  0x1F, 0x9F, 0xF0, 0xF0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0, 0xFE, 0x0F, 0x0F,
  0xE0, 0xF0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0,
  0xFE, 0x0F, 0x0F, 0xE0, 0xF0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0, 0xF0, 0xE7,
  0xCE, 0xFE, 0xFF, 0xEF, 0x9F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xF0, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1F, 0x3E, 0x78, 0x7B, 0xC0, 0xEF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0x78, 0x79,
  0xF1, 0xE3, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0xE7, 0xC7, 0x7F, 0x3F, 0xFD,
  0xE3, 0xEF, 0x0F, 0x70, 0x3B, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xEE, 0x0F, 0x78, 0x7B, 0xFF, 0x9D, 0xFC, 0xE7, 0x87, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x1F, 0x39,
  0xFD, 0xDF, 0xFE, 0xF1, 0xF7, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF7, 0x07, 0xBC, 0x7D, 0xFF, 0xE7, 0xFF,
  0x1F, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0xE7, 0xEF, 0xFF, 0xFF, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x0F, 0x83, 0xFE, 0x7F, 0xE7, 0x8F,
  0x70, 0xF7, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F,
  0xF0, 0x77, 0x8F, 0x7F, 0xF3, 0xFE, 0x0F, 0x80, 0x1C, 0x0E, 0x07, 0x03,
  0x8F, 0xFF, 0xFF, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0F, 0x07, 0xE3, 0xF0, 0xF8, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0x3E, 0xF0, 0xE0, 0x7F,
  0x0F, 0xF0, 0xF7, 0x0E, 0x70, 0xE7, 0x9E, 0x79, 0xE3, 0x9C, 0x39, 0xC3,
  0xDC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0xE1, 0xFC, 0x3C, 0x3F, 0xC7, 0x87, 0x78, 0xF0, 0xE7, 0x1F, 0x3C,
  0xE7, 0xE7, 0x9C, 0xFC, 0xE3, 0xDD, 0x9C, 0x3B, 0xBB, 0x87, 0xE7, 0x70,
  0xFC, 0xFE, 0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0xC0,
  0xF0, 0x70, 0x1E, 0x0E, 0x00, 0xF0, 0xF3, 0x87, 0x9E, 0x78, 0x73, 0xC3,
  0xDC, 0x0F, 0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0x00, 0x7C, 0x07, 0xE0, 0x3F,
  0x83, 0xDC, 0x3C, 0xF1, 0xE7, 0x9E, 0x1E, 0xF0, 0xF0, 0x70, 0x7B, 0xC3,
  0xDE, 0x1E, 0xF0, 0xE3, 0x8F, 0x1E, 0x78, 0xF3, 0xC3, 0x9C, 0x1C, 0xE0,
  0xFF, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x78,
  0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x02, 0x07, 0x0E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x38, 0xF8, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x0E, 0x07, 0x02, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x1F, 0x0F, 0x1F, 0x3C, 0x3C, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0xF0, 0xE0, 0xC0, 0x3C,
  0x0E, 0xFC, 0x1B, 0xFC, 0x77, 0x3C, 0xEE, 0x3F, 0xDC, 0x3F, 0x00, 0x3C,
  0x00,
};

const GFXglyph RobotoCondensed_Medium32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 23, 8, 2, -23 },
  { 13, 7, 8, 10, 2, -24 },
  { 20, 14, 23, 17, 2, -23 },
  { 61, 12, 29, 16, 2, -26 },
  { 105, 17, 23, 20, 2, -23 },
  { 154, 17, 23, 18, 1, -23 },
  { 203, 3, 8, 5, 1, -24 },
  { 206, 7, 32, 10, 2, -25 },
  { 234, 7, 32, 10, 1, -25 },
  { 262, 14, 14, 14, 0, -23 },
  { 287, 13, 16, 16, 1, -18 },
  { 313, 4, 9, 7, 1, -4 },
  { 318, 7, 3, 10, 1, -11 },
  { 321, 5, 4, 9, 2, -4 },
  { 324, 10, 25, 11, 0, -23 },
  { 356, 12, 23, 16, 2, -23 },
  { 391, 9, 23, 16, 2, -23 },
  { 417, 14, 23, 16, 1, -23 },
  { 458, 13, 23, 16, 1, -23 },
  { 496, 14, 23, 16, 1, -23 },
  { 537, 13, 23, 16, 2, -23 },
  { 575, 13, 23, 16, 2, -23 },
  { 613, 14, 23, 16, 1, -23 },
  { 654, 12, 23, 16, 2, -23 },
  { 689, 12, 23, 16, 2, -23 },
  { 724, 4, 17, 8, 2, -17 },
  { 733, 5, 22, 7, 1, -17 },
  { 747, 11, 14, 14, 1, -17 },
  { 767, 12, 9, 16, 2, -15 },
  { 781, 11, 14, 15, 2, -17 },
  { 801, 12, 23, 14, 1, -23 },
  { 836, 22, 29, 25, 1, -22 },
  { 916, 18, 23, 19, 0, -23 },
  { 968, 14, 23, 18, 2, -23 },
  { 1009, 15, 23, 18, 2, -23 },
  { 1053, 14, 23, 18, 2, -23 },
  { 1094, 13, 23, 16, 2, -23 },
  { 1132, 12, 23, 15, 2, -23 },
  { 1167, 15, 23, 19, 2, -23 },
  { 1211, 16, 23, 20, 2, -23 },
  { 1257, 4, 23, 8, 2, -23 },
  { 1269, 13, 23, 16, 1, -23 },
  { 1307, 16, 23, 18, 2, -23 },
  { 1353, 12, 23, 15, 2, -23 },
  { 1388, 20, 23, 24, 2, -23 },
  { 1446, 16, 23, 20, 2, -23 },
  { 1492, 16, 23, 19, 2, -23 },
  { 1538, 15, 23, 18, 2, -23 },
  { 1582, 16, 27, 19, 2, -23 },
  { 1636, 15, 23, 17, 2, -23 },
  { 1680, 15, 23, 17, 1, -23 },
  { 1724, 15, 23, 17, 1, -23 },
  { 1768, 14, 23, 18, 2, -23 },
  { 1809, 18, 23, 18, 0, -23 },
  { 1861, 22, 23, 24, 1, -23 },
  { 1925, 16, 23, 18, 1, -23 },
  { 1971, 17, 23, 17, 0, -23 },
  { 2020, 15, 23, 17, 1, -23 },
  { 2064, 6, 31, 8, 2, -26 },
  { 2088, 12, 25, 12, 0, -23 },
  { 2126, 5, 31, 8, 1, -26 },
  { 2146, 10, 11, 12, 1, -23 },
  { 2160, 13, 3, 13, 0, 0 },
  { 2165, 7, 5, 10, 1, -24 },
  { 2170, 13, 17, 15, 1, -17 },
  { 2198, 13, 24, 16, 2, -24 },
  { 2237, 13, 17, 15, 1, -17 },
  { 2265, 13, 24, 16, 1, -24 },
  { 2304, 13, 17, 15, 1, -17 },
  { 2332, 9, 24, 10, 1, -24 },
  { 2359, 13, 24, 16, 1, -17 },
  { 2398, 12, 24, 16, 2, -24 },
  { 2434, 4, 23, 8, 2, -23 },
  { 2446, 7, 30, 8, -1, -23 },
  { 2473, 13, 24, 15, 2, -24 },
  { 2512, 4, 24, 8, 2, -24 },
  { 2524, 20, 17, 24, 2, -17 },
  { 2567, 12, 17, 16, 2, -17 },
  { 2593, 14, 17, 16, 1, -17 },
  { 2623, 13, 24, 16, 2, -17 },
  { 2662, 13, 24, 16, 1, -17 },
  { 2701, 8, 17, 10, 2, -17 },
  { 2718, 12, 17, 15, 1, -17 },
  { 2744, 9, 21, 10, 0, -21 },
  { 2768, 12, 17, 16, 2, -17 },
  { 2794, 12, 17, 14, 1, -17 },
  { 2820, 19, 17, 21, 1, -17 },
  { 2861, 13, 17, 14, 1, -17 },
  { 2889, 13, 24, 14, 0, -17 },
  { 2928, 12, 17, 14, 1, -17 },
  { 2954, 8, 31, 10, 1, -25 },
  { 2985, 2, 27, 8, 3, -23 },
  { 2992, 8, 31, 10, 1, -25 },
  { 3023, 15, 7, 18, 2, -13 },
};

const GFXfont RobotoCondensed_Medium32pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium32pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOCONDENSED_MEDIUM32PT7B_H_
