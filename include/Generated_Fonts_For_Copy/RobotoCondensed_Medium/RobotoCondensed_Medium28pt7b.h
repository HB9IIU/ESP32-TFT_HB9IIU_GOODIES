#ifndef _ROBOTOCONDENSED_MEDIUM28PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0xEF, 0xDF, 0xBF,
  0x7C, 0xF9, 0xB3, 0x00, 0x06, 0x30, 0x33, 0x81, 0x98, 0x0C, 0xC0, 0xE6,
  0x06, 0x31, 0xFF, 0xEF, 0xFF, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x39, 0x8F,
  0xFF, 0x7F, 0xF8, 0x67, 0x03, 0x30, 0x19, 0x81, 0xCC, 0x0C, 0x60, 0x63,
  0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0xF8, 0x3F, 0xC3, 0xFE, 0x78, 0xE7,
  0x0E, 0x70, 0xF7, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0,
  0x0E, 0x00, 0xFF, 0x0F, 0xF0, 0xF7, 0x0E, 0x7F, 0xE3, 0xFC, 0x0F, 0x80,
  0x60, 0x06, 0x00, 0x60, 0x3C, 0x00, 0x7E, 0x00, 0x66, 0x10, 0xE7, 0x38,
  0xE7, 0x30, 0xE7, 0x70, 0x66, 0x60, 0x7E, 0xC0, 0x3C, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x3C, 0x03, 0x7E, 0x06, 0x66, 0x06, 0xE7, 0x0C, 0xE7,
  0x1C, 0xE7, 0x18, 0x66, 0x00, 0x7E, 0x00, 0x3C, 0x0F, 0x00, 0x7E, 0x03,
  0xFC, 0x0E, 0x70, 0x38, 0xC0, 0xE3, 0x03, 0x9C, 0x0F, 0xE0, 0x1F, 0x00,
  0x78, 0x03, 0xF1, 0x9F, 0xCE, 0x73, 0xBB, 0x8F, 0xEE, 0x1F, 0xBC, 0x3C,
  0xF0, 0xF1, 0xFF, 0xE3, 0xFF, 0x87, 0xCF, 0xFF, 0xFD, 0xB0, 0x04, 0x31,
  0xCE, 0x31, 0xC7, 0x18, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0x61, 0xC7, 0x0C, 0x38, 0x70, 0xC1, 0x83, 0x0E, 0x1C, 0x30, 0xE3,
  0x86, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x18, 0xE3,
  0x8C, 0x73, 0x8C, 0x20, 0x06, 0x00, 0x60, 0x06, 0x04, 0x60, 0x7E, 0xFF,
  0xFF, 0x0F, 0x80, 0xF0, 0x1F, 0x83, 0x9C, 0x38, 0xE1, 0x08, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x39, 0xCE, 0x73, 0x39, 0xCC,
  0xFF, 0xFF, 0xC0, 0x6F, 0xFE, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38,
  0x18, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x30,
  0x38, 0x1C, 0x0C, 0x06, 0x07, 0x00, 0x0F, 0x03, 0xFC, 0x3F, 0xC7, 0x0E,
  0x70, 0xE7, 0x0E, 0xF0, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xF7, 0x0E, 0x70, 0xE7, 0x0E, 0x78, 0xE3, 0xFC, 0x3F, 0xC0, 0xF0,
  0x02, 0x3D, 0xFF, 0xFE, 0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x1E,
  0xF0, 0xEE, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78,
  0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0x07, 0xF9, 0xFF, 0xF8, 0xFE, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x0F,
  0xC1, 0xF0, 0x3F, 0x00, 0xF0, 0x0E, 0x01, 0xF8, 0x3F, 0x87, 0x70, 0xEF,
  0xFC, 0xFF, 0x0F, 0x80, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0xFC, 0x0D, 0xC1, 0xDC, 0x19, 0xC3, 0x9C, 0x31, 0xC7, 0x1C, 0x61, 0xCF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x7F, 0xCF,
  0xF9, 0xFF, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x78, 0xFF, 0x9F, 0xF9,
  0x87, 0x00, 0xF0, 0x0E, 0x01, 0xF8, 0x3F, 0x0F, 0xF1, 0xCF, 0xF9, 0xFE,
  0x0F, 0x80, 0x07, 0x03, 0xE0, 0xFC, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x07,
  0x78, 0xFF, 0x9F, 0xFB, 0xC7, 0x70, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F,
  0xF1, 0xCF, 0xF8, 0xFE, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70,
  0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x9E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x9E,
  0x3F, 0xC1, 0xF8, 0x3F, 0xC7, 0x9E, 0x70, 0xE7, 0x0E, 0xF0, 0xF7, 0x0E,
  0x70, 0xE7, 0xFE, 0x3F, 0xC0, 0xF0, 0x0F, 0x07, 0xF1, 0xFF, 0x38, 0xF7,
  0x0F, 0xE1, 0xF8, 0x3F, 0x87, 0xF0, 0xEE, 0x3D, 0xFF, 0x9F, 0xF1, 0xEE,
  0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC3, 0xF0, 0x7C, 0x0E, 0x00, 0x6F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x6F, 0xFE, 0x27, 0x77, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x77, 0x77, 0xEE, 0x40, 0x00, 0x40, 0x70, 0x7C, 0x7E, 0x7E, 0x3E,
  0x0E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x38,
  0x0F, 0x83, 0xF8, 0x3F, 0x83, 0xF0, 0x1C, 0x3F, 0x3F, 0xBF, 0x8F, 0x83,
  0x80, 0x80, 0x00, 0x1F, 0x1F, 0xEF, 0xFF, 0xCF, 0xE1, 0xC0, 0x70, 0x1C,
  0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x78, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x07, 0x01, 0xE0, 0x70, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3C, 0x1C, 0x0E,
  0x00, 0xC1, 0x80, 0x0C, 0x60, 0x01, 0x8C, 0x1E, 0x1B, 0x0F, 0xE3, 0x61,
  0xCC, 0x6C, 0x71, 0x8D, 0x8C, 0x71, 0xF1, 0x8E, 0x3E, 0x71, 0xC7, 0xCE,
  0x38, 0xF9, 0xC6, 0x1F, 0x38, 0xC7, 0x63, 0xBC, 0xCC, 0x7D, 0xF1, 0x87,
  0x1C, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x82, 0x00, 0x7F,
  0xE0, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x38,
  0x1E, 0x38, 0x1C, 0x38, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x1E,
  0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0F, 0x70, 0x0F, 0xFF, 0x8F, 0xFC, 0xFF,
  0xEE, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xFF, 0xEF, 0xF8, 0xFF,
  0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF, 0xFE, 0xFF,
  0xEF, 0xF8, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x0E, 0x70, 0x39, 0xC0,
  0xF7, 0x01, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xC0, 0x77, 0x03, 0xDC, 0x0F, 0x78, 0x38, 0xFF, 0xE1, 0xFF, 0x03,
  0xF0, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x1E, 0xE0, 0xFE, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0F, 0xE1, 0xEF, 0xFE, 0xFF, 0xCF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xDF, 0xFB, 0xFF, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F,
  0xFB, 0xFF, 0x7F, 0xEE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x0E, 0x70, 0x3D,
  0xC0, 0x77, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F,
  0xF0, 0x1D, 0xC0, 0x77, 0x01, 0xDE, 0x07, 0x78, 0x3C, 0xFF, 0xF1, 0xFF,
  0x81, 0xF8, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x70, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xF8, 0x7F, 0x0F, 0xF1, 0xDF, 0xF9, 0xFE, 0x0F, 0x80, 0xE0,
  0x7F, 0x07, 0xB8, 0x79, 0xC3, 0xCE, 0x3C, 0x71, 0xC3, 0x9E, 0x1D, 0xE0,
  0xEE, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0x78, 0x71, 0xE3, 0x87, 0x1C,
  0x3C, 0xE0, 0xE7, 0x07, 0xB8, 0x1F, 0xC0, 0xF0, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xEE, 0x1B, 0xF7, 0x1D, 0xFB, 0x8E, 0xFC,
  0xE6, 0x7E, 0x77, 0x3F, 0x3B, 0x9F, 0x8D, 0xCF, 0xC7, 0xC7, 0xE3, 0xE3,
  0xF0, 0xF1, 0xF8, 0x70, 0xFC, 0x38, 0x70, 0xE0, 0x3F, 0x81, 0xFC, 0x0F,
  0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0xFD, 0xC7, 0xEE, 0x3F, 0x39, 0xF9,
  0xCF, 0xC7, 0x7E, 0x3B, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x03,
  0xF8, 0x1F, 0xC0, 0x70, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x1E, 0x78,
  0x3D, 0xC0, 0x77, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0x70, 0x1D, 0xC0, 0x77, 0x01, 0xDE, 0x0F, 0x78, 0x38, 0xFF, 0xE1,
  0xFF, 0x01, 0xF0, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xC1, 0xEE, 0x07, 0x70,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x77, 0x07, 0xBF, 0xFD, 0xFF, 0xCF, 0xF8,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x1E, 0x70, 0x3D, 0xC0, 0x77, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1D, 0xC0,
  0x77, 0x01, 0xDC, 0x0F, 0x78, 0x78, 0xFF, 0xE1, 0xFF, 0x01, 0xFE, 0x00,
  0x7C, 0x00, 0x70, 0x00, 0x80, 0xFF, 0x87, 0xFE, 0x3F, 0xF9, 0xC1, 0xEE,
  0x0F, 0x70, 0x3B, 0x81, 0xDC, 0x1E, 0xE0, 0xF7, 0xFF, 0x3F, 0xF1, 0xFF,
  0x0E, 0x3C, 0x71, 0xE3, 0x87, 0x1C, 0x3C, 0xE0, 0xE7, 0x07, 0xB8, 0x1D,
  0xC0, 0xF0, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xE1, 0xE7, 0x07, 0x78, 0x3D,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0x00,
  0x3F, 0x81, 0xFE, 0x0F, 0x70, 0x73, 0xFF, 0x8F, 0xF8, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xF7, 0xFE, 0x7F,
  0xC1, 0xF8, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x1C,
  0x38, 0x1C, 0x3C, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x78, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0xE0, 0xEE, 0x0E, 0x0E, 0xE0,
  0xF0, 0xEF, 0x0F, 0x0E, 0x71, 0xF1, 0xE7, 0x1F, 0x1C, 0x71, 0xF1, 0xC7,
  0x1B, 0x9C, 0x71, 0xB9, 0xC3, 0xBB, 0x9C, 0x3B, 0x99, 0xC3, 0xB9, 0xB8,
  0x3B, 0x1F, 0x83, 0xB1, 0xF8, 0x1F, 0x1F, 0x81, 0xF0, 0xF8, 0x1E, 0x0F,
  0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0xF0, 0x3D, 0xC1, 0xE7,
  0x87, 0x8E, 0x3C, 0x3C, 0xF0, 0x73, 0x81, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x77, 0x83, 0xCE, 0x0F, 0x3C,
  0x78, 0xF1, 0xE1, 0xEF, 0x07, 0xBC, 0x0F, 0x70, 0x1C, 0xF0, 0x79, 0xE0,
  0xF1, 0xC1, 0xC3, 0xC7, 0x83, 0x8E, 0x07, 0x1C, 0x07, 0x70, 0x0E, 0xE0,
  0x1F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xFE, 0x70,
  0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03,
  0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xFF, 0xFE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0xFF, 0xFE, 0x1C,
  0x0E, 0x0F, 0x07, 0xC3, 0x63, 0xB1, 0xDC, 0xC6, 0xE3, 0x71, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF1, 0xE3, 0x87, 0x1F, 0x07, 0xF9, 0xFF, 0x38,
  0xF7, 0x1E, 0x03, 0xC7, 0xF9, 0xFF, 0x79, 0xFE, 0x3F, 0x87, 0xF8, 0xF7,
  0xFE, 0xFD, 0xCF, 0x38, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x3B, 0xC7, 0xFC, 0xFF, 0xDC, 0x3B, 0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x0F, 0xE1, 0xFC, 0x3B, 0xFF, 0x7F, 0xCE, 0xF0, 0x1F, 0x07, 0xF9,
  0xFF, 0x38, 0xFF, 0x0F, 0xC1, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC3,
  0xB8, 0x77, 0xFC, 0x7F, 0x87, 0xC0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC7, 0xB9, 0xFF, 0x7F, 0xEE, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0xEE, 0x1D, 0xFF, 0x9F, 0xF1, 0xEE, 0x1F,
  0x87, 0xF9, 0xFF, 0xB8, 0x7F, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C,
  0x03, 0xC0, 0x38, 0x27, 0xFE, 0x7F, 0xC3, 0xE0, 0x0F, 0x1F, 0x3F, 0x38,
  0x38, 0x38, 0xFE, 0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x1E, 0xE7, 0xFD, 0xFF, 0xB8, 0x7F, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xB8, 0x77, 0xFE, 0x7F,
  0xC7, 0xB8, 0x07, 0x00, 0xE4, 0x1D, 0xFF, 0xBF, 0xE1, 0xF0, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0xF3, 0xFE, 0xFF, 0xF8, 0xFE, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xC0, 0x5F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x08, 0x73, 0xC7,
  0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0xFF, 0xEF, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0xF7, 0x1C, 0xE7, 0x9D, 0xE3, 0xB8, 0x7E, 0x0F, 0xC1,
  0xFC, 0x3F, 0x87, 0x78, 0xE7, 0x1C, 0xF3, 0x8F, 0x71, 0xEE, 0x1E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xEF, 0x1E, 0x7F, 0xDF, 0xBF,
  0xFF, 0xFC, 0x7C, 0x7E, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87,
  0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x7E, 0x1C, 0x3F, 0x0E,
  0x1F, 0x87, 0x0E, 0xEF, 0x3F, 0xEF, 0xFF, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0x0F, 0x03,
  0xFC, 0x7F, 0xE7, 0x0E, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0xF7, 0x0E, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0xEF, 0x1F, 0xF3,
  0xFF, 0x70, 0xEE, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x87,
  0xF0, 0xEF, 0xFD, 0xFF, 0x3B, 0xC7, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x00, 0x1E, 0xE7, 0xFD, 0xFF, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xB8, 0x77, 0xFE, 0x7F, 0xC7, 0xB8, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0xEF, 0xFF, 0xFC, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x00, 0x1F, 0x07, 0xF1, 0xFF, 0x38,
  0xEF, 0x1C, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7B, 0x87, 0xF0, 0xF7,
  0xFC, 0xFF, 0x87, 0xC0, 0x38, 0x38, 0x38, 0xFF, 0xFF, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x3F, 0x1F, 0x0F, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x8F, 0xFF, 0xDF, 0xF3, 0xDC, 0x70, 0xF7, 0x0E, 0x70, 0xE7, 0x8E, 0x39,
  0xE3, 0x9C, 0x39, 0xC1, 0xDC, 0x1D, 0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0x07, 0x00, 0xE1, 0x87, 0xE3, 0x87, 0xE3, 0xC7, 0xE3, 0xC7,
  0x73, 0xCE, 0x77, 0xCE, 0x77, 0xEE, 0x76, 0xEE, 0x76, 0x6C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0xE1, 0xFE,
  0x39, 0xCF, 0x3D, 0xC3, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1F, 0x07, 0xE0,
  0xFE, 0x3D, 0xC7, 0x3D, 0xE3, 0xB8, 0x78, 0xF0, 0xF7, 0x0E, 0x70, 0xE7,
  0x8E, 0x39, 0xC3, 0x9C, 0x39, 0xC1, 0xDC, 0x1F, 0x81, 0xF8, 0x1F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x7C, 0x07,
  0xC0, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x81, 0xC0, 0xE0,
  0x78, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x04, 0x1C,
  0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xCF, 0x1C, 0x3C, 0x38,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x1C, 0x1C, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xC3, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE0, 0xE1, 0xC3, 0xC3, 0xC7, 0x9C, 0x38, 0xF1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0xF1, 0xC2, 0x00, 0x38, 0x33, 0xE1, 0xBF, 0x9D,
  0x8F, 0xEC, 0x3E, 0x00, 0xE0,
};

const GFXglyph RobotoCondensed_Medium28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 20, 7, 2, -20 },
  { 9, 7, 7, 9, 1, -21 },
  { 16, 13, 20, 15, 1, -20 },
  { 49, 12, 26, 14, 1, -23 },
  { 88, 16, 20, 18, 1, -20 },
  { 128, 14, 20, 16, 1, -20 },
  { 163, 3, 7, 5, 1, -21 },
  { 166, 6, 28, 9, 2, -22 },
  { 187, 6, 28, 9, 1, -22 },
  { 208, 12, 12, 12, 0, -20 },
  { 226, 11, 15, 14, 1, -17 },
  { 247, 5, 8, 6, 0, -3 },
  { 252, 6, 3, 9, 1, -10 },
  { 255, 4, 4, 8, 2, -4 },
  { 257, 9, 22, 10, 0, -20 },
  { 282, 12, 20, 14, 1, -20 },
  { 312, 7, 20, 14, 2, -20 },
  { 330, 12, 20, 14, 1, -20 },
  { 360, 11, 20, 14, 1, -20 },
  { 388, 12, 20, 14, 1, -20 },
  { 418, 11, 20, 14, 2, -20 },
  { 446, 11, 20, 14, 2, -20 },
  { 474, 12, 20, 14, 1, -20 },
  { 504, 12, 20, 14, 1, -20 },
  { 534, 11, 20, 14, 1, -20 },
  { 562, 4, 16, 7, 2, -16 },
  { 570, 4, 21, 6, 1, -16 },
  { 581, 10, 13, 13, 1, -15 },
  { 598, 10, 9, 14, 2, -14 },
  { 610, 10, 13, 13, 2, -15 },
  { 627, 10, 20, 12, 1, -20 },
  { 652, 19, 25, 22, 1, -19 },
  { 712, 16, 20, 16, 0, -20 },
  { 752, 12, 20, 16, 2, -20 },
  { 782, 14, 20, 16, 1, -20 },
  { 817, 12, 20, 16, 2, -20 },
  { 847, 11, 20, 14, 2, -20 },
  { 875, 11, 20, 13, 2, -20 },
  { 903, 14, 20, 16, 1, -20 },
  { 938, 13, 20, 17, 2, -20 },
  { 971, 3, 20, 7, 2, -20 },
  { 979, 11, 20, 14, 1, -20 },
  { 1007, 13, 20, 15, 2, -20 },
  { 1040, 11, 20, 13, 2, -20 },
  { 1068, 17, 20, 21, 2, -20 },
  { 1111, 13, 20, 17, 2, -20 },
  { 1144, 14, 20, 17, 1, -20 },
  { 1179, 13, 20, 16, 2, -20 },
  { 1212, 14, 23, 17, 1, -20 },
  { 1253, 13, 20, 15, 2, -20 },
  { 1286, 13, 20, 15, 1, -20 },
  { 1319, 13, 20, 15, 1, -20 },
  { 1352, 12, 20, 16, 2, -20 },
  { 1382, 16, 20, 16, 0, -20 },
  { 1422, 20, 20, 21, 1, -20 },
  { 1472, 14, 20, 16, 1, -20 },
  { 1507, 15, 20, 15, 0, -20 },
  { 1545, 13, 20, 15, 1, -20 },
  { 1578, 5, 27, 7, 2, -23 },
  { 1595, 11, 22, 11, 0, -20 },
  { 1626, 5, 27, 7, 0, -23 },
  { 1643, 9, 10, 11, 1, -20 },
  { 1655, 11, 3, 11, 0, 0 },
  { 1660, 6, 4, 9, 1, -21 },
  { 1663, 11, 15, 13, 1, -15 },
  { 1684, 11, 21, 14, 2, -21 },
  { 1713, 11, 15, 13, 1, -15 },
  { 1734, 11, 21, 14, 1, -21 },
  { 1763, 11, 15, 13, 1, -15 },
  { 1784, 8, 21, 9, 1, -21 },
  { 1805, 11, 21, 14, 1, -15 },
  { 1834, 10, 21, 14, 2, -21 },
  { 1861, 3, 21, 7, 2, -21 },
  { 1869, 6, 27, 7, -1, -21 },
  { 1890, 11, 21, 13, 2, -21 },
  { 1919, 3, 21, 7, 2, -21 },
  { 1927, 17, 15, 21, 2, -15 },
  { 1959, 10, 15, 14, 2, -15 },
  { 1978, 12, 15, 14, 1, -15 },
  { 2001, 11, 21, 14, 2, -15 },
  { 2030, 11, 21, 14, 1, -15 },
  { 2059, 6, 15, 9, 2, -15 },
  { 2071, 11, 15, 13, 1, -15 },
  { 2092, 8, 18, 8, 0, -18 },
  { 2110, 10, 15, 14, 2, -15 },
  { 2129, 12, 15, 12, 0, -15 },
  { 2152, 16, 15, 18, 1, -15 },
  { 2182, 11, 15, 13, 1, -15 },
  { 2203, 12, 21, 12, 0, -15 },
  { 2235, 10, 15, 13, 1, -15 },
  { 2254, 7, 27, 8, 1, -22 },
  { 2278, 3, 24, 7, 2, -20 },
  { 2287, 7, 27, 8, 1, -22 },
  { 2311, 13, 6, 16, 2, -11 },
};

const GFXfont RobotoCondensed_Medium28pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium28pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium28pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOCONDENSED_MEDIUM28PT7B_H_
