#ifndef _ROBOTOCONDENSED_MEDIUM56PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium56pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xEF, 0xFF, 0xFF, 0xBE,
  0x00, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7B, 0xC3,
  0xDE, 0x1E, 0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x78,
  0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xE1, 0xE0, 0x01, 0xF0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x1F, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x7C, 0x00,
  0x7C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80,
  0x07, 0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xE0, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1F,
  0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x3F, 0x87, 0xF8, 0xFC, 0x0F, 0xE7, 0xF0, 0x1F, 0xDF, 0xC0,
  0x7F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0x7F, 0x01, 0xFD, 0xFE, 0x1F,
  0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xE1, 0xF0, 0x18, 0x0F, 0x87, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x1F, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x03, 0xC3, 0xE0,
  0x3C, 0x0F, 0x0F, 0x00, 0xF0, 0x3C, 0x7C, 0x03, 0xE1, 0xF1, 0xE0, 0x0F,
  0x87, 0xCF, 0x80, 0x1F, 0xFE, 0x3C, 0x00, 0x7F, 0xF9, 0xE0, 0x00, 0xFF,
  0xC7, 0x80, 0x01, 0xFE, 0x3C, 0x00, 0x00, 0x80, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC7,
  0xF8, 0x00, 0x1E, 0x3F, 0xF0, 0x00, 0x79, 0xFF, 0xE0, 0x03, 0xC7, 0xFF,
  0x80, 0x1F, 0x3E, 0x1F, 0x00, 0x78, 0xF0, 0x7C, 0x03, 0xE3, 0xC0, 0xF0,
  0x0F, 0x0F, 0x03, 0xC0, 0x7C, 0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F,
  0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x3E, 0x1F, 0x03, 0x80,
  0xF8, 0x7C, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF8,
  0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E,
  0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x3F, 0x1F, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xF0, 0xFC,
  0x3F, 0xBF, 0x87, 0xE3, 0xF8, 0xFE, 0x3E, 0x1F, 0xC7, 0xF9, 0xF0, 0xFC,
  0x1F, 0xDF, 0x8F, 0xE0, 0x7F, 0xFC, 0x7F, 0x03, 0xFF, 0xE3, 0xF8, 0x0F,
  0xFE, 0x1F, 0xC0, 0x3F, 0xF0, 0x7E, 0x00, 0xFF, 0x83, 0xF8, 0x07, 0xF8,
  0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xF9, 0xFE, 0x03, 0xFF,
  0x07, 0xF0, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x10, 0x01, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0x80,
  0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x38,
  0x00, 0x80, 0x20, 0x01, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x10, 0x1F, 0x00, 0x38, 0x1E, 0x0E, 0x7E, 0x3C, 0x7D, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x0F, 0x9F, 0x80,
  0x3F, 0x1F, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x01,
  0x80, 0x70, 0x01, 0x00, 0x40, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7C, 0x7E, 0x3F, 0x1F, 0x9F, 0x8F, 0x8F, 0xC3, 0xC0, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x39, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0x08, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xF8, 0x7F, 0x1F, 0xC0,
  0xFE, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07,
  0xE7, 0xF0, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x7C, 0x03, 0xF8, 0x1F, 0xF1, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xF1, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0x83, 0xFC, 0x7F,
  0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xE0,
  0xFE, 0x3F, 0x80, 0xFE, 0x7E, 0x01, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xF9, 0xFC, 0x07, 0xF3, 0xFC, 0x1F,
  0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0xFB, 0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xFB, 0xF0, 0x01, 0xF3, 0xF0,
  0x03, 0xF3, 0xF0, 0x03, 0xE3, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xC3, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xCF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xE3, 0xFC, 0x7F, 0xC3, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x3F,
  0x00, 0x7E, 0x7E, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x0F, 0xE1, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0x80, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x3F,
  0x7F, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE7, 0xFE,
  0x3F, 0xCF, 0xF8, 0x3F, 0xDF, 0xE0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00,
  0x7E, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0x3F, 0x00, 0x7E,
  0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0xFF, 0x0F, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xF8, 0x7F, 0x1F, 0xC0, 0xFE,
  0x7F, 0x03, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E,
  0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0xC0, 0xFE, 0x3F, 0x03,
  0xF0, 0xFF, 0x3F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE1, 0xFC, 0x7F, 0x03, 0xF9, 0xF8,
  0x07, 0xEF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF7,
  0xF0, 0x3F, 0x9F, 0xE1, 0xFE, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0x1F, 0xC1, 0xFC, 0x7E, 0x03, 0xFB, 0xF8,
  0x0F, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFD, 0xFC, 0x0F, 0xF7, 0xF8,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xDF,
  0x80, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x0F, 0x07, 0xE3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xE1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x0F, 0xC3, 0xF1, 0xF8, 0x7C, 0x1F, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x3F,
  0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E,
  0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x07,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0x0F, 0xEF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00,
  0x04, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x00, 0xF0, 0xF8, 0x03, 0xFE, 0x03, 0xC3, 0xC0, 0x1F, 0xFE,
  0x0F, 0x9F, 0x00, 0xFF, 0xF8, 0x1E, 0x7C, 0x07, 0xE3, 0xE0, 0x79, 0xE0,
  0x3F, 0x0F, 0x81, 0xE7, 0x80, 0xF8, 0x3E, 0x07, 0xBE, 0x07, 0xC0, 0xF8,
  0x1E, 0xF8, 0x1F, 0x03, 0xE0, 0x7B, 0xE0, 0x7C, 0x0F, 0x81, 0xEF, 0x03,
  0xE0, 0x3E, 0x07, 0xBC, 0x0F, 0x80, 0xF0, 0x1E, 0xF0, 0x3E, 0x03, 0xC0,
  0x7B, 0xC0, 0xF8, 0x0F, 0x01, 0xEF, 0x03, 0xE0, 0x3C, 0x07, 0xBC, 0x0F,
  0x80, 0xF0, 0x1E, 0xF0, 0x3E, 0x07, 0xC0, 0x7B, 0xC0, 0xF8, 0x1F, 0x01,
  0xEF, 0x03, 0xE0, 0x7C, 0x07, 0xBC, 0x0F, 0x81, 0xF0, 0x3C, 0xF0, 0x3E,
  0x0F, 0xC0, 0xF3, 0xE0, 0xF8, 0x3F, 0x07, 0xCF, 0x83, 0xF1, 0xFC, 0x1E,
  0x3E, 0x07, 0xFF, 0xFD, 0xF8, 0x78, 0x1F, 0xFB, 0xFF, 0xC1, 0xF0, 0x3F,
  0xC7, 0xFE, 0x07, 0xC0, 0x7E, 0x0F, 0xF0, 0x0F, 0x00, 0x00, 0x04, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x03, 0x00, 0x00, 0x3F, 0xE0, 0x7C, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFC, 0x01,
  0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFC, 0x01,
  0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xE0,
  0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03,
  0xF3, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xF0, 0x0F, 0xF1,
  0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x1F,
  0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xFB,
  0xF0, 0x01, 0xFD, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x01, 0xFE,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x0F, 0xF8, 0x1F, 0xE1, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x1F,
  0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xDF,
  0x80, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x01,
  0xFC, 0xFF, 0x00, 0x7F, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xBF,
  0x00, 0x7E, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFF, 0x1F, 0xE1, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0x00, 0x10, 0x00, 0xFC, 0x00, 0x3F, 0xDF, 0x80, 0x0F, 0xF3, 0xF0,
  0x01, 0xFE, 0x7E, 0x00, 0x7F, 0x8F, 0xC0, 0x1F, 0xE1, 0xF8, 0x03, 0xF8,
  0x3F, 0x00, 0xFF, 0x07, 0xE0, 0x3F, 0xC0, 0xFC, 0x07, 0xF0, 0x1F, 0x81,
  0xFE, 0x03, 0xF0, 0x7F, 0x80, 0x7E, 0x0F, 0xE0, 0x0F, 0xC3, 0xFC, 0x01,
  0xF8, 0x7F, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE7, 0xF8, 0x00, 0xFC, 0xFE,
  0x00, 0x1F, 0xBF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0x9F, 0xC0, 0x1F, 0xE3, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7E,
  0x07, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0x00, 0xFE,
  0x07, 0xE0, 0x1F, 0xE0, 0xFC, 0x01, 0xFE, 0x1F, 0x80, 0x3F, 0xC3, 0xF0,
  0x03, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF9, 0xF8, 0x00, 0x7F,
  0x3F, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFB, 0xFF, 0xFF, 0x00, 0x3F,
  0x7F, 0xFF, 0xE0, 0x07, 0xEF, 0xFF, 0x7E, 0x00, 0xFD, 0xFF, 0xEF, 0xC0,
  0x1F, 0x7F, 0xFD, 0xF8, 0x07, 0xEF, 0xFF, 0x9F, 0x00, 0xFD, 0xFF, 0xF3,
  0xF0, 0x1F, 0x3F, 0xFE, 0x7E, 0x07, 0xE7, 0xFF, 0xCF, 0xC0, 0xFC, 0xFF,
  0xF8, 0xFC, 0x1F, 0x1F, 0xFF, 0x1F, 0x87, 0xE3, 0xFF, 0xE3, 0xF0, 0xFC,
  0x7F, 0xFC, 0x3F, 0x1F, 0x0F, 0xFF, 0x87, 0xE7, 0xE1, 0xFF, 0xF0, 0xFC,
  0xFC, 0x3F, 0xFE, 0x0F, 0xDF, 0x87, 0xFF, 0xC1, 0xFB, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xE0,
  0x3F, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0xFF, 0xF8, 0x07,
  0xE0, 0x1F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0x80, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0x7F,
  0x03, 0xFF, 0xE7, 0xE0, 0x7F, 0xFC, 0xFE, 0x0F, 0xFF, 0x8F, 0xC1, 0xFF,
  0xF1, 0xFC, 0x3F, 0xFE, 0x1F, 0x87, 0xFF, 0xC3, 0xF8, 0xFF, 0xF8, 0x3F,
  0x1F, 0xFF, 0x07, 0xF3, 0xFF, 0xE0, 0x7E, 0x7F, 0xFC, 0x0F, 0xEF, 0xFF,
  0x80, 0xFD, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xF0, 0xFF, 0x83, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x01,
  0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3,
  0xF0, 0x03, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0xFF, 0x83, 0xFC,
  0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7E,
  0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xC7, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC3, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x47,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xF0, 0x07, 0xF9, 0xF8, 0x01, 0xFC, 0xFC,
  0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xEF,
  0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0xFE,
  0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0x9F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x80,
  0xFE, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8,
  0x03, 0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFF, 0x3F, 0x00, 0x3F, 0x9F,
  0x80, 0x1F, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0x07,
  0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0,
  0x0F, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x80,
  0x1F, 0xDF, 0xE0, 0x0F, 0xE7, 0xF8, 0x1F, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x3F,
  0x9F, 0xC0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xF7, 0xF0,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07,
  0xF0, 0x7E, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8,
  0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F,
  0xC0, 0x1F, 0x9F, 0x80, 0x7F, 0x80, 0x7F, 0x3F, 0x00, 0xFF, 0x80, 0xFE,
  0x7F, 0x01, 0xFF, 0x01, 0xF8, 0xFE, 0x03, 0xFE, 0x03, 0xF0, 0xFC, 0x0F,
  0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0xF8, 0x3F,
  0x87, 0xE0, 0x7D, 0xF0, 0x7E, 0x0F, 0xE0, 0xFB, 0xE0, 0xFC, 0x1F, 0xC3,
  0xF7, 0xC1, 0xF8, 0x1F, 0x87, 0xEF, 0x83, 0xF0, 0x3F, 0x0F, 0x9F, 0x87,
  0xE0, 0x7E, 0x1F, 0x1F, 0x1F, 0xC0, 0xFC, 0x3E, 0x3E, 0x3F, 0x01, 0xF8,
  0xFC, 0x7C, 0x7E, 0x01, 0xF9, 0xF0, 0xF8, 0xFC, 0x03, 0xF3, 0xE1, 0xF9,
  0xF8, 0x07, 0xE7, 0xC1, 0xF3, 0xF0, 0x0F, 0xCF, 0x83, 0xEF, 0xC0, 0x1F,
  0xBF, 0x07, 0xDF, 0x80, 0x1F, 0x7C, 0x0F, 0xBF, 0x00, 0x3F, 0xF8, 0x1F,
  0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F,
  0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0xFE, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0x7F, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F,
  0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xC3, 0xFC,
  0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF9, 0xF8,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0x7C, 0x07, 0xDF, 0x01, 0xF3, 0xE0, 0x78, 0xF8, 0x3E,
  0x3E, 0x0F, 0x87, 0xC7, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0xBF, 0x03,
  0xEF, 0x80, 0xFB, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x20, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1,
  0xFC, 0x1F, 0xDF, 0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xE0, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFC, 0x1F, 0xBF, 0x80, 0xFD, 0xFC, 0x07,
  0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC,
  0x07, 0xF7, 0xF0, 0x7F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0x9F, 0xFD, 0xFC, 0x3F, 0xC7, 0xE0, 0x10, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x1F, 0xDF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF9, 0xFF, 0x07, 0xF3,
  0xFC, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF,
  0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xBF, 0x80,
  0x3F, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x07,
  0xF7, 0xF8, 0x0F, 0xEF, 0xF8, 0x3F, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0x7E, 0xFF, 0xF8, 0xFC, 0xFF, 0xE1, 0xF8, 0xFF, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xF8, 0x3F, 0x9F, 0xC0, 0x7E, 0x7E, 0x01,
  0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x03,
  0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7F, 0x01, 0xFC, 0xFE, 0x0F, 0xE3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x03, 0xFC, 0xFC, 0x3F, 0xFB, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFD, 0xFE, 0x0F, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x3F, 0x7E,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFD, 0xF8,
  0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0xC0, 0x7F, 0x7F, 0x83, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFE, 0x7C, 0x0F, 0xF1, 0xF0,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F,
  0x80, 0xFE, 0x7F, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x08,
  0x7F, 0x80, 0x30, 0x7F, 0x81, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0xFC, 0x3F, 0xFD, 0xF8, 0xFF, 0xFB,
  0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xF0, 0xFF, 0xBF, 0x80, 0x7F,
  0x7F, 0x00, 0xFE, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00,
  0xFE, 0x7F, 0x87, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE1, 0xFF, 0xDF, 0xC0, 0xFF, 0x3F, 0x80, 0x20, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x20, 0x03, 0xF0, 0x60, 0x0F, 0xE1, 0xF8, 0x7F, 0xC3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x08, 0x0F, 0xC7, 0xF8,
  0x7E, 0x7F, 0xE3, 0xF7, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFC,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0xCF, 0x00,
  0x00, 0x00, 0x03, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0x07, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x0F, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xEF, 0xF7, 0xFE, 0xFF,
  0xDF, 0xF3, 0xFC, 0x7E, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xDF, 0xC0, 0xFF, 0x3F, 0x81, 0xFC,
  0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0xFE, 0x07,
  0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xDF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xCF, 0xC0, 0x7F, 0x1F,
  0xC0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x87, 0xF0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC,
  0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x04, 0x00, 0x10, 0x0F, 0xC7, 0xF8, 0x1F, 0xF0, 0xFC,
  0xFF, 0xC3, 0xFF, 0x8F, 0xDF, 0xFE, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x87, 0xFE, 0x1F, 0xEF, 0xE0, 0x3F,
  0xC0, 0xFE, 0xFE, 0x03, 0xFC, 0x07, 0xEF, 0xE0, 0x1F, 0x80, 0x7E, 0xFE,
  0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE,
  0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE,
  0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x04,
  0x07, 0xE3, 0xFC, 0x3F, 0x3F, 0xF9, 0xFB, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x00, 0xFE, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x80, 0xFC, 0x3F,
  0xC1, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xF1,
  0xFE, 0x0F, 0xCF, 0xFE, 0x3F, 0x7F, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xEF, 0xF8, 0x7F, 0xBF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFB, 0xFF, 0x8F, 0xE7, 0xF8, 0x3F, 0x82, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF1, 0xF0, 0xFF, 0xE7,
  0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xF8, 0x3F, 0xDF,
  0xC0, 0x7F, 0x7F, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0xC0, 0x3F, 0x7F, 0x01,
  0xFD, 0xFE, 0x0F, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFB, 0xF0, 0x3F, 0xCF, 0xC0, 0x10, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF1, 0xFF, 0xCF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFC,
  0x1F, 0xCF, 0xC0, 0x7F, 0x7E, 0x03, 0xFB, 0xF0, 0x0F, 0xDF, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFB, 0xF8, 0x1F, 0xDF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x04, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x01, 0xFC,
  0x00, 0x80, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0x7F, 0x0F, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xDF, 0x87, 0xFC, 0xFC, 0x02, 0x00, 0x00,
  0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xE7,
  0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xF8, 0x3F,
  0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x00, 0xF8,
  0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xCF,
  0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0xFC, 0x07, 0xE7,
  0xE0, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xC0, 0x7E, 0x7E, 0x07, 0xF0, 0x1F,
  0x9F, 0x81, 0xFE, 0x0F, 0xE3, 0xF0, 0x7F, 0x83, 0xF0, 0xFC, 0x1F, 0xE0,
  0xFC, 0x3F, 0x0F, 0xF8, 0x3F, 0x0F, 0xC3, 0xFF, 0x0F, 0xC3, 0xF0, 0xFF,
  0xC3, 0xE0, 0x7E, 0x3F, 0xF1, 0xF8, 0x1F, 0x9F, 0x7C, 0x7E, 0x07, 0xE7,
  0xCF, 0x9F, 0x81, 0xF9, 0xF3, 0xE7, 0xE0, 0x3E, 0x7C, 0xF9, 0xF0, 0x0F,
  0xBE, 0x3E, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0,
  0x3F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7F,
  0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8,
  0x3F, 0x03, 0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xF7, 0xF0, 0x07, 0xEF,
  0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0xFD, 0xF8, 0x03, 0xFB, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0xC7, 0xF0, 0x7F,
  0x07, 0xF0, 0xFE, 0x0F, 0xE3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xDF, 0xC0,
  0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xDF, 0x80,
  0x7E, 0x7F, 0x01, 0xF9, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0xFC,
  0x3F, 0x83, 0xF0, 0x7E, 0x1F, 0xC1, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F,
  0xC7, 0xE0, 0x3F, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xEF,
  0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x18, 0x01, 0xE0, 0x0F, 0x80, 0x7F, 0x03, 0xF0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x80, 0xFF, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x78, 0x00,
  0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x60, 0x01, 0xE0, 0x07, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x0F,
  0xC0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x78, 0x01, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xFC, 0x01, 0xF1, 0xFF, 0x80, 0x7C, 0xFF, 0xF0,
  0x1F, 0x7F, 0xFE, 0x0F, 0xDF, 0xFF, 0xC3, 0xE7, 0xC3, 0xFF, 0xFB, 0xF0,
  0x7F, 0xFE, 0xF8, 0x0F, 0xFF, 0x3E, 0x01, 0xFF, 0x8F, 0x80, 0x3F, 0xC0,
  0x00, 0x03, 0xE0,
};

const GFXglyph RobotoCondensed_Medium56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 7, 41, 14, 4, -40 },
  { 37, 13, 14, 18, 3, -42 },
  { 60, 25, 40, 30, 3, -40 },
  { 185, 22, 53, 28, 3, -47 },
  { 331, 30, 42, 36, 3, -41 },
  { 489, 29, 42, 32, 2, -41 },
  { 642, 5, 14, 9, 2, -42 },
  { 651, 13, 58, 18, 3, -45 },
  { 746, 14, 58, 18, 1, -45 },
  { 848, 23, 24, 25, 1, -40 },
  { 917, 23, 29, 27, 2, -33 },
  { 1001, 9, 15, 12, 1, -6 },
  { 1018, 13, 5, 17, 2, -19 },
  { 1027, 7, 8, 16, 4, -7 },
  { 1034, 18, 43, 20, 0, -40 },
  { 1131, 22, 42, 28, 3, -41 },
  { 1247, 15, 40, 28, 4, -40 },
  { 1322, 24, 41, 28, 2, -41 },
  { 1445, 23, 42, 28, 2, -41 },
  { 1566, 24, 40, 28, 2, -40 },
  { 1686, 23, 41, 28, 3, -40 },
  { 1804, 23, 41, 28, 3, -40 },
  { 1922, 24, 40, 28, 2, -40 },
  { 2042, 22, 42, 28, 3, -41 },
  { 2158, 22, 41, 28, 3, -41 },
  { 2271, 7, 31, 14, 4, -30 },
  { 2299, 10, 39, 13, 1, -30 },
  { 2348, 19, 26, 25, 2, -30 },
  { 2410, 20, 17, 28, 4, -26 },
  { 2453, 19, 25, 26, 4, -30 },
  { 2513, 20, 42, 24, 2, -41 },
  { 2618, 38, 51, 43, 3, -39 },
  { 2861, 31, 40, 33, 1, -40 },
  { 3016, 24, 40, 31, 4, -40 },
  { 3136, 27, 42, 32, 3, -41 },
  { 3278, 25, 40, 32, 4, -40 },
  { 3403, 22, 40, 28, 4, -40 },
  { 3513, 21, 40, 27, 4, -40 },
  { 3618, 27, 42, 33, 3, -41 },
  { 3760, 27, 40, 35, 4, -40 },
  { 3895, 7, 40, 15, 4, -40 },
  { 3930, 23, 41, 27, 1, -40 },
  { 4048, 27, 40, 31, 4, -40 },
  { 4183, 21, 40, 27, 4, -40 },
  { 4288, 35, 40, 42, 4, -40 },
  { 4463, 27, 40, 34, 4, -40 },
  { 4598, 28, 42, 34, 3, -41 },
  { 4745, 25, 40, 31, 4, -40 },
  { 4870, 28, 48, 34, 3, -41 },
  { 5038, 25, 40, 30, 4, -40 },
  { 5163, 25, 42, 30, 2, -41 },
  { 5295, 26, 40, 30, 2, -40 },
  { 5425, 26, 41, 32, 3, -40 },
  { 5559, 30, 40, 32, 1, -40 },
  { 5709, 39, 40, 42, 2, -40 },
  { 5904, 29, 40, 31, 1, -40 },
  { 6049, 28, 40, 30, 1, -40 },
  { 6189, 25, 40, 30, 2, -40 },
  { 6314, 10, 55, 14, 3, -46 },
  { 6383, 20, 43, 21, 1, -40 },
  { 6491, 10, 55, 14, 1, -46 },
  { 6560, 18, 20, 21, 2, -40 },
  { 6605, 21, 5, 23, 1, 0 },
  { 6619, 13, 8, 18, 1, -42 },
  { 6632, 21, 32, 27, 3, -31 },
  { 6716, 23, 43, 28, 3, -42 },
  { 6840, 22, 32, 26, 2, -31 },
  { 6928, 22, 43, 28, 2, -42 },
  { 7047, 23, 32, 27, 2, -31 },
  { 7139, 16, 43, 18, 1, -43 },
  { 7225, 23, 42, 28, 2, -31 },
  { 7346, 21, 42, 27, 3, -42 },
  { 7457, 7, 41, 14, 3, -41 },
  { 7493, 11, 52, 13, -1, -41 },
  { 7565, 23, 42, 26, 3, -42 },
  { 7686, 6, 42, 14, 4, -42 },
  { 7718, 36, 31, 42, 3, -31 },
  { 7858, 21, 31, 27, 3, -31 },
  { 7940, 24, 32, 28, 2, -31 },
  { 8036, 22, 42, 28, 3, -31 },
  { 8152, 22, 42, 28, 2, -31 },
  { 8268, 14, 31, 18, 3, -31 },
  { 8323, 21, 32, 25, 2, -31 },
  { 8407, 14, 38, 17, 1, -37 },
  { 8474, 21, 31, 27, 3, -30 },
  { 8556, 23, 30, 25, 1, -30 },
  { 8643, 34, 30, 36, 1, -30 },
  { 8771, 23, 30, 25, 1, -30 },
  { 8858, 22, 41, 24, 1, -30 },
  { 8971, 21, 30, 25, 2, -30 },
  { 9050, 14, 54, 17, 2, -44 },
  { 9145, 4, 47, 14, 5, -40 },
  { 9169, 14, 54, 17, 1, -44 },
  { 9264, 26, 12, 32, 3, -23 },
};

const GFXfont RobotoCondensed_Medium56pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium56pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium56pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOCONDENSED_MEDIUM56PT7B_H_
