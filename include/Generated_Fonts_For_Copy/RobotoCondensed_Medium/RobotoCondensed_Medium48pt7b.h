#ifndef _ROBOTOCONDENSED_MEDIUM48PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x00, 0x00, 0x00, 0x79, 0xFF,
  0xFF, 0x7D, 0xE0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xF0, 0x00, 0x70, 0xF0, 0x03,
  0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xF1, 0xE0, 0x03, 0x87,
  0x80, 0x0E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x07, 0x0F, 0x00, 0x3C,
  0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0x1E, 0x00, 0x38, 0x78,
  0x00, 0xE1, 0xE0, 0x07, 0x87, 0x83, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x1C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xF1, 0xE0, 0x03, 0x87, 0x80,
  0x0E, 0x1E, 0x00, 0x78, 0x78, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0x0F, 0xE3, 0xE0, 0x7E,
  0x3E, 0x03, 0xE7, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7,
  0xC0, 0x3F, 0x7E, 0x03, 0xE7, 0xF0, 0x7E, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x78, 0xF0, 0x30, 0x3C, 0x1E,
  0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE1, 0xC0, 0xF0, 0x78, 0xF0, 0x3C,
  0x1E, 0x38, 0x07, 0x07, 0x9E, 0x01, 0xE3, 0xC7, 0x00, 0x7D, 0xF3, 0xC0,
  0x0F, 0xFC, 0xE0, 0x01, 0xFE, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC3, 0xE0, 0x00, 0xF3, 0xFC, 0x00,
  0x39, 0xFF, 0x80, 0x1E, 0x7D, 0xF0, 0x07, 0x3C, 0x3C, 0x03, 0xCF, 0x0F,
  0x00, 0xE3, 0xC1, 0xC0, 0x78, 0xF0, 0x70, 0x3C, 0x3C, 0x1C, 0x0F, 0x0F,
  0x07, 0x07, 0x83, 0xC3, 0xC1, 0xC0, 0xF0, 0xF0, 0x10, 0x1F, 0x7C, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x1F, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x3F, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0xBF, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x3F, 0xFC, 0x3C, 0x7E, 0x7E, 0x3C,
  0x7C, 0x7F, 0x7C, 0xFC, 0x3F, 0x7C, 0xFC, 0x1F, 0xFC, 0xFC, 0x1F, 0xF8,
  0xFC, 0x0F, 0xF8, 0xFC, 0x07, 0xF8, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFE, 0x7E,
  0x03, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x18,
  0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0,
  0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07,
  0xC0, 0x78, 0x06, 0x00, 0x40, 0x40, 0x06, 0x00, 0x70, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07,
  0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x7C,
  0x07, 0x80, 0x70, 0x06, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x04, 0x0F, 0x02, 0xF0, 0xF0,
  0xEF, 0xEF, 0x7E, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x7B, 0xC0, 0x0F, 0xBE, 0x00, 0xF1, 0xF0, 0x1E,
  0x0F, 0x03, 0xE0, 0xF8, 0x1C, 0x07, 0x00, 0x40, 0x20, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x7C, 0xFB, 0xE7, 0x82, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7D, 0xFB, 0xFF, 0xF7, 0xC7, 0x00, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC3, 0xF0, 0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0x7C, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7C, 0x3F, 0x0F,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x1F,
  0x80, 0x00, 0x30, 0x0F, 0x07, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xC1, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xE0, 0xFE, 0x7C, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F, 0xBF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xF7,
  0xE0, 0xFE, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x79, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x7C,
  0x03, 0xE3, 0xE0, 0x1E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xCF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF,
  0xCF, 0x81, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xE7, 0xE0, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x7E, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFE, 0x0F, 0xDF, 0x81, 0xFB,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0x3F, 0x07, 0xE7,
  0xE0, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7F, 0xFF, 0x9F, 0x87, 0xEF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x7C, 0x0F, 0x9F, 0x87, 0xE3, 0xFF,
  0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xF8, 0x7E,
  0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0xFF, 0xE7, 0xFF,
  0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7E, 0x1F, 0x9F, 0x83,
  0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x7E, 0x07,
  0xEF, 0xC1, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xF7,
  0xC0, 0xF9, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xC0,
  0x0F, 0xF0, 0x01, 0xF0, 0x00, 0x7D, 0xFB, 0xFF, 0xF7, 0xCF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xDF,
  0xBF, 0xFF, 0x7C, 0xF0, 0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C,
  0x78, 0x30, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFF,
  0x03, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00,
  0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0x00,
  0x0E, 0x00, 0x04, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0x87, 0xF7, 0xE0, 0xFD, 0xF0, 0x3F, 0xFC,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x7E, 0x03, 0x87, 0x80, 0x7F, 0xC1, 0xE3,
  0xC0, 0x7F, 0xF0, 0xF1, 0xE0, 0x7F, 0xF8, 0x39, 0xE0, 0x7C, 0x3C, 0x1C,
  0xF0, 0x3C, 0x1E, 0x0E, 0x78, 0x3C, 0x0E, 0x07, 0xBC, 0x1E, 0x0F, 0x03,
  0xDC, 0x0F, 0x07, 0x81, 0xFE, 0x0F, 0x83, 0xC0, 0xFF, 0x07, 0x81, 0xE0,
  0x7F, 0x83, 0xC0, 0xF0, 0x3F, 0xC1, 0xE0, 0x78, 0x1F, 0xE0, 0xF0, 0x3C,
  0x0E, 0xF0, 0x78, 0x1E, 0x07, 0x78, 0x3C, 0x0F, 0x07, 0xBC, 0x1E, 0x0F,
  0x83, 0xDE, 0x0F, 0x87, 0xC1, 0xC7, 0x07, 0xC7, 0xE1, 0xE3, 0xC1, 0xFF,
  0xF9, 0xE1, 0xE0, 0xFF, 0xBF, 0xF0, 0xF0, 0x3F, 0x9F, 0xF0, 0x78, 0x0F,
  0x03, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x0C, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x1F,
  0x00, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xC0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0x87, 0xE0,
  0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xF8, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7E, 0x03, 0xFB, 0xF0,
  0x0F, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7D,
  0xF8, 0x03, 0xEF, 0xC0, 0x3F, 0x7E, 0x03, 0xFB, 0xF0, 0x3F, 0x9F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xF8, 0x0F, 0xEF,
  0xC0, 0x3F, 0x7E, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x0F, 0xE0, 0x7F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7E,
  0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xEF,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xFC, 0x00,
  0x7D, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF3, 0xF0, 0x0F, 0xC7, 0xF0, 0x3F,
  0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xF0, 0x3F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00,
  0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3E, 0xFC, 0x01, 0xFB,
  0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0xFC, 0xFC, 0x0F, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xE0, 0x7F,
  0x1F, 0x80, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFB,
  0xE0, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF8, 0x01,
  0xFB, 0xF0, 0x03, 0xF7, 0xF8, 0x0F, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xBF, 0x03, 0xF7, 0xF0, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0xFF, 0xF8, 0x03, 0xFB, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x7F,
  0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0x81,
  0xF8, 0x7E, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F,
  0xBF, 0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xF7, 0xF0, 0x1F, 0xC7,
  0xE0, 0x3F, 0x8F, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F,
  0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7F,
  0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFC,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xBE,
  0x00, 0xFF, 0xFE, 0xF8, 0x07, 0xDF, 0xFB, 0xE0, 0x1F, 0x7F, 0xEF, 0xC0,
  0x7D, 0xFF, 0x9F, 0x01, 0xE7, 0xFF, 0x7C, 0x0F, 0x9F, 0xFD, 0xF0, 0x3E,
  0x7F, 0xF3, 0xE0, 0xF1, 0xFF, 0xCF, 0x87, 0xC7, 0xFF, 0x3E, 0x1F, 0x1F,
  0xFC, 0x7C, 0x78, 0x7F, 0xF1, 0xF3, 0xE1, 0xFF, 0xC7, 0xCF, 0x87, 0xFF,
  0x0F, 0xBE, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0x07, 0xFF, 0x07, 0xF8, 0x1F, 0xFC, 0x1F, 0xE0, 0x7F, 0xF0, 0x3F,
  0x81, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0x03, 0xF0, 0x1F, 0xFC, 0x07, 0xC0,
  0x7F, 0xF0, 0x1E, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x81, 0xFF, 0xDF, 0x03, 0xFF, 0xBF, 0x07, 0xFF, 0x3E, 0x0F,
  0xFE, 0x7E, 0x1F, 0xFC, 0x7C, 0x3F, 0xF8, 0xFC, 0x7F, 0xF0, 0xF8, 0xFF,
  0xE1, 0xF9, 0xFF, 0xC1, 0xF3, 0xFF, 0x83, 0xF7, 0xFF, 0x03, 0xEF, 0xFE,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F,
  0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF8, 0x03,
  0xF3, 0xF0, 0x07, 0xE7, 0xF8, 0x3F, 0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xF0,
  0x0F, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFE,
  0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0x9F, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7,
  0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F,
  0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x01,
  0xF7, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF8,
  0x1F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x01,
  0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB,
  0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x3F, 0x01, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x8F,
  0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0,
  0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1,
  0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7C, 0x00, 0xF9, 0xF0,
  0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0x9F, 0x80, 0x7E, 0x7F, 0x03, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x1F,
  0xBF, 0x00, 0x7E, 0x7E, 0x03, 0xF9, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xEF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00,
  0x7E, 0x07, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x03, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x07, 0xE0,
  0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x8F,
  0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x07,
  0xDF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x01, 0xF0, 0x0F, 0xDF, 0x00, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x00, 0xFD,
  0xF8, 0x0F, 0xC0, 0x3E, 0x7E, 0x03, 0xF8, 0x0F, 0x9F, 0x80, 0xFE, 0x03,
  0xE3, 0xE0, 0x3F, 0x81, 0xF8, 0xF8, 0x1F, 0xE0, 0x7E, 0x3E, 0x07, 0xF8,
  0x1F, 0x8F, 0xC1, 0xFF, 0x07, 0xC3, 0xF0, 0x7F, 0xC1, 0xF0, 0x7C, 0x1F,
  0xF0, 0x7C, 0x1F, 0x0F, 0xBC, 0x3F, 0x07, 0xC3, 0xEF, 0x0F, 0xC1, 0xF0,
  0xF3, 0xE3, 0xE0, 0x7E, 0x3C, 0xF8, 0xF8, 0x1F, 0x8F, 0x1E, 0x3E, 0x03,
  0xE7, 0xC7, 0x8F, 0x80, 0xF9, 0xF1, 0xE7, 0xE0, 0x3E, 0x78, 0x7D, 0xF0,
  0x0F, 0x9E, 0x1F, 0x7C, 0x03, 0xFF, 0x83, 0xDF, 0x00, 0x7F, 0xE0, 0xF7,
  0xC0, 0x1F, 0xF8, 0x3D, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xF8,
  0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F,
  0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0x87, 0xF0, 0x1F,
  0xC1, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x7E,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xDF, 0x80,
  0x07, 0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x03, 0xF0, 0x7E,
  0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xE0, 0xFC, 0x03,
  0xF8, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x07,
  0xC7, 0xE0, 0x07, 0xE7, 0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E,
  0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0,
  0xFC, 0x0F, 0x80, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC7, 0xFB, 0xF8, 0xFC, 0x1F, 0x9F, 0x03, 0xF3, 0xE0, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x80, 0xFB, 0xF0,
  0x1F, 0x7E, 0x07, 0xEF, 0xC1, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1, 0xFF,
  0xBE, 0x1F, 0xF7, 0xC0, 0xF8, 0xFC, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE3, 0xF0, 0x7D, 0xFF, 0x0F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xF0, 0x7E, 0xFC, 0x07, 0xDF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xBF, 0x83, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0x9F, 0xFF, 0xE3, 0xEF, 0xF8, 0x7C, 0x7E, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x1F, 0x9F, 0x01,
  0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0xFF, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xE0, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x9F,
  0x8F, 0xFB, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xDF, 0x83, 0xFB,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0x7C, 0x3F, 0xCF, 0x83, 0xF1, 0xF0,
  0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0xFC, 0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x47,
  0xF0, 0x3C, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF,
  0xFB, 0xFF, 0xE1, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE3, 0xE1, 0xFF, 0x7C, 0x7F, 0xFF,
  0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFC, 0x0F, 0xDF, 0x01, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xBE, 0x03, 0xF7, 0xE0, 0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x0F, 0xFB, 0xE0, 0xFC, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x20, 0x0F, 0xC6, 0x03, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x87,
  0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x8F, 0xC3, 0xEF, 0xF8, 0xFF, 0xFF,
  0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xF8, 0x7E, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0x7B, 0xFF, 0xFF, 0xF9, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x03, 0xE0, 0xFC, 0x3F,
  0x0F, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0xBF, 0xEF,
  0xFB, 0xFC, 0xFE, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x7F, 0x7C, 0x0F, 0xCF, 0x83, 0xF9,
  0xF0, 0x7E, 0x3E, 0x1F, 0x87, 0xC7, 0xE0, 0xF8, 0xFC, 0x1F, 0x3F, 0x03,
  0xEF, 0xC0, 0x7D, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xF3, 0xF0, 0x7C, 0x3E, 0x0F,
  0x87, 0xE1, 0xF0, 0x7E, 0x3E, 0x0F, 0xC7, 0xC0, 0xFC, 0xF8, 0x1F, 0x9F,
  0x01, 0xFB, 0xE0, 0x3F, 0x7C, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC,
  0x0F, 0xC3, 0xEF, 0xF8, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xF0, 0x7F, 0x83, 0xFF, 0xC0, 0xFC, 0x0F,
  0xFE, 0x03, 0xF0, 0x3F, 0xF8, 0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0x01, 0xFF,
  0x80, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0x1F, 0xF8, 0x0F, 0xC0, 0x7F, 0xE0,
  0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0x1F, 0xF8, 0x0F,
  0xC0, 0x7F, 0xE0, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x07, 0xFE, 0x03, 0xF0,
  0x1F, 0xF8, 0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x07,
  0xFE, 0x03, 0xF0, 0x1F, 0xF8, 0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0x01, 0xF0,
  0xF8, 0xFC, 0x3E, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0x87, 0xEF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7,
  0xF0, 0xFE, 0x7E, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xE7, 0xE0,
  0x7E, 0x7E, 0x07, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07,
  0xFE, 0x00, 0x1F, 0x80, 0xF8, 0xFC, 0x1F, 0x7F, 0xC3, 0xFF, 0xFC, 0x7F,
  0xFF, 0xCF, 0xFF, 0xFD, 0xF8, 0x1F, 0xBE, 0x03, 0xF7, 0xC0, 0x3E, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0x7C, 0x07, 0xEF, 0xC0, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF,
  0xF8, 0xFB, 0xFE, 0x1F, 0x1F, 0x83, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE3, 0xE3, 0xFF, 0x7C, 0xFF,
  0xEF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xBE, 0x03, 0xF7, 0xE0, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFC, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0xF9, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x03, 0xFF,
  0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0x3F, 0x9F, 0x03, 0xE7, 0xC0, 0xFD,
  0xF0, 0x3F, 0x7C, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xDF, 0xCF, 0xE7, 0xFF, 0xF8,
  0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x81,
  0xFF, 0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF,
  0xFF, 0x3F, 0xE7, 0xC3, 0xF1, 0xF0, 0xFC, 0x07, 0xFF, 0x80, 0xFD, 0xF0,
  0x1F, 0x3E, 0x03, 0xE7, 0xE0, 0x7C, 0xFC, 0x1F, 0x8F, 0x83, 0xE1, 0xF0,
  0x7C, 0x3E, 0x0F, 0x87, 0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1,
  0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x00, 0xF7,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x0F, 0x81, 0xFF,
  0xE0, 0x7C, 0x0F, 0x9F, 0x03, 0xE0, 0x7C, 0xF8, 0x3F, 0x03, 0xE7, 0xC1,
  0xF8, 0x1F, 0x3E, 0x0F, 0xE1, 0xF9, 0xF8, 0x7F, 0x0F, 0x87, 0xC7, 0xF8,
  0x7C, 0x3E, 0x3F, 0xC3, 0xE1, 0xF1, 0xFF, 0x1F, 0x0F, 0x8F, 0x78, 0xF0,
  0x3C, 0x7B, 0xCF, 0x81, 0xF7, 0xDE, 0x7C, 0x0F, 0xBC, 0xFB, 0xE0, 0x7D,
  0xE3, 0xDF, 0x03, 0xEF, 0x1E, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0x87,
  0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0,
  0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07,
  0xE0, 0x3E, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xEF, 0xC0, 0xF9,
  0xF8, 0x3F, 0x1F, 0x87, 0xC3, 0xF1, 0xF8, 0x3F, 0x3E, 0x03, 0xEF, 0xC0,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x3E, 0xFC, 0x0F, 0xDF, 0x81, 0xF9, 0xF8, 0x7E, 0x3F, 0x0F,
  0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x07, 0xFF, 0x80, 0xFC, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0x3E, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F,
  0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x87, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xF3, 0xF0, 0x3F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x20,
  0x0F, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x81, 0xF0, 0x3F, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFE, 0x03,
  0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x60, 0x07, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xE0, 0x7F,
  0x03, 0xF0, 0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0xFC, 0x0F, 0x80, 0x70, 0x06, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0x00, 0xF7, 0xFE, 0x03, 0xDF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x7B, 0xE3, 0xFF, 0xEF, 0x07, 0xFF, 0xBC, 0x0F, 0xFC, 0xF0, 0x1F,
  0xE0, 0x00, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_Medium48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 34, 12, 3, -34 },
  { 27, 11, 12, 15, 2, -36 },
  { 44, 22, 34, 26, 2, -34 },
  { 138, 20, 43, 24, 2, -39 },
  { 246, 26, 34, 31, 2, -34 },
  { 357, 24, 34, 27, 2, -34 },
  { 459, 4, 12, 8, 2, -36 },
  { 465, 11, 49, 15, 3, -38 },
  { 533, 12, 49, 15, 1, -38 },
  { 607, 20, 20, 21, 1, -34 },
  { 657, 19, 25, 23, 2, -29 },
  { 717, 7, 13, 11, 1, -5 },
  { 729, 11, 5, 15, 2, -17 },
  { 736, 7, 6, 13, 3, -6 },
  { 742, 16, 37, 17, 0, -34 },
  { 816, 20, 34, 24, 2, -34 },
  { 901, 12, 34, 24, 4, -34 },
  { 952, 20, 34, 24, 2, -34 },
  { 1037, 19, 34, 24, 2, -34 },
  { 1118, 21, 34, 24, 1, -34 },
  { 1208, 19, 34, 24, 3, -34 },
  { 1289, 19, 34, 24, 3, -34 },
  { 1370, 20, 34, 24, 2, -34 },
  { 1455, 18, 34, 24, 3, -34 },
  { 1532, 19, 34, 24, 2, -34 },
  { 1613, 7, 26, 12, 3, -26 },
  { 1636, 8, 34, 11, 1, -26 },
  { 1670, 16, 22, 21, 2, -26 },
  { 1714, 17, 15, 24, 3, -23 },
  { 1746, 17, 22, 22, 3, -26 },
  { 1793, 18, 34, 21, 1, -34 },
  { 1870, 33, 44, 37, 2, -33 },
  { 2052, 27, 34, 28, 1, -34 },
  { 2167, 21, 34, 27, 3, -34 },
  { 2257, 23, 34, 27, 3, -34 },
  { 2355, 22, 34, 27, 3, -34 },
  { 2449, 19, 34, 24, 3, -34 },
  { 2530, 19, 34, 23, 3, -34 },
  { 2611, 23, 34, 28, 3, -34 },
  { 2709, 23, 34, 30, 3, -34 },
  { 2807, 6, 34, 13, 3, -34 },
  { 2833, 19, 34, 23, 1, -34 },
  { 2914, 23, 34, 26, 3, -34 },
  { 3012, 19, 34, 23, 3, -34 },
  { 3093, 30, 34, 36, 3, -34 },
  { 3221, 23, 34, 30, 3, -34 },
  { 3319, 23, 34, 29, 3, -34 },
  { 3417, 22, 34, 27, 3, -34 },
  { 3511, 25, 40, 29, 2, -34 },
  { 3636, 22, 34, 26, 3, -34 },
  { 3730, 22, 34, 25, 2, -34 },
  { 3824, 23, 34, 26, 1, -34 },
  { 3922, 22, 34, 27, 3, -34 },
  { 4016, 26, 34, 27, 1, -34 },
  { 4127, 34, 34, 36, 1, -34 },
  { 4272, 25, 34, 27, 1, -34 },
  { 4379, 24, 34, 26, 1, -34 },
  { 4481, 22, 34, 25, 2, -34 },
  { 4575, 8, 47, 12, 3, -39 },
  { 4622, 17, 37, 18, 1, -34 },
  { 4701, 8, 47, 12, 1, -39 },
  { 4748, 16, 17, 18, 1, -34 },
  { 4782, 18, 5, 19, 1, 0 },
  { 4794, 11, 7, 15, 1, -36 },
  { 4804, 19, 26, 23, 2, -26 },
  { 4866, 19, 36, 24, 3, -36 },
  { 4952, 19, 26, 22, 2, -26 },
  { 5014, 19, 36, 24, 2, -36 },
  { 5100, 19, 26, 23, 2, -26 },
  { 5162, 14, 36, 15, 1, -36 },
  { 5225, 19, 36, 24, 2, -26 },
  { 5311, 18, 36, 23, 3, -36 },
  { 5392, 6, 36, 12, 3, -36 },
  { 5419, 10, 46, 11, -1, -36 },
  { 5477, 19, 36, 22, 3, -36 },
  { 5563, 6, 36, 12, 3, -36 },
  { 5590, 30, 26, 36, 3, -26 },
  { 5688, 18, 26, 23, 3, -26 },
  { 5747, 20, 26, 24, 2, -26 },
  { 5812, 19, 36, 24, 3, -26 },
  { 5898, 19, 36, 24, 2, -26 },
  { 5984, 11, 26, 15, 3, -26 },
  { 6020, 18, 26, 22, 2, -26 },
  { 6079, 12, 32, 14, 1, -32 },
  { 6127, 18, 26, 23, 3, -26 },
  { 6186, 19, 26, 21, 1, -26 },
  { 6248, 29, 26, 31, 1, -26 },
  { 6343, 19, 26, 21, 1, -26 },
  { 6405, 19, 36, 21, 1, -26 },
  { 6491, 18, 26, 21, 2, -26 },
  { 6550, 12, 46, 15, 1, -37 },
  { 6619, 4, 40, 12, 4, -34 },
  { 6639, 12, 46, 15, 1, -37 },
  { 6708, 22, 10, 27, 3, -19 },
};

const GFXfont RobotoCondensed_Medium48pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium48pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium48pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _ROBOTOCONDENSED_MEDIUM48PT7B_H_
