#ifndef _ROBOTOCONDENSED_MEDIUM34PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium34pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x70,
  0x00, 0x07, 0x7B, 0xCE, 0xE7, 0xCF, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6,
  0x07, 0x18, 0x0E, 0x30, 0x1C, 0xE0, 0x39, 0xC0, 0x63, 0x80, 0xC7, 0x1F,
  0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x1C, 0xE0, 0x31, 0xC0, 0x63, 0x80, 0xC7,
  0x03, 0x8C, 0x07, 0x18, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x63, 0x81,
  0xC6, 0x03, 0x8C, 0x07, 0x18, 0x0E, 0x70, 0x18, 0xE0, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0xF8, 0x1F, 0xF0, 0xFF, 0xCF, 0xBE, 0x78, 0x7B,
  0x83, 0xFC, 0x1E, 0xE0, 0xF7, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0x7D, 0xFB, 0xFF, 0x8F, 0xF8, 0x1F, 0x80, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0x8C, 0x30, 0xC3, 0x0C, 0x30,
  0xC7, 0x0C, 0x31, 0x83, 0x8C, 0xE0, 0xFF, 0x30, 0x1F, 0x9C, 0x03, 0xCE,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x63, 0xC0, 0x3B, 0xF8, 0x0C, 0xEF,
  0x07, 0x71, 0xC1, 0x9C, 0x70, 0xE7, 0x1C, 0x31, 0xC7, 0x1C, 0x71, 0xC2,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xF8, 0x01, 0xFF,
  0x00, 0xF9, 0xE0, 0x3C, 0x78, 0x0F, 0x0E, 0x03, 0xC7, 0x80, 0xF1, 0xC0,
  0x1E, 0xF0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xC7, 0x0F,
  0xF1, 0xC7, 0x9E, 0x71, 0xE7, 0xDC, 0xF0, 0xFF, 0x3C, 0x1F, 0xC7, 0x07,
  0xE1, 0xE0, 0xF8, 0x7C, 0x7E, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0x1E,
  0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x07, 0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x38,
  0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x38, 0x38, 0x1C, 0x1C, 0x0E,
  0x07, 0x07, 0x02, 0x80, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1C,
  0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0,
  0xC0, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x07, 0x38, 0xCF,
  0xFF, 0x9F, 0xFF, 0x87, 0xF0, 0x07, 0xC0, 0x1D, 0xC0, 0x7B, 0x80, 0xE3,
  0x83, 0x83, 0x81, 0x04, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x7B, 0xDE, 0xF7, 0xBB, 0xDC, 0x40, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE,
  0xE0, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x1C,
  0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF9, 0xEF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xF0, 0xF7, 0x9F, 0x3F,
  0xF8, 0xFF, 0x81, 0xF0, 0x01, 0x0F, 0x3F, 0xFF, 0xFF, 0xEF, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE7, 0xC7,
  0x87, 0xCF, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF,
  0xFF, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x3E, 0x78, 0x7D, 0xE0, 0xF7,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x7F, 0x01, 0xF8, 0x07, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xC0, 0xFF, 0x03, 0xDE, 0x0F,
  0x7C, 0xF8, 0xFF, 0xE1, 0xFF, 0x03, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xDE, 0x03, 0xBC, 0x0E, 0x78,
  0x1C, 0xF0, 0x71, 0xE0, 0xE3, 0xC3, 0xC7, 0x87, 0x0F, 0x1E, 0x1E, 0x38,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x3F, 0xF8, 0xFF, 0xE7, 0xFF, 0x9E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x77, 0xC1, 0xFF, 0x87, 0xFF, 0x1E,
  0x3E, 0x10, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3F, 0xC0, 0xEF,
  0x07, 0xBC, 0x1E, 0x7C, 0xF9, 0xFF, 0xC3, 0xFE, 0x03, 0xE0, 0x01, 0xE0,
  0x1F, 0x81, 0xFE, 0x0F, 0xE0, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xF3, 0xC3, 0xFF, 0x8F, 0xFF, 0x3F, 0x3E, 0xF0, 0x7B, 0xC1, 0xEF, 0x03,
  0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xEF, 0x07, 0x9E, 0x1E, 0x7C, 0xF8, 0xFF,
  0xC1, 0xFE, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFB, 0xEF, 0x8F, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0x70, 0xF3, 0xEF, 0x8F, 0xF8, 0x3F, 0x83, 0xFE, 0x3C, 0x7B,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0xDF, 0xBF,
  0xF8, 0xFF, 0x81, 0xF0, 0x0F, 0x81, 0xFE, 0x1F, 0xF8, 0xFB, 0xEF, 0x0F,
  0x78, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x9F, 0xBF, 0xFC, 0xFF, 0xE3, 0xCF, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0xFE, 0x0F, 0xE0, 0x7E, 0x03, 0xC0, 0x7F, 0xFE, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFB, 0x80, 0x79, 0xF7, 0x8E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x38, 0xE7, 0x9E, 0x73, 0x86,
  0x00, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7F, 0x1F, 0xE7, 0xF0, 0xFC, 0x0F,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xF0, 0x07, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0x03, 0xF0, 0xFE, 0x3F, 0x8F, 0xE0, 0xF8,
  0x0E, 0x00, 0x80, 0x00, 0x0F, 0x83, 0xFE, 0x7F, 0xFF, 0xDF, 0xF0, 0xFF,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xBF,
  0x80, 0x78, 0x07, 0x01, 0xC0, 0x07, 0x07, 0x80, 0x07, 0x0E, 0x00, 0x06,
  0x38, 0x1E, 0x0E, 0x70, 0x7F, 0x1C, 0xC1, 0xFE, 0x1B, 0x87, 0x1C, 0x37,
  0x0E, 0x38, 0x6E, 0x38, 0x70, 0xFC, 0x70, 0xE1, 0xF0, 0xE1, 0xC3, 0xE1,
  0xC3, 0x87, 0xC3, 0x87, 0x0D, 0x87, 0x0E, 0x1B, 0x0E, 0x1C, 0x36, 0x1C,
  0x78, 0xEE, 0x38, 0xF1, 0x9C, 0x7F, 0xE7, 0x38, 0x7C, 0xFC, 0x70, 0x70,
  0xF0, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1C, 0xE0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x38, 0x70, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xC0, 0xE0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0xBC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7,
  0x87, 0xEF, 0x03, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3D, 0xE0,
  0xFB, 0xFF, 0xE7, 0xFF, 0x8F, 0xFF, 0xDE, 0x07, 0xBC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x0F, 0xDF, 0xFF, 0xBF,
  0xFE, 0x7F, 0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x7E, 0x78,
  0x1E, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x7E, 0x7E, 0x3F, 0xFC, 0x1F,
  0xF8, 0x07, 0xE0, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x8F, 0xEF, 0x03,
  0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x81, 0xEF, 0x1F, 0xDF, 0xFF, 0x3F, 0xFC, 0x7F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0x3F, 0xFC, 0xFF, 0xF3, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0xF0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7F, 0x7E, 0x78, 0x1E, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0x78,
  0x0F, 0x7F, 0x3F, 0x3F, 0xFF, 0x1F, 0xFC, 0x07, 0xF0, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0xDF, 0xBF, 0xF8,
  0xFF, 0x81, 0xF0, 0xF0, 0x1F, 0x78, 0x1F, 0x3C, 0x0F, 0x9E, 0x0F, 0x8F,
  0x07, 0x87, 0x87, 0xC3, 0xC7, 0xC1, 0xE3, 0xC0, 0xF3, 0xC0, 0x7B, 0xE0,
  0x3D, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xF7, 0x81, 0xF3,
  0xE0, 0xF0, 0xF0, 0x78, 0x7C, 0x3C, 0x1F, 0x1E, 0x0F, 0x8F, 0x03, 0xE7,
  0x80, 0xF3, 0xC0, 0x7D, 0xE0, 0x1E, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xBF, 0xB8, 0x3D, 0xFD,
  0xE1, 0xEF, 0xEF, 0x0E, 0x7F, 0x38, 0x73, 0xF9, 0xE7, 0x9F, 0xCF, 0x38,
  0xFE, 0x39, 0xC7, 0xF1, 0xDE, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1,
  0xF8, 0x7F, 0x0F, 0x83, 0xF8, 0x3C, 0x1F, 0xC1, 0xE0, 0xFE, 0x0F, 0x07,
  0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xF7, 0x87, 0xFB, 0xC3, 0xFC, 0xF1, 0xFE,
  0x78, 0xFF, 0x1E, 0x7F, 0x8F, 0x3F, 0xC3, 0xDF, 0xE1, 0xEF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xE0, 0x1F, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xEF, 0xC7,
  0x81, 0xF7, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x0F, 0x78, 0x07, 0xBE, 0x03, 0xCF, 0x03, 0xE7, 0xF7, 0xE1,
  0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xF0, 0x7E, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x0F, 0xFF, 0xC7, 0x81, 0xF7, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0x78, 0x07, 0xBE, 0x03, 0xCF, 0x03,
  0xE7, 0xF7, 0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xC0, 0x00, 0x40, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xF0, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7E, 0x7E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x7E, 0x7E,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xF7, 0xEF, 0xEF, 0xFF, 0x8F,
  0xFE, 0x07, 0xF0, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x80, 0x79, 0xE0, 0x1E,
  0x78, 0x0F, 0x9E, 0x03, 0xC7, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1E, 0x0F,
  0x07, 0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x03, 0x8F, 0x00, 0xF3,
  0xC0, 0x3D, 0xE0, 0x0F, 0x78, 0x01, 0xDE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x7E, 0x1E,
  0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1C, 0x38, 0xFE, 0x3C,
  0x3C, 0xFF, 0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C,
  0x1D, 0xE7, 0x38, 0x1D, 0xC7, 0xB8, 0x1D, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xE0, 0xF8, 0x0F, 0xBC,
  0x07, 0x9F, 0x07, 0xC7, 0x83, 0xC3, 0xE3, 0xE0, 0xF1, 0xE0, 0x7D, 0xF0,
  0x1E, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0x3E, 0x07,
  0x8F, 0x07, 0xC7, 0xC3, 0xC1, 0xE3, 0xE0, 0xF9, 0xE0, 0x3D, 0xF0, 0x1F,
  0x78, 0x07, 0xDE, 0x01, 0xE7, 0xC0, 0xF8, 0xF0, 0x3C, 0x3E, 0x0F, 0x07,
  0x87, 0x81, 0xE1, 0xE0, 0x3C, 0x70, 0x0F, 0x3C, 0x01, 0xCF, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xFC, 0x70, 0x03, 0xC0, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xFF, 0xFF, 0xFC, 0x0E, 0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xB0, 0x77, 0x0E,
  0xE1, 0xDC, 0x71, 0xCE, 0x3B, 0xC7, 0xF0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x78, 0x3C, 0x1E, 0x0E, 0x1F, 0x81, 0xFF, 0x1F, 0xF9, 0xF3,
  0xEF, 0x0F, 0x78, 0x78, 0x03, 0xC3, 0xFE, 0x7F, 0xF7, 0xFF, 0xBC, 0x3D,
  0xE1, 0xEE, 0x0F, 0x78, 0x7B, 0xC7, 0xDF, 0xFE, 0x7F, 0xF1, 0xF3, 0xC0,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF7, 0xC7, 0xFF, 0xBF, 0xFD, 0xF9, 0xFF, 0x07, 0xF8, 0x3F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F,
  0xE3, 0xFF, 0xFE, 0xFF, 0xF7, 0xBE, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF,
  0x1F, 0x3E, 0x78, 0x79, 0xE0, 0xEF, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x70, 0x3D, 0xE0, 0xE7, 0xC7, 0x8F, 0xFE, 0x1F,
  0xF0, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x0F, 0x3C, 0xFF, 0xF3, 0xFF, 0xDF, 0x3F,
  0x78, 0x3D, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0xCF, 0xCF, 0xFF, 0x3F, 0xFC, 0x3C,
  0xF0, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x3E, 0x78, 0x3D, 0xE0, 0xF7,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x78, 0x01,
  0xE0, 0x47, 0xC3, 0x8F, 0xFF, 0x1F, 0xF8, 0x1F, 0x80, 0x07, 0xC3, 0xF1,
  0xFC, 0x7C, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0xFF, 0xBF, 0xEF, 0xF8, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x0F, 0xBC, 0xFF, 0xF3, 0xFF, 0xDF,
  0x3F, 0x78, 0x3D, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0xC7, 0xCF, 0xFF, 0x3F, 0xFC,
  0x3E, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0xE3, 0xE3, 0xFF, 0x8F, 0xFC,
  0x0F, 0xC0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF3, 0xC7, 0xFF, 0x3F, 0xFD, 0xFB, 0xEF, 0x0F, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xC0, 0xFF, 0xF7, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x3C,
  0x78, 0x60, 0x00, 0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF3, 0xFF,
  0xBF, 0x78, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0xFB, 0xC7, 0xCF, 0x1E, 0x3C, 0xF8, 0xF7,
  0xC3, 0xDE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3C,
  0xF0, 0xF3, 0xE3, 0xC7, 0x8F, 0x1F, 0x3C, 0x3C, 0xF0, 0xFB, 0xC1, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xC3, 0xE7, 0xFF, 0x3F, 0xBF, 0xFF, 0xFF, 0xFB, 0xF9, 0xFF,
  0x0F, 0x87, 0xF8, 0x3C, 0x3F, 0xC1, 0xE0, 0xFE, 0x0F, 0x07, 0xF0, 0x78,
  0x3F, 0x83, 0xC1, 0xFC, 0x1E, 0x0F, 0xE0, 0xF0, 0x7F, 0x07, 0x83, 0xF8,
  0x3C, 0x1F, 0xC1, 0xE0, 0xFE, 0x0F, 0x07, 0xF0, 0x78, 0x3F, 0x83, 0xC1,
  0xC0, 0xF3, 0xC7, 0xFF, 0x3F, 0xFD, 0xFB, 0xEF, 0x0F, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xC0, 0x07, 0xC0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xE3, 0xE7, 0x83, 0xCF, 0x07, 0xBC, 0x07, 0x78, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xE7, 0x83, 0xCF, 0x07, 0x9F, 0x1F, 0x1F,
  0xFC, 0x1F, 0xF0, 0x0F, 0x80, 0xF7, 0xC7, 0xFF, 0xBF, 0xFD, 0xF3, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xE3, 0xFF, 0xFE, 0xFF, 0xE7, 0xBE, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0xBC,
  0xFF, 0xF3, 0xFF, 0xDF, 0x1F, 0x78, 0x3D, 0xE0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0xC7,
  0xCF, 0xFF, 0x3F, 0xFC, 0x3E, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0xF7, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0x0F, 0xC1, 0xFF, 0x0F, 0xFC, 0xF1, 0xF7, 0x87, 0xBC, 0x3D, 0xF0, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x3D, 0xE1,
  0xEF, 0xFE, 0x3F, 0xE0, 0x7E, 0x00, 0x1E, 0x0F, 0x07, 0x83, 0xCF, 0xFF,
  0xFF, 0xFE, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xF0, 0xF8, 0x3C, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0xE7, 0xEF, 0xFF, 0x7F, 0xF8, 0xF3,
  0xC0, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xE1, 0xE7, 0x8F, 0x3C, 0x79, 0xE3,
  0x87, 0x1C, 0x3D, 0xE1, 0xEF, 0x07, 0x70, 0x3B, 0x81, 0xFC, 0x0F, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x38, 0x00, 0xF0, 0xE0, 0xFF, 0x0F, 0x0F,
  0xF0, 0xF0, 0xFF, 0x0F, 0x0E, 0x71, 0xF1, 0xE7, 0x9F, 0x9E, 0x79, 0xF9,
  0xE7, 0x9F, 0x9C, 0x3B, 0xB9, 0xC3, 0xB9, 0xDC, 0x3B, 0x9F, 0xC3, 0xF9,
  0xFC, 0x3F, 0x1F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1E,
  0x0F, 0x00, 0xE0, 0x70, 0xF0, 0x79, 0xE3, 0xE7, 0x8F, 0x0F, 0x38, 0x3D,
  0xE0, 0x7F, 0x01, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0xE0, 0xF7, 0x83, 0xCF, 0x1E, 0x3C, 0xF8, 0x7B, 0xC1, 0xE0,
  0x78, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x07, 0x3C, 0x1E, 0xF0, 0x7B, 0xC0, 0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0x7F, 0xFB, 0xFF, 0xDF,
  0xFE, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78,
  0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0x07, 0x0F, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0xF8, 0xF0, 0xF8, 0x38, 0x3C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x0F, 0x07, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0xE0,
  0xF0, 0x78, 0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x1E, 0x1F, 0x07, 0x1F, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x38, 0x38, 0x78, 0xF0, 0xE0, 0xC0, 0x1E, 0x07, 0x7F, 0x07, 0x7F,
  0x8E, 0xF7, 0xDE, 0xE1, 0xFE, 0xE0, 0xFC, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_Medium34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 24, 9, 2, -24 },
  { 16, 7, 9, 11, 2, -26 },
  { 24, 15, 24, 18, 2, -24 },
  { 69, 13, 31, 17, 2, -28 },
  { 120, 18, 24, 22, 2, -24 },
  { 174, 18, 24, 19, 1, -24 },
  { 228, 3, 9, 6, 1, -26 },
  { 232, 8, 35, 11, 2, -27 },
  { 267, 8, 35, 11, 1, -27 },
  { 302, 15, 14, 15, 0, -24 },
  { 329, 14, 18, 17, 1, -21 },
  { 361, 5, 9, 8, 1, -4 },
  { 367, 8, 3, 11, 1, -12 },
  { 370, 5, 4, 9, 2, -4 },
  { 373, 11, 26, 12, 0, -24 },
  { 409, 13, 24, 17, 2, -24 },
  { 448, 8, 24, 17, 3, -24 },
  { 472, 15, 24, 17, 1, -24 },
  { 517, 14, 24, 17, 1, -24 },
  { 559, 15, 24, 17, 1, -24 },
  { 604, 14, 24, 17, 2, -24 },
  { 646, 14, 24, 17, 2, -24 },
  { 688, 15, 24, 17, 1, -24 },
  { 733, 13, 24, 17, 2, -24 },
  { 772, 13, 24, 17, 2, -24 },
  { 811, 5, 18, 9, 2, -18 },
  { 823, 6, 23, 8, 1, -18 },
  { 841, 12, 15, 15, 1, -18 },
  { 864, 13, 10, 17, 2, -16 },
  { 881, 12, 15, 16, 2, -18 },
  { 904, 12, 24, 15, 1, -24 },
  { 940, 23, 32, 26, 2, -24 },
  { 1032, 18, 24, 20, 1, -24 },
  { 1086, 15, 24, 19, 2, -24 },
  { 1131, 16, 24, 19, 2, -24 },
  { 1179, 15, 24, 19, 2, -24 },
  { 1224, 14, 24, 17, 2, -24 },
  { 1266, 13, 24, 16, 2, -24 },
  { 1305, 16, 24, 20, 2, -24 },
  { 1353, 17, 24, 21, 2, -24 },
  { 1404, 4, 24, 9, 2, -24 },
  { 1416, 13, 24, 17, 1, -24 },
  { 1455, 17, 24, 19, 2, -24 },
  { 1506, 13, 24, 16, 2, -24 },
  { 1545, 21, 24, 26, 2, -24 },
  { 1608, 17, 24, 21, 2, -24 },
  { 1659, 17, 24, 20, 2, -24 },
  { 1710, 16, 24, 19, 2, -24 },
  { 1758, 17, 28, 20, 2, -24 },
  { 1818, 16, 24, 18, 2, -24 },
  { 1866, 16, 24, 18, 1, -24 },
  { 1914, 16, 24, 18, 1, -24 },
  { 1962, 15, 24, 19, 2, -24 },
  { 2007, 18, 24, 19, 1, -24 },
  { 2061, 24, 24, 26, 1, -24 },
  { 2133, 17, 24, 19, 1, -24 },
  { 2184, 18, 24, 18, 0, -24 },
  { 2238, 16, 24, 18, 1, -24 },
  { 2286, 6, 33, 9, 2, -28 },
  { 2311, 13, 26, 13, 0, -24 },
  { 2354, 6, 33, 9, 1, -28 },
  { 2379, 11, 12, 13, 1, -24 },
  { 2396, 13, 3, 14, 0, 0 },
  { 2401, 8, 5, 11, 1, -25 },
  { 2406, 13, 18, 16, 2, -18 },
  { 2436, 13, 26, 17, 2, -26 },
  { 2479, 14, 18, 16, 1, -18 },
  { 2511, 14, 26, 17, 1, -26 },
  { 2557, 14, 18, 16, 1, -18 },
  { 2589, 10, 26, 11, 1, -26 },
  { 2622, 14, 25, 17, 1, -18 },
  { 2666, 13, 26, 17, 2, -26 },
  { 2709, 4, 25, 8, 2, -25 },
  { 2722, 7, 32, 8, -1, -25 },
  { 2750, 14, 26, 16, 2, -26 },
  { 2796, 4, 26, 8, 2, -26 },
  { 2809, 21, 18, 25, 2, -18 },
  { 2857, 13, 18, 17, 2, -18 },
  { 2887, 15, 18, 17, 1, -18 },
  { 2921, 13, 25, 17, 2, -18 },
  { 2962, 14, 25, 17, 1, -18 },
  { 3006, 8, 18, 11, 2, -18 },
  { 3024, 13, 18, 15, 1, -18 },
  { 3054, 9, 22, 10, 0, -22 },
  { 3079, 13, 18, 17, 2, -18 },
  { 3109, 13, 18, 15, 1, -18 },
  { 3139, 20, 18, 22, 1, -18 },
  { 3184, 14, 18, 15, 1, -18 },
  { 3216, 14, 25, 15, 0, -18 },
  { 3260, 13, 18, 15, 1, -18 },
  { 3290, 8, 33, 10, 1, -27 },
  { 3323, 3, 28, 8, 3, -24 },
  { 3334, 8, 33, 10, 1, -27 },
  { 3367, 16, 7, 19, 2, -13 },
};

const GFXfont RobotoCondensed_Medium34pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium34pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium34pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOCONDENSED_MEDIUM34PT7B_H_
