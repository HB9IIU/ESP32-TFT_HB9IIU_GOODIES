#ifndef _ROBOTOCONDENSED_MEDIUM49PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7C, 0x00, 0x00, 0x00, 0xE7,
  0xFF, 0xFD, 0xF3, 0x80, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF0, 0xFF,
  0x0E, 0xF0, 0xEF, 0x0E, 0xF0, 0xEF, 0x0E, 0xF0, 0xEF, 0x0E, 0xF0, 0xE0,
  0x00, 0x78, 0xF0, 0x00, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80,
  0x0F, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x70, 0xF0, 0x00,
  0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x70, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3,
  0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x78,
  0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0x0F, 0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x78, 0x00, 0xF0, 0xF0, 0x01,
  0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x1C,
  0x3C, 0x00, 0x38, 0x78, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0x87, 0xE3, 0xF0, 0x7E, 0x3E,
  0x03, 0xF3, 0xE0, 0x3F, 0x3E, 0x03, 0xF3, 0xE0, 0x3F, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0,
  0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x07, 0xE3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0x87, 0x81, 0x80, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3,
  0xC0, 0xF0, 0x78, 0x78, 0x1E, 0x0F, 0x1E, 0x01, 0xC1, 0xE3, 0x80, 0x3C,
  0x3C, 0xF0, 0x07, 0xFF, 0x1C, 0x00, 0x7F, 0xE7, 0x80, 0x07, 0xF8, 0xE0,
  0x00, 0x7C, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xC7, 0xF8, 0x00, 0x71, 0xFF,
  0x80, 0x1E, 0x7D, 0xF0, 0x03, 0x8F, 0x0F, 0x00, 0xF3, 0xC1, 0xE0, 0x1C,
  0x78, 0x3C, 0x07, 0x8F, 0x07, 0x80, 0xE1, 0xE0, 0xF0, 0x3C, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x78, 0x08, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x07,
  0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF9,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFE, 0x0F, 0x87, 0xFF, 0x87, 0xC3,
  0xFF, 0xE3, 0xE3, 0xF3, 0xF1, 0xF1, 0xF0, 0xFC, 0xF9, 0xF8, 0x7F, 0xFC,
  0xFC, 0x1F, 0xFC, 0x7E, 0x07, 0xFE, 0x3F, 0x01, 0xFF, 0x1F, 0x80, 0xFF,
  0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x1F, 0xC1, 0xFC, 0x3F, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xBF, 0x81, 0xFF, 0x0F, 0xE0, 0x08,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x1C, 0x07,
  0x81, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x78,
  0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x00, 0xE0, 0x08, 0x40, 0x06, 0x00, 0x70, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E,
  0x07, 0xC0, 0x78, 0x07, 0x00, 0x60, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x60,
  0xF0, 0x6F, 0xCF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xC0,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xBE, 0x00, 0xF9, 0xE0,
  0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x3E, 0x07, 0xC0, 0xC0, 0x70, 0x04, 0x02,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0xF9, 0xF7, 0xCF, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7D, 0xFF, 0xFF, 0xF7, 0xE7, 0x80, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF0,
  0xFE, 0x3E, 0x07, 0xE7, 0xE0, 0x3E, 0x7E, 0x03, 0xE7, 0xC0, 0x3F, 0x7C,
  0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03,
  0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xE7, 0xE0, 0x3E, 0x3E, 0x07, 0xE3, 0xF0,
  0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x01,
  0xF8, 0x00, 0x00, 0x30, 0x0F, 0x03, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xE1, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x87, 0xF1, 0xF8,
  0x1F, 0x9F, 0x80, 0x7C, 0xFC, 0x03, 0xE7, 0xE0, 0x1F, 0xBF, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7E, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x03, 0xEF, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3E, 0xFC, 0x07, 0xE7, 0xE0, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xDF, 0x80, 0x1F,
  0x7E, 0x00, 0x79, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0x1F, 0x80, 0x7C, 0x7E,
  0x01, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x81, 0xF0, 0x7E, 0x07,
  0xC1, 0xF8, 0x3E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xCF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF,
  0xCF, 0x81, 0xF8, 0x20, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x1F, 0x9F, 0xFF, 0xF1, 0xFF, 0xFC,
  0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x1F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xCF, 0xC1, 0xFB, 0xFE, 0x3E, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0xDF, 0xC1, 0xFB, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xBE, 0x03, 0xF7, 0xE0, 0x7E, 0xFE, 0x1F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8,
  0xFC, 0x3F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x07, 0xDF, 0x80, 0xFB,
  0xF0, 0x1F, 0x7E, 0x07, 0xE7, 0xC0, 0xFC, 0xFC, 0x3F, 0x0F, 0xFF, 0xE0,
  0xFF, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0x0F, 0xC7,
  0xC0, 0xFD, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFD, 0xFC, 0x1F, 0x9F,
  0xFF, 0xF3, 0xFF, 0xFC, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF,
  0x83, 0xF0, 0xFC, 0x7E, 0x07, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x7F, 0x7F, 0x0F, 0xF3,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFB, 0xE0, 0x3E, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0x00, 0x07, 0x80, 0x00, 0x7D, 0xFF, 0xFF, 0xF7, 0xC7, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xDF, 0xFF,
  0xFF, 0x7C, 0x70, 0x1F, 0x3F, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x78,
  0x30, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x20,
  0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xF8,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC1,
  0xE0, 0x0F, 0x80, 0xF0, 0x78, 0x0F, 0xF8, 0x1C, 0x3C, 0x07, 0xFF, 0x07,
  0x8F, 0x03, 0xFF, 0xC1, 0xE3, 0xC0, 0xF0, 0xF0, 0x79, 0xE0, 0x7C, 0x3C,
  0x0E, 0x78, 0x1E, 0x0F, 0x03, 0x9E, 0x0F, 0x83, 0xC0, 0xE7, 0x83, 0xC0,
  0xF0, 0x39, 0xE0, 0xF0, 0x3C, 0x0E, 0xF0, 0x7C, 0x0F, 0x03, 0xBC, 0x1F,
  0x03, 0xC0, 0xEF, 0x07, 0xC0, 0xF0, 0x3B, 0xC1, 0xE0, 0x78, 0x0E, 0xF0,
  0x78, 0x1E, 0x03, 0xBC, 0x1E, 0x07, 0x81, 0xEF, 0x07, 0x81, 0xE0, 0x7B,
  0xC1, 0xF0, 0x78, 0x1C, 0x70, 0x7C, 0x3E, 0x0F, 0x1E, 0x1F, 0x0F, 0x83,
  0xC7, 0x83, 0xFF, 0xF1, 0xE1, 0xE0, 0xFF, 0xBF, 0xF8, 0x78, 0x1F, 0xE7,
  0xFC, 0x0F, 0x03, 0xF0, 0xFC, 0x03, 0xC0, 0x20, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x06, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x1F, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x1F,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x3E,
  0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80,
  0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0xBF,
  0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0x7E, 0xFC, 0x01, 0xF3, 0xF0, 0x0F, 0xCF, 0xC1, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0x00, 0xFC, 0xFC,
  0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x01, 0xFB,
  0xF0, 0x0F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF0, 0x3F, 0x9F, 0x80,
  0x3F, 0x3F, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFB, 0xF0,
  0x07, 0xE7, 0xE0, 0x0F, 0xC7, 0xF0, 0x3F, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3,
  0xF0, 0x3F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0xBF, 0x00, 0x7E, 0xFC, 0x03, 0xF3, 0xF0, 0x3F, 0xCF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xCF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF0, 0x3F, 0x9F, 0x80, 0x3F, 0x3F,
  0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xF7,
  0xF0, 0x07, 0xE7, 0xF0, 0x1F, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0x7E, 0x07, 0xE7, 0xF0, 0xFE, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8,
  0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00,
  0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0xFD, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0x80,
  0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0,
  0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFC,
  0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x3E, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xBE, 0x03, 0xEF, 0xFF, 0x7C, 0x07, 0xDF, 0xFE, 0xF8, 0x0F, 0xBF, 0xFD,
  0xF8, 0x3E, 0x7F, 0xF9, 0xF0, 0x7C, 0xFF, 0xF3, 0xE0, 0xF9, 0xFF, 0xE7,
  0xE1, 0xE3, 0xFF, 0xC7, 0xC7, 0xC7, 0xFF, 0x8F, 0x8F, 0x8F, 0xFF, 0x1F,
  0x1F, 0x1F, 0xFE, 0x1F, 0x7C, 0x3F, 0xFC, 0x3E, 0xF8, 0x7F, 0xF8, 0x7D,
  0xF0, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0x07, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0x03, 0xF8, 0x1F, 0xFE, 0x07, 0xF0,
  0x3F, 0xFC, 0x07, 0xC0, 0x7F, 0xF8, 0x0F, 0x80, 0xFF, 0xF0, 0x1F, 0x01,
  0xF8, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFD, 0xF0, 0x3F, 0xFD, 0xF8, 0x3F, 0xFC, 0xF8, 0x3F, 0xFC, 0xFC,
  0x3F, 0xFC, 0x7C, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x3E, 0x3F, 0xFC, 0x3F,
  0x3F, 0xFC, 0x1F, 0x3F, 0xFC, 0x1F, 0xBF, 0xFC, 0x0F, 0xBF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x3F, 0x83, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00,
  0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x80, 0x7F,
  0x3F, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xBF,
  0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x03, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xF0, 0xFE, 0x01, 0xF8, 0x7E, 0x00,
  0xFE, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xCF, 0x80,
  0x03, 0xF7, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7E,
  0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F,
  0xC7, 0xE0, 0x07, 0xE3, 0xF8, 0x07, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x04, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F,
  0x80, 0xFF, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8,
  0x01, 0xF3, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0x9F, 0x80,
  0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xFC, 0xFC, 0x07, 0xF1, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0xC3,
  0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xFD, 0xF8, 0x01, 0xFB, 0xF0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF1, 0xFC, 0x0F, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E,
  0x7C, 0x00, 0xFD, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x7E, 0x01, 0xFD, 0xFC, 0x0F,
  0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xF9, 0xFC, 0x0F, 0xE7, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xF9, 0xF8,
  0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xE3, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x1F, 0x81, 0xF8, 0x07,
  0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x00, 0xFC,
  0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xFC, 0xFC,
  0x00, 0x3F, 0x3F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xEF,
  0x80, 0x3E, 0x00, 0xFD, 0xF8, 0x07, 0xE0, 0x1F, 0x3F, 0x00, 0xFC, 0x03,
  0xE7, 0xE0, 0x3F, 0x80, 0xFC, 0xFC, 0x07, 0xF0, 0x1F, 0x8F, 0x80, 0xFE,
  0x03, 0xF1, 0xF0, 0x1F, 0xE0, 0x7C, 0x3F, 0x03, 0xFC, 0x0F, 0x87, 0xE0,
  0xFF, 0x81, 0xF0, 0xFC, 0x1F, 0xF0, 0x7E, 0x0F, 0x83, 0xFE, 0x0F, 0xC1,
  0xF0, 0x7B, 0xE1, 0xF8, 0x3E, 0x1F, 0x7C, 0x3E, 0x07, 0xC3, 0xEF, 0x87,
  0xC0, 0xFC, 0x7C, 0xF0, 0xF8, 0x1F, 0x8F, 0x1E, 0x3F, 0x01, 0xF1, 0xE3,
  0xE7, 0xE0, 0x3E, 0x7C, 0x7C, 0xF8, 0x07, 0xCF, 0x8F, 0x9F, 0x00, 0xF9,
  0xF0, 0xF3, 0xE0, 0x1F, 0xBC, 0x1E, 0x7C, 0x01, 0xF7, 0x83, 0xFF, 0x80,
  0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0x8F,
  0xC0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xE0,
  0x3F, 0x07, 0xF0, 0x1F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xF3, 0xF0, 0x03,
  0xF1, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0xC0,
  0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x7F, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0xBF, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x7F, 0x00,
  0x1F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x0F, 0xC7, 0xF0, 0x07, 0xE1, 0xF8,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x07,
  0xC0, 0xFC, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x3E, 0x00,
  0x3F, 0x3F, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x78, 0x1E, 0x7C, 0x1E, 0x3C, 0x3E,
  0x3C, 0x3C, 0x3E, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x1F, 0x78, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F,
  0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xFF,
  0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xC1, 0xF3, 0xF0, 0x3E,
  0xFC, 0x07, 0xDF, 0x80, 0xFB, 0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0xE0, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xF7, 0xE0, 0xF8, 0xFC,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x7E, 0x0F, 0x9F, 0xF1, 0xF7, 0xFF, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFE, 0x0F, 0xDF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x7E, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xEF, 0xFE, 0x7C,
  0xFF, 0x8F, 0x8F, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFC, 0xFC, 0x1F, 0x9F, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0xF0,
  0x0F, 0xBE, 0x03, 0xF7, 0xE0, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x83, 0xF1, 0xF0, 0xFF,
  0xBE, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7E, 0x0F, 0xEF, 0xC0,
  0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xDF, 0x81, 0xFB, 0xF0, 0x7F, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFD, 0xF0, 0x7E, 0x3E, 0x01, 0xFC,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF0,
  0x7E, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x08,
  0x7F, 0x01, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x07, 0xFF,
  0x80, 0x1F, 0xC0, 0x00, 0x10, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC,
  0x3F, 0xC0, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE1,
  0xF0, 0xFF, 0xBF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF0,
  0x7F, 0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x3F,
  0x7F, 0x07, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFB,
  0xF0, 0x3E, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE1, 0x00,
  0x7E, 0x1C, 0x0F, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE3, 0xF0, 0xF9, 0xFF, 0x3E, 0xFF, 0xCF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xC0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xF0, 0xFC, 0x3F,
  0x0F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0xBF, 0xEF,
  0xFB, 0xFC, 0xFE, 0x3F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0xF8,
  0x1F, 0xCF, 0x83, 0xF8, 0xF8, 0x3F, 0x0F, 0x87, 0xF0, 0xF8, 0xFE, 0x0F,
  0x8F, 0xC0, 0xF9, 0xF8, 0x0F, 0xBF, 0x80, 0xFB, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFE, 0xFC,
  0x0F, 0xCF, 0xC0, 0xF8, 0x7E, 0x0F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0x83,
  0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0xFE, 0xF8,
  0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0xFC, 0x07, 0xE1, 0xF3, 0xFE,
  0x3F, 0xE3, 0xFF, 0xFC, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xC3, 0xFE, 0x1F, 0xBF, 0x03, 0xF8, 0x1F, 0xFC, 0x07, 0xE0,
  0x3F, 0xF8, 0x0F, 0xC0, 0x7F, 0xF0, 0x1F, 0x80, 0xFF, 0xE0, 0x3F, 0x01,
  0xFF, 0xC0, 0x7E, 0x03, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0x01, 0xF8, 0x0F,
  0xFE, 0x03, 0xF0, 0x1F, 0xFC, 0x07, 0xE0, 0x3F, 0xF8, 0x0F, 0xC0, 0x7F,
  0xF0, 0x1F, 0x80, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xC0, 0x7E, 0x03, 0xFF,
  0x80, 0xFC, 0x07, 0xFF, 0x01, 0xF8, 0x0F, 0xFE, 0x03, 0xF0, 0x1F, 0xFC,
  0x07, 0xE0, 0x3F, 0xF8, 0x0F, 0xC0, 0x7F, 0xF0, 0x1F, 0x80, 0xFC, 0xF8,
  0x7C, 0x3E, 0x7F, 0xCF, 0xBF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x87,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF0,
  0x7E, 0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xF7, 0xE0, 0x3F,
  0x7F, 0x07, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFF,
  0x00, 0x1F, 0xC0, 0xF8, 0xFC, 0x1F, 0x7F, 0xE3, 0xEF, 0xFE, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFC, 0x1F, 0xBF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xDF, 0xFC,
  0xFB, 0xFF, 0x1F, 0x1F, 0x83, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE3, 0xE3, 0xFF, 0x7C, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFC, 0x0F, 0xDF, 0x80, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xE0, 0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x0F, 0xFB, 0xE0, 0xFC, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0xFF, 0xBF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x03, 0xF8,
  0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xBF, 0x9F, 0x83, 0xF7,
  0xC0, 0xFD, 0xF0, 0x3F, 0x7C, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xDF, 0xFF, 0xF7,
  0xFF, 0xF8, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFD, 0xFF, 0xFF, 0x3F, 0xF7, 0xC3, 0xF1, 0xF0, 0xFC, 0x03, 0xEF, 0xC0,
  0x7E, 0x7C, 0x07, 0xE7, 0xC0, 0x7E, 0x7E, 0x07, 0xC7, 0xE0, 0x7C, 0x3E,
  0x0F, 0xC3, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x1F, 0x81,
  0xF1, 0xF0, 0x1F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x9E, 0x00, 0xFB, 0xE0,
  0x07, 0xBE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0xFC, 0x0F, 0x80, 0xFF, 0xE0, 0x7C, 0x07, 0xDF, 0x03, 0xE0, 0x7E,
  0xF8, 0x1F, 0x83, 0xF7, 0xC1, 0xFC, 0x1F, 0x3E, 0x0F, 0xE0, 0xF9, 0xF8,
  0x7F, 0x07, 0xC7, 0xC3, 0xFC, 0x3E, 0x3E, 0x3F, 0xE3, 0xE1, 0xF1, 0xFF,
  0x1F, 0x0F, 0x8F, 0x78, 0xF8, 0x3E, 0x7B, 0xE7, 0xC1, 0xF7, 0xDF, 0x3E,
  0x0F, 0xBE, 0x7B, 0xE0, 0x7D, 0xE3, 0xDF, 0x03, 0xEF, 0x1F, 0xF8, 0x0F,
  0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0,
  0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0xFC,
  0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0xFE, 0x07, 0xE7, 0xE0, 0x7E, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x0F,
  0x81, 0xF9, 0xF8, 0x0F, 0x9F, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x01,
  0xF9, 0xF0, 0x1F, 0x9F, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0x7E,
  0x7E, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x7E, 0xFC, 0x07,
  0xE7, 0xC0, 0x7E, 0x7E, 0x07, 0xC7, 0xE0, 0xFC, 0x3E, 0x0F, 0xC3, 0xE0,
  0xF8, 0x3F, 0x0F, 0x83, 0xF1, 0xF8, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F,
  0x9F, 0x00, 0xFB, 0xF0, 0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0x0F, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60,
  0x1E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x80, 0xFC, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1E, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x07, 0x00, 0xFC, 0x0F, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0x03, 0xF0, 0x7F, 0x0F, 0xC0, 0xF8,
  0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x0F, 0xC0,
  0xFC, 0x07, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0xF3, 0xFF,
  0x03, 0xDF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF,
  0xBC, 0x0F, 0xFC, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_Medium49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 35, 12, 3, -35 },
  { 28, 12, 13, 16, 2, -37 },
  { 48, 23, 35, 26, 2, -35 },
  { 149, 20, 45, 25, 2, -40 },
  { 262, 27, 35, 31, 2, -35 },
  { 381, 25, 36, 28, 2, -35 },
  { 494, 4, 12, 8, 2, -37 },
  { 500, 11, 50, 16, 3, -39 },
  { 569, 12, 50, 16, 1, -39 },
  { 644, 20, 21, 22, 1, -35 },
  { 697, 20, 25, 24, 2, -29 },
  { 760, 7, 14, 11, 1, -6 },
  { 773, 11, 5, 15, 2, -18 },
  { 780, 7, 6, 14, 3, -6 },
  { 786, 16, 38, 17, 0, -35 },
  { 862, 20, 35, 25, 2, -35 },
  { 950, 12, 35, 25, 4, -35 },
  { 1003, 21, 35, 25, 2, -35 },
  { 1095, 20, 35, 25, 2, -35 },
  { 1183, 22, 35, 25, 1, -35 },
  { 1280, 19, 35, 25, 3, -35 },
  { 1364, 19, 35, 25, 3, -35 },
  { 1448, 20, 35, 25, 2, -35 },
  { 1536, 19, 35, 25, 3, -35 },
  { 1620, 20, 35, 25, 2, -35 },
  { 1708, 7, 26, 12, 3, -26 },
  { 1731, 8, 34, 11, 1, -26 },
  { 1765, 17, 22, 22, 2, -26 },
  { 1812, 18, 16, 24, 3, -24 },
  { 1848, 18, 22, 22, 3, -26 },
  { 1898, 17, 35, 21, 2, -35 },
  { 1973, 34, 45, 38, 2, -34 },
  { 2165, 27, 35, 29, 1, -35 },
  { 2284, 22, 35, 27, 3, -35 },
  { 2381, 23, 35, 28, 3, -35 },
  { 2482, 22, 35, 28, 3, -35 },
  { 2579, 20, 35, 24, 3, -35 },
  { 2667, 19, 35, 23, 3, -35 },
  { 2751, 23, 35, 29, 3, -35 },
  { 2852, 24, 35, 30, 3, -35 },
  { 2957, 6, 35, 13, 3, -35 },
  { 2984, 20, 35, 24, 1, -35 },
  { 3072, 24, 35, 27, 3, -35 },
  { 3177, 19, 35, 23, 3, -35 },
  { 3261, 31, 35, 37, 3, -35 },
  { 3397, 24, 35, 30, 3, -35 },
  { 3502, 24, 35, 30, 3, -35 },
  { 3607, 23, 35, 28, 3, -35 },
  { 3708, 25, 41, 30, 2, -35 },
  { 3837, 23, 35, 27, 3, -35 },
  { 3938, 22, 35, 26, 2, -35 },
  { 4035, 24, 35, 26, 1, -35 },
  { 4140, 22, 35, 28, 3, -35 },
  { 4237, 26, 35, 28, 1, -35 },
  { 4351, 35, 35, 37, 1, -35 },
  { 4505, 25, 35, 27, 1, -35 },
  { 4615, 25, 35, 26, 1, -35 },
  { 4725, 22, 35, 26, 2, -35 },
  { 4822, 9, 48, 13, 3, -40 },
  { 4876, 17, 38, 18, 1, -35 },
  { 4957, 8, 48, 13, 1, -40 },
  { 5005, 16, 17, 19, 1, -35 },
  { 5039, 18, 5, 20, 1, 0 },
  { 5051, 12, 7, 16, 1, -37 },
  { 5062, 19, 26, 23, 2, -26 },
  { 5124, 19, 37, 24, 3, -37 },
  { 5212, 19, 26, 23, 2, -26 },
  { 5274, 19, 37, 24, 2, -37 },
  { 5362, 20, 26, 23, 2, -26 },
  { 5427, 14, 38, 16, 1, -38 },
  { 5494, 20, 36, 24, 2, -26 },
  { 5584, 18, 37, 24, 3, -37 },
  { 5668, 6, 36, 12, 3, -36 },
  { 5695, 10, 46, 12, -1, -36 },
  { 5753, 20, 37, 23, 3, -37 },
  { 5846, 6, 37, 12, 3, -37 },
  { 5874, 31, 26, 37, 3, -26 },
  { 5975, 18, 26, 24, 3, -26 },
  { 6034, 20, 26, 24, 2, -26 },
  { 6099, 19, 36, 24, 3, -26 },
  { 6185, 19, 36, 24, 2, -26 },
  { 6271, 12, 26, 16, 3, -26 },
  { 6310, 18, 26, 22, 2, -26 },
  { 6369, 12, 32, 15, 1, -32 },
  { 6417, 18, 26, 24, 3, -26 },
  { 6476, 20, 26, 22, 1, -26 },
  { 6541, 29, 26, 31, 1, -26 },
  { 6636, 20, 26, 22, 1, -26 },
  { 6701, 20, 36, 21, 1, -26 },
  { 6791, 18, 26, 22, 2, -26 },
  { 6850, 12, 47, 15, 2, -38 },
  { 6921, 4, 41, 12, 4, -35 },
  { 6942, 12, 47, 15, 1, -38 },
  { 7013, 22, 10, 28, 3, -19 },
};

const GFXfont RobotoCondensed_Medium49pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium49pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium49pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOCONDENSED_MEDIUM49PT7B_H_
