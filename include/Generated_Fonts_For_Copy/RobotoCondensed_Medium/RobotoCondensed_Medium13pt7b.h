#ifndef _ROBOTOCONDENSED_MEDIUM13PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium13pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xA2, 0x80, 0xB7, 0x00, 0x28, 0xA4, 0xBF, 0x53, 0xE5, 0x14,
  0x50, 0x23, 0xB7, 0x3C, 0x38, 0x73, 0xDB, 0x88, 0xE1, 0x52, 0xA7, 0x81,
  0x05, 0x8C, 0xA9, 0x0C, 0x73, 0x4D, 0x1C, 0x6E, 0xF9, 0xA6, 0xFC, 0xE0,
  0x29, 0x49, 0x24, 0x91, 0x22, 0x89, 0x92, 0x49, 0x25, 0xA8, 0x20, 0x8F,
  0xCC, 0x71, 0x20, 0x30, 0xC3, 0x3F, 0x30, 0xC3, 0x00, 0x56, 0xC0, 0xB0,
  0x11, 0x22, 0x26, 0x44, 0x48, 0x76, 0xA7, 0x39, 0xCE, 0x7A, 0x70, 0x3C,
  0x92, 0x49, 0x20, 0x76, 0xE6, 0x33, 0x11, 0x18, 0xF8, 0x76, 0xE6, 0x27,
  0x0E, 0x73, 0x70, 0x18, 0x63, 0x8A, 0x69, 0x2F, 0xC2, 0x08, 0xFE, 0x31,
  0xE9, 0x8E, 0x7B, 0x70, 0x33, 0x31, 0xED, 0xCE, 0x7B, 0x70, 0xFC, 0x30,
  0x82, 0x18, 0x43, 0x08, 0x20, 0x76, 0xE7, 0xA7, 0x4E, 0x7B, 0x70, 0x76,
  0xA7, 0x3D, 0xFC, 0x46, 0x60, 0xB0, 0x2C, 0x48, 0x00, 0x12, 0x58, 0x09,
  0xF9, 0xC3, 0x84, 0xF8, 0x3E, 0x8E, 0x33, 0xE8, 0x76, 0xC2, 0x33, 0x10,
  0x04, 0x20, 0x3C, 0x42, 0xC1, 0x9D, 0xB5, 0xA5, 0xA5, 0xAD, 0xB6, 0x80,
  0x40, 0x3C, 0x18, 0x30, 0xE1, 0x62, 0x4C, 0x9F, 0xA3, 0xC2, 0xFA, 0x68,
  0xA2, 0xFA, 0x28, 0xE2, 0xF8, 0x7B, 0x38, 0xE0, 0x82, 0x08, 0xF3, 0x78,
  0xF2, 0x68, 0xE3, 0x8E, 0x38, 0xE6, 0xF0, 0xFC, 0x21, 0x0F, 0x42, 0x10,
  0xF8, 0xFC, 0x21, 0x0F, 0x42, 0x10, 0x80, 0x7B, 0x38, 0xE0, 0x82, 0x78,
  0xF3, 0x78, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x84, 0xFF, 0x80, 0x0C,
  0x30, 0xC3, 0x0C, 0x3C, 0xD2, 0x78, 0x8E, 0x69, 0x2C, 0xF3, 0xC9, 0xA2,
  0x8C, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0xC3, 0xC3, 0xE7, 0xA5, 0xA5,
  0xBF, 0x9B, 0x9B, 0x9B, 0xC7, 0x1E, 0x69, 0xB6, 0x59, 0xE3, 0x8C, 0x7B,
  0x38, 0xE1, 0x86, 0x18, 0xF3, 0x78, 0xFA, 0x28, 0xE3, 0x8F, 0xE8, 0x20,
  0x80, 0x7B, 0x38, 0xE1, 0x86, 0x18, 0xF3, 0x78, 0x30, 0x40, 0xF2, 0x68,
  0xA2, 0x9B, 0xC9, 0xA6, 0x8C, 0x39, 0xB4, 0x58, 0x38, 0x34, 0x5B, 0x38,
  0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xF2, 0x78, 0xC6, 0x8D, 0x93, 0x22, 0xC5, 0x8E, 0x1C, 0x18, 0xCC,
  0x93, 0x24, 0xC9, 0x36, 0x7F, 0x9C, 0xC3, 0x30, 0xCC, 0x33, 0x00, 0x46,
  0xD8, 0xB1, 0xC1, 0x87, 0x0B, 0x36, 0x46, 0xC6, 0x89, 0xB1, 0x43, 0x82,
  0x04, 0x08, 0x10, 0xF8, 0xC4, 0x62, 0x33, 0x10, 0xF8, 0xEA, 0xAA, 0xAA,
  0xC0, 0xC2, 0x10, 0xC2, 0x10, 0xC2, 0x10, 0xC0, 0xED, 0xB6, 0xDB, 0x6D,
  0xBE, 0x23, 0x14, 0xA5, 0x00, 0xF8, 0x44, 0x74, 0x85, 0xE9, 0x4B, 0xE0,
  0x84, 0x21, 0xED, 0xCE, 0x73, 0xDF, 0x80, 0x74, 0xA7, 0x08, 0x4D, 0xC0,
  0x18, 0xC7, 0xF9, 0xCE, 0x73, 0x9F, 0xC0, 0x74, 0xA7, 0xF8, 0x69, 0xC0,
  0x36, 0x6F, 0x66, 0x66, 0x66, 0xFE, 0xE7, 0x39, 0xCF, 0xE3, 0x9F, 0x80,
  0x84, 0x21, 0xED, 0xCE, 0x73, 0x9C, 0xC0, 0xDF, 0xC0, 0x51, 0x55, 0x55,
  0xC0, 0x84, 0x21, 0x2B, 0x73, 0x96, 0x94, 0xC0, 0xFF, 0xC0, 0xF6, 0xDB,
  0x9B, 0x9B, 0x9B, 0x9B, 0x9B, 0xF6, 0xE7, 0x39, 0xCE, 0x60, 0x76, 0xE7,
  0x39, 0xED, 0xC0, 0xF6, 0xE7, 0x39, 0xCF, 0xD0, 0x84, 0x00, 0xFC, 0xE7,
  0x39, 0xCF, 0xE3, 0x18, 0xC0, 0xFE, 0x49, 0x20, 0x7A, 0x50, 0x70, 0xA5,
  0xE0, 0x66, 0xF6, 0x66, 0x66, 0x70, 0x9C, 0xE7, 0x39, 0xCF, 0xE0, 0xCA,
  0x56, 0xE7, 0x18, 0xC0, 0xD9, 0x5B, 0x5B, 0x5E, 0x76, 0x66, 0x26, 0x49,
  0xE3, 0x0C, 0x31, 0xE4, 0x80, 0xCA, 0x56, 0xE7, 0x18, 0xC4, 0x23, 0x00,
  0xF3, 0x26, 0xC8, 0xF0, 0x22, 0x66, 0x66, 0xC6, 0x66, 0x22, 0xFF, 0xE0,
  0xC4, 0x66, 0x66, 0x36, 0x66, 0x4C, 0xE6, 0xB9, 0x80,
};

const GFXglyph RobotoCondensed_Medium13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 3, 1, -9 },
  { 4, 3, 3, 4, 1, -10 },
  { 6, 6, 9, 7, 1, -9 },
  { 13, 5, 11, 7, 1, -10 },
  { 20, 7, 9, 8, 1, -9 },
  { 28, 6, 9, 7, 1, -9 },
  { 35, 1, 3, 2, 1, -10 },
  { 36, 3, 13, 4, 1, -10 },
  { 41, 3, 13, 4, 0, -10 },
  { 46, 6, 6, 6, 0, -9 },
  { 51, 6, 7, 6, 0, -8 },
  { 57, 2, 4, 3, 0, -1 },
  { 58, 2, 1, 4, 1, -4 },
  { 59, 2, 2, 4, 1, -2 },
  { 60, 4, 10, 5, 0, -9 },
  { 65, 5, 9, 7, 1, -9 },
  { 71, 3, 9, 7, 1, -9 },
  { 75, 5, 9, 7, 1, -9 },
  { 81, 5, 9, 7, 1, -9 },
  { 87, 6, 9, 7, 0, -9 },
  { 94, 5, 9, 7, 1, -9 },
  { 100, 5, 9, 7, 1, -9 },
  { 106, 6, 9, 7, 0, -9 },
  { 113, 5, 9, 7, 1, -9 },
  { 119, 5, 9, 7, 1, -9 },
  { 125, 2, 7, 3, 1, -7 },
  { 127, 3, 10, 3, 0, -7 },
  { 131, 5, 6, 6, 0, -7 },
  { 135, 5, 3, 6, 1, -6 },
  { 137, 4, 6, 6, 1, -7 },
  { 140, 5, 9, 6, 0, -9 },
  { 146, 8, 12, 10, 1, -9 },
  { 158, 7, 9, 8, 0, -9 },
  { 166, 6, 9, 7, 1, -9 },
  { 173, 6, 9, 7, 1, -9 },
  { 180, 6, 9, 7, 1, -9 },
  { 187, 5, 9, 6, 1, -9 },
  { 193, 5, 9, 6, 1, -9 },
  { 199, 6, 9, 8, 1, -9 },
  { 206, 6, 9, 8, 1, -9 },
  { 213, 1, 9, 3, 1, -9 },
  { 215, 6, 9, 6, 0, -9 },
  { 222, 6, 9, 7, 1, -9 },
  { 229, 5, 9, 6, 1, -9 },
  { 235, 8, 9, 10, 1, -9 },
  { 244, 6, 9, 8, 1, -9 },
  { 251, 6, 9, 8, 1, -9 },
  { 258, 6, 9, 7, 1, -9 },
  { 265, 6, 11, 8, 1, -9 },
  { 274, 6, 9, 7, 1, -9 },
  { 281, 6, 9, 7, 0, -9 },
  { 288, 7, 9, 7, 0, -9 },
  { 296, 6, 9, 7, 1, -9 },
  { 303, 7, 9, 7, 0, -9 },
  { 311, 10, 9, 10, 0, -9 },
  { 323, 7, 9, 7, 0, -9 },
  { 331, 7, 9, 7, 0, -9 },
  { 339, 5, 9, 7, 1, -9 },
  { 345, 2, 13, 3, 1, -11 },
  { 349, 5, 10, 5, 0, -9 },
  { 356, 3, 13, 3, 0, -11 },
  { 361, 5, 5, 5, 0, -9 },
  { 365, 5, 1, 5, 0, 0 },
  { 366, 3, 2, 4, 0, -10 },
  { 367, 5, 7, 6, 1, -7 },
  { 372, 5, 10, 6, 1, -10 },
  { 379, 5, 7, 6, 1, -7 },
  { 384, 5, 10, 6, 1, -10 },
  { 391, 5, 7, 6, 1, -7 },
  { 396, 4, 10, 4, 0, -10 },
  { 401, 5, 10, 6, 1, -7 },
  { 408, 5, 10, 6, 1, -10 },
  { 415, 1, 10, 3, 1, -10 },
  { 417, 2, 13, 3, 0, -10 },
  { 421, 5, 10, 6, 1, -10 },
  { 428, 1, 10, 3, 1, -10 },
  { 430, 8, 7, 10, 1, -7 },
  { 437, 5, 7, 6, 1, -7 },
  { 442, 5, 7, 7, 1, -7 },
  { 447, 5, 10, 6, 1, -7 },
  { 454, 5, 10, 6, 1, -7 },
  { 461, 3, 7, 4, 1, -7 },
  { 464, 5, 7, 6, 0, -7 },
  { 469, 4, 9, 4, 0, -9 },
  { 474, 5, 7, 6, 1, -7 },
  { 479, 5, 7, 6, 0, -7 },
  { 484, 8, 7, 8, 0, -7 },
  { 491, 6, 7, 6, 0, -7 },
  { 497, 5, 10, 6, 0, -7 },
  { 504, 4, 7, 6, 1, -7 },
  { 508, 4, 12, 4, 0, -10 },
  { 514, 1, 11, 3, 1, -9 },
  { 516, 4, 12, 4, 0, -10 },
  { 522, 6, 3, 7, 1, -5 },
};

const GFXfont RobotoCondensed_Medium13pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium13pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium13pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOCONDENSED_MEDIUM13PT7B_H_
