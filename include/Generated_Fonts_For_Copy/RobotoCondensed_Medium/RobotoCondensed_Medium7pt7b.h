#ifndef _ROBOTOCONDENSED_MEDIUM7PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium7pt7bBitmaps[] PROGMEM = {
  0x00, 0xE8, 0xF0, 0x47, 0x6E, 0x40, 0x0E, 0xBA, 0xC0, 0xCE, 0x27, 0x30,
  0x66, 0x4A, 0x60, 0xC0, 0x1A, 0xA4, 0x25, 0x58, 0x4E, 0x80, 0x5D, 0x20,
  0xC0, 0x00, 0x80, 0x16, 0x80, 0x76, 0xD6, 0xF8, 0x74, 0xAE, 0x65, 0x96,
  0x2D, 0xF2, 0x71, 0x96, 0x73, 0xD6, 0xE4, 0xA4, 0x75, 0xD6, 0x76, 0xB4,
  0x90, 0x88, 0x39, 0x00, 0x5C, 0x8D, 0x00, 0xE5, 0x24, 0x32, 0x6F, 0xBB,
  0xA0, 0x80, 0x26, 0x67, 0x90, 0xE9, 0xE9, 0xE0, 0x69, 0x89, 0x60, 0xE9,
  0x99, 0xE0, 0xF3, 0xCE, 0xF3, 0xC8, 0x69, 0xB9, 0x70, 0x99, 0xF9, 0x90,
  0xF8, 0x24, 0x9E, 0xAA, 0xCA, 0x90, 0x92, 0x4E, 0xCE, 0xF7, 0x5A, 0x80,
  0xDD, 0xBB, 0x90, 0x69, 0x99, 0x60, 0xE9, 0xE8, 0x80, 0x69, 0x99, 0x61,
  0xE9, 0xEA, 0x90, 0x71, 0xD6, 0xF4, 0x44, 0x40, 0x99, 0x99, 0x60, 0x99,
  0x66, 0x60, 0xAD, 0x56, 0xA5, 0x00, 0x86, 0x46, 0xA0, 0x86, 0x64, 0x40,
  0xE5, 0x2E, 0xEA, 0xAC, 0x91, 0x24, 0xFE, 0x78, 0xE0, 0x40, 0x67, 0xF0,
  0x9E, 0xDE, 0x76, 0x30, 0x2E, 0xD6, 0x77, 0x30, 0x75, 0x40, 0x76, 0xB6,
  0x9E, 0xDA, 0xF8, 0xFC, 0x97, 0x6A, 0xF8, 0xFD, 0x6B, 0x50, 0xF6, 0xD0,
  0x76, 0xB0, 0xF6, 0xF8, 0x76, 0xB2, 0xEA, 0x51, 0xF0, 0x3A, 0x40, 0xB6,
  0xB0, 0xB5, 0x20, 0xAB, 0x75, 0xA9, 0x50, 0xB5, 0x24, 0x00, 0xE9, 0x70,
  0x59, 0x50, 0x78, 0x25, 0xA0, 0x5A,
};

const GFXglyph RobotoCondensed_Medium7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 5, 2, 0, -5 },
  { 2, 2, 2, 2, 0, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 3, 7, 4, 0, -6 },
  { 9, 4, 5, 4, 0, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 2, 1, 0, -5 },
  { 16, 2, 8, 2, 0, -6 },
  { 18, 2, 8, 2, 0, -6 },
  { 20, 3, 3, 3, 0, -5 },
  { 22, 3, 4, 3, 0, -4 },
  { 24, 1, 2, 2, 0, -1 },
  { 25, 2, 1, 2, 0, -3 },
  { 26, 1, 1, 2, 0, -1 },
  { 27, 2, 5, 2, 0, -5 },
  { 29, 3, 5, 4, 0, -5 },
  { 31, 1, 5, 4, 1, -5 },
  { 32, 3, 5, 4, 0, -5 },
  { 34, 3, 5, 4, 0, -5 },
  { 36, 3, 5, 4, 0, -5 },
  { 38, 3, 5, 4, 0, -5 },
  { 40, 3, 5, 4, 0, -5 },
  { 42, 3, 5, 4, 0, -5 },
  { 44, 3, 5, 4, 0, -5 },
  { 46, 3, 5, 4, 0, -5 },
  { 48, 1, 4, 2, 0, -4 },
  { 49, 1, 5, 2, 0, -4 },
  { 50, 3, 3, 3, 0, -4 },
  { 52, 3, 2, 3, 0, -3 },
  { 53, 3, 3, 3, 0, -4 },
  { 55, 3, 5, 3, 0, -5 },
  { 57, 5, 7, 5, 0, -5 },
  { 62, 4, 5, 4, 0, -5 },
  { 65, 4, 5, 4, 0, -5 },
  { 68, 4, 5, 4, 0, -5 },
  { 71, 4, 5, 4, 0, -5 },
  { 74, 3, 5, 3, 0, -5 },
  { 76, 3, 5, 3, 0, -5 },
  { 78, 4, 5, 4, 0, -5 },
  { 81, 4, 5, 4, 0, -5 },
  { 84, 1, 5, 2, 0, -5 },
  { 85, 3, 5, 3, 0, -5 },
  { 87, 4, 5, 4, 0, -5 },
  { 90, 3, 5, 3, 0, -5 },
  { 92, 5, 5, 5, 0, -5 },
  { 96, 4, 5, 4, 0, -5 },
  { 99, 4, 5, 4, 0, -5 },
  { 102, 4, 5, 4, 0, -5 },
  { 105, 4, 6, 4, 0, -5 },
  { 108, 4, 5, 4, 0, -5 },
  { 111, 3, 5, 4, 0, -5 },
  { 113, 4, 5, 4, 0, -5 },
  { 116, 4, 5, 4, 0, -5 },
  { 119, 4, 5, 4, 0, -5 },
  { 122, 5, 5, 5, 0, -5 },
  { 126, 4, 5, 4, 0, -5 },
  { 129, 4, 5, 4, 0, -5 },
  { 132, 3, 5, 4, 0, -5 },
  { 134, 2, 7, 2, 0, -6 },
  { 136, 3, 5, 3, 0, -5 },
  { 138, 1, 7, 2, 0, -6 },
  { 139, 2, 3, 3, 0, -5 },
  { 140, 3, 1, 3, 0, 0 },
  { 141, 2, 1, 2, 0, -5 },
  { 142, 3, 4, 3, 0, -4 },
  { 144, 3, 5, 3, 0, -5 },
  { 146, 3, 4, 3, 0, -4 },
  { 148, 3, 5, 3, 0, -5 },
  { 150, 3, 4, 3, 0, -4 },
  { 152, 2, 5, 2, 0, -5 },
  { 154, 3, 5, 3, 0, -4 },
  { 156, 3, 5, 3, 0, -5 },
  { 158, 1, 5, 2, 0, -5 },
  { 159, 1, 7, 2, 0, -5 },
  { 160, 3, 5, 3, 0, -5 },
  { 162, 1, 5, 2, 0, -5 },
  { 163, 5, 4, 5, 0, -4 },
  { 166, 3, 4, 3, 0, -4 },
  { 168, 3, 4, 4, 0, -4 },
  { 170, 3, 5, 3, 0, -4 },
  { 172, 3, 5, 3, 0, -4 },
  { 174, 2, 4, 2, 0, -4 },
  { 175, 3, 4, 3, 0, -4 },
  { 177, 2, 5, 2, 0, -5 },
  { 179, 3, 4, 3, 0, -4 },
  { 181, 3, 4, 3, 0, -4 },
  { 183, 4, 4, 4, 0, -4 },
  { 185, 3, 4, 3, 0, -4 },
  { 187, 3, 6, 3, 0, -4 },
  { 190, 3, 4, 3, 0, -4 },
  { 192, 2, 6, 2, 0, -5 },
  { 194, 1, 6, 2, 0, -5 },
  { 195, 2, 6, 2, 0, -5 },
  { 197, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoCondensed_Medium7pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium7pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOCONDENSED_MEDIUM7PT7B_H_
