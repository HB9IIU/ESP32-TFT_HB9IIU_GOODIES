#ifndef _ROBOTOCONDENSED_MEDIUM47PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0x9E, 0x79, 0xE7, 0x80, 0x00, 0x00, 0x1E, 0xFF, 0xFF,
  0xFF, 0x78, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x03, 0xC3,
  0x80, 0x0F, 0x1E, 0x00, 0x38, 0x78, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x80,
  0x1E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xE3, 0xC0, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x0F, 0x0E, 0x00, 0x3C, 0x38,
  0x00, 0xF1, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1E, 0x00, 0x78, 0x70, 0x01,
  0xE1, 0xC0, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0x07, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC7, 0x80,
  0x0E, 0x1E, 0x00, 0x38, 0x78, 0x00, 0xE1, 0xE0, 0x07, 0x87, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87,
  0xFF, 0xF8, 0xFC, 0x3F, 0x1F, 0x03, 0xE7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF,
  0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xDF, 0x00, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xE7, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x78, 0xF0, 0x30, 0x3C, 0x1C,
  0x1E, 0x0F, 0x07, 0x07, 0x03, 0xC1, 0xC3, 0xC0, 0xF0, 0x70, 0xE0, 0x3C,
  0x1C, 0x78, 0x0F, 0x07, 0x1C, 0x01, 0xE3, 0xCF, 0x00, 0x7D, 0xF3, 0x80,
  0x0F, 0xF9, 0xE0, 0x03, 0xFC, 0xF0, 0x00, 0x3E, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x1F, 0x00, 0x03, 0xCF, 0xF0, 0x00, 0xE7, 0xFE, 0x00,
  0x7B, 0xE7, 0x80, 0x1C, 0xF0, 0xE0, 0x0F, 0x3C, 0x3C, 0x07, 0x8E, 0x0F,
  0x01, 0xC3, 0x83, 0xC0, 0xF0, 0xE0, 0xF0, 0x38, 0x38, 0x3C, 0x1E, 0x0F,
  0x0F, 0x07, 0x03, 0xC3, 0x80, 0x40, 0xF9, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x0F, 0x80,
  0x3F, 0x0F, 0x80, 0x3E, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x7C,
  0x3F, 0xF8, 0x7C, 0x7E, 0xFC, 0x7C, 0x7C, 0x7E, 0x7C, 0xFC, 0x3F, 0x7C,
  0xF8, 0x3F, 0xF8, 0xF8, 0x1F, 0xF8, 0xF8, 0x0F, 0xF8, 0xFC, 0x0F, 0xF0,
  0xFC, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFE, 0x7E, 0x03, 0xF8, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x18, 0x07, 0x01, 0xE0, 0x7C, 0x0F, 0x03,
  0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x78,
  0x0F, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x30, 0x02, 0x40, 0x0C, 0x03,
  0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x3E,
  0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78,
  0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0,
  0x18, 0x02, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x3C, 0x38, 0x77, 0xF7, 0x3F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0x3F, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF8,
  0x03, 0xEF, 0x80, 0xF8, 0xF0, 0x1E, 0x1F, 0x07, 0xC1, 0xF0, 0x70, 0x1C,
  0x00, 0x02, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9E, 0x7C, 0xFB, 0xE7, 0x82, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x79, 0xFB, 0xFF, 0xFF, 0xCF,
  0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7C, 0x1F, 0x9F,
  0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xEF, 0x80, 0xF9, 0xF8,
  0x1F, 0x1F, 0x07, 0xE3, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F,
  0xF0, 0x01, 0xF8, 0x00, 0x00, 0x30, 0x1F, 0x07, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xC3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xE0, 0xFC, 0x7C, 0x07, 0xCF,
  0xC0, 0x7E, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3E,
  0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0x7F, 0x07, 0xE7,
  0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7B, 0xF0, 0x07, 0xDF, 0x80, 0x3C, 0xFC, 0x03, 0xE7,
  0xE0, 0x1E, 0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0x0F, 0xC0, 0xF8, 0x7E, 0x07,
  0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xC0, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE3, 0xFB, 0xFC, 0x7C, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF7, 0xC0, 0x3E,
  0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xF0, 0x3F, 0x3F, 0x0F, 0xE7, 0xFF, 0xF8,
  0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0x80,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x7C, 0x0F, 0xBF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFE, 0x1F, 0xDF, 0x81, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x80, 0xF9,
  0xF0, 0x3F, 0x3F, 0x0F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80,
  0x7F, 0xE0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0xFC, 0x1F, 0x9F, 0x81, 0xF3, 0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9,
  0xF8, 0x1F, 0x3F, 0x03, 0xE3, 0xE0, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xFC, 0x7F, 0x3F, 0x03, 0xE7,
  0xC0, 0x7E, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xEF,
  0x80, 0xFD, 0xF0, 0x1F, 0xBF, 0x07, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x07,
  0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x80,
  0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFC, 0x3F, 0x1F, 0x83, 0xF3,
  0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x80, 0xFB, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0x3F, 0x7E, 0x0F, 0xEF,
  0xF7, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0x7C, 0x0F, 0xCF, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0x80, 0x00, 0x79, 0xFB, 0xF7, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xCF, 0xDF, 0xBF, 0x7E, 0x78,
  0x1E, 0x3F, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0x30, 0x00, 0x01, 0x00,
  0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFF, 0x1F, 0xF8, 0x7F,
  0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80,
  0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xE0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC0, 0xFF, 0x80, 0x7F,
  0x00, 0x3E, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xE7, 0xC0, 0xF9,
  0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0x3F, 0xC0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x1C, 0x1E, 0x01, 0xF0, 0x1E, 0x3C, 0x07, 0xFC, 0x0E, 0x3C,
  0x0F, 0xFE, 0x0E, 0x38, 0x0F, 0xFE, 0x0E, 0x78, 0x1E, 0x1E, 0x0F, 0x78,
  0x3E, 0x1E, 0x0F, 0x78, 0x3C, 0x1E, 0x0F, 0x70, 0x3C, 0x1E, 0x07, 0x70,
  0x78, 0x1E, 0x07, 0xF0, 0x78, 0x1E, 0x07, 0xF0, 0x78, 0x1E, 0x07, 0xF0,
  0x78, 0x1E, 0x07, 0xF0, 0x78, 0x1C, 0x0F, 0xF0, 0x78, 0x1C, 0x0F, 0xF0,
  0xF8, 0x3C, 0x0E, 0xF0, 0x78, 0x3C, 0x0E, 0xF0, 0x78, 0x3C, 0x0E, 0xF0,
  0x78, 0x3C, 0x1E, 0x70, 0x7C, 0x7C, 0x3C, 0x78, 0x7F, 0xFE, 0x7C, 0x78,
  0x3F, 0xDF, 0xF8, 0x78, 0x1F, 0x8F, 0xF0, 0x3C, 0x0F, 0x07, 0xC0, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x04, 0x00, 0x03,
  0xFE, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7D, 0xF0, 0x00,
  0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x7C,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xC1, 0xF8, 0x01, 0xF0,
  0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x03, 0xF0, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x7E, 0x00,
  0x1F, 0x1F, 0x80, 0x07, 0xE7, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3E, 0xFC,
  0x00, 0x0F, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7E, 0x03, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E,
  0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0,
  0x7E, 0x7E, 0x07, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x3F, 0x01, 0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0x7E, 0x00,
  0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xBF,
  0x00, 0xFD, 0xF8, 0x0F, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF0, 0x3F, 0x8F,
  0xC0, 0x3F, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF0,
  0x01, 0xFB, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x1F,
  0xBE, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xF8, 0xFC, 0x03, 0xF1,
  0xFC, 0x0F, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7E, 0x07, 0xF3, 0xF0, 0x0F, 0xDF,
  0x80, 0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xF7, 0xE0,
  0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x1F, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF3, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xF0, 0x3F, 0x8F,
  0xC0, 0x3F, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF0,
  0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x1F,
  0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF9,
  0xFC, 0x07, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFD, 0xF0, 0x1F, 0x3F, 0x07, 0xE7,
  0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00,
  0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xE7, 0xE0, 0x3F, 0x8F,
  0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC,
  0x3F, 0x01, 0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0xDF,
  0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFB, 0xF0, 0x0F, 0xE7, 0xF0,
  0x1F, 0xC7, 0xE0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x8F, 0xC0, 0x3F, 0x1F,
  0x80, 0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF7, 0xC0, 0x3F, 0xFF, 0xBE, 0x01,
  0xEF, 0xFD, 0xF0, 0x1F, 0x7F, 0xE7, 0xC0, 0xFB, 0xFF, 0x3E, 0x07, 0x9F,
  0xF9, 0xF0, 0x7C, 0xFF, 0xC7, 0xC3, 0xE7, 0xFE, 0x3E, 0x1E, 0x3F, 0xF9,
  0xF1, 0xF1, 0xFF, 0xC7, 0xCF, 0x8F, 0xFE, 0x3E, 0x78, 0x7F, 0xF1, 0xF7,
  0xC3, 0xFF, 0x87, 0xBE, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0x07,
  0xFF, 0x07, 0xF8, 0x3F, 0xF8, 0x3F, 0xC1, 0xFF, 0xC1, 0xFC, 0x0F, 0xFE,
  0x07, 0xE0, 0x7F, 0xF0, 0x3F, 0x03, 0xFF, 0x81, 0xF0, 0x1F, 0xFC, 0x07,
  0x80, 0xF8, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03,
  0xFF, 0xDF, 0x07, 0xFF, 0xBF, 0x0F, 0xFF, 0x3E, 0x1F, 0xFE, 0x7E, 0x3F,
  0xFC, 0x7C, 0x7F, 0xF8, 0xFC, 0xFF, 0xF0, 0xF9, 0xFF, 0xE1, 0xFB, 0xFF,
  0xC1, 0xF7, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x3E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x81,
  0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xBF,
  0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0xFE,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xF0, 0x1F,
  0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xF0, 0x07, 0xEF,
  0xC0, 0x1F, 0xBF, 0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0,
  0x7F, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01,
  0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x83, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x3F,
  0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xDF,
  0x80, 0x7E, 0xFE, 0x07, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x07, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3,
  0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E,
  0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F,
  0x80, 0x7C, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x07, 0xC1,
  0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01,
  0xF7, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xBE, 0x01, 0xF8, 0x07,
  0xDF, 0x00, 0xFC, 0x07, 0xEF, 0x80, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x01,
  0xFB, 0xF0, 0x3F, 0x80, 0xF8, 0xF8, 0x1F, 0xE0, 0x7C, 0x7C, 0x0F, 0xF0,
  0x3E, 0x3E, 0x07, 0xF8, 0x3F, 0x1F, 0x03, 0xFC, 0x1F, 0x8F, 0xC3, 0xFE,
  0x0F, 0x83, 0xE1, 0xFF, 0x87, 0xC1, 0xF0, 0xF7, 0xC3, 0xE0, 0xF8, 0x79,
  0xE1, 0xF0, 0x7C, 0x3C, 0xF1, 0xF8, 0x3E, 0x3E, 0x78, 0xF8, 0x1F, 0x9F,
  0x3E, 0x7C, 0x07, 0xCF, 0x1F, 0x3E, 0x03, 0xE7, 0x87, 0x9F, 0x01, 0xF3,
  0xC3, 0xCF, 0x80, 0xFB, 0xE1, 0xEF, 0xC0, 0x7D, 0xE0, 0xFF, 0xC0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03,
  0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0,
  0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x7F,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC,
  0x1F, 0x81, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x07, 0xE3, 0xF0,
  0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x03, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC3, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x81, 0xFC,
  0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7F,
  0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x01,
  0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7C,
  0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x03, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0x3F, 0x9F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0xFC, 0x3F, 0xFF, 0x3F, 0xFF,
  0xDF, 0xF3, 0xF7, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7F, 0xFF, 0x7F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F,
  0x9F, 0x0F, 0xC7, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x8F, 0x83, 0xEF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFB, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3E, 0xFF, 0x8F, 0x8F, 0x80, 0x03,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0x83,
  0xF7, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x07, 0xFF, 0x01, 0xF7, 0xC0, 0x7D, 0xF8, 0x3F, 0x7F, 0xBF, 0x8F, 0xFF,
  0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x9F, 0x8F, 0xFB,
  0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xF0, 0x7F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x1F, 0xDF, 0xFF, 0xF9, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE3, 0xFE, 0x7C, 0x1F, 0x8F, 0x80, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFC, 0x1F, 0x9F, 0x01,
  0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x04, 0x3F, 0x01, 0xC7, 0xFD, 0xFC, 0x7F, 0xFF,
  0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xF0,
  0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE1, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE3,
  0xE3, 0xFF, 0x7C, 0xFF, 0xEF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFC, 0x1F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xBF, 0x07, 0xF7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xBF, 0x07, 0xE7, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF1, 0x00, 0x7C, 0x30, 0x1F, 0x8F, 0xCF, 0xF1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x3E, 0x1F, 0x7F, 0xCF,
  0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xE0, 0x73, 0xEF, 0xFF, 0xF9, 0xC0, 0x00, 0x00, 0x0F, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0x80, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x3F, 0xFF, 0xFF, 0xBF, 0xDF, 0xCF, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x7F, 0x7C, 0x1F, 0xCF,
  0x83, 0xF1, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xC7, 0xE0, 0xF9, 0xF8, 0x1F,
  0x3E, 0x03, 0xEF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0x9F, 0x03, 0xE3, 0xF0, 0x7C,
  0x3E, 0x0F, 0x87, 0xE1, 0xF0, 0x7E, 0x3E, 0x0F, 0xC7, 0xC0, 0xFC, 0xF8,
  0x1F, 0x9F, 0x01, 0xFB, 0xE0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0xF8, 0x0F, 0x87, 0xDF, 0xF1, 0xFF,
  0x3F, 0xFF, 0xDF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xE0, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0x01, 0xF0, 0x1F, 0xF8, 0x0F,
  0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x01,
  0xFF, 0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x7F, 0xE0, 0x3E, 0x03, 0xFF,
  0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03,
  0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xC0,
  0x7F, 0xE0, 0x3E, 0x03, 0xFF, 0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xF8,
  0xF8, 0xF8, 0x7D, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xE0, 0xFC, 0x7C, 0x07, 0xEF,
  0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xFC, 0x03,
  0xEF, 0xC0, 0x3E, 0x7C, 0x07, 0xE7, 0xE0, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xF8, 0xF8, 0x3E,
  0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFF, 0x7F, 0xBF, 0xFF, 0xEF, 0xFF,
  0xF3, 0xEF, 0xF8, 0xF8, 0xF8, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE3, 0xE3, 0xFE, 0x7C, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xBF, 0x07, 0xF7, 0xFB, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xBF, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xF3, 0xFB, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0x7C, 0x00, 0x3F, 0x80,
  0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xF7, 0xF3, 0xFB,
  0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8,
  0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x03, 0xF0, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x83, 0xFF, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xDF, 0x0F,
  0x8F, 0x80, 0xF8, 0x07, 0xFF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xE7,
  0xC0, 0xF8, 0xFC, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x03,
  0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF3, 0xE0, 0x1E, 0x7C, 0x03,
  0xEF, 0x80, 0x7D, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0x7C, 0x1F, 0x83,
  0xF7, 0xC1, 0xF8, 0x3E, 0x7C, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x3E, 0x7C,
  0x3F, 0xC3, 0xE3, 0xE3, 0xFC, 0x3C, 0x3E, 0x3F, 0xC7, 0xC3, 0xE3, 0xFC,
  0x7C, 0x3E, 0x7F, 0xE7, 0xC1, 0xE7, 0x9E, 0x7C, 0x1F, 0x79, 0xE7, 0x81,
  0xF7, 0x9E, 0xF8, 0x1F, 0xF9, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x07, 0xF0,
  0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x7C,
  0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0xFC, 0x07, 0xEF, 0xC1, 0xF9, 0xF8,
  0x3F, 0x1F, 0x8F, 0xC3, 0xF1, 0xF0, 0x3F, 0x3E, 0x03, 0xEF, 0x80, 0x7F,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xF7,
  0xC0, 0x7E, 0xFC, 0x0F, 0x8F, 0x83, 0xF1, 0xF8, 0x7C, 0x1F, 0x1F, 0x83,
  0xF3, 0xF0, 0x7E, 0xFC, 0x07, 0xE0, 0xF8, 0x07, 0xFF, 0x80, 0xFB, 0xF0,
  0x3F, 0x3E, 0x07, 0xE7, 0xC0, 0xF8, 0xFC, 0x1F, 0x1F, 0x87, 0xE1, 0xF0,
  0xFC, 0x3E, 0x1F, 0x07, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x9F, 0x01, 0xF3,
  0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x20, 0x0F, 0x01, 0xF0, 0x3F, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x3F, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFE, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x07, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0,
  0x7F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x07, 0x00, 0x40, 0x00,
  0x0F, 0x00, 0x01, 0xFE, 0x03, 0xDF, 0xF8, 0x1E, 0xFF, 0xE0, 0xFF, 0xFF,
  0x8F, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xDE, 0x07, 0xFC, 0xF0, 0x1F, 0xE0,
  0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_Medium47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 33, 12, 3, -33 },
  { 26, 11, 12, 15, 2, -35 },
  { 43, 22, 33, 25, 2, -33 },
  { 134, 19, 42, 24, 2, -38 },
  { 234, 26, 33, 30, 2, -33 },
  { 342, 24, 33, 26, 2, -33 },
  { 441, 4, 12, 8, 2, -35 },
  { 447, 11, 48, 15, 3, -37 },
  { 513, 11, 48, 15, 1, -37 },
  { 579, 19, 20, 21, 1, -33 },
  { 627, 19, 24, 23, 2, -27 },
  { 684, 7, 13, 10, 1, -5 },
  { 696, 10, 5, 15, 2, -17 },
  { 703, 7, 6, 13, 3, -6 },
  { 709, 15, 36, 16, 0, -33 },
  { 777, 19, 33, 24, 2, -33 },
  { 856, 12, 33, 24, 4, -33 },
  { 906, 20, 33, 24, 2, -33 },
  { 989, 19, 33, 24, 2, -33 },
  { 1068, 21, 33, 24, 1, -33 },
  { 1155, 19, 33, 24, 3, -33 },
  { 1234, 19, 33, 24, 3, -33 },
  { 1313, 19, 33, 24, 2, -33 },
  { 1392, 19, 33, 24, 2, -33 },
  { 1471, 19, 33, 24, 2, -33 },
  { 1550, 7, 25, 12, 3, -25 },
  { 1572, 8, 33, 11, 1, -25 },
  { 1605, 16, 21, 21, 2, -25 },
  { 1647, 17, 15, 23, 3, -23 },
  { 1679, 17, 21, 21, 3, -25 },
  { 1724, 18, 33, 21, 1, -33 },
  { 1799, 32, 43, 36, 2, -33 },
  { 1971, 26, 33, 28, 1, -33 },
  { 2079, 21, 33, 26, 3, -33 },
  { 2166, 23, 33, 27, 2, -33 },
  { 2261, 21, 33, 27, 3, -33 },
  { 2348, 19, 33, 23, 3, -33 },
  { 2427, 18, 33, 22, 3, -33 },
  { 2502, 23, 33, 28, 2, -33 },
  { 2597, 23, 33, 29, 3, -33 },
  { 2692, 6, 33, 12, 3, -33 },
  { 2717, 19, 33, 23, 1, -33 },
  { 2796, 23, 33, 26, 3, -33 },
  { 2891, 18, 33, 22, 3, -33 },
  { 2966, 29, 33, 36, 3, -33 },
  { 3086, 23, 33, 29, 3, -33 },
  { 3181, 24, 33, 28, 2, -33 },
  { 3280, 22, 33, 26, 3, -33 },
  { 3371, 24, 39, 28, 2, -33 },
  { 3488, 22, 33, 26, 3, -33 },
  { 3579, 21, 33, 25, 2, -33 },
  { 3666, 23, 33, 25, 1, -33 },
  { 3761, 21, 33, 27, 3, -33 },
  { 3848, 25, 33, 27, 1, -33 },
  { 3952, 33, 33, 35, 1, -33 },
  { 4089, 24, 33, 26, 1, -33 },
  { 4188, 25, 33, 25, 0, -33 },
  { 4292, 21, 33, 25, 2, -33 },
  { 4379, 8, 47, 12, 3, -39 },
  { 4426, 17, 36, 18, 1, -33 },
  { 4503, 8, 47, 12, 1, -39 },
  { 4550, 16, 17, 18, 1, -33 },
  { 4584, 17, 4, 19, 1, 0 },
  { 4593, 11, 7, 15, 1, -35 },
  { 4603, 18, 25, 22, 2, -25 },
  { 4660, 18, 35, 23, 3, -35 },
  { 4739, 18, 25, 22, 2, -25 },
  { 4796, 19, 35, 23, 2, -35 },
  { 4880, 19, 25, 22, 2, -25 },
  { 4940, 14, 35, 15, 1, -35 },
  { 5002, 19, 35, 23, 2, -25 },
  { 5086, 17, 35, 23, 3, -35 },
  { 5161, 6, 35, 11, 3, -35 },
  { 5188, 9, 45, 11, -1, -35 },
  { 5239, 19, 35, 22, 3, -35 },
  { 5323, 5, 35, 11, 3, -35 },
  { 5345, 29, 25, 35, 3, -25 },
  { 5436, 17, 25, 23, 3, -25 },
  { 5490, 20, 25, 23, 2, -25 },
  { 5553, 18, 35, 23, 3, -25 },
  { 5632, 19, 35, 23, 2, -25 },
  { 5716, 11, 25, 15, 3, -25 },
  { 5751, 17, 25, 21, 2, -25 },
  { 5805, 12, 31, 14, 1, -31 },
  { 5852, 17, 25, 23, 3, -25 },
  { 5906, 19, 25, 21, 1, -25 },
  { 5966, 28, 25, 30, 1, -25 },
  { 6054, 19, 25, 21, 1, -25 },
  { 6114, 19, 35, 20, 1, -25 },
  { 6198, 17, 25, 21, 2, -25 },
  { 6252, 12, 45, 14, 1, -37 },
  { 6320, 4, 39, 12, 4, -33 },
  { 6340, 12, 45, 14, 1, -37 },
  { 6408, 21, 10, 27, 3, -19 },
};

const GFXfont RobotoCondensed_Medium47pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium47pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium47pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOCONDENSED_MEDIUM47PT7B_H_
