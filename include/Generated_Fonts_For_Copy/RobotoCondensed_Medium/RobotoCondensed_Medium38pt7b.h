#ifndef _ROBOTOCONDENSED_MEDIUM38PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xEF, 0xFF, 0xE0, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x77, 0x3B, 0x9D, 0xCE,
  0xE7, 0x63, 0x80, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0,
  0x38, 0xE0, 0x18, 0x60, 0x1C, 0x70, 0x0E, 0x38, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xE0, 0xE3, 0x80, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C,
  0x70, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC3, 0x8E, 0x01, 0xC7, 0x00,
  0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x18, 0x60, 0x1C, 0x70, 0x0E, 0x38,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x7E, 0x03, 0xFE,
  0x0F, 0xFE, 0x1F, 0xFE, 0x7C, 0x7C, 0xF0, 0x7D, 0xE0, 0xFB, 0xC0, 0xF7,
  0x81, 0xEF, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xF0, 0x7D, 0xF0, 0xFB, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0x01, 0xF8, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x0E, 0x38, 0x30, 0xE1, 0xC3, 0x8E, 0x1C, 0x70, 0xE1, 0xC6,
  0x0E, 0x1C, 0xE0, 0xE1, 0xDC, 0x0E, 0x39, 0xC0, 0x7F, 0xB8, 0x07, 0xF3,
  0x80, 0x1E, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE7, 0xC0, 0x0E, 0xFE, 0x01,
  0xDF, 0xF0, 0x19, 0xC7, 0x03, 0x9C, 0x70, 0x31, 0xC3, 0x07, 0x1C, 0x30,
  0xE1, 0xC3, 0x0E, 0x1C, 0x70, 0xC1, 0xC7, 0x00, 0x1F, 0xF0, 0x00, 0xFE,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFC,
  0x03, 0xC7, 0x80, 0x78, 0x70, 0x1E, 0x0E, 0x01, 0xE1, 0xC0, 0x3C, 0x78,
  0x07, 0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xF0, 0xE3, 0xFF, 0x1C, 0xF9, 0xE7, 0x9E, 0x3E, 0xF3, 0xC3, 0xFE,
  0x78, 0x3F, 0xCF, 0x07, 0xF1, 0xE0, 0x7E, 0x3E, 0x0F, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFF, 0x87, 0xFE, 0xF8, 0x3F, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0x01, 0xC0, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC0, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x38,
  0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x04, 0x40, 0x70, 0x3C, 0x0E,
  0x07, 0x81, 0xE0, 0x70, 0x3C, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x38,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1C, 0x1E, 0x0E, 0x0E,
  0x0F, 0x07, 0x01, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x08,
  0x38, 0x3E, 0x73, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x0F, 0x80, 0x3F,
  0x80, 0xF7, 0x01, 0xC7, 0x07, 0x8F, 0x0E, 0x0E, 0x00, 0x10, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x7D, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0xF3, 0x86, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x79, 0xFF, 0xDF, 0x78, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7,
  0xCF, 0x07, 0xBE, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x83, 0xEF, 0x07, 0x9F, 0x1F, 0x3F, 0xFE,
  0x3F, 0xF8, 0x3F, 0xE0, 0x1F, 0x00, 0x00, 0xC0, 0xF1, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC,
  0xF8, 0x7C, 0xF8, 0x3E, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0,
  0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xEF, 0x87, 0xDE, 0x07, 0xBC, 0x0F, 0x00,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE,
  0x03, 0xFE, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0xFF,
  0x03, 0xFE, 0x07, 0xFE, 0x1F, 0x3F, 0xFE, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0x78, 0x07, 0xBC, 0x03, 0x9E, 0x03, 0xCF,
  0x01, 0xC7, 0x81, 0xE3, 0xC0, 0xE1, 0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x78,
  0x3C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x3F,
  0xFE, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF7, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xC7,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0x80,
  0xFF, 0x81, 0xEF, 0x07, 0xDF, 0x0F, 0xBF, 0xFE, 0x3F, 0xF8, 0x3F, 0xE0,
  0x1F, 0x80, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF3, 0xC3, 0xFF, 0xE7, 0xFF,
  0xEF, 0xFF, 0xDF, 0x87, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xF7, 0x81, 0xEF, 0x07, 0xDF, 0x0F, 0x9F, 0xFE, 0x1F,
  0xF8, 0x1F, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xCF, 0x07, 0xBE, 0x0F,
  0x7C, 0x1F, 0x78, 0x3C, 0xF0, 0x79, 0xF1, 0xF1, 0xFF, 0xC1, 0xFF, 0x03,
  0xFE, 0x0F, 0xFE, 0x3E, 0x3E, 0x78, 0x3D, 0xF0, 0x7F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x0F, 0xBF, 0xFE, 0x3F, 0xF8, 0x3F, 0xE0,
  0x3F, 0x00, 0x07, 0xC0, 0x3F, 0xC0, 0xFF, 0xC3, 0xFF, 0xC7, 0x87, 0xDF,
  0x07, 0xBC, 0x0F, 0x78, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x83, 0xFF, 0x0F, 0xDF, 0xFF, 0xBF, 0xFF, 0x3F, 0xFE, 0x1E, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x0F, 0xF8, 0x1F,
  0xE0, 0x3F, 0x80, 0x78, 0x00, 0x79, 0xEF, 0xDE, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x79, 0xFF, 0xDF, 0x78, 0x39, 0xF7, 0xDF,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xCF,
  0x3C, 0xF3, 0xDE, 0x79, 0xCF, 0x08, 0x00, 0x08, 0x01, 0xC0, 0x1E, 0x03,
  0xF0, 0x7F, 0x8F, 0xF1, 0xFE, 0x1F, 0xC0, 0xF8, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFC, 0x01, 0xE0, 0x03, 0x00, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x3C, 0x07, 0xF0,
  0x7F, 0x87, 0xF8, 0x7F, 0x83, 0xF8, 0x0F, 0x80, 0x38, 0x00, 0x80, 0x00,
  0x0F, 0xC0, 0xFF, 0xC3, 0xFF, 0x9F, 0xFE, 0x78, 0x7F, 0xE1, 0xFF, 0x83,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x70, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x01,
  0xF0, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x1C, 0x38, 0x1F, 0x03, 0x9C, 0x0F, 0xF0, 0xE7, 0x07, 0xFC, 0x39,
  0xC3, 0xC7, 0x0E, 0xE0, 0xE1, 0xC1, 0xB8, 0x38, 0x70, 0x6E, 0x1E, 0x1C,
  0x1B, 0x87, 0x07, 0x06, 0xE1, 0xC1, 0xC1, 0xB8, 0x70, 0x70, 0x6E, 0x3C,
  0x1C, 0x3B, 0x8F, 0x07, 0x0E, 0xE1, 0xC3, 0xC3, 0xB8, 0x70, 0xF0, 0xCE,
  0x1E, 0x7C, 0x73, 0x87, 0xFF, 0xF8, 0xF0, 0xFD, 0xFE, 0x1C, 0x1E, 0x1E,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x0C, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7B, 0xC0,
  0x07, 0xDE, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0xC0, 0x0F, 0x1E, 0x00, 0xF0,
  0xF0, 0x07, 0x87, 0x80, 0x3C, 0x1E, 0x03, 0xE0, 0xF0, 0x1E, 0x07, 0x80,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3E, 0x01,
  0xF1, 0xF0, 0x07, 0x8F, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xBC,
  0x00, 0x3E, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x3E,
  0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E,
  0xF0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7E, 0x0F, 0x9F, 0x01, 0xF7, 0x80, 0x7F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x3F, 0xE0, 0x0F, 0x78, 0x07, 0xDF, 0x01, 0xF7, 0xE0, 0xF8,
  0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0x03, 0xE7, 0x80, 0xF3, 0xC0, 0x7D,
  0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xBC,
  0x03, 0xDE, 0x01, 0xEF, 0x01, 0xF7, 0x80, 0xF3, 0xC1, 0xF9, 0xFF, 0xF8,
  0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF,
  0xF7, 0xFF, 0xEF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xF8,
  0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7E, 0x0F, 0x9F, 0x01, 0xF7,
  0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0x78, 0x03, 0xDF, 0x00, 0xF7,
  0xE0, 0x7C, 0xFF, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xC0, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x1F, 0x3F, 0xFE, 0x3F,
  0xF8, 0x3F, 0xE0, 0x3F, 0x00, 0xF0, 0x0F, 0xBC, 0x07, 0xCF, 0x03, 0xF3,
  0xC0, 0xF8, 0xF0, 0x7C, 0x3C, 0x1F, 0x0F, 0x0F, 0x83, 0xC7, 0xC0, 0xF1,
  0xF0, 0x3C, 0xF8, 0x0F, 0x7C, 0x03, 0xDF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFD, 0xF0, 0x3E, 0x7E, 0x0F, 0x0F, 0x83,
  0xC1, 0xF0, 0xF0, 0x7C, 0x3C, 0x0F, 0x8F, 0x03, 0xE3, 0xC0, 0x7C, 0xF0,
  0x1F, 0x3C, 0x03, 0xEF, 0x00, 0xFC, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xBF, 0xFC,
  0x0F, 0x7F, 0xBC, 0x1E, 0xFF, 0x78, 0x3D, 0xFE, 0xF0, 0xF3, 0xFC, 0xF1,
  0xE7, 0xF9, 0xE3, 0xCF, 0xF3, 0xCF, 0x1F, 0xE3, 0xDE, 0x3F, 0xC7, 0xBC,
  0x7F, 0x8F, 0x70, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x07,
  0xF8, 0x3E, 0x0F, 0xF0, 0x7C, 0x1F, 0xE0, 0xF8, 0x3F, 0xC0, 0xE0, 0x78,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFD, 0xE1, 0xFF, 0x78,
  0x7F, 0xCF, 0x1F, 0xF3, 0xC7, 0xFC, 0x79, 0xFF, 0x1E, 0x7F, 0xC3, 0xDF,
  0xF0, 0xF7, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x7C, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0,
  0xF8, 0xF8, 0x0F, 0x9E, 0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xF7, 0x80, 0x3C, 0xF8, 0x0F, 0x9F, 0x83, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF,
  0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF,
  0x9F, 0xFF, 0xEF, 0x01, 0xF7, 0x80, 0x7B, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xF7, 0xFF, 0xFB,
  0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC7, 0xE0, 0xF8, 0xF8, 0x0F, 0x9E, 0x01, 0xF7, 0xC0, 0x1E, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xE7, 0x80, 0x7C, 0xF8, 0x0F, 0x9F, 0x83, 0xE1, 0xFF,
  0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x04, 0xFF, 0xE0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x03, 0xE7, 0x80, 0xFB, 0xC0, 0x7D, 0xE0,
  0x3E, 0xF0, 0x0F, 0x78, 0x0F, 0xBC, 0x07, 0xDE, 0x03, 0xEF, 0x03, 0xE7,
  0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x78, 0x7C, 0x3C, 0x3E,
  0x1E, 0x0F, 0x8F, 0x07, 0xC7, 0x81, 0xF3, 0xC0, 0xF9, 0xE0, 0x3C, 0xF0,
  0x1F, 0x78, 0x0F, 0xBC, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3E, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0x79, 0xF0, 0x1F,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xEF, 0x80,
  0x7D, 0xE0, 0x1F, 0x78, 0x07, 0xDF, 0x01, 0xE7, 0xE0, 0xF8, 0xFF, 0xFE,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7D, 0xF0, 0x3E, 0xFF, 0xFE, 0x3F,
  0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xE7, 0x80, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x3C, 0x07, 0xC3,
  0xC0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x78, 0x1E, 0x0F, 0x81, 0xE0, 0xF8,
  0x1F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x9E,
  0x00, 0x79, 0xE0, 0x07, 0xBE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0xF8, 0x1E, 0x03, 0xFF, 0x03, 0xE0, 0x7D, 0xE0, 0x7C, 0x0F,
  0x3C, 0x0F, 0x81, 0xE7, 0x81, 0xF0, 0x3C, 0xF0, 0x7E, 0x0F, 0x9F, 0x0F,
  0xE1, 0xF3, 0xE1, 0xFC, 0x3C, 0x3C, 0x3B, 0x87, 0x87, 0x87, 0x70, 0xF0,
  0xF1, 0xEE, 0x1E, 0x1E, 0x3D, 0xE7, 0xC3, 0xE7, 0xBC, 0xF0, 0x3C, 0xE3,
  0x9E, 0x07, 0x9C, 0x73, 0xC0, 0xF7, 0x8F, 0x78, 0x1E, 0xF1, 0xEF, 0x03,
  0xDE, 0x3D, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F,
  0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x03, 0xE0, 0x07,
  0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x03,
  0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x1E,
  0x07, 0xC7, 0xC0, 0x7C, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xFC, 0x00, 0xF7, 0x80, 0x3E, 0xF8, 0x07, 0x8F, 0x01, 0xF1, 0xF0,
  0x3E, 0x1E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x7C, 0x07, 0xCF, 0x80, 0xFB,
  0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0,
  0x3C, 0x3E, 0x07, 0xC1, 0xE0, 0x78, 0x1F, 0x0F, 0x80, 0xF0, 0xF8, 0x0F,
  0x8F, 0x00, 0x79, 0xF0, 0x07, 0x9E, 0x00, 0x7D, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0x00,
  0xF0, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xDC, 0x3D, 0xC3, 0x9C, 0x39, 0xE7,
  0x8E, 0x70, 0xF7, 0x0F, 0xF0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x38, 0x0F, 0xC0, 0xFF,
  0xC7, 0xFF, 0x9F, 0xFE, 0xF8, 0x7F, 0xC1, 0xF0, 0x07, 0xC0, 0x1F, 0x0F,
  0xFC, 0xFF, 0xF7, 0xFF, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xFF, 0xFD, 0xFF, 0xF7, 0xFB, 0xC7, 0xCF, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF7, 0xC3, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xDF, 0x07, 0xFE, 0x0F,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xFF, 0xFB, 0xFF, 0xF7, 0xBF,
  0xCF, 0x1E, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0xF8, 0x7F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0xFF, 0x03, 0xFE, 0x1F, 0x7F, 0xF9, 0xFF, 0xE3, 0xFF,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x0F, 0x9F, 0x1F, 0xFF,
  0x3F, 0xFF, 0x7F, 0xFF, 0x7C, 0x3F, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x78, 0x1F,
  0x78, 0x1F, 0x7C, 0x3F, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xEF, 0x07, 0x8F,
  0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xEF, 0x83, 0xDF, 0x07, 0xBC,
  0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x02, 0x7C, 0x0C, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0,
  0x3F, 0x00, 0x03, 0xE1, 0xFC, 0x3F, 0x8F, 0xF1, 0xF0, 0x3C, 0x0F, 0x81,
  0xF0, 0x3E, 0x1F, 0xFB, 0xFF, 0x7F, 0xE3, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x0F, 0x9E, 0x7F, 0xBD, 0xFF, 0xFB,
  0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x1F,
  0x7F, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7D, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x98, 0x3E, 0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC7, 0x8F, 0x7F, 0xBF, 0xFE, 0xFF, 0xFF, 0xE1, 0xFF,
  0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3C, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x1F, 0x1F, 0x1F,
  0x0E, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0xFE, 0xFE, 0xFC, 0xF8, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xF8, 0xF9, 0xF0, 0xF9, 0xF0,
  0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xE0, 0xF9, 0xE0, 0xF9, 0xF0, 0xF8, 0xF0, 0xF8, 0xF8, 0xF8, 0x7C,
  0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF1, 0xE0, 0xF8, 0xF7, 0xF9, 0xFE, 0xFF, 0xFB, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7E, 0x1F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C,
  0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C,
  0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C,
  0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C,
  0x0F, 0xF1, 0xE3, 0xDF, 0xEF, 0xFF, 0xBF, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xEF, 0x83, 0xFF, 0x07, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0x7F, 0xFC, 0x7F, 0xF0, 0x7F, 0xC0,
  0x3F, 0x00, 0xF3, 0xE1, 0xEF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0x83, 0xFF,
  0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xFD, 0xFF, 0xFB,
  0xFF, 0xE7, 0xDF, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0xCF, 0x1F, 0xEF, 0x3F,
  0xFF, 0x7F, 0xFF, 0x7C, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x78,
  0x1F, 0x7C, 0x1F, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0x9F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0xF3, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xF7, 0xE7, 0x83, 0xCF,
  0x07, 0xDF, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x0F,
  0xE0, 0x07, 0xDF, 0x07, 0xDE, 0x0F, 0xBC, 0x1F, 0x7F, 0xFC, 0x7F, 0xF8,
  0x7F, 0xE0, 0x3F, 0x00, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x3F, 0xFF,
  0xFF, 0xFF, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xF0, 0xFC, 0x3F, 0x07, 0xC0,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x83, 0xFE, 0x1F, 0x7F, 0xFD, 0xFF, 0xF3, 0xFF, 0xC7, 0xCF, 0xF0,
  0x3F, 0xE0, 0x7F, 0xE0, 0xF3, 0xC1, 0xE7, 0x87, 0xCF, 0x0F, 0x0F, 0x1E,
  0x1E, 0x3C, 0x3C, 0x78, 0x79, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF0, 0x78, 0x3D, 0xE0, 0xF0, 0x7B, 0xC1, 0xE0, 0xF3, 0xC3, 0xE1,
  0xE7, 0x8F, 0xC7, 0xCF, 0x1F, 0x8F, 0x1E, 0x3F, 0x1E, 0x3C, 0x7F, 0x3C,
  0x3D, 0xFE, 0x78, 0x7B, 0xDC, 0xE0, 0xF7, 0x3B, 0xC1, 0xEE, 0x7F, 0x81,
  0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F,
  0x83, 0xE0, 0x1E, 0x07, 0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF8,
  0x3E, 0xF0, 0x79, 0xF1, 0xF1, 0xE3, 0xC3, 0xEF, 0x83, 0xDE, 0x07, 0xFC,
  0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x03,
  0xFE, 0x07, 0xBC, 0x1F, 0x7C, 0x3C, 0x78, 0xF8, 0xF9, 0xE0, 0xF7, 0xC1,
  0xF0, 0x78, 0x1F, 0x7C, 0x1E, 0x7C, 0x1E, 0x3C, 0x3E, 0x3C, 0x3E, 0x3C,
  0x3C, 0x3E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0,
  0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0xE0, 0x7C, 0x3C, 0x0F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x03, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x03,
  0xC0, 0x7C, 0x0E, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x1F,
  0x07, 0xC1, 0xE1, 0xF1, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x3E, 0x1E, 0x04, 0x00, 0x1E,
  0x00, 0x0F, 0xE0, 0xF7, 0xFC, 0x3D, 0xFF, 0x8E, 0xF1, 0xFF, 0xBC, 0x3F,
  0xEE, 0x07, 0xF0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_Medium38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 27, 10, 3, -27 },
  { 15, 9, 10, 12, 2, -29 },
  { 27, 17, 27, 20, 2, -27 },
  { 85, 15, 35, 19, 2, -31 },
  { 151, 20, 27, 24, 2, -27 },
  { 219, 19, 27, 21, 2, -27 },
  { 284, 3, 10, 6, 2, -29 },
  { 288, 9, 39, 12, 2, -30 },
  { 332, 9, 39, 12, 1, -30 },
  { 376, 15, 16, 17, 1, -27 },
  { 406, 16, 20, 18, 1, -23 },
  { 446, 6, 11, 8, 1, -4 },
  { 455, 8, 4, 12, 2, -14 },
  { 459, 6, 5, 11, 2, -5 },
  { 463, 12, 29, 13, 0, -27 },
  { 507, 15, 27, 19, 2, -27 },
  { 558, 10, 27, 19, 3, -27 },
  { 592, 16, 27, 19, 2, -27 },
  { 646, 15, 27, 19, 2, -27 },
  { 697, 17, 27, 19, 1, -27 },
  { 755, 15, 27, 19, 2, -27 },
  { 806, 15, 27, 19, 2, -27 },
  { 857, 16, 27, 19, 1, -27 },
  { 911, 15, 27, 19, 2, -27 },
  { 962, 15, 27, 19, 2, -27 },
  { 1013, 6, 21, 10, 2, -21 },
  { 1029, 6, 28, 9, 1, -21 },
  { 1050, 13, 17, 17, 1, -20 },
  { 1078, 13, 12, 19, 3, -18 },
  { 1098, 14, 17, 17, 2, -20 },
  { 1128, 14, 27, 17, 1, -27 },
  { 1176, 26, 34, 29, 2, -26 },
  { 1287, 21, 27, 22, 1, -27 },
  { 1358, 16, 27, 21, 3, -27 },
  { 1412, 18, 27, 22, 2, -27 },
  { 1473, 17, 27, 22, 3, -27 },
  { 1531, 15, 27, 19, 3, -27 },
  { 1582, 14, 27, 18, 3, -27 },
  { 1630, 18, 27, 22, 2, -27 },
  { 1691, 18, 27, 23, 3, -27 },
  { 1752, 4, 27, 10, 3, -27 },
  { 1766, 15, 27, 19, 1, -27 },
  { 1817, 18, 27, 21, 3, -27 },
  { 1878, 14, 27, 18, 3, -27 },
  { 1926, 23, 27, 29, 3, -27 },
  { 2004, 18, 27, 23, 3, -27 },
  { 2065, 19, 27, 23, 2, -27 },
  { 2130, 17, 27, 21, 3, -27 },
  { 2188, 19, 32, 23, 2, -27 },
  { 2264, 17, 27, 21, 3, -27 },
  { 2322, 18, 27, 20, 1, -27 },
  { 2383, 18, 27, 20, 1, -27 },
  { 2444, 17, 27, 22, 2, -27 },
  { 2502, 20, 27, 22, 1, -27 },
  { 2570, 27, 27, 29, 1, -27 },
  { 2662, 19, 27, 21, 1, -27 },
  { 2727, 20, 27, 20, 0, -27 },
  { 2795, 17, 27, 20, 2, -27 },
  { 2853, 7, 37, 10, 2, -31 },
  { 2886, 13, 29, 14, 1, -27 },
  { 2934, 6, 37, 10, 1, -31 },
  { 2962, 12, 13, 15, 1, -27 },
  { 2982, 15, 4, 15, 0, 0 },
  { 2990, 9, 6, 12, 1, -29 },
  { 2997, 14, 20, 18, 2, -20 },
  { 3032, 15, 29, 19, 2, -29 },
  { 3087, 14, 20, 18, 2, -20 },
  { 3122, 16, 29, 19, 1, -29 },
  { 3180, 15, 20, 18, 2, -20 },
  { 3218, 11, 29, 12, 1, -29 },
  { 3258, 15, 28, 19, 2, -20 },
  { 3311, 14, 29, 19, 2, -29 },
  { 3362, 5, 28, 9, 2, -28 },
  { 3380, 8, 36, 9, -1, -28 },
  { 3416, 16, 29, 18, 2, -29 },
  { 3474, 5, 29, 9, 2, -29 },
  { 3493, 24, 20, 28, 2, -20 },
  { 3553, 14, 20, 19, 2, -20 },
  { 3588, 15, 20, 19, 2, -20 },
  { 3626, 15, 28, 19, 2, -20 },
  { 3679, 16, 28, 19, 1, -20 },
  { 3735, 9, 20, 12, 2, -20 },
  { 3758, 15, 20, 17, 1, -20 },
  { 3796, 10, 25, 11, 0, -25 },
  { 3828, 14, 20, 19, 2, -20 },
  { 3863, 15, 20, 17, 1, -20 },
  { 3901, 23, 20, 24, 1, -20 },
  { 3959, 15, 20, 17, 1, -20 },
  { 3997, 16, 28, 16, 0, -20 },
  { 4053, 13, 20, 17, 2, -20 },
  { 4086, 10, 37, 11, 1, -30 },
  { 4133, 3, 32, 9, 3, -27 },
  { 4145, 9, 37, 11, 1, -30 },
  { 4187, 18, 8, 22, 2, -15 },
};

const GFXfont RobotoCondensed_Medium38pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium38pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium38pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOCONDENSED_MEDIUM38PT7B_H_
