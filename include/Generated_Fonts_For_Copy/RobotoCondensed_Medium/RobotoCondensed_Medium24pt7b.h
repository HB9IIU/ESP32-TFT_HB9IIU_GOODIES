#ifndef _ROBOTOCONDENSED_MEDIUM24PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x6D, 0xB6, 0xDB, 0x60, 0x37, 0xC0, 0xCF, 0x3C, 0xF3, 0xCB,
  0x20, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x40, 0x98, 0xFF, 0xDF, 0xF8, 0xCC,
  0x19, 0x83, 0x23, 0xFF, 0x7F, 0xE3, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x32,
  0x00, 0x0C, 0x03, 0x00, 0xC0, 0x78, 0x3F, 0x1E, 0xE7, 0x19, 0x87, 0x71,
  0xDC, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xE0, 0x1F, 0x87, 0xE1, 0xDC, 0xE7,
  0xF8, 0x78, 0x0C, 0x03, 0x00, 0x38, 0x03, 0xE0, 0x33, 0x19, 0x88, 0x8C,
  0xCC, 0x66, 0xC1, 0xF6, 0x07, 0x60, 0x03, 0x00, 0x37, 0x81, 0xFE, 0x1B,
  0x30, 0x99, 0x8C, 0xCC, 0x46, 0x60, 0x3F, 0x00, 0xF0, 0x1E, 0x03, 0xF0,
  0x73, 0x87, 0x38, 0x73, 0x87, 0x30, 0x3F, 0x03, 0xE0, 0x3C, 0x07, 0xE6,
  0xE7, 0x6E, 0x76, 0xE3, 0xEE, 0x1C, 0xF3, 0xC7, 0xFE, 0x3E, 0x70, 0xFF,
  0xF0, 0x04, 0x31, 0x8E, 0x30, 0xC7, 0x18, 0x61, 0x8E, 0x38, 0xE3, 0x86,
  0x18, 0x61, 0x83, 0x0C, 0x38, 0x60, 0xC1, 0x86, 0x38, 0xC7, 0x18, 0xE7,
  0x38, 0xC6, 0x31, 0x8C, 0x67, 0x39, 0xCC, 0xE6, 0x73, 0x10, 0x0C, 0x03,
  0x00, 0xC1, 0x93, 0xFF, 0xC3, 0xC1, 0xE0, 0xEC, 0x33, 0x80, 0x40, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x00, 0x33, 0x37, 0x76, 0x40, 0xFF, 0xC0, 0xFF, 0x00,
  0x03, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x38, 0x30,
  0x30, 0x30, 0x60, 0x60, 0x60, 0xC0, 0x1E, 0x0F, 0xC7, 0x39, 0x86, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xD8, 0x67,
  0x38, 0xFC, 0x1E, 0x00, 0x0C, 0xFF, 0xFF, 0x9C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x1E, 0x1F, 0xE7, 0x3B, 0x86, 0xE1, 0xC0,
  0x60, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x07, 0x03,
  0xFF, 0xFF, 0xC0, 0x1E, 0x1F, 0xC7, 0x3B, 0x86, 0xE1, 0x80, 0x60, 0x38,
  0x7C, 0x1F, 0x00, 0xE0, 0x18, 0x07, 0xE1, 0xF8, 0x6F, 0x79, 0xFC, 0x1E,
  0x00, 0x03, 0x81, 0xE0, 0xF8, 0x3E, 0x1F, 0x86, 0xE3, 0xB8, 0xCE, 0x73,
  0x98, 0xEE, 0x3B, 0xFF, 0xFF, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x3F,
  0x9F, 0xE7, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0xF1, 0xFE, 0x73, 0x80, 0x70,
  0x1C, 0x07, 0xE1, 0xD8, 0x77, 0x38, 0xFE, 0x1E, 0x00, 0x07, 0x07, 0xC3,
  0xE0, 0xE0, 0x70, 0x18, 0x06, 0xF3, 0xFE, 0xFB, 0xB8, 0x7E, 0x1F, 0x87,
  0x61, 0xDC, 0x77, 0xB8, 0xFE, 0x1E, 0x00, 0xFF, 0xFF, 0xF0, 0x1C, 0x06,
  0x03, 0x80, 0xE0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07,
  0x03, 0x80, 0xE0, 0x38, 0x00, 0x1E, 0x1F, 0xE7, 0x39, 0x86, 0x61, 0x98,
  0x67, 0x38, 0xFC, 0x3F, 0x1C, 0xEE, 0x1F, 0x87, 0xE1, 0xF8, 0x77, 0x39,
  0xFE, 0x1E, 0x00, 0x1E, 0x1F, 0xC7, 0x7B, 0x8E, 0xE1, 0xB8, 0x7E, 0x1F,
  0x87, 0x73, 0xDF, 0xF3, 0xD8, 0x06, 0x03, 0x80, 0xE1, 0xF0, 0xF8, 0x38,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x6F, 0x60, 0x00, 0x00, 0x00, 0x66,
  0x66, 0xEC, 0xC0, 0x01, 0x07, 0x1F, 0x7E, 0xF8, 0xE0, 0xF8, 0x7E, 0x1F,
  0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0xF0, 0x7C,
  0x1F, 0x07, 0x1F, 0x7C, 0xF0, 0xC0, 0x80, 0x3C, 0x3F, 0xBD, 0xDC, 0x6E,
  0x38, 0x18, 0x1C, 0x1C, 0x1E, 0x0E, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x70, 0x18, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x1C, 0x0C, 0x38, 0x06, 0x30,
  0x06, 0x61, 0xE3, 0x63, 0xF3, 0x63, 0x33, 0xC6, 0x31, 0xC6, 0x31, 0xC6,
  0x31, 0xCE, 0x31, 0xCE, 0x63, 0xCE, 0x63, 0xC6, 0x63, 0xC7, 0xFE, 0x63,
  0xBC, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1F, 0xF0, 0x07, 0xE0, 0x03,
  0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xC0, 0x3B, 0x00, 0xCC, 0x07,
  0x38, 0x1C, 0xE0, 0x61, 0x83, 0x87, 0x0F, 0xFC, 0x3F, 0xF1, 0xC0, 0xE7,
  0x03, 0x9C, 0x0E, 0x70, 0x1C, 0xFE, 0x3F, 0xEC, 0x7B, 0x07, 0xC1, 0xF0,
  0x7C, 0x3B, 0xFC, 0xFF, 0xB0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x7F,
  0xFE, 0xFE, 0x00, 0x0F, 0x83, 0xFC, 0x7D, 0xE7, 0x0E, 0x60, 0x7E, 0x07,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x07, 0x60, 0x77, 0x0E,
  0x79, 0xE3, 0xFC, 0x0F, 0x80, 0xFE, 0x3F, 0xCC, 0x7B, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x7B,
  0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFE,
  0xFF, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0x7F, 0xB0, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x0F, 0x83, 0xFC, 0x7D, 0xE7,
  0x07, 0xE0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE3, 0xFE, 0x3F, 0xE0, 0x7E,
  0x07, 0x60, 0x77, 0x07, 0x7D, 0xF3, 0xFE, 0x0F, 0x80, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x7C, 0x3F, 0x1F, 0xDE, 0xFE, 0x3E, 0x00,
  0xC1, 0xF8, 0x3B, 0x0E, 0x63, 0xCC, 0x71, 0x9C, 0x37, 0x06, 0xE0, 0xFC,
  0x1F, 0xC3, 0xB8, 0x73, 0x8C, 0x79, 0x87, 0x30, 0xF6, 0x0E, 0xC0, 0xE0,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0xFF, 0x80, 0xE0, 0x1F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x0F, 0xF6, 0x1B, 0xEC, 0x37, 0xDC,
  0xEF, 0x99, 0x9F, 0x33, 0x3E, 0x7E, 0x7C, 0x7C, 0xF8, 0xF1, 0xF1, 0xE3,
  0xE1, 0xC7, 0xC3, 0x0E, 0xE0, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x8F, 0xF1,
  0xF7, 0x3E, 0xE7, 0xCE, 0xF8, 0xDF, 0x1F, 0xE1, 0xFC, 0x3F, 0x83, 0xF0,
  0x7E, 0x07, 0xC0, 0xE0, 0x0F, 0x83, 0xFC, 0x7D, 0xE7, 0x0F, 0x60, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x60, 0x77,
  0x07, 0x7D, 0xE3, 0xFC, 0x0F, 0x80, 0xFF, 0x1F, 0xF3, 0x0F, 0x60, 0xEC,
  0x0D, 0x81, 0xF0, 0x3E, 0x0E, 0xC3, 0xDF, 0xF3, 0xFC, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x0F, 0x83, 0xFC, 0x7D, 0xE7, 0x0E,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x77, 0x0F, 0x7D, 0xE3, 0xFC, 0x0F, 0xE0, 0x0F, 0x00, 0x70, 0x02,
  0xFF, 0x1F, 0xF3, 0x1F, 0x60, 0xEC, 0x1D, 0x83, 0xB0, 0x76, 0x3C, 0xFF,
  0x9F, 0xE3, 0x1C, 0x63, 0x8C, 0x39, 0x87, 0x30, 0x76, 0x0E, 0xC1, 0xC0,
  0x1F, 0x0F, 0xF1, 0xEF, 0x70, 0x6E, 0x0F, 0xC0, 0x1C, 0x03, 0xF0, 0x1F,
  0x80, 0xF8, 0x07, 0x00, 0x7E, 0x0F, 0xC1, 0xDE, 0xF3, 0xFE, 0x1F, 0x00,
  0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0xE1, 0xDE, 0x79, 0xFE, 0x1F, 0x00,
  0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0xE3, 0x87, 0x1C, 0x38, 0xE1, 0x83,
  0x1C, 0x1C, 0xE0, 0xE6, 0x03, 0x70, 0x1B, 0x80, 0xFC, 0x07, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0xE1, 0x83, 0x70, 0xE3, 0xB8, 0xF1, 0xDC, 0x78,
  0xE6, 0x3C, 0x73, 0x1E, 0x39, 0xCF, 0x98, 0xEE, 0xCC, 0x76, 0x6E, 0x3B,
  0x37, 0x0D, 0x9B, 0x86, 0xCF, 0x83, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0,
  0x38, 0x78, 0x1C, 0x38, 0x00, 0xE0, 0xEF, 0x0E, 0x71, 0xC7, 0x9C, 0x3B,
  0x83, 0xB8, 0x1F, 0x00, 0xF0, 0x0E, 0x01, 0xF0, 0x1F, 0x03, 0xB8, 0x3B,
  0xC7, 0x1C, 0x71, 0xEF, 0x0E, 0xE0, 0xF0, 0xF0, 0x73, 0x83, 0x9C, 0x38,
  0x71, 0xC3, 0x8E, 0x0C, 0xE0, 0x77, 0x01, 0xB0, 0x0F, 0x80, 0x78, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0xFF,
  0xFF, 0xFC, 0x07, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x0E, 0x03,
  0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0xFF, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C,
  0x06, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xFF,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9F, 0xFF, 0x38, 0x70, 0xE3, 0xE6, 0xCD, 0x99, 0xE3, 0xC6, 0xFF, 0xFF,
  0xC0, 0xE3, 0x8C, 0x70, 0x1E, 0x3F, 0x9C, 0xFC, 0x70, 0x39, 0xFD, 0xFF,
  0xC7, 0xE3, 0xF1, 0xF9, 0xEF, 0xF3, 0xB8, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x3B, 0xCF, 0xFB, 0xCE, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0xCE, 0xFF, 0xBB, 0xC0, 0x1E, 0x3F, 0x9C, 0xFC, 0x7E, 0x1F,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0xDC, 0xEF, 0xE3, 0xE0, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x19, 0xED, 0xFF, 0xE7, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x86, 0xEF, 0x7F, 0x9E, 0xC0, 0x1E, 0x1F, 0xC7, 0x3B, 0x86, 0xE1,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x07, 0x39, 0xFE, 0x1F, 0x00, 0x1C,
  0xF7, 0x9C, 0x73, 0xFF, 0xDC, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC0, 0x3D, 0xDF, 0xF7, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x77, 0x3D, 0xFF, 0x3D, 0xC0, 0x70, 0x19, 0x8E, 0x7F, 0x8F, 0x80,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x7B, 0xFF, 0xE7, 0xE3, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xC0, 0x7D, 0x80, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6C, 0x37, 0x30, 0x07, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x7F, 0xE0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xEE,
  0x7B, 0x9C, 0xEE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFE, 0x39, 0xCE, 0x73, 0x8E,
  0xE3, 0xB8, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xEF, 0x3C, 0xFF, 0xFE,
  0xF3, 0xEE, 0xE3, 0xC6, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87,
  0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xEF, 0x7F,
  0xFC, 0xFC, 0x7E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x18, 0x1E, 0x1F, 0xE7, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x77, 0x39, 0xFE, 0x1E, 0x00, 0xEF, 0x3F, 0xEF, 0x3B, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x3B, 0xFE, 0xEF, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x00, 0x3D, 0xBF, 0xFC, 0xFC, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xFC, 0xEF, 0xF3, 0xD8, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0xEF, 0xFF, 0xFC, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE0,
  0x3E, 0x3F, 0xB9, 0xFC, 0x7E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xF1, 0xF8,
  0xEF, 0xE3, 0xE0, 0x38, 0x70, 0xE7, 0xFF, 0xE7, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0F, 0x8F, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xDD, 0xEF, 0xF3, 0xD8, 0x61, 0xDC, 0x77, 0x19,
  0xCE, 0x33, 0x8C, 0xE3, 0xB0, 0x6C, 0x1F, 0x07, 0x81, 0xE0, 0x38, 0x0E,
  0x00, 0x61, 0x8E, 0xC7, 0x1D, 0xCE, 0x33, 0x9E, 0x67, 0x3D, 0xC6, 0xDB,
  0x8D, 0xB6, 0x1F, 0x7C, 0x3E, 0x78, 0x38, 0xF0, 0x71, 0xE0, 0xE3, 0x81,
  0xC3, 0x00, 0x71, 0xDC, 0xE3, 0xB8, 0xEC, 0x1F, 0x07, 0x80, 0xE0, 0x78,
  0x1F, 0x0E, 0xC3, 0xB9, 0xC6, 0x71, 0xC0, 0xE1, 0xDC, 0x77, 0x19, 0xCE,
  0x33, 0x8E, 0xE3, 0xB0, 0xFC, 0x1F, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x03,
  0x01, 0xC0, 0xF0, 0x78, 0x1C, 0x00, 0xFF, 0xFF, 0xC1, 0xC0, 0xE0, 0xE0,
  0xE0, 0x70, 0x70, 0x38, 0x38, 0x38, 0x1F, 0xFF, 0xF8, 0x08, 0x73, 0x8C,
  0x30, 0xC3, 0x0C, 0x71, 0xC7, 0x38, 0xE1, 0xC7, 0x0C, 0x30, 0xC3, 0x0C,
  0x38, 0x70, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0x06, 0x18, 0x71,
  0xC7, 0x1C, 0x71, 0xC3, 0x0F, 0x3C, 0xC7, 0x1C, 0x71, 0xC7, 0x18, 0x63,
  0x88, 0x00, 0x38, 0x6F, 0x8D, 0xBF, 0xF3, 0xFC, 0x3C,
};

const GFXglyph RobotoCondensed_Medium24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 17, 6, 2, -17 },
  { 8, 6, 6, 8, 1, -18 },
  { 13, 11, 17, 13, 1, -17 },
  { 37, 10, 22, 12, 1, -20 },
  { 65, 13, 17, 15, 1, -17 },
  { 93, 12, 17, 14, 1, -17 },
  { 119, 2, 6, 4, 1, -18 },
  { 121, 6, 24, 8, 1, -19 },
  { 139, 5, 24, 8, 1, -19 },
  { 154, 10, 10, 11, 0, -17 },
  { 167, 10, 13, 12, 1, -15 },
  { 184, 4, 7, 5, 0, -3 },
  { 188, 5, 2, 7, 1, -8 },
  { 190, 3, 3, 7, 2, -3 },
  { 192, 8, 18, 8, 0, -17 },
  { 210, 10, 17, 12, 1, -17 },
  { 232, 6, 17, 12, 2, -17 },
  { 245, 10, 17, 12, 1, -17 },
  { 267, 10, 17, 12, 1, -17 },
  { 289, 10, 17, 12, 1, -17 },
  { 311, 10, 17, 12, 1, -17 },
  { 333, 10, 17, 12, 1, -17 },
  { 355, 10, 17, 12, 1, -17 },
  { 377, 10, 17, 12, 1, -17 },
  { 399, 10, 17, 12, 1, -17 },
  { 421, 3, 13, 6, 2, -13 },
  { 426, 4, 17, 6, 1, -13 },
  { 435, 8, 11, 11, 1, -13 },
  { 446, 8, 6, 12, 2, -11 },
  { 452, 8, 11, 11, 2, -13 },
  { 463, 9, 17, 10, 1, -17 },
  { 483, 16, 22, 18, 1, -17 },
  { 527, 14, 17, 14, 0, -17 },
  { 557, 10, 17, 13, 2, -17 },
  { 579, 12, 17, 14, 1, -17 },
  { 605, 10, 17, 14, 2, -17 },
  { 627, 9, 17, 12, 2, -17 },
  { 647, 9, 17, 11, 2, -17 },
  { 667, 12, 17, 14, 1, -17 },
  { 693, 11, 17, 15, 2, -17 },
  { 717, 3, 17, 6, 2, -17 },
  { 724, 9, 17, 12, 1, -17 },
  { 744, 11, 17, 13, 2, -17 },
  { 768, 9, 17, 11, 2, -17 },
  { 788, 15, 17, 18, 2, -17 },
  { 820, 11, 17, 15, 2, -17 },
  { 844, 12, 17, 14, 1, -17 },
  { 870, 11, 17, 13, 2, -17 },
  { 894, 12, 20, 14, 1, -17 },
  { 924, 11, 17, 13, 2, -17 },
  { 948, 11, 17, 13, 1, -17 },
  { 972, 11, 17, 13, 1, -17 },
  { 996, 11, 17, 14, 1, -17 },
  { 1020, 13, 17, 14, 0, -17 },
  { 1048, 17, 17, 18, 1, -17 },
  { 1085, 12, 17, 13, 1, -17 },
  { 1111, 13, 17, 13, 0, -17 },
  { 1139, 11, 17, 13, 1, -17 },
  { 1163, 5, 24, 6, 1, -20 },
  { 1178, 9, 18, 9, 0, -17 },
  { 1199, 5, 24, 6, 0, -20 },
  { 1214, 7, 9, 9, 1, -17 },
  { 1222, 9, 2, 10, 0, 0 },
  { 1225, 5, 4, 8, 1, -18 },
  { 1228, 9, 13, 11, 1, -13 },
  { 1243, 10, 18, 12, 1, -18 },
  { 1266, 9, 13, 11, 1, -13 },
  { 1281, 9, 18, 12, 1, -18 },
  { 1302, 10, 13, 11, 1, -13 },
  { 1319, 6, 18, 8, 1, -18 },
  { 1333, 10, 18, 12, 1, -13 },
  { 1356, 9, 18, 12, 1, -18 },
  { 1377, 3, 18, 6, 1, -18 },
  { 1384, 4, 23, 6, 0, -18 },
  { 1396, 10, 18, 11, 1, -18 },
  { 1419, 2, 18, 6, 2, -18 },
  { 1424, 16, 13, 18, 1, -13 },
  { 1450, 9, 13, 12, 1, -13 },
  { 1465, 10, 13, 12, 1, -13 },
  { 1482, 10, 18, 12, 1, -13 },
  { 1505, 9, 18, 12, 1, -13 },
  { 1526, 6, 13, 8, 1, -13 },
  { 1536, 9, 13, 11, 1, -13 },
  { 1551, 7, 16, 7, 0, -16 },
  { 1565, 9, 13, 12, 1, -13 },
  { 1580, 10, 13, 11, 0, -13 },
  { 1597, 15, 13, 15, 0, -13 },
  { 1622, 10, 13, 11, 0, -13 },
  { 1639, 10, 18, 10, 0, -13 },
  { 1662, 9, 13, 11, 1, -13 },
  { 1677, 6, 23, 7, 1, -19 },
  { 1695, 2, 20, 6, 2, -17 },
  { 1700, 6, 23, 7, 1, -19 },
  { 1718, 11, 5, 14, 1, -10 },
};

const GFXfont RobotoCondensed_Medium24pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium24pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium24pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOCONDENSED_MEDIUM24PT7B_H_
