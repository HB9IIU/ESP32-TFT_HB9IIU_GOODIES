#ifndef _ROBOTOCONDENSED_MEDIUM16PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xCF, 0xB6, 0xD0, 0x34, 0x68, 0x91, 0x2F, 0xE5, 0x0A,
  0x7F, 0x68, 0x91, 0x22, 0xC0, 0x10, 0x47, 0x9F, 0xCF, 0x3C, 0x1C, 0x38,
  0x3C, 0xF3, 0xFD, 0xE3, 0x0C, 0xE0, 0xB0, 0x96, 0x94, 0xEC, 0x08, 0x10,
  0x17, 0x2D, 0x2D, 0x4D, 0x07, 0x78, 0x78, 0xCC, 0x48, 0x78, 0x70, 0x72,
  0xDE, 0xDE, 0xCC, 0xFE, 0x7E, 0xF0, 0x12, 0x64, 0x4C, 0xCC, 0xCC, 0xCC,
  0x44, 0x62, 0x10, 0x44, 0x62, 0x33, 0x33, 0x33, 0x33, 0x32, 0x64, 0x40,
  0x10, 0x23, 0x5B, 0xE3, 0x8D, 0x81, 0x00, 0x30, 0xC3, 0x3F, 0xFC, 0xC3,
  0x0C, 0x6D, 0x60, 0xFC, 0xF0, 0x08, 0xC4, 0x21, 0x18, 0x84, 0x63, 0x10,
  0x8C, 0x00, 0x7B, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xDE, 0x17,
  0xD1, 0x11, 0x11, 0x11, 0x11, 0x7B, 0xFC, 0xE3, 0x0C, 0x21, 0x8C, 0x61,
  0x8F, 0xFF, 0x7B, 0xFC, 0xC3, 0x0C, 0xE3, 0x83, 0x0F, 0x3F, 0xDE, 0x0C,
  0x18, 0x70, 0xA3, 0x44, 0x99, 0x3F, 0x7E, 0x08, 0x10, 0x20, 0x7D, 0xF4,
  0x30, 0xFB, 0xF0, 0xC3, 0x0F, 0x3F, 0xDE, 0x39, 0xE6, 0x30, 0xFB, 0xFC,
  0xF1, 0xC7, 0x37, 0xCE, 0xFF, 0xF0, 0xC2, 0x18, 0x61, 0x0C, 0x30, 0x86,
  0x18, 0x7B, 0xFC, 0xF3, 0xCD, 0xE7, 0xB3, 0xCF, 0x3F, 0xDE, 0x73, 0xEC,
  0xF3, 0xCF, 0x3F, 0xDF, 0x0C, 0x27, 0x9C, 0xF0, 0x03, 0xC0, 0x6C, 0x00,
  0x03, 0x6F, 0x00, 0x09, 0xDD, 0x8C, 0x38, 0xE1, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x83, 0x87, 0x87, 0x1D, 0xEE, 0x20, 0x39, 0xF4, 0xC1, 0x0C, 0x31,
  0x84, 0x30, 0x03, 0x0C, 0x1F, 0x06, 0x31, 0x83, 0x27, 0x2D, 0xB5, 0x24,
  0xE4, 0x9C, 0x93, 0x92, 0x52, 0xCA, 0x7E, 0x60, 0x04, 0x00, 0xC0, 0x07,
  0x80, 0x0C, 0x0E, 0x07, 0x02, 0xC1, 0x61, 0xB0, 0xCC, 0x7E, 0x7F, 0x30,
  0x98, 0x78, 0x30, 0xFD, 0xFB, 0x1E, 0x3C, 0x79, 0xBF, 0x63, 0xC7, 0x8F,
  0xFF, 0xE0, 0x3C, 0x7E, 0xC6, 0xC2, 0xC0, 0xC0, 0xC0, 0xC0, 0xC2, 0xC6,
  0x7E, 0x3C, 0xF9, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xF7,
  0xC0, 0xFF, 0xFC, 0x30, 0xC3, 0xFF, 0xF0, 0xC3, 0x0F, 0xFF, 0xFF, 0xFC,
  0x30, 0xC3, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0x3C, 0x7E, 0xC6, 0xC2, 0xC0,
  0xCF, 0xCF, 0xC3, 0xC3, 0xC3, 0x7E, 0x3C, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xFF, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xFF, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0x8D, 0xF1, 0xC0, 0xC6, 0xCE, 0xCC,
  0xD8, 0xD8, 0xF0, 0xF8, 0xF8, 0xCC, 0xCC, 0xC6, 0xC7, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xF3,
  0xFC, 0xFD, 0x2F, 0x7B, 0xDE, 0xF3, 0x3C, 0xCF, 0x33, 0xC3, 0xE3, 0xE3,
  0xF3, 0xF3, 0xDB, 0xDB, 0xCF, 0xCF, 0xC7, 0xC7, 0xC3, 0x3C, 0x7E, 0xC6,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0x7E, 0x3C, 0xFD, 0xFF, 0x1E,
  0x3C, 0x78, 0xFF, 0xFE, 0xC1, 0x83, 0x06, 0x00, 0x3C, 0x7E, 0xC6, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0x7E, 0x3C, 0x07, 0x02, 0xFD, 0xFF,
  0x1E, 0x3C, 0x7F, 0xBE, 0x66, 0xCD, 0x9B, 0x1E, 0x30, 0x79, 0xFB, 0x1E,
  0x0E, 0x0F, 0x0F, 0x07, 0xC7, 0x8F, 0xF3, 0xC0, 0xFF, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xFB, 0xE0, 0xC1, 0xB1, 0x98, 0xCC, 0x62,
  0x31, 0xB0, 0xD8, 0x6C, 0x14, 0x0E, 0x07, 0x03, 0x80, 0x46, 0x36, 0x62,
  0x66, 0x66, 0x76, 0x6F, 0x66, 0xF6, 0x2D, 0x62, 0x94, 0x39, 0xC3, 0x9C,
  0x39, 0xC1, 0x8C, 0x63, 0x31, 0x8D, 0x86, 0xC1, 0xC0, 0xE0, 0x70, 0x38,
  0x36, 0x1B, 0x18, 0xCC, 0x60, 0xC3, 0x63, 0x66, 0x36, 0x36, 0x3C, 0x1C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFC, 0x30, 0x41, 0x86, 0x0C, 0x30,
  0x61, 0x83, 0xFF, 0xF0, 0xFF, 0x6D, 0xB6, 0xDB, 0x6D, 0xB7, 0xC1, 0x86,
  0x18, 0x20, 0xC3, 0x04, 0x18, 0x61, 0x83, 0x0C, 0xFD, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDF, 0x30, 0xC3, 0x9E, 0x49, 0x20, 0xFF, 0xF0, 0x63, 0x7B, 0xEC,
  0xC3, 0x7F, 0x3C, 0xFF, 0x7C, 0xC3, 0x0C, 0x3E, 0xFF, 0x3C, 0xF3, 0xCF,
  0x3F, 0xFE, 0x7B, 0xFC, 0xE0, 0x82, 0x0C, 0xFF, 0x78, 0x0C, 0x30, 0xDF,
  0xFF, 0x38, 0xE3, 0x8F, 0x3F, 0xDF, 0x7B, 0xFC, 0xF3, 0xFF, 0x0C, 0x3F,
  0x78, 0x39, 0xD9, 0xF6, 0x31, 0x8C, 0x63, 0x18, 0xC0, 0x7F, 0xFC, 0xE3,
  0x8E, 0x3C, 0xFF, 0x7C, 0x3F, 0xDE, 0xC3, 0x0C, 0x3E, 0xFF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xF3, 0xFF, 0xFF, 0x6C, 0x36, 0xDB, 0x6D, 0xB7, 0xF0,
  0xC3, 0x0C, 0x33, 0xDB, 0xCF, 0x3C, 0xDB, 0x6C, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFB, 0xBF, 0xFC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xCC, 0xC0,
  0xFB, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCC, 0x7B, 0xFC, 0xE1, 0x86, 0x1C,
  0xFF, 0x78, 0xFB, 0xFC, 0xF3, 0xCF, 0x3C, 0xFF, 0xFB, 0x0C, 0x30, 0x7F,
  0xFC, 0xE3, 0x8E, 0x3C, 0xFF, 0x7C, 0x30, 0xC3, 0xFF, 0xCC, 0xCC, 0xCC,
  0xC0, 0x7B, 0x6C, 0xF8, 0x78, 0x68, 0xF6, 0x78, 0x66, 0xF6, 0x66, 0x66,
  0x67, 0x30, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0x7C, 0xC6, 0x89, 0xB3,
  0x66, 0xC5, 0x0E, 0x1C, 0x10, 0xCC, 0xD3, 0x36, 0xC9, 0xBA, 0x7F, 0x9E,
  0xE3, 0x38, 0xCC, 0x33, 0x00, 0x64, 0xD8, 0xA1, 0xC1, 0x87, 0x0B, 0x36,
  0x66, 0xC6, 0xD9, 0xB3, 0x66, 0x87, 0x0E, 0x1C, 0x10, 0x61, 0xC3, 0x00,
  0xFB, 0xE1, 0x8C, 0x21, 0x8C, 0x3F, 0xFC, 0x13, 0x22, 0x22, 0x6C, 0x62,
  0x22, 0x23, 0x10, 0xFF, 0xFF, 0xFF, 0xF0, 0x46, 0x66, 0x66, 0x33, 0x26,
  0x66, 0x66, 0x40, 0x73, 0xFE, 0x30,
};

const GFXglyph RobotoCondensed_Medium16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 12, 4, 1, -12 },
  { 4, 3, 4, 5, 1, -12 },
  { 6, 7, 12, 9, 1, -12 },
  { 17, 6, 16, 8, 1, -14 },
  { 29, 8, 12, 10, 1, -12 },
  { 41, 8, 12, 9, 1, -12 },
  { 53, 1, 4, 3, 1, -12 },
  { 54, 4, 17, 5, 1, -13 },
  { 63, 4, 17, 5, 0, -13 },
  { 72, 7, 7, 7, 0, -12 },
  { 79, 6, 8, 8, 1, -10 },
  { 85, 3, 4, 4, 0, -2 },
  { 87, 3, 2, 5, 1, -6 },
  { 88, 2, 2, 4, 1, -2 },
  { 89, 5, 13, 6, 0, -12 },
  { 98, 6, 12, 8, 1, -12 },
  { 107, 4, 12, 8, 1, -12 },
  { 113, 6, 12, 8, 1, -12 },
  { 122, 6, 12, 8, 1, -12 },
  { 131, 7, 12, 8, 0, -12 },
  { 142, 6, 12, 8, 1, -12 },
  { 151, 6, 12, 8, 1, -12 },
  { 160, 6, 12, 8, 1, -12 },
  { 169, 6, 12, 8, 1, -12 },
  { 178, 6, 12, 8, 1, -12 },
  { 187, 2, 9, 4, 1, -9 },
  { 190, 3, 11, 4, 0, -9 },
  { 195, 5, 8, 7, 1, -9 },
  { 200, 6, 6, 8, 1, -8 },
  { 205, 6, 8, 7, 1, -9 },
  { 211, 6, 12, 7, 0, -12 },
  { 220, 11, 15, 12, 1, -11 },
  { 241, 9, 12, 9, 0, -12 },
  { 255, 7, 12, 9, 1, -12 },
  { 266, 8, 12, 9, 1, -12 },
  { 278, 7, 12, 9, 1, -12 },
  { 289, 6, 12, 8, 1, -12 },
  { 298, 6, 12, 8, 1, -12 },
  { 307, 8, 12, 9, 1, -12 },
  { 319, 8, 12, 10, 1, -12 },
  { 331, 2, 12, 4, 1, -12 },
  { 334, 7, 12, 8, 0, -12 },
  { 345, 8, 12, 9, 1, -12 },
  { 357, 6, 12, 8, 1, -12 },
  { 366, 10, 12, 12, 1, -12 },
  { 381, 8, 12, 10, 1, -12 },
  { 393, 8, 12, 10, 1, -12 },
  { 405, 7, 12, 9, 1, -12 },
  { 416, 8, 14, 10, 1, -12 },
  { 430, 7, 12, 9, 1, -12 },
  { 441, 7, 12, 8, 1, -12 },
  { 452, 8, 12, 9, 0, -12 },
  { 464, 7, 12, 9, 1, -12 },
  { 475, 9, 12, 9, 0, -12 },
  { 489, 12, 12, 12, 0, -12 },
  { 507, 9, 12, 9, 0, -12 },
  { 521, 8, 12, 9, 0, -12 },
  { 533, 7, 12, 8, 1, -12 },
  { 544, 3, 16, 4, 1, -13 },
  { 550, 6, 13, 6, 0, -12 },
  { 560, 3, 16, 4, 0, -13 },
  { 566, 6, 6, 6, 0, -12 },
  { 571, 6, 2, 6, 0, 0 },
  { 573, 4, 2, 5, 0, -12 },
  { 574, 6, 9, 8, 1, -9 },
  { 581, 6, 12, 8, 1, -12 },
  { 590, 6, 9, 7, 1, -9 },
  { 597, 6, 12, 8, 1, -12 },
  { 606, 6, 9, 8, 1, -9 },
  { 613, 5, 12, 5, 0, -12 },
  { 621, 6, 12, 8, 1, -9 },
  { 630, 6, 12, 8, 1, -12 },
  { 639, 2, 12, 4, 1, -12 },
  { 642, 3, 15, 4, 0, -12 },
  { 648, 6, 12, 7, 1, -12 },
  { 657, 2, 12, 4, 1, -12 },
  { 660, 10, 9, 12, 1, -9 },
  { 672, 6, 9, 8, 1, -9 },
  { 679, 6, 9, 8, 1, -9 },
  { 686, 6, 12, 8, 1, -9 },
  { 695, 6, 12, 8, 1, -9 },
  { 704, 4, 9, 5, 1, -9 },
  { 709, 6, 9, 7, 1, -9 },
  { 716, 4, 11, 5, 0, -11 },
  { 722, 6, 9, 8, 1, -9 },
  { 729, 7, 9, 7, 0, -9 },
  { 737, 10, 9, 10, 0, -9 },
  { 749, 7, 9, 7, 0, -9 },
  { 757, 7, 12, 7, 0, -9 },
  { 768, 6, 9, 7, 1, -9 },
  { 775, 4, 15, 5, 0, -12 },
  { 783, 2, 14, 4, 1, -12 },
  { 787, 4, 15, 5, 0, -12 },
  { 795, 7, 3, 9, 1, -6 },
};

const GFXfont RobotoCondensed_Medium16pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium16pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _ROBOTOCONDENSED_MEDIUM16PT7B_H_
