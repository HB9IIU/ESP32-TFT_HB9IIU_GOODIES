#ifndef _ROBOTOCONDENSED_MEDIUM58PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium58pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xEF, 0xFF, 0xFF, 0xFF,
  0x7C, 0x20, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F,
  0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0x78,
  0x7B, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x07, 0xC1,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0x87, 0xC0, 0x03, 0xC1, 0xF0, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0xF8, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xC1, 0xF0,
  0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x81, 0xF0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0x87, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0xC7, 0xF0, 0x3F, 0x8F, 0xC0, 0x7F,
  0x3F, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB,
  0xF8, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0x7F, 0x00, 0xFE, 0xFE, 0x03, 0xF9, 0xFF, 0x0F, 0xF1, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0x0F, 0x80, 0x40, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x03, 0xC0,
  0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x1E, 0x03, 0xC0, 0xF8, 0x7C, 0x07,
  0x81, 0xF0, 0xF0, 0x0F, 0x83, 0xE3, 0xE0, 0x1F, 0x07, 0xC7, 0x80, 0x3E,
  0x1F, 0x1F, 0x00, 0x3F, 0xFE, 0x3C, 0x00, 0x7F, 0xF8, 0xF8, 0x00, 0x7F,
  0xF1, 0xE0, 0x00, 0x7F, 0x87, 0x80, 0x00, 0x08, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x0F, 0xF0, 0x00, 0x3E, 0x3F, 0xF0, 0x00, 0x78,
  0xFF, 0xF0, 0x01, 0xF3, 0xFF, 0xE0, 0x03, 0xC7, 0xC3, 0xE0, 0x0F, 0x8F,
  0x07, 0xC0, 0x1E, 0x3E, 0x07, 0x80, 0x7C, 0x7C, 0x0F, 0x00, 0xF0, 0xF8,
  0x1E, 0x03, 0xC1, 0xF0, 0x3C, 0x07, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0xC0,
  0xF0, 0x3C, 0x07, 0x83, 0xE0, 0x30, 0x0F, 0x87, 0xC0, 0x20, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFE, 0x3F, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF,
  0x83, 0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xF1, 0xFE, 0x3E, 0x1F, 0xC3, 0xFD,
  0xF8, 0x7E, 0x07, 0xF7, 0xE1, 0xF8, 0x1F, 0xFF, 0x8F, 0xE0, 0x3F, 0xFE,
  0x3F, 0x80, 0x7F, 0xF0, 0x7E, 0x00, 0xFF, 0xC1, 0xFC, 0x03, 0xFE, 0x07,
  0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC3, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xE7, 0xF8, 0x07, 0xFE, 0x0F, 0xF0, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0x80, 0x00, 0x10,
  0x01, 0x80, 0x1C, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F,
  0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0x80, 0x04, 0x40, 0x07,
  0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0,
  0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x00, 0x10, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x3C, 0x06, 0x7C, 0x3C,
  0x3E, 0xFF, 0xBC, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xEF, 0xC0, 0x07, 0xE7, 0xC0, 0x0F, 0xC3, 0xE0, 0x0F, 0x83,
  0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x06, 0x00, 0xE0, 0x02, 0x00,
  0x40, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x1F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE1, 0xE0,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7C,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xF1, 0xFE, 0x1F, 0x80, 0xFC, 0x7F, 0x01, 0xFC, 0xFC, 0x01, 0xF9, 0xF8,
  0x03, 0xF7, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFE, 0x01, 0xF9, 0xFC, 0x07, 0xF1, 0xFC,
  0x0F, 0xC3, 0xFC, 0x7F, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C,
  0x00, 0xF0, 0x0F, 0xC1, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xE3, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0x0F, 0xF8, 0x7F, 0x03, 0xFC, 0x7F,
  0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x1F, 0x9F, 0xC0, 0x0F, 0xCF,
  0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0xC3,
  0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0x9F, 0x80,
  0x0F, 0xCF, 0xC0, 0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xE1, 0xF8,
  0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x1F,
  0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0x03, 0xFC, 0x06, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x01,
  0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x7F, 0xE0, 0x7E, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x81,
  0xFC, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7F, 0x00,
  0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF,
  0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xF1, 0xFE, 0x3F, 0xC1, 0xFE,
  0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7,
  0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x3F,
  0x01, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0x83,
  0xF8, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFB, 0xF8, 0x0F, 0xE7, 0xF8, 0x3F, 0xC7,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xE1,
  0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xF9, 0xFC, 0x03, 0xFB, 0xF8, 0x07,
  0xF7, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x0F, 0xF7, 0xF0, 0x1F, 0xEF, 0xF0, 0x7F, 0xDF, 0xFB, 0xFF, 0x9F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFD, 0xF8, 0x1F, 0xF3, 0xF0, 0x0F,
  0x87, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7E, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7E, 0x10, 0x0F, 0x87, 0xF3, 0xFC, 0xFF, 0x3F, 0xC7, 0xF1, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E,
  0x1F, 0x03, 0xC0, 0x60, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFE, 0x3F, 0xDF, 0xE0, 0xFE, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xE0,
  0x00, 0x01, 0xE0, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x07, 0x87, 0xC0,
  0x1F, 0xF8, 0x0F, 0x8F, 0x80, 0x7F, 0xFC, 0x0F, 0x1E, 0x01, 0xFF, 0xF8,
  0x1E, 0x7C, 0x03, 0xF3, 0xF0, 0x3C, 0xF8, 0x0F, 0xC3, 0xE0, 0x79, 0xF0,
  0x3F, 0x07, 0xC0, 0xFB, 0xC0, 0x7C, 0x0F, 0x80, 0xFF, 0x80, 0xF8, 0x1F,
  0x01, 0xFF, 0x03, 0xE0, 0x3E, 0x03, 0xFE, 0x07, 0xC0, 0x7C, 0x07, 0xFC,
  0x0F, 0x80, 0xF8, 0x0F, 0xF8, 0x3F, 0x01, 0xE0, 0x1F, 0xE0, 0x7E, 0x03,
  0xC0, 0x3F, 0xC0, 0xF8, 0x07, 0x80, 0x7F, 0x81, 0xF0, 0x1F, 0x00, 0xFF,
  0x03, 0xE0, 0x3E, 0x03, 0xFE, 0x07, 0xC0, 0x7C, 0x07, 0xBC, 0x0F, 0x80,
  0xF8, 0x0F, 0x78, 0x1F, 0x01, 0xF0, 0x1E, 0xF8, 0x3E, 0x03, 0xE0, 0x7D,
  0xF0, 0x7E, 0x0F, 0xC0, 0xF3, 0xE0, 0xFC, 0x1F, 0x83, 0xE7, 0xC0, 0xFC,
  0x7F, 0x87, 0x8F, 0x81, 0xFF, 0xFF, 0xFF, 0x0F, 0x01, 0xFF, 0xBF, 0xFC,
  0x1F, 0x03, 0xFE, 0x3F, 0xF0, 0x3E, 0x01, 0xF8, 0x3F, 0xC0, 0x7C, 0x00,
  0x80, 0x0C, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x30,
  0x00, 0x03, 0xFF, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xF8, 0x07, 0xFD, 0xFC, 0x01, 0xFE, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xEF,
  0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFC, 0x01,
  0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F,
  0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x7E, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0x7F,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xFC, 0x01,
  0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xE0, 0x3F,
  0xE3, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xE0,
  0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00,
  0x7F, 0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x3F, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0xC3, 0xFC, 0x01, 0xFE, 0x3F,
  0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xFE, 0x00,
  0xFF, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x81, 0xFE, 0x3F,
  0xE7, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xFE, 0x00, 0x1F, 0xEF,
  0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0xCF, 0xE0, 0x07, 0xF8, 0xFE, 0x00,
  0xFF, 0x0F, 0xE0, 0x1F, 0xF0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0,
  0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE3, 0xFC, 0x00, 0xFE, 0x3F, 0x80,
  0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xDF, 0xC0, 0x0F,
  0xF9, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x07,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0,
  0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0,
  0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F,
  0xCF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFB, 0xFF,
  0xDF, 0x80, 0x1F, 0xBF, 0xFD, 0xF8, 0x01, 0xFB, 0xFF, 0xDF, 0x80, 0x1F,
  0x3F, 0xFD, 0xFC, 0x03, 0xF3, 0xFF, 0xCF, 0xC0, 0x3F, 0x3F, 0xFC, 0xFC,
  0x03, 0xF3, 0xFF, 0xCF, 0xE0, 0x7E, 0x3F, 0xFC, 0x7E, 0x07, 0xE7, 0xFF,
  0xC7, 0xE0, 0x7E, 0x7F, 0xFC, 0x7E, 0x0F, 0xC7, 0xFF, 0xC3, 0xF0, 0xFC,
  0x7F, 0xFE, 0x3F, 0x0F, 0xC7, 0xFF, 0xE3, 0xF1, 0xF8, 0x7F, 0xFE, 0x1F,
  0x9F, 0x87, 0xFF, 0xE1, 0xF9, 0xF8, 0x7F, 0xFE, 0x1F, 0x9F, 0x07, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xFE, 0x07,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0xFE, 0x03, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xC0, 0x7F, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x80,
  0x7F, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xEF,
  0xC0, 0x7F, 0xFE, 0x7E, 0x07, 0xFF, 0xE7, 0xE0, 0x7F, 0xFE, 0x3F, 0x07,
  0xFF, 0xE3, 0xF8, 0x7F, 0xFE, 0x1F, 0x87, 0xFF, 0xE1, 0xFC, 0x7F, 0xFE,
  0x0F, 0xC7, 0xFF, 0xE0, 0xFE, 0x7F, 0xFE, 0x07, 0xE7, 0xFF, 0xE0, 0x7F,
  0x7F, 0xFE, 0x03, 0xF7, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x3F,
  0x80, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0xFE, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03,
  0xF8, 0x7F, 0x80, 0x3F, 0xC1, 0xFF, 0x8F, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xCF, 0xE0, 0x0F, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x07, 0xF8, 0x07,
  0xF8, 0x3F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC,
  0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0xC1, 0xFF, 0x8F, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x9F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xCF, 0xE0, 0x1F, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0xBF,
  0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00,
  0x7F, 0xBF, 0x80, 0x1F, 0xCF, 0xE0, 0x1F, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xF3,
  0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0x80,
  0x3F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF8,
  0x01, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xF0, 0xFF, 0x87, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0xFE, 0x7F,
  0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x7F,
  0xC3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFE,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xF8,
  0xFE, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00,
  0x7E, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x7E, 0x00, 0xFF, 0x00, 0x7E, 0x7F, 0x00, 0xFF, 0x00, 0x7E, 0x7F,
  0x00, 0xFF, 0x00, 0xFE, 0x7F, 0x01, 0xFF, 0x80, 0xFE, 0x7F, 0x01, 0xFF,
  0x80, 0xFE, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x3F, 0x01, 0xFF, 0x80, 0xFC,
  0x3F, 0x01, 0xFF, 0xC0, 0xFC, 0x3F, 0x83, 0xFF, 0xC1, 0xFC, 0x3F, 0x83,
  0xFF, 0xC1, 0xFC, 0x1F, 0x83, 0xF7, 0xC1, 0xFC, 0x1F, 0x83, 0xE7, 0xC1,
  0xF8, 0x1F, 0x83, 0xE7, 0xE1, 0xF8, 0x1F, 0x87, 0xE7, 0xE1, 0xF8, 0x1F,
  0xC7, 0xE3, 0xE3, 0xF8, 0x0F, 0xC7, 0xC3, 0xE3, 0xF8, 0x0F, 0xC7, 0xC3,
  0xE3, 0xF0, 0x0F, 0xC7, 0xC3, 0xF3, 0xF0, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0,
  0x0F, 0xCF, 0xC1, 0xF3, 0xF0, 0x0F, 0xEF, 0x81, 0xF7, 0xF0, 0x07, 0xEF,
  0x81, 0xF7, 0xE0, 0x07, 0xEF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0x81, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F,
  0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x80,
  0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x0F,
  0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC,
  0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC,
  0xFF, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFE, 0x0F,
  0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x01, 0xFE,
  0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFC, 0xFF, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x7F,
  0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xF7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF1, 0xF0,
  0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xFC, 0x7C, 0x0F, 0x8F, 0x81, 0xF1,
  0xF0, 0x3F, 0x7E, 0x03, 0xEF, 0x80, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xF0, 0x7F, 0xBF, 0x80, 0xFE, 0xFE, 0x03,
  0xFB, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF,
  0x87, 0xE7, 0xF0, 0x1F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xF0, 0x07,
  0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xEF,
  0xF0, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xF7, 0xF1, 0xFF,
  0xDF, 0xC3, 0xFC, 0x7F, 0x00, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x40, 0x1F, 0xCF, 0xF8, 0x3F,
  0xBF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFB, 0xFF,
  0x0F, 0xF7, 0xF8, 0x0F, 0xEF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0xF0, 0xFF, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFB, 0xFF, 0x87, 0xE3,
  0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xF0,
  0xFF, 0x1F, 0xC0, 0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xF8, 0x01,
  0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0xBF,
  0x00, 0x3F, 0x7F, 0x00, 0xFE, 0x7E, 0x01, 0xF8, 0xFF, 0x0F, 0xF1, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x02, 0x07, 0xE0, 0x7F, 0x8F, 0xC3, 0xFF, 0xDF, 0x8F,
  0xFF, 0xBF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0x0F, 0xFB, 0xFC,
  0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF8, 0x03, 0xF7,
  0xF0, 0x0F, 0xEF, 0xF0, 0x1F, 0xCF, 0xF0, 0xFF, 0x9F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFE, 0xFC, 0x3F, 0xFD, 0xF8, 0x1F, 0xE3, 0xF0, 0x06,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F,
  0x80, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x08, 0x3F, 0x80, 0x38, 0x3F, 0xE0, 0x7C, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x03, 0xFF,
  0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC1, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x3F, 0x07,
  0xFF, 0x3F, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F,
  0xC3, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0xFF, 0x3F,
  0xC3, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0x7F, 0x03, 0xFE, 0x7F, 0x00, 0x20, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x0C, 0x00, 0xFE, 0x0E, 0x01, 0xFE, 0x1F,
  0xEF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x0F, 0xEF, 0xFE, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFC, 0x7F, 0xBF, 0xC0, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x3C, 0x7E, 0xFF, 0xFF, 0x7F, 0x7E,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x07, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC0, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x1F, 0xC3, 0xF8, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xCF,
  0xF1, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC,
  0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00,
  0xFE, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xBF, 0x80, 0xFF, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFE,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x08, 0x07, 0xF1, 0xFE, 0x07, 0xFC, 0x3F, 0xBF, 0xF8,
  0x7F, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x1F, 0xFE, 0x3F, 0xDF, 0xE0, 0x7F, 0xC0,
  0xFF, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0x00, 0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F,
  0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0x80, 0x7F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0x00, 0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0,
  0x3F, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xC0,
  0x3F, 0x80, 0x7F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xC0, 0x3F, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xFF,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0x0F, 0xEF, 0xFE,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFC, 0x7F, 0xBF,
  0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0xFF, 0x8F, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0x7F,
  0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xC0, 0x07, 0xEF, 0xE0, 0x03,
  0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F,
  0x00, 0x7F, 0x1F, 0xC0, 0x7F, 0x0F, 0xF0, 0x7F, 0x83, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x01, 0xF8, 0xFF, 0x83, 0xFB, 0xFF,
  0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF,
  0x7F, 0x80, 0xFE, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFB, 0xFE, 0x0F, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xBF, 0xF8, 0x7F, 0x3F, 0xE0,
  0xFE, 0x04, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x07, 0xF8, 0xFC, 0x3F, 0xFD, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xF0, 0xFF, 0xBF, 0xC0, 0x7F, 0x7F, 0x00,
  0x7E, 0xFE, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFF,
  0x01, 0xFC, 0xFF, 0x07, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xC3, 0xFF, 0xDF, 0x81, 0xFE, 0x3F, 0x00, 0x20, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF9, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xF8, 0x3F, 0x9F, 0xC0, 0x7F,
  0x7F, 0x01, 0xFD, 0xF8, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFD, 0xF8,
  0x07, 0xF7, 0xF0, 0x3F, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x08, 0x00, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x7F, 0x03, 0xFD, 0xFE, 0x1F, 0xF7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFE, 0xFC, 0x7F, 0xF3, 0xF0, 0x7F, 0x8F,
  0xC0, 0x20, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xFB,
  0xF8, 0x07, 0xE7, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7F, 0x1F,
  0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC,
  0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xE3,
  0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0x7E,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xF0,
  0x0F, 0xEF, 0xC0, 0x3E, 0x01, 0xFD, 0xF8, 0x0F, 0xE0, 0x3F, 0x3F, 0x01,
  0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x80, 0xFC, 0xFE, 0x07, 0xF0, 0x3F, 0x8F,
  0xC1, 0xFF, 0x07, 0xF1, 0xF8, 0x3F, 0xE0, 0xFC, 0x3F, 0x07, 0xFC, 0x1F,
  0x87, 0xE0, 0xFF, 0x83, 0xF0, 0x7E, 0x3F, 0xF8, 0x7E, 0x0F, 0xC7, 0xDF,
  0x1F, 0x81, 0xF8, 0xFB, 0xE3, 0xF0, 0x3F, 0x1F, 0x7C, 0x7E, 0x07, 0xE7,
  0xEF, 0xCF, 0xC0, 0x7E, 0xF8, 0xF9, 0xF8, 0x0F, 0xDF, 0x1F, 0x7E, 0x01,
  0xFB, 0xE3, 0xEF, 0xC0, 0x3F, 0xFC, 0x7F, 0xF8, 0x03, 0xFF, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7,
  0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xE7,
  0xF0, 0x0F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0x81,
  0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFB, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F,
  0xCF, 0xE0, 0x3F, 0x8F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x83, 0xF8,
  0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xFC, 0x7F, 0x01,
  0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xF3, 0xF0, 0x07, 0xEF, 0xE0, 0x0F,
  0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xE0, 0x0F, 0xC0, 0x7F, 0x03,
  0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x83,
  0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x00, 0xE0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x60, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xFC, 0x07, 0xF8, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFE, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x18, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x7C, 0x7F, 0xF0, 0x0F, 0x9F, 0xFF, 0x01, 0xF3, 0xFF, 0xF0,
  0x7E, 0xFF, 0xFF, 0x1F, 0x9F, 0x8F, 0xFF, 0xF3, 0xE0, 0xFF, 0xFE, 0xFC,
  0x0F, 0xFF, 0x9F, 0x00, 0xFF, 0xE3, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x7E,
  0x00,
};

const GFXglyph RobotoCondensed_Medium58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 7, 42, 15, 4, -41 },
  { 38, 13, 15, 19, 3, -44 },
  { 63, 26, 41, 31, 3, -41 },
  { 197, 23, 54, 29, 3, -48 },
  { 353, 31, 43, 37, 3, -42 },
  { 520, 30, 43, 33, 2, -42 },
  { 682, 6, 15, 10, 2, -44 },
  { 694, 13, 59, 19, 4, -46 },
  { 790, 13, 59, 19, 2, -46 },
  { 886, 24, 25, 26, 1, -41 },
  { 961, 24, 30, 28, 2, -34 },
  { 1051, 9, 16, 13, 1, -7 },
  { 1069, 13, 6, 18, 2, -21 },
  { 1079, 8, 8, 16, 4, -7 },
  { 1087, 19, 45, 20, 0, -41 },
  { 1194, 23, 43, 29, 3, -42 },
  { 1318, 14, 41, 29, 5, -41 },
  { 1390, 25, 42, 29, 2, -42 },
  { 1522, 24, 43, 29, 2, -42 },
  { 1651, 25, 41, 29, 2, -41 },
  { 1780, 24, 42, 29, 3, -41 },
  { 1906, 24, 42, 29, 3, -41 },
  { 2032, 25, 41, 29, 2, -41 },
  { 2161, 23, 43, 29, 3, -42 },
  { 2285, 23, 42, 29, 3, -42 },
  { 2406, 8, 32, 15, 4, -31 },
  { 2438, 10, 40, 13, 1, -31 },
  { 2488, 20, 26, 26, 2, -31 },
  { 2553, 21, 18, 29, 4, -28 },
  { 2601, 20, 26, 27, 4, -31 },
  { 2666, 21, 43, 25, 2, -42 },
  { 2779, 39, 53, 45, 3, -40 },
  { 3038, 32, 41, 34, 1, -41 },
  { 3202, 25, 41, 32, 4, -41 },
  { 3331, 28, 43, 33, 3, -42 },
  { 3482, 26, 41, 33, 4, -41 },
  { 3616, 23, 41, 29, 4, -41 },
  { 3734, 22, 41, 28, 4, -41 },
  { 3847, 28, 43, 34, 3, -42 },
  { 3998, 28, 41, 36, 4, -41 },
  { 4142, 7, 41, 15, 4, -41 },
  { 4178, 24, 42, 28, 1, -41 },
  { 4304, 28, 41, 32, 4, -41 },
  { 4448, 22, 41, 28, 4, -41 },
  { 4561, 36, 41, 44, 4, -41 },
  { 4746, 28, 41, 36, 4, -41 },
  { 4890, 29, 43, 35, 3, -42 },
  { 5046, 26, 41, 33, 4, -41 },
  { 5180, 29, 49, 35, 3, -42 },
  { 5358, 26, 41, 32, 4, -41 },
  { 5492, 26, 43, 31, 2, -42 },
  { 5632, 27, 41, 31, 2, -41 },
  { 5771, 27, 42, 33, 3, -41 },
  { 5913, 31, 41, 33, 1, -41 },
  { 6072, 40, 41, 44, 2, -41 },
  { 6277, 30, 41, 32, 1, -41 },
  { 6431, 29, 41, 31, 1, -41 },
  { 6580, 26, 41, 31, 2, -41 },
  { 6714, 10, 57, 15, 4, -48 },
  { 6786, 21, 45, 22, 1, -41 },
  { 6905, 10, 57, 15, 1, -48 },
  { 6977, 19, 21, 22, 2, -41 },
  { 7027, 22, 5, 23, 1, 0 },
  { 7041, 13, 9, 19, 2, -44 },
  { 7056, 22, 33, 28, 3, -32 },
  { 7147, 23, 45, 29, 3, -44 },
  { 7277, 23, 33, 27, 2, -32 },
  { 7372, 23, 45, 29, 2, -44 },
  { 7502, 24, 33, 28, 2, -32 },
  { 7601, 17, 45, 19, 1, -45 },
  { 7697, 24, 44, 29, 2, -32 },
  { 7829, 22, 44, 28, 3, -44 },
  { 7950, 8, 42, 14, 3, -42 },
  { 7992, 11, 54, 14, -1, -42 },
  { 8067, 24, 44, 27, 3, -44 },
  { 8199, 6, 44, 14, 4, -44 },
  { 8232, 37, 32, 43, 3, -32 },
  { 8380, 22, 32, 28, 3, -32 },
  { 8468, 25, 33, 29, 2, -32 },
  { 8572, 23, 44, 29, 3, -32 },
  { 8699, 23, 44, 29, 2, -32 },
  { 8826, 14, 32, 19, 3, -32 },
  { 8882, 22, 33, 26, 2, -32 },
  { 8973, 15, 39, 18, 1, -38 },
  { 9047, 22, 32, 28, 3, -31 },
  { 9135, 23, 31, 25, 1, -31 },
  { 9225, 35, 31, 37, 1, -31 },
  { 9361, 24, 31, 26, 1, -31 },
  { 9454, 23, 43, 25, 1, -31 },
  { 9578, 22, 31, 26, 2, -31 },
  { 9664, 14, 55, 18, 2, -45 },
  { 9761, 5, 49, 14, 5, -41 },
  { 9792, 15, 55, 18, 1, -45 },
  { 9896, 27, 12, 33, 3, -23 },
};

const GFXfont RobotoCondensed_Medium58pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium58pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium58pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _ROBOTOCONDENSED_MEDIUM58PT7B_H_
