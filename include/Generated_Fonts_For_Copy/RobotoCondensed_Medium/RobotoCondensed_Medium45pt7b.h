#ifndef _ROBOTOCONDENSED_MEDIUM45PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xF9, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0x00, 0x07, 0xBE, 0xFF, 0xFF,
  0x9E, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xEF, 0x1D, 0xE3, 0xBC, 0x77, 0x8E,
  0xE1, 0xDC, 0x3B, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38,
  0x70, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x0E, 0x00,
  0x38, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x1C, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x81, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07,
  0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0E, 0x1C, 0x0F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x81, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x70,
  0xF0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x0F, 0x1E, 0x00,
  0x78, 0xF0, 0x03, 0x87, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x8F, 0xEF, 0xE3, 0xE0, 0xF9, 0xF8, 0x3F, 0x7C, 0x07, 0xDF, 0x01,
  0xF7, 0xC0, 0x7D, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01,
  0xF7, 0xC0, 0x7D, 0xF8, 0x3F, 0x7F, 0xBF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0,
  0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x0F, 0x06, 0x07, 0x87, 0x87, 0x83, 0xC3, 0xC3, 0x81,
  0xE1, 0xE3, 0xC0, 0xF0, 0xF1, 0xC0, 0x78, 0x79, 0xE0, 0x3C, 0x3C, 0xE0,
  0x0F, 0x3C, 0xF0, 0x07, 0xFE, 0x70, 0x01, 0xFE, 0x78, 0x00, 0x3E, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x7C, 0x00, 0x1E,
  0x7F, 0x80, 0x0E, 0x7F, 0xE0, 0x0F, 0x3C, 0xF0, 0x07, 0x3C, 0x38, 0x07,
  0x9E, 0x1E, 0x03, 0x8F, 0x0F, 0x03, 0xC7, 0x87, 0x81, 0xC3, 0xC3, 0xC1,
  0xC1, 0xE1, 0xE0, 0xE0, 0xF0, 0xE0, 0x20, 0x3C, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xC3, 0xE0, 0x0F,
  0x83, 0xC0, 0x1F, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x78, 0x7F, 0xE0, 0xF1, 0xFF, 0xE3,
  0xE3, 0xE7, 0xE7, 0xCF, 0xC7, 0xEF, 0x9F, 0x07, 0xDE, 0x3E, 0x0F, 0xFC,
  0x7C, 0x0F, 0xF8, 0xF8, 0x0F, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x83,
  0xF9, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0x3F, 0x01,
  0xF8, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0xE0, 0x00, 0x80, 0x70, 0x3C,
  0x1F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xF0, 0x78,
  0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0x7C, 0x0F, 0x01, 0xC0, 0x20, 0x40, 0x0C, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78,
  0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x06, 0x00, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x83, 0xC1,
  0x3E, 0x78, 0xF7, 0xF7, 0xFE, 0xFF, 0xFF, 0xC7, 0xFF, 0xE0, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x80, 0x1E, 0xF8, 0x07, 0xCF, 0x00, 0xF0, 0xF0,
  0x3C, 0x1F, 0x03, 0x81, 0xC0, 0x20, 0x10, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0x8F, 0x3E, 0x79, 0xF3, 0xC1,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x3F, 0xBF, 0x9F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0, 0x1F, 0x7C,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C,
  0x07, 0xDF, 0x03, 0xE7, 0xE0, 0xF8, 0xFC, 0xFE, 0x3F, 0xFF, 0x07, 0xFF,
  0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x60, 0x3C, 0x3F, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xF3,
  0xF8, 0xF8, 0x1F, 0x3F, 0x03, 0xF7, 0xC0, 0x7E, 0xF8, 0x07, 0xDF, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7F, 0x3F, 0x9F, 0x07, 0xEF, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0xC0, 0xF9, 0xFC, 0xFE, 0x7F, 0xFF, 0x0F, 0xFF,
  0x81, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x03, 0xCF, 0x80, 0x3C, 0xF8, 0x07,
  0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F, 0xFF,
  0x9F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF7, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF3, 0xF9,
  0xFC, 0x38, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF,
  0xC1, 0xF9, 0xF9, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xE7, 0xE0, 0xFB, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xF8,
  0xFC, 0xFC, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3E, 0xF8, 0x0F, 0xBF, 0x03, 0xE7,
  0xC1, 0xF9, 0xFD, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x3F, 0x3F, 0x9F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0, 0x3F, 0x7C,
  0x0F, 0xDF, 0x03, 0xF7, 0xC0, 0xF9, 0xF0, 0x3E, 0x3E, 0x0F, 0x8F, 0xCF,
  0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0xC3, 0xE1, 0xF9,
  0xF0, 0x3E, 0x7C, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC,
  0x07, 0xDF, 0x01, 0xF7, 0xE0, 0xFD, 0xFC, 0xFE, 0x3F, 0xFF, 0x87, 0xFF,
  0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x3F, 0x3F, 0x1F, 0x87, 0xE7, 0xC0, 0xFB, 0xF0, 0x3E, 0xF8,
  0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01,
  0xF7, 0xC0, 0xFD, 0xF0, 0x3F, 0x7F, 0x3F, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC,
  0x7F, 0xDF, 0x07, 0xC7, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0xFE, 0x00, 0x3E, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0x78,
  0x1C, 0x3E, 0x3F, 0x3F, 0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0xF0, 0x30, 0x00, 0x02, 0x00, 0x1C,
  0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE0, 0xFF,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x01, 0xFF,
  0x07, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF8, 0x00,
  0xE0, 0x00, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF,
  0xE7, 0xF7, 0xF3, 0xE0, 0xFB, 0xF0, 0x7F, 0xF8, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3C, 0x03,
  0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x00, 0x70, 0xF0, 0x0F, 0x80, 0xF1, 0xE0, 0x3F, 0xC0, 0xE7, 0x80,
  0xFF, 0xC1, 0xCF, 0x03, 0xE7, 0x83, 0x9E, 0x0F, 0x0F, 0x07, 0x38, 0x1E,
  0x1E, 0x0E, 0x70, 0x78, 0x3C, 0x1D, 0xE0, 0xF0, 0x78, 0x3F, 0xC1, 0xE0,
  0xF0, 0x7F, 0x87, 0x81, 0xE0, 0xFF, 0x0F, 0x03, 0xC1, 0xDE, 0x1E, 0x07,
  0x03, 0xBC, 0x3C, 0x0E, 0x07, 0x78, 0x78, 0x1C, 0x0E, 0xF0, 0xF0, 0x78,
  0x3D, 0xE1, 0xE0, 0xF0, 0x73, 0xC3, 0xE3, 0xE1, 0xE3, 0x83, 0xFF, 0xE7,
  0x87, 0x07, 0xFF, 0xFF, 0x0F, 0x07, 0xF3, 0xFC, 0x1E, 0x07, 0x83, 0xE0,
  0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x80, 0x00,
  0xFF, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x79,
  0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x1F,
  0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0xF8, 0x03,
  0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xF7, 0xE0, 0x01,
  0xFB, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x3F, 0xCF, 0x80, 0x7E, 0xF8, 0x07,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x7E, 0xF8, 0x07, 0xCF, 0x81, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x0F, 0xEF, 0x80, 0x7E, 0xF8, 0x03, 0xEF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3E,
  0xF8, 0x07, 0xEF, 0x83, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x1F, 0xEF, 0xF0, 0xFC, 0x07, 0xE3, 0xE0, 0x0F, 0x9F, 0x80,
  0x3E, 0x7C, 0x00, 0xFD, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x7E, 0x00, 0xF9,
  0xF8, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0xFB, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF8, 0xFF, 0xCF, 0x80, 0xFC, 0xF8, 0x07,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x7E,
  0xF8, 0x0F, 0xCF, 0x8F, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF,
  0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBE, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xEF,
  0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x0F, 0x9F, 0x80, 0x3F, 0x7C, 0x00, 0xFD,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x00, 0x7D, 0xF0, 0x01, 0xF7,
  0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xF0,
  0x0F, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x3F, 0xC0, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xE1, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xFB, 0xE0, 0x0F,
  0xCF, 0x80, 0x7F, 0x3E, 0x01, 0xF8, 0xF8, 0x0F, 0xC3, 0xE0, 0x7F, 0x0F,
  0x81, 0xF8, 0x3E, 0x0F, 0xC0, 0xF8, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0x8F,
  0xC0, 0x3E, 0x7E, 0x00, 0xF9, 0xF8, 0x03, 0xEF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0x9F, 0x80, 0xFE, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0x83, 0xF0, 0x3E, 0x07,
  0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x3F, 0x0F, 0x80, 0xFE, 0x3E, 0x01, 0xF8,
  0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x7E, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xDF, 0xFB, 0xE0, 0x3D, 0xFF, 0xBE, 0x07, 0xDF, 0xFB, 0xE0, 0x79, 0xFF,
  0x9E, 0x07, 0x9F, 0xF9, 0xF0, 0xF9, 0xFF, 0x9F, 0x0F, 0x9F, 0xF8, 0xF0,
  0xF1, 0xFF, 0x8F, 0x9F, 0x1F, 0xF8, 0xF9, 0xF1, 0xFF, 0x87, 0x9E, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x3F, 0xC1, 0xFF, 0x83,
  0xFC, 0x1F, 0xF8, 0x3F, 0xC1, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x1F, 0x81,
  0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF0, 0x1F, 0xF8,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFE, 0xF8, 0x1F, 0xF9, 0xF0, 0x7F, 0xE7,
  0xC1, 0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x1F, 0xF8, 0x7C, 0x7F, 0xE1, 0xF1,
  0xFF, 0x83, 0xE7, 0xFE, 0x0F, 0x9F, 0xF8, 0x1F, 0x7F, 0xE0, 0x7D, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xE0, 0x3F, 0x0F, 0x80, 0x3E, 0x3F,
  0x00, 0x7E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x3E,
  0x7E, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xFC, 0x07, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0x81, 0xFE,
  0x7C, 0x03, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xFB,
  0xE0, 0x0F, 0xDF, 0x03, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x07, 0xE0, 0x3F, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x7E, 0x7C, 0x00,
  0x7C, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0xFC, 0xFC,
  0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x02,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0x83, 0xFC, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0x7C, 0xF8, 0x03,
  0xE7, 0xC0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C,
  0x03, 0xF3, 0xE0, 0x1F, 0x9F, 0x07, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xE0,
  0x7C, 0x1F, 0x03, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7E, 0x3E, 0x01, 0xF1,
  0xF0, 0x0F, 0xCF, 0x80, 0x7E, 0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F,
  0xBF, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x1F, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xFD, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xE7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0,
  0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE7, 0xC0,
  0x03, 0xE7, 0xC0, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xC0,
  0x1F, 0x7C, 0x03, 0xE0, 0x3F, 0x7C, 0x07, 0xE0, 0x3E, 0x7C, 0x07, 0xE0,
  0x3E, 0x7C, 0x07, 0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0x3E, 0x7E, 0x07, 0xF0,
  0x3E, 0x3E, 0x0F, 0xF0, 0x7E, 0x3E, 0x0F, 0xF0, 0x7C, 0x3E, 0x0F, 0xF0,
  0x7C, 0x3E, 0x0F, 0xF0, 0x7C, 0x3E, 0x0F, 0xF8, 0x7C, 0x1F, 0x1F, 0x78,
  0x7C, 0x1F, 0x1E, 0x78, 0xF8, 0x1F, 0x1E, 0x78, 0xF8, 0x1F, 0x1E, 0x78,
  0xF8, 0x1F, 0x1E, 0x3C, 0xF8, 0x0F, 0x3E, 0x3C, 0xF8, 0x0F, 0xBC, 0x3C,
  0xF0, 0x0F, 0xBC, 0x3D, 0xF0, 0x0F, 0xBC, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F,
  0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F,
  0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x00, 0x7E, 0xFC, 0x01, 0xF8, 0xFC,
  0x03, 0xF1, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x83, 0xF0, 0x7E, 0x03, 0xE0,
  0xFC, 0x07, 0xE3, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0xDF, 0x80, 0x0F, 0xBE,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x07,
  0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81,
  0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xE7,
  0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xBC,
  0x0F, 0x78, 0x1E, 0xF0, 0x3C, 0xF0, 0xF1, 0xE1, 0xE3, 0xC7, 0xC3, 0xCF,
  0x07, 0x9E, 0x0F, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0,
  0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x3F, 0x1F,
  0x07, 0xEF, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xFF, 0xE1, 0xFF,
  0xF8, 0xFF, 0xFE, 0x7F, 0x8F, 0x9F, 0x03, 0xEF, 0xC0, 0xFB, 0xE0, 0x3E,
  0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0xC1, 0xFB, 0xF9, 0xFE, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE3, 0xFE, 0xF8, 0x3E, 0x3E, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x9F, 0x83, 0xEF, 0xF0, 0xFF, 0xFE, 0x3F,
  0xFF, 0xCF, 0xF7, 0xF3, 0xF0, 0x7E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80,
  0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3E,
  0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x1F, 0xBF,
  0x9F, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xF3, 0xFC, 0x3C, 0x7E, 0x00, 0x03,
  0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xF3, 0xF3, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0xFE,
  0x07, 0xDF, 0x03, 0xEF, 0xE7, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0xF0,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x7C, 0x7C, 0x7F, 0xDF, 0x3F, 0xF7, 0xDF, 0xFF, 0xF7, 0xF3, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0xCF, 0xF7, 0xFF, 0xFC,
  0xFF, 0xDF, 0x1F, 0xF7, 0xC1, 0xF1, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0x3F, 0x9F, 0x03, 0xE7, 0xC0, 0xFB, 0xE0,
  0x1E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x31, 0xFE, 0x3E, 0x3F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F,
  0xE0, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFE, 0x8F, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC7, 0xC7,
  0xFD, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xBF, 0xDF, 0x03, 0xFF, 0xC0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF,
  0x01, 0xF7, 0xC0, 0xFD, 0xFE, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF,
  0x7C, 0x1F, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x40, 0x3E,
  0x3E, 0x3F, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x3F, 0x1F,
  0xBF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xC0, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x06, 0x07,
  0xC7, 0xE3, 0xF0, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF1, 0xFD, 0xFF, 0xFD, 0xFE, 0xFE, 0x7C, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x81, 0xFB, 0xE0,
  0xFC, 0xF8, 0x7E, 0x3E, 0x1F, 0x0F, 0x8F, 0xC3, 0xE7, 0xE0, 0xF9, 0xF0,
  0x3E, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFD, 0xF0, 0x3E, 0x7E, 0x0F, 0x8F, 0xC3, 0xE3,
  0xF0, 0xF8, 0x7E, 0x3E, 0x0F, 0x8F, 0x83, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F,
  0xBE, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF1, 0xF8, 0x1F, 0x0F, 0xBF, 0xC7, 0xFC, 0xFF, 0xFE, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFE, 0x7F, 0xEF, 0xEF, 0x83, 0xF8, 0x3F, 0xF8, 0x1F,
  0x81, 0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xFF, 0x81, 0xF0, 0x1F,
  0xF8, 0x1F, 0x01, 0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xFF, 0x81,
  0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x1F, 0x01,
  0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xFF, 0x81, 0xF0, 0x1F, 0xF8,
  0x1F, 0x01, 0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xFF, 0x81, 0xF0,
  0x1F, 0xF8, 0xFC, 0x7C, 0xFF, 0x3E, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC7, 0xF3, 0xF8, 0xFC, 0x1F, 0xBF, 0x01, 0xF7, 0xC0, 0x3E, 0xF8,
  0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x80, 0xF9, 0xF0,
  0x3F, 0x3F, 0x9F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F,
  0xC0, 0xF1, 0xF8, 0x79, 0xFE, 0x3D, 0xFF, 0x9F, 0xFF, 0xEF, 0xF7, 0xF7,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0xCF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3,
  0xEF, 0xF1, 0xF3, 0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC7, 0xC7, 0xFD, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0x3F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFD, 0xFC, 0xFF, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0xF1, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x07, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xE3, 0xF7, 0xE0, 0xFB, 0xE0, 0x7D,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0xF8, 0x1F, 0xFC, 0x07, 0xFE,
  0x07, 0xDF, 0x87, 0xE7, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xFD, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xBE, 0x07, 0xDF,
  0x07, 0xEF, 0xEF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFC, 0x7F, 0x9E, 0x1F, 0x8F,
  0xF8, 0x0F, 0xFE, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F,
  0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0x81, 0xF3,
  0xE0, 0x7C, 0xF8, 0x1F, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0xC0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x1E, 0x03, 0xFF, 0x03, 0xE0,
  0x7F, 0xE0, 0x7C, 0x1F, 0x3E, 0x0F, 0x83, 0xE7, 0xC3, 0xF0, 0x7C, 0xF8,
  0x7F, 0x0F, 0x9F, 0x0F, 0xE1, 0xE1, 0xE1, 0xFC, 0x7C, 0x3E, 0x7F, 0x8F,
  0x87, 0xCF, 0x79, 0xF0, 0xF9, 0xEF, 0x3E, 0x1F, 0x3D, 0xE7, 0x81, 0xEF,
  0x3C, 0xF0, 0x3D, 0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xF0,
  0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0,
  0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x3E, 0x03, 0xE0, 0xFC, 0x0F, 0xDF, 0x03, 0xE7, 0xE1, 0xF8, 0xF8, 0x7C,
  0x3F, 0x3F, 0x07, 0xCF, 0x81, 0xFB, 0xE0, 0x3F, 0xF0, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xEF, 0x81, 0xF3, 0xE0, 0xFC, 0xFC,
  0x3E, 0x1F, 0x1F, 0x87, 0xE7, 0xC0, 0xFB, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xEF, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x1F, 0x9F, 0x07, 0xC7, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x3E, 0x0F, 0x8F, 0x81, 0xF3, 0xE0, 0x7C, 0xF8,
  0x1F, 0x7C, 0x03, 0xDF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x1E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0,
  0x0F, 0x01, 0xF0, 0x3F, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFE, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x0E, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x40, 0x0E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xF0,
  0x3E, 0x07, 0xC1, 0xF8, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C,
  0x0F, 0x83, 0xE0, 0xF8, 0x0E, 0x01, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0x03, 0xCF, 0xFC, 0x1E, 0xFF, 0xF0, 0xF7, 0xFF, 0xFF, 0xBC, 0x3F, 0xF9,
  0xE0, 0xFF, 0xDE, 0x03, 0xFC, 0x00, 0x07, 0x80,
};

const GFXglyph RobotoCondensed_Medium45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 32, 11, 3, -32 },
  { 25, 11, 11, 14, 2, -34 },
  { 41, 21, 32, 24, 2, -32 },
  { 125, 18, 41, 23, 2, -37 },
  { 218, 25, 32, 29, 2, -32 },
  { 318, 23, 32, 25, 2, -32 },
  { 410, 4, 11, 8, 2, -34 },
  { 416, 10, 46, 14, 3, -36 },
  { 474, 11, 46, 14, 1, -36 },
  { 538, 19, 19, 20, 1, -32 },
  { 584, 18, 24, 22, 2, -27 },
  { 638, 7, 12, 10, 1, -5 },
  { 649, 10, 4, 14, 2, -16 },
  { 654, 6, 6, 13, 3, -6 },
  { 659, 15, 35, 16, 0, -32 },
  { 725, 18, 32, 23, 2, -32 },
  { 797, 11, 32, 23, 4, -32 },
  { 841, 19, 32, 23, 2, -32 },
  { 917, 18, 32, 23, 2, -32 },
  { 989, 20, 32, 23, 1, -32 },
  { 1069, 18, 32, 23, 3, -32 },
  { 1141, 18, 32, 23, 3, -32 },
  { 1213, 19, 32, 23, 2, -32 },
  { 1289, 18, 32, 23, 2, -32 },
  { 1361, 18, 32, 23, 2, -32 },
  { 1433, 6, 25, 11, 3, -25 },
  { 1452, 8, 32, 10, 1, -25 },
  { 1484, 15, 20, 20, 2, -24 },
  { 1522, 16, 13, 22, 3, -21 },
  { 1548, 16, 20, 21, 3, -24 },
  { 1588, 17, 32, 20, 1, -32 },
  { 1656, 31, 41, 35, 2, -31 },
  { 1815, 25, 32, 26, 1, -32 },
  { 1915, 20, 32, 25, 3, -32 },
  { 1995, 22, 32, 26, 2, -32 },
  { 2083, 20, 32, 26, 3, -32 },
  { 2163, 18, 32, 22, 3, -32 },
  { 2235, 17, 32, 22, 3, -32 },
  { 2303, 22, 32, 26, 2, -32 },
  { 2391, 22, 32, 28, 3, -32 },
  { 2479, 6, 32, 12, 3, -32 },
  { 2503, 18, 32, 22, 1, -32 },
  { 2575, 22, 32, 25, 3, -32 },
  { 2663, 17, 32, 21, 3, -32 },
  { 2731, 28, 32, 34, 3, -32 },
  { 2843, 22, 32, 28, 3, -32 },
  { 2931, 23, 32, 27, 2, -32 },
  { 3023, 21, 32, 25, 3, -32 },
  { 3107, 23, 38, 27, 2, -32 },
  { 3217, 21, 32, 24, 3, -32 },
  { 3301, 20, 32, 24, 2, -32 },
  { 3381, 22, 32, 24, 1, -32 },
  { 3469, 20, 32, 26, 3, -32 },
  { 3549, 24, 32, 26, 1, -32 },
  { 3645, 32, 32, 34, 1, -32 },
  { 3773, 23, 32, 25, 1, -32 },
  { 3865, 24, 32, 24, 0, -32 },
  { 3961, 20, 32, 24, 2, -32 },
  { 4041, 8, 44, 12, 3, -37 },
  { 4085, 16, 35, 17, 1, -32 },
  { 4155, 8, 44, 12, 1, -37 },
  { 4199, 15, 16, 17, 1, -32 },
  { 4229, 18, 4, 18, 0, 0 },
  { 4238, 11, 7, 14, 1, -34 },
  { 4248, 18, 24, 21, 2, -24 },
  { 4302, 18, 34, 22, 3, -34 },
  { 4379, 17, 24, 21, 2, -24 },
  { 4430, 18, 34, 22, 2, -34 },
  { 4507, 18, 24, 21, 2, -24 },
  { 4561, 13, 34, 15, 1, -34 },
  { 4617, 18, 33, 22, 2, -24 },
  { 4692, 17, 34, 22, 2, -34 },
  { 4765, 5, 33, 11, 3, -33 },
  { 4786, 9, 42, 11, -1, -33 },
  { 4834, 18, 34, 21, 3, -34 },
  { 4911, 5, 34, 11, 3, -34 },
  { 4933, 28, 24, 34, 3, -24 },
  { 5017, 17, 24, 22, 2, -24 },
  { 5068, 19, 24, 22, 2, -24 },
  { 5125, 17, 33, 22, 3, -24 },
  { 5196, 18, 33, 22, 2, -24 },
  { 5271, 10, 24, 14, 3, -24 },
  { 5301, 17, 24, 20, 2, -24 },
  { 5352, 12, 30, 14, 0, -30 },
  { 5397, 17, 24, 22, 2, -24 },
  { 5448, 18, 24, 20, 1, -24 },
  { 5502, 27, 24, 29, 1, -24 },
  { 5583, 18, 24, 20, 1, -24 },
  { 5637, 18, 33, 19, 1, -24 },
  { 5712, 16, 24, 20, 2, -24 },
  { 5760, 12, 43, 14, 1, -35 },
  { 5825, 3, 38, 11, 4, -32 },
  { 5840, 11, 43, 14, 1, -35 },
  { 5900, 21, 9, 26, 2, -18 },
};

const GFXfont RobotoCondensed_Medium45pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium45pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium45pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOCONDENSED_MEDIUM45PT7B_H_
