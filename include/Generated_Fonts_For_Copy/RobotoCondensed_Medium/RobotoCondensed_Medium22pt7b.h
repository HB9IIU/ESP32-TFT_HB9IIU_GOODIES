#ifndef _ROBOTOCONDENSED_MEDIUM22PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium22pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0x80, 0xFB, 0xDE, 0xF7, 0xBD, 0xEC, 0x09,
  0x82, 0x61, 0x98, 0x64, 0x7F, 0xDF, 0xF1, 0xB0, 0x4C, 0x13, 0x0C, 0xCF,
  0xFB, 0xFE, 0x36, 0x09, 0x82, 0x60, 0x98, 0x0C, 0x06, 0x07, 0x8F, 0xE7,
  0x33, 0x1D, 0x8E, 0xC0, 0x70, 0x1E, 0x07, 0xC0, 0xE0, 0x3F, 0x1F, 0x8E,
  0xC7, 0x7F, 0x1F, 0x02, 0x01, 0x00, 0x78, 0x0F, 0x80, 0xCC, 0xCC, 0xC8,
  0xCD, 0x8F, 0x90, 0x7B, 0x00, 0x20, 0x06, 0x00, 0xCE, 0x0D, 0xF1, 0xB3,
  0x1B, 0x33, 0x33, 0x01, 0xF0, 0x0E, 0x1C, 0x07, 0xC1, 0xDC, 0x31, 0x86,
  0x30, 0xEC, 0x0F, 0x81, 0xC0, 0x7C, 0xDD, 0xDB, 0xBB, 0x63, 0xEE, 0x39,
  0xC7, 0x1F, 0xF1, 0xE7, 0xFF, 0xF0, 0x08, 0xC6, 0x63, 0x31, 0x8C, 0x67,
  0x39, 0xCE, 0x71, 0x8C, 0x63, 0x0C, 0x61, 0x8C, 0x20, 0x86, 0x30, 0xC6,
  0x18, 0xC6, 0x39, 0xCE, 0x73, 0x9C, 0xE6, 0x31, 0x98, 0xCC, 0x62, 0x00,
  0x0C, 0x03, 0x00, 0xC3, 0xFE, 0x3F, 0x07, 0x03, 0xE0, 0xCC, 0x23, 0x00,
  0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x00, 0x77, 0x76, 0x64, 0xFF, 0xC0, 0x7D, 0x80, 0x06, 0x0C, 0x30, 0x60,
  0xC1, 0x86, 0x0C, 0x18, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0xC0, 0x3E,
  0x3F, 0x98, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3B, 0x99, 0xFC, 0x7C, 0x09, 0xFF, 0xB1, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x3E, 0x3F, 0xB9, 0xDC, 0x7C, 0x38, 0x1C, 0x0C, 0x0E,
  0x0E, 0x07, 0x07, 0x07, 0x07, 0x03, 0x83, 0xFF, 0xFF, 0x3C, 0x3F, 0xB9,
  0xDC, 0x70, 0x38, 0x18, 0x1C, 0x3C, 0x1F, 0x01, 0x80, 0xE0, 0x7C, 0x3F,
  0x39, 0xFC, 0x78, 0x07, 0x07, 0x83, 0xC3, 0xE1, 0xF1, 0xB8, 0xDC, 0xCE,
  0x67, 0x63, 0xBF, 0xFF, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x7F, 0xBF, 0xD8,
  0x0C, 0x06, 0x03, 0xF1, 0xFC, 0xC7, 0x03, 0x80, 0xC0, 0x60, 0x7E, 0x3B,
  0x19, 0xFC, 0x7C, 0x0E, 0x0F, 0x0E, 0x0E, 0x06, 0x03, 0x73, 0xFD, 0xE7,
  0xE3, 0xF0, 0xF8, 0x7C, 0x36, 0x3B, 0x98, 0xFC, 0x3C, 0xFF, 0xFF, 0xC0,
  0xE0, 0x60, 0x30, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0x81,
  0xC0, 0xC0, 0xE0, 0x3E, 0x3F, 0x9D, 0xDC, 0x7E, 0x3B, 0x19, 0xDC, 0x7C,
  0x7F, 0x31, 0xB8, 0xFC, 0x7E, 0x3F, 0x1D, 0xFC, 0x7C, 0x3C, 0x3F, 0x19,
  0xDC, 0x6E, 0x3F, 0x1F, 0x8F, 0xC7, 0x67, 0xBF, 0xCE, 0xC0, 0x60, 0x70,
  0x70, 0xF0, 0x70, 0x7D, 0x80, 0x00, 0x0F, 0xB0, 0x7D, 0x80, 0x00, 0x0D,
  0xBF, 0xA0, 0x02, 0x1C, 0x7B, 0xCE, 0x1C, 0x1E, 0x0F, 0x0E, 0x04, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x80, 0xE0, 0xF8, 0x3E, 0x07, 0x07, 0x3E,
  0xF8, 0xE0, 0x80, 0x3C, 0xFE, 0xE7, 0xC7, 0x07, 0x06, 0x0E, 0x1C, 0x18,
  0x38, 0x38, 0x00, 0x00, 0x10, 0x38, 0x38, 0x07, 0xE0, 0x1F, 0xE0, 0x60,
  0x61, 0x80, 0x66, 0x00, 0x4C, 0x78, 0xD1, 0xF9, 0xE3, 0x33, 0xCC, 0x67,
  0x98, 0xCF, 0x31, 0x1E, 0x62, 0x3C, 0xCC, 0x59, 0xFF, 0xB1, 0xDE, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1F, 0x00, 0xD8, 0x06, 0xC0, 0x77, 0x03, 0x18, 0x18, 0xC1,
  0xC7, 0x0F, 0xF8, 0x7F, 0xC7, 0x07, 0x38, 0x39, 0x81, 0xDC, 0x06, 0xFF,
  0x3F, 0xEE, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1B, 0xFC, 0xFF, 0xB8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFB, 0xFC, 0x1F, 0x07, 0xF1, 0xC7, 0x30,
  0x6E, 0x0F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x76,
  0x0C, 0xE3, 0x8F, 0xE0, 0xF8, 0xFE, 0x3F, 0xCE, 0x3B, 0x87, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xF8, 0xEF, 0xF3,
  0xF8, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFE, 0xFF, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xFE, 0xFF, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0x1F, 0x07, 0xF9, 0xC7, 0x30, 0x6E, 0x0F, 0xC0, 0x38, 0x07, 0x00,
  0xE3, 0xFC, 0x7F, 0x83, 0xF0, 0x76, 0x0E, 0xE3, 0xCF, 0xF0, 0xFC, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0xC3, 0xC3, 0xE7, 0x7E, 0x3C, 0xE1, 0xFC, 0x3B, 0x8E, 0x71, 0xCE, 0x71,
  0xDC, 0x3B, 0x07, 0xE0, 0xFE, 0x1E, 0xC3, 0x9C, 0x71, 0xCE, 0x39, 0xC3,
  0xB8, 0x77, 0x07, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0,
  0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xBF, 0xC6, 0xFB, 0x1B, 0xEC,
  0xEF, 0xBB, 0x3E, 0x6C, 0xF9, 0xF3, 0xE7, 0x8F, 0x8E, 0x3E, 0x38, 0xF8,
  0xC3, 0xE0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0xF8, 0xFB, 0x1F, 0x73,
  0xE6, 0x7C, 0xEF, 0x8D, 0xF1, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0x1F,
  0x07, 0xF1, 0xC7, 0x30, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x76, 0x0E, 0xE3, 0x8F, 0xE0, 0xF8, 0xFF, 0x1F, 0xF3,
  0x87, 0x70, 0x6E, 0x0F, 0xC1, 0xF8, 0x37, 0x0E, 0xFF, 0x9F, 0xE3, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x1F, 0x07, 0xF1, 0xC7, 0x30,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x76,
  0x0E, 0xE3, 0x8F, 0xE0, 0xFC, 0x01, 0xC0, 0x1C, 0x01, 0x00, 0xFF, 0x1F,
  0xF3, 0x8F, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x1C, 0xFF, 0x9F, 0xE3,
  0x9C, 0x71, 0xCE, 0x39, 0xC3, 0xB8, 0x77, 0x06, 0x1E, 0x1F, 0xC7, 0x3B,
  0x87, 0xE1, 0xF8, 0x07, 0x80, 0xF8, 0x1F, 0x80, 0xE0, 0x1F, 0x07, 0xE1,
  0xFC, 0xE7, 0xF8, 0x78, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE1, 0xDC, 0x77, 0xF8, 0x7C, 0xE0, 0x77, 0x07, 0x70,
  0x67, 0x0E, 0x30, 0xE3, 0x8E, 0x38, 0xC1, 0x9C, 0x19, 0xC1, 0xD8, 0x1D,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x07, 0x00, 0x70, 0xC3, 0x8F, 0x87, 0x1F,
  0x8E, 0x3F, 0x1C, 0x6E, 0x78, 0xCC, 0xF9, 0x99, 0xB7, 0x33, 0x6E, 0x76,
  0xDC, 0xF9, 0xB0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0E, 0x1C,
  0x1C, 0x18, 0xE1, 0xDC, 0x39, 0xC6, 0x39, 0xC3, 0xB0, 0x7E, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0xFC, 0x1D, 0x87, 0x38, 0xE3, 0x38, 0x77, 0x0E,
  0xE0, 0xE7, 0x0E, 0x70, 0xC3, 0x1C, 0x39, 0xC1, 0x98, 0x1B, 0x81, 0xF0,
  0x0F, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0xFF, 0xFF, 0xF0, 0x38, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06,
  0x03, 0x81, 0xC0, 0x70, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xFF, 0xE0, 0x60, 0x70, 0x70, 0x30,
  0x38, 0x38, 0x18, 0x1C, 0x1C, 0x0C, 0x0E, 0x0E, 0x06, 0x06, 0x07, 0x03,
  0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x30,
  0x71, 0xE3, 0xC6, 0xD9, 0xB3, 0x63, 0xFF, 0xFF, 0xC0, 0xE3, 0x8C, 0x3E,
  0x3F, 0xB9, 0xDC, 0x60, 0x31, 0xF9, 0xFD, 0xC6, 0xC3, 0x73, 0xBF, 0xCF,
  0x60, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x73, 0xFD, 0xC7, 0xE3, 0xF1,
  0xF8, 0x7C, 0x3E, 0x3F, 0x1F, 0x8F, 0xFE, 0xEE, 0x00, 0x3E, 0x7F, 0xE3,
  0xE3, 0xC0, 0xC0, 0xC0, 0xC0, 0xE3, 0xE3, 0x7F, 0x3C, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x39, 0xDD, 0xFF, 0xCF, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F,
  0x1F, 0x9E, 0xFF, 0x3B, 0x80, 0x3E, 0x3F, 0x98, 0xDC, 0x6E, 0x3F, 0xFF,
  0xFF, 0x80, 0xE0, 0x70, 0x9F, 0xC7, 0xC0, 0x1C, 0xF7, 0x1C, 0x73, 0xEF,
  0x9C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0x3F, 0xBF, 0xF8, 0xFC,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xF1, 0xDF, 0xE7, 0x70, 0x3A, 0x19,
  0xFC, 0x7C, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x73, 0xFD, 0xC6, 0xE3,
  0x71, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0x80, 0x7D, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x27, 0x70, 0x07, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x7E, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x3B, 0x9D,
  0xDC, 0xEC, 0x7E, 0x3F, 0x1F, 0x8E, 0xE7, 0x73, 0x9D, 0xC6, 0xE3, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xEE, 0x7B, 0xFF, 0xFE, 0x79,
  0xF8, 0xE3, 0xE3, 0x0F, 0x8C, 0x3E, 0x30, 0xF8, 0xC3, 0xE3, 0x0F, 0x8C,
  0x3E, 0x30, 0xF8, 0xC3, 0xEE, 0x7F, 0xB8, 0xDC, 0x6E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x70, 0x3E, 0x3F, 0xB8, 0xFC, 0x7C, 0x1E,
  0x0F, 0x07, 0x83, 0xE3, 0xF1, 0xDF, 0xC7, 0xC0, 0xEE, 0x7F, 0xB8, 0xFC,
  0x7E, 0x3F, 0x0F, 0x87, 0xC7, 0xE3, 0xF1, 0xFF, 0xDD, 0xCE, 0x07, 0x03,
  0x81, 0xC0, 0x3B, 0xBF, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE3,
  0xF1, 0xDF, 0xE7, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFF, 0xF8, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x3C, 0x7E, 0xE7, 0xE3, 0xF0, 0x7C, 0x1E,
  0x07, 0xC3, 0xE7, 0x7F, 0x3C, 0x30, 0xCF, 0xFF, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x3C, 0x70, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF3, 0xDF, 0xE7, 0x70, 0x61, 0xB1, 0xDC, 0xEE, 0x63, 0x31,
  0xB8, 0xD8, 0x7C, 0x1E, 0x0F, 0x07, 0x01, 0x80, 0x63, 0x1D, 0x8C, 0x66,
  0x79, 0x9D, 0xE6, 0x77, 0xB8, 0xDE, 0xC3, 0x4F, 0x0F, 0x3C, 0x3C, 0xF0,
  0x73, 0xC1, 0x86, 0x06, 0x18, 0x73, 0xB9, 0xCD, 0xC7, 0xC1, 0xE0, 0xE0,
  0x78, 0x3C, 0x3F, 0x1B, 0x9C, 0xEC, 0x70, 0xE3, 0xB1, 0xDC, 0xCE, 0x63,
  0x71, 0xB8, 0xF8, 0x3C, 0x1E, 0x0E, 0x07, 0x01, 0x81, 0xC0, 0xC1, 0xE0,
  0xE0, 0xFF, 0xFF, 0x06, 0x0E, 0x1C, 0x18, 0x38, 0x30, 0x70, 0xE0, 0xFF,
  0xFF, 0x19, 0xCC, 0xE7, 0x39, 0xCE, 0x67, 0x38, 0xC7, 0x39, 0xCE, 0x71,
  0x8C, 0x70, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x43, 0x83, 0x0C, 0x30,
  0xC3, 0x0C, 0x38, 0x71, 0xCE, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x18, 0x40,
  0x38, 0xDF, 0x36, 0xEF, 0x1F, 0xC3, 0x80,
};

const GFXglyph RobotoCondensed_Medium22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 16, 6, 1, -16 },
  { 7, 5, 6, 7, 1, -17 },
  { 11, 10, 16, 12, 1, -16 },
  { 31, 9, 20, 11, 1, -18 },
  { 54, 12, 16, 14, 1, -16 },
  { 78, 11, 16, 12, 1, -16 },
  { 100, 2, 6, 4, 1, -17 },
  { 102, 5, 23, 7, 1, -18 },
  { 117, 5, 23, 7, 1, -18 },
  { 132, 10, 9, 10, 0, -16 },
  { 144, 9, 11, 11, 1, -12 },
  { 157, 4, 6, 5, 0, -3 },
  { 160, 5, 2, 7, 1, -8 },
  { 162, 3, 3, 6, 1, -3 },
  { 164, 7, 17, 8, 0, -16 },
  { 179, 9, 16, 11, 1, -16 },
  { 197, 5, 16, 11, 2, -16 },
  { 207, 9, 16, 11, 1, -16 },
  { 225, 9, 16, 11, 1, -16 },
  { 243, 9, 16, 11, 1, -16 },
  { 261, 9, 16, 11, 1, -16 },
  { 279, 9, 16, 11, 1, -16 },
  { 297, 9, 16, 11, 1, -16 },
  { 315, 9, 16, 11, 1, -16 },
  { 333, 9, 16, 11, 1, -16 },
  { 351, 3, 12, 6, 1, -12 },
  { 356, 3, 15, 5, 1, -12 },
  { 362, 7, 10, 10, 1, -12 },
  { 371, 7, 6, 11, 2, -10 },
  { 377, 8, 10, 10, 1, -12 },
  { 387, 8, 16, 10, 1, -16 },
  { 403, 15, 20, 17, 1, -15 },
  { 441, 13, 16, 13, 0, -16 },
  { 467, 10, 16, 12, 1, -16 },
  { 487, 11, 16, 13, 1, -16 },
  { 509, 10, 16, 13, 1, -16 },
  { 529, 9, 16, 11, 1, -16 },
  { 547, 9, 16, 11, 1, -16 },
  { 565, 11, 16, 13, 1, -16 },
  { 587, 11, 16, 14, 1, -16 },
  { 609, 2, 16, 6, 2, -16 },
  { 613, 8, 16, 11, 1, -16 },
  { 629, 11, 16, 12, 1, -16 },
  { 651, 9, 16, 11, 1, -16 },
  { 669, 14, 16, 17, 1, -16 },
  { 697, 11, 16, 14, 1, -16 },
  { 719, 11, 16, 13, 1, -16 },
  { 741, 11, 16, 12, 1, -16 },
  { 763, 11, 19, 13, 1, -16 },
  { 790, 11, 16, 12, 1, -16 },
  { 812, 10, 16, 12, 1, -16 },
  { 832, 10, 16, 12, 1, -16 },
  { 852, 10, 16, 12, 1, -16 },
  { 872, 12, 16, 13, 0, -16 },
  { 896, 15, 16, 17, 1, -16 },
  { 926, 11, 16, 12, 1, -16 },
  { 948, 12, 16, 12, 0, -16 },
  { 972, 10, 16, 12, 1, -16 },
  { 992, 4, 22, 6, 1, -18 },
  { 1003, 8, 17, 8, 0, -16 },
  { 1020, 4, 22, 6, 0, -18 },
  { 1031, 7, 8, 8, 1, -16 },
  { 1038, 9, 2, 9, 0, 0 },
  { 1041, 5, 3, 7, 1, -16 },
  { 1043, 9, 12, 10, 1, -12 },
  { 1057, 9, 17, 11, 1, -17 },
  { 1077, 8, 12, 10, 1, -12 },
  { 1089, 9, 17, 11, 1, -17 },
  { 1109, 9, 12, 10, 1, -12 },
  { 1123, 6, 17, 7, 1, -17 },
  { 1136, 9, 16, 11, 1, -12 },
  { 1154, 9, 17, 11, 1, -17 },
  { 1174, 3, 17, 5, 1, -17 },
  { 1181, 4, 21, 5, 0, -17 },
  { 1192, 9, 17, 10, 1, -17 },
  { 1212, 3, 17, 5, 1, -17 },
  { 1219, 14, 12, 16, 1, -12 },
  { 1240, 9, 12, 11, 1, -12 },
  { 1254, 9, 12, 11, 1, -12 },
  { 1268, 9, 16, 11, 1, -12 },
  { 1286, 9, 16, 11, 1, -12 },
  { 1304, 6, 12, 7, 1, -12 },
  { 1313, 8, 12, 10, 1, -12 },
  { 1325, 6, 14, 7, 0, -14 },
  { 1336, 9, 12, 11, 1, -12 },
  { 1350, 9, 12, 10, 0, -12 },
  { 1364, 14, 12, 14, 0, -12 },
  { 1385, 9, 12, 10, 0, -12 },
  { 1399, 9, 16, 10, 0, -12 },
  { 1417, 8, 12, 10, 1, -12 },
  { 1429, 5, 21, 7, 1, -17 },
  { 1443, 2, 19, 5, 2, -16 },
  { 1448, 6, 21, 7, 0, -17 },
  { 1464, 10, 5, 13, 1, -9 },
};

const GFXfont RobotoCondensed_Medium22pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium22pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOCONDENSED_MEDIUM22PT7B_H_
