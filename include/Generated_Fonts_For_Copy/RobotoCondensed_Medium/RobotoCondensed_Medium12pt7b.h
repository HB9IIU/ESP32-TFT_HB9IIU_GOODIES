#ifndef _ROBOTOCONDENSED_MEDIUM12PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x80, 0xFC, 0x32, 0x95, 0xF5, 0x7D, 0x54, 0xA0, 0x27, 0x99,
  0xC6, 0x19, 0x97, 0x20, 0xC2, 0xAB, 0x34, 0x20, 0xF5, 0x55, 0x1C, 0x63,
  0x49, 0x38, 0x62, 0xAB, 0xA6, 0xE8, 0xF8, 0x2B, 0x49, 0x24, 0x93, 0x22,
  0x89, 0x12, 0x49, 0x25, 0x28, 0x25, 0x5E, 0xE5, 0x00, 0x31, 0xBE, 0x63,
  0x18, 0x58, 0xC0, 0xC0, 0x12, 0x22, 0x24, 0x44, 0xC8, 0x69, 0x99, 0x99,
  0x99, 0x60, 0x3C, 0x92, 0x49, 0x20, 0x39, 0x24, 0x82, 0x18, 0xC2, 0x18,
  0x7C, 0x72, 0x42, 0x13, 0x04, 0x29, 0x70, 0x18, 0x63, 0x8E, 0x59, 0x6F,
  0xC6, 0x18, 0xF8, 0x8F, 0x91, 0x19, 0xF0, 0x66, 0x21, 0xE9, 0x4A, 0x52,
  0x70, 0xF8, 0x42, 0x31, 0x18, 0xC4, 0x60, 0x69, 0x99, 0x69, 0x99, 0xF0,
  0x69, 0x99, 0x9F, 0x13, 0x60, 0xC6, 0x50, 0x05, 0xC0, 0x0B, 0xB0, 0xE0,
  0x80, 0xF0, 0x0F, 0x8E, 0x1E, 0x80, 0x76, 0xC6, 0x23, 0x10, 0x04, 0x20,
  0x3C, 0x42, 0x82, 0x99, 0xA9, 0xA9, 0xAA, 0xBE, 0x80, 0xC0, 0x38, 0x10,
  0x70, 0xA1, 0x42, 0xCD, 0x9F, 0x22, 0xC6, 0xF4, 0xE7, 0x3F, 0x4E, 0x33,
  0xF0, 0x76, 0x63, 0x08, 0x42, 0x39, 0x70, 0xF4, 0xE3, 0x18, 0xC6, 0x33,
  0xF0, 0xFC, 0x21, 0x0F, 0x42, 0x10, 0xF8, 0xF8, 0x88, 0xF8, 0x88, 0x80,
  0x76, 0xE3, 0x08, 0x4E, 0x39, 0x78, 0x8E, 0x38, 0xE3, 0xFE, 0x38, 0xE3,
  0x8C, 0xFF, 0x80, 0x08, 0x42, 0x10, 0x87, 0x2B, 0x70, 0x9A, 0x6B, 0x28,
  0xE3, 0xC9, 0x26, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0xC7, 0x8F, 0x1F,
  0x7A, 0xB5, 0x6A, 0xCD, 0x92, 0x8F, 0x3C, 0xEB, 0xAE, 0xF9, 0xE7, 0x8C,
  0x73, 0x68, 0xA3, 0x8E, 0x38, 0xB6, 0x70, 0xF4, 0xE3, 0x19, 0xFA, 0x10,
  0x80, 0x73, 0x68, 0xA3, 0x8E, 0x38, 0xB6, 0x78, 0x20, 0xF4, 0xE3, 0x19,
  0xFA, 0x53, 0x88, 0x39, 0x34, 0xD8, 0x38, 0x3C, 0xD3, 0x38, 0xFC, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x8C, 0x63, 0x18, 0xC6, 0x33, 0x70, 0xC6,
  0x89, 0x13, 0x66, 0x85, 0x0A, 0x1C, 0x10, 0xC9, 0xA4, 0xD7, 0x4A, 0xA5,
  0x53, 0xA8, 0xDC, 0x64, 0x22, 0x00, 0x45, 0xB2, 0x8E, 0x30, 0xE6, 0x9B,
  0x44, 0xC5, 0x36, 0x8E, 0x30, 0xC3, 0x0C, 0x30, 0xFC, 0x20, 0x84, 0x30,
  0x86, 0x10, 0xFC, 0xEA, 0xAA, 0xAB, 0xC2, 0x10, 0xC2, 0x10, 0x86, 0x10,
  0x80, 0xD5, 0x55, 0x57, 0x26, 0x55, 0xF8, 0x4C, 0xE9, 0x1F, 0x9B, 0xF0,
  0x88, 0xF9, 0x99, 0x99, 0xF0, 0x7A, 0x51, 0x84, 0x25, 0xC0, 0x08, 0x5E,
  0x94, 0xE5, 0x29, 0x78, 0x69, 0x9F, 0x89, 0xF0, 0x36, 0xF4, 0x44, 0x44,
  0x40, 0x7A, 0x53, 0x94, 0xA5, 0xE9, 0x70, 0x88, 0xF9, 0x99, 0x99, 0x90,
  0xDF, 0xC0, 0x11, 0x55, 0x57, 0x84, 0x2D, 0x4E, 0x72, 0x96, 0x90, 0xFF,
  0x80, 0xFF, 0x26, 0x4C, 0x99, 0x32, 0x64, 0x80, 0xF9, 0x99, 0x99, 0x90,
  0x31, 0x24, 0xB3, 0x49, 0x23, 0x00, 0xF9, 0x99, 0x99, 0xF8, 0x80, 0x7A,
  0x73, 0x94, 0xA5, 0xE1, 0x08, 0xFA, 0x49, 0x20, 0x72, 0xD0, 0xE1, 0xA5,
  0xC0, 0x5D, 0x24, 0x93, 0x99, 0x99, 0x99, 0xF0, 0xCA, 0xD4, 0xA7, 0x18,
  0x80, 0xD2, 0xB5, 0x6A, 0xD6, 0xEC, 0x89, 0x00, 0x5A, 0x9C, 0x47, 0x2B,
  0x60, 0xDA, 0xD4, 0xA7, 0x10, 0x84, 0x40, 0xF2, 0x24, 0xC8, 0xF0, 0x2D,
  0xB5, 0x93, 0x6C, 0x80, 0xFF, 0xE0, 0xC9, 0x24, 0x52, 0x4B, 0x00, 0xCD,
  0x66,
};

const GFXglyph RobotoCondensed_Medium12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 2, 3, 4, 1, -9 },
  { 4, 5, 9, 6, 1, -9 },
  { 10, 4, 11, 6, 1, -10 },
  { 16, 6, 9, 8, 1, -9 },
  { 23, 6, 9, 7, 1, -9 },
  { 30, 2, 3, 2, 0, -9 },
  { 31, 3, 13, 4, 1, -10 },
  { 36, 3, 13, 4, 0, -10 },
  { 41, 5, 5, 5, 0, -9 },
  { 45, 5, 6, 6, 0, -6 },
  { 49, 2, 3, 3, 0, -1 },
  { 50, 2, 1, 4, 1, -4 },
  { 51, 1, 2, 3, 1, -2 },
  { 52, 4, 10, 4, 0, -9 },
  { 57, 4, 9, 6, 1, -9 },
  { 62, 3, 9, 6, 1, -9 },
  { 66, 6, 9, 6, 0, -9 },
  { 73, 5, 9, 6, 0, -9 },
  { 79, 6, 9, 6, 0, -9 },
  { 86, 4, 9, 6, 1, -9 },
  { 91, 5, 9, 6, 1, -9 },
  { 97, 5, 9, 6, 0, -9 },
  { 103, 4, 9, 6, 1, -9 },
  { 108, 4, 9, 6, 1, -9 },
  { 113, 1, 7, 3, 1, -7 },
  { 114, 2, 9, 3, 0, -7 },
  { 117, 5, 5, 5, 0, -6 },
  { 121, 4, 4, 6, 1, -6 },
  { 123, 4, 5, 5, 1, -6 },
  { 126, 5, 9, 5, 0, -9 },
  { 132, 8, 11, 9, 1, -8 },
  { 143, 7, 9, 7, 0, -9 },
  { 151, 5, 9, 7, 1, -9 },
  { 157, 5, 9, 7, 1, -9 },
  { 163, 5, 9, 7, 1, -9 },
  { 169, 5, 9, 6, 1, -9 },
  { 175, 4, 9, 6, 1, -9 },
  { 180, 5, 9, 7, 1, -9 },
  { 186, 6, 9, 7, 1, -9 },
  { 193, 1, 9, 3, 1, -9 },
  { 195, 5, 9, 6, 0, -9 },
  { 201, 6, 9, 7, 1, -9 },
  { 208, 4, 9, 6, 1, -9 },
  { 213, 7, 9, 9, 1, -9 },
  { 221, 6, 9, 7, 1, -9 },
  { 228, 6, 9, 7, 1, -9 },
  { 235, 5, 9, 7, 1, -9 },
  { 241, 6, 10, 7, 1, -9 },
  { 249, 5, 9, 7, 1, -9 },
  { 255, 6, 9, 6, 0, -9 },
  { 262, 6, 9, 6, 0, -9 },
  { 269, 5, 9, 7, 1, -9 },
  { 275, 7, 9, 7, 0, -9 },
  { 283, 9, 9, 9, 0, -9 },
  { 294, 6, 9, 7, 0, -9 },
  { 301, 6, 9, 6, 0, -9 },
  { 308, 6, 9, 6, 0, -9 },
  { 315, 2, 12, 3, 1, -10 },
  { 318, 5, 10, 5, 0, -9 },
  { 325, 2, 12, 3, 0, -10 },
  { 328, 4, 4, 5, 0, -9 },
  { 330, 5, 1, 5, 0, 0 },
  { 331, 3, 2, 4, 0, -9 },
  { 332, 4, 7, 6, 1, -7 },
  { 336, 4, 9, 6, 1, -9 },
  { 341, 5, 7, 6, 0, -7 },
  { 346, 5, 9, 6, 0, -9 },
  { 352, 4, 7, 6, 1, -7 },
  { 356, 4, 9, 4, 0, -9 },
  { 361, 5, 9, 6, 0, -7 },
  { 367, 4, 9, 6, 1, -9 },
  { 372, 1, 10, 3, 1, -10 },
  { 374, 2, 12, 3, 0, -10 },
  { 377, 5, 9, 6, 1, -9 },
  { 383, 1, 9, 3, 1, -9 },
  { 385, 7, 7, 9, 1, -7 },
  { 392, 4, 7, 6, 1, -7 },
  { 396, 6, 7, 6, 0, -7 },
  { 402, 4, 9, 6, 1, -7 },
  { 407, 5, 9, 6, 0, -7 },
  { 413, 3, 7, 4, 1, -7 },
  { 416, 5, 7, 5, 0, -7 },
  { 421, 3, 8, 4, 0, -8 },
  { 424, 4, 7, 6, 1, -7 },
  { 428, 5, 7, 5, 0, -7 },
  { 433, 7, 7, 8, 0, -7 },
  { 440, 5, 7, 5, 0, -7 },
  { 445, 5, 9, 5, 0, -7 },
  { 451, 4, 7, 5, 1, -7 },
  { 455, 3, 11, 4, 0, -9 },
  { 460, 1, 11, 3, 1, -9 },
  { 462, 3, 11, 4, 0, -9 },
  { 467, 5, 3, 7, 1, -5 },
};

const GFXfont RobotoCondensed_Medium12pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium12pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _ROBOTOCONDENSED_MEDIUM12PT7B_H_
