#ifndef _ROBOTOCONDENSED_MEDIUM35PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF7, 0xBD, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x70,
  0x00, 0x07, 0x7F, 0xFF, 0x70, 0xE7, 0xE7, 0xE7, 0xE7, 0xC7, 0xC6, 0xC6,
  0xC6, 0xC6, 0x03, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x18, 0x07, 0x18,
  0x07, 0x38, 0x06, 0x38, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x0E, 0x30,
  0x0E, 0x70, 0x0C, 0x70, 0x0C, 0x70, 0x1C, 0x70, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x1C, 0xE0, 0x18, 0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xC0,
  0x38, 0xC0, 0x39, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0F,
  0xC0, 0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0x78, 0x79, 0xE1, 0xE7, 0x83, 0xDE,
  0x0F, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x1F, 0x80, 0x1E, 0x00, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x79,
  0xF7, 0xE7, 0xFF, 0x8F, 0xFC, 0x0F, 0xC0, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x3C, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x71, 0xC3, 0x0E, 0x38, 0xE1,
  0x87, 0x18, 0x30, 0xE7, 0x07, 0x1C, 0xC0, 0xE3, 0xB8, 0x1F, 0xE6, 0x01,
  0xFD, 0xC0, 0x1E, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x9E, 0x00, 0x77, 0xE0,
  0x1D, 0xFE, 0x03, 0x38, 0xC0, 0xE6, 0x1C, 0x18, 0xC3, 0x87, 0x18, 0x70,
  0xC3, 0x0E, 0x38, 0x71, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x79, 0xE0, 0x3C, 0x38, 0x0F,
  0x0E, 0x03, 0xC3, 0x80, 0xF1, 0xE0, 0x1E, 0xF0, 0x07, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xF1, 0xE3, 0xFE, 0x79, 0xE7, 0xDE,
  0x78, 0xF7, 0xBC, 0x3F, 0xCF, 0x07, 0xF1, 0xE0, 0xFC, 0x78, 0x3E, 0x1F,
  0x9F, 0xC3, 0xFF, 0xF0, 0x7F, 0xDE, 0x0F, 0xC7, 0xC0, 0xFF, 0xFE, 0xEE,
  0xEE, 0xE0, 0x01, 0x03, 0x07, 0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x38, 0x78,
  0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0x70, 0x70, 0x70, 0x78, 0x38, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x07,
  0x03, 0x01, 0x80, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x1E,
  0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0,
  0xE0, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x06, 0x18, 0x4F,
  0x33, 0xDF, 0xFF, 0x8F, 0xFE, 0x03, 0xC0, 0x0F, 0xC0, 0x3B, 0x80, 0xF3,
  0x81, 0xC7, 0x83, 0x07, 0x02, 0x04, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xDE, 0xE2, 0x00,
  0xFF, 0xFF, 0xFF, 0x33, 0xFF, 0xF7, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80,
  0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x7F,
  0x83, 0xFF, 0x1F, 0x3C, 0x78, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xBC, 0x1E, 0x78, 0x79, 0xF7, 0xC3,
  0xFF, 0x07, 0xF8, 0x0F, 0x80, 0x01, 0x83, 0xCF, 0xFF, 0xFF, 0xFF, 0x3E,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x80, 0x07, 0xE0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xF7, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x78,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x07, 0xC0, 0x3F,
  0xE0, 0xFF, 0xE3, 0xF7, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x03, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3B, 0xC0, 0xF3, 0xC1, 0xE7, 0x83,
  0xCF, 0xDF, 0x8F, 0xFE, 0x0F, 0xF8, 0x0F, 0xC0, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xBC, 0x0F,
  0x78, 0x1C, 0xF0, 0x79, 0xE0, 0xE3, 0xC3, 0xC7, 0x87, 0x0F, 0x1E, 0x1E,
  0x38, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF,
  0x9F, 0xFE, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7B, 0xC1, 0xFF,
  0xC7, 0xFF, 0x1F, 0x7E, 0x10, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x79, 0xF7, 0xE3, 0xFF, 0x07,
  0xF8, 0x0F, 0xC0, 0x01, 0xE0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3E, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF3, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF, 0x3E,
  0xF8, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xDE, 0x0F, 0x78, 0x79, 0xFF, 0xE3, 0xFF, 0x07, 0xF8, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0xFF, 0x87, 0xFF, 0x1F, 0x7E, 0x78, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E,
  0xF0, 0x79, 0xE1, 0xE7, 0xDF, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0xC7, 0x8F,
  0xBC, 0x1E, 0xF0, 0x3B, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xF8, 0x79, 0xF7,
  0xE7, 0xFF, 0x0F, 0xF8, 0x0F, 0xC0, 0x0F, 0x81, 0xFF, 0x1F, 0xF8, 0xFB,
  0xEF, 0x8F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F,
  0xE0, 0xFF, 0x07, 0xBE, 0xFD, 0xFF, 0xE7, 0xFF, 0x1F, 0x78, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x1F, 0x0F, 0xF0, 0x7F, 0x03, 0xF0, 0x1E, 0x00, 0x23,
  0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x7F, 0xFE, 0xE0,
  0x11, 0xE7, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0xE3, 0x8E, 0x39, 0xE7, 0x9C, 0xE1, 0x80, 0x00, 0x10, 0x07, 0x01,
  0xF0, 0x3F, 0x0F, 0xE3, 0xF8, 0xFE, 0x0F, 0x80, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFF, 0x03, 0xF0, 0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x07, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x1F, 0x00, 0xF8, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xE0, 0x7C, 0x03,
  0x80, 0x10, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFB, 0xEF, 0x8F, 0xF8,
  0x3F, 0xC1, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x7C,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x78, 0x07, 0x81, 0xE0, 0x03, 0x83, 0x80,
  0x03, 0x0E, 0x00, 0x07, 0x1C, 0x1F, 0x06, 0x70, 0x7F, 0x0E, 0xE1, 0xFF,
  0x1D, 0x83, 0x8E, 0x3F, 0x0E, 0x1C, 0x3E, 0x1C, 0x38, 0x7C, 0x70, 0x60,
  0xF8, 0xE1, 0xC1, 0xF1, 0xC3, 0x83, 0xC3, 0x87, 0x07, 0x87, 0x0E, 0x1F,
  0x0E, 0x1C, 0x3F, 0x1C, 0x38, 0x6E, 0x3C, 0xF1, 0xDC, 0x7F, 0xF7, 0xB8,
  0x7E, 0xFE, 0x70, 0x78, 0xF0, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x10, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xEE, 0x00, 0x3D, 0xE0, 0x07,
  0x3C, 0x01, 0xE7, 0x80, 0x3C, 0x70, 0x07, 0x8F, 0x01, 0xE1, 0xE0, 0x3C,
  0x3C, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF,
  0xFE, 0x3C, 0x03, 0xC7, 0x80, 0x7C, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0x80,
  0x1F, 0xF0, 0x01, 0xE0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE,
  0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E,
  0xF0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x07, 0xEF, 0xC7, 0xC1, 0xF3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0,
  0x0F, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x07, 0xFC, 0x03, 0xCF, 0x01,
  0xE7, 0x81, 0xF3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00,
  0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF1, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFE, 0xFF,
  0xFB, 0xFF, 0xEF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x8F, 0xEF, 0xC7, 0xC1, 0xF3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1F, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x0F, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xEF, 0x01,
  0xF7, 0xC0, 0xF9, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x03, 0xF0, 0x00,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0x03, 0xFC, 0x1F, 0xF8, 0x79, 0xFF,
  0xE7, 0xFF, 0x0F, 0xF8, 0x0F, 0xC0, 0xF0, 0x0F, 0xF8, 0x0F, 0xBC, 0x0F,
  0x9E, 0x07, 0xCF, 0x07, 0xC7, 0x87, 0xC3, 0xC3, 0xC1, 0xE3, 0xE0, 0xF3,
  0xE0, 0x79, 0xE0, 0x3D, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFB, 0xE0, 0xF8, 0xF0, 0x78, 0x7C, 0x3C, 0x1F, 0x1E, 0x0F,
  0x8F, 0x03, 0xE7, 0x81, 0xF3, 0xC0, 0x7D, 0xE0, 0x1E, 0xF0, 0x0F, 0x80,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xDC, 0x0F, 0xFF,
  0x78, 0x3B, 0xFD, 0xE1, 0xEF, 0xF3, 0x87, 0xBF, 0xCF, 0x1C, 0xFF, 0x3C,
  0xF3, 0xFC, 0x73, 0xCF, 0xF1, 0xEE, 0x3F, 0xC7, 0xB8, 0xFF, 0x0F, 0xE3,
  0xFC, 0x3F, 0x0F, 0xF0, 0xFC, 0x3F, 0xC1, 0xF0, 0xFF, 0x07, 0xC3, 0xFC,
  0x1E, 0x0F, 0xF0, 0x38, 0x3C, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xF7, 0x87,
  0xFB, 0xC3, 0xFC, 0xF1, 0xFE, 0x78, 0xFF, 0x1E, 0x7F, 0x8F, 0x3F, 0xC3,
  0xDF, 0xE1, 0xEF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0x80, 0x07,
  0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xC1, 0xF3, 0xC0, 0x7B,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFE, 0x01, 0xEF, 0x01, 0xE7, 0xC1, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8,
  0x3F, 0xF8, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFE, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF,
  0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x87, 0xFF, 0xC7, 0xC1, 0xF3, 0xC0, 0x7B, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xEF,
  0x01, 0xE7, 0xC1, 0xF3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xFE,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x20, 0xFF, 0xE0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8,
  0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF0, 0xF8, 0xF0, 0xF8, 0xF8, 0xF8, 0x78, 0xF8, 0x7C, 0xF8,
  0x3C, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x0F, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0x7E, 0x7C, 0x1E, 0x78, 0x1F, 0x78,
  0x0F, 0x78, 0x0F, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0x78, 0x0F, 0x7C, 0x1F, 0x3F, 0x7E, 0x3F, 0xFE, 0x1F, 0xFC, 0x07,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8,
  0x1E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x7D, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x03, 0xE7, 0xC0,
  0xF8, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0xC1, 0xE1, 0xE0, 0x78, 0x78,
  0x1E, 0x1E, 0x03, 0x8F, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x3C, 0x0F, 0xF8, 0x1E, 0x07,
  0xBE, 0x0F, 0x83, 0xCF, 0x07, 0xC1, 0xE7, 0x83, 0xE0, 0xF3, 0xC3, 0xF0,
  0x79, 0xE1, 0xF8, 0x78, 0xF0, 0xFE, 0x3C, 0x38, 0x7F, 0x1E, 0x1E, 0x3B,
  0x8F, 0x0F, 0x3D, 0xC7, 0x87, 0x9E, 0xE3, 0x83, 0xCE, 0x7B, 0xC0, 0xE7,
  0x1D, 0xE0, 0x73, 0x8E, 0xF0, 0x3F, 0xC7, 0x78, 0x1F, 0xE3, 0xBC, 0x0F,
  0xE1, 0xFC, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x07, 0x80, 0xF0,
  0x00, 0xF8, 0x07, 0x9E, 0x03, 0xE7, 0xC0, 0xF0, 0xF0, 0x7C, 0x3E, 0x1E,
  0x07, 0x8F, 0x81, 0xF3, 0xC0, 0x3D, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x0F, 0x78, 0x03, 0xDF, 0x01, 0xF3, 0xC0, 0x78, 0xF8, 0x3E, 0x1E,
  0x0F, 0x07, 0xC7, 0xC0, 0xF1, 0xE0, 0x3E, 0xF8, 0x07, 0x80, 0x78, 0x03,
  0xDF, 0x01, 0xF7, 0xC0, 0x78, 0xF0, 0x3E, 0x3E, 0x0F, 0x07, 0x83, 0xC1,
  0xE1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x01, 0xCF, 0x00, 0x7B, 0xC0, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFF, 0xC0,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xFF, 0xC0, 0x0E, 0x01, 0xE0, 0x7C,
  0x0F, 0x81, 0xF8, 0x77, 0x0E, 0xE1, 0xCE, 0x71, 0xCE, 0x39, 0xC3, 0xF8,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F,
  0x0F, 0x81, 0xFF, 0x1F, 0xFD, 0xF1, 0xEF, 0x0F, 0x78, 0x3C, 0x01, 0xE3,
  0xFF, 0x3F, 0xFB, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0xE7,
  0xFF, 0xFF, 0x7F, 0x79, 0xF3, 0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF3, 0xE3, 0xFF, 0xCF,
  0xFF, 0xBF, 0x7E, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0xDF, 0xBF, 0xFE,
  0xFF, 0xF3, 0xCF, 0x80, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xBE, 0x78,
  0x3D, 0xE0, 0xFF, 0x83, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x3D, 0xE0, 0xF7, 0xEF, 0xCF, 0xFE, 0x1F, 0xF0, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x0F, 0xBC, 0xFF, 0xF3, 0xFF, 0xDF, 0xBF, 0x78, 0x3D, 0xE0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x78,
  0x3D, 0xE0, 0xF7, 0xEF, 0xCF, 0xFF, 0x1F, 0xDC, 0x3E, 0x70, 0x07, 0xE0,
  0x7F, 0xC3, 0xFF, 0x9F, 0xBF, 0x78, 0x3D, 0xE0, 0xF7, 0x83, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x27, 0xE3,
  0xCF, 0xFF, 0x1F, 0xF8, 0x1F, 0x80, 0x07, 0xC3, 0xF1, 0xFC, 0x7D, 0x3E,
  0x0F, 0x03, 0xC0, 0xF0, 0xFF, 0xBF, 0xEF, 0xF8, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x00, 0x0F, 0x9C, 0x7F, 0x73, 0xFF, 0xDF, 0xBF, 0x78, 0x3D,
  0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F,
  0x78, 0x3D, 0xE0, 0xF7, 0xEF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3E, 0xF0, 0x03,
  0xC0, 0x0F, 0x10, 0x3C, 0xF3, 0xF3, 0xFF, 0x8F, 0xFC, 0x0F, 0xC0, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF3, 0xC7, 0xFF, 0xBF, 0xFD, 0xFB, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xC0, 0xFF, 0xF7, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x3C, 0x78, 0x70, 0x00,
  0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFB, 0xFF, 0xFF, 0x7C, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0xFB, 0xC3, 0xCF, 0x1F, 0x3C, 0xF8, 0xF3, 0xC3, 0xDE, 0x0F,
  0xF8, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xBC, 0x3C, 0xF0, 0xF1, 0xE3,
  0xC7, 0xCF, 0x0F, 0x3C, 0x3E, 0xF0, 0x7B, 0xC1, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xC1,
  0xE3, 0xFF, 0xDF, 0xEF, 0xFF, 0xFF, 0xBF, 0x7F, 0xBF, 0xF0, 0x7C, 0x3F,
  0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1,
  0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0,
  0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xF0,
  0xF3, 0xC7, 0xFF, 0xBF, 0xFD, 0xFB, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xC0, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3,
  0xF7, 0xE7, 0x83, 0xCF, 0x03, 0xDE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x07, 0x9F, 0x9F, 0x1F, 0xFC,
  0x1F, 0xF0, 0x0F, 0xC0, 0xF3, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0x7E, 0xF0,
  0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC1, 0xEF, 0xCF, 0xBF, 0xFE, 0xFF, 0xF3, 0xCF, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x0F, 0x9C, 0xFF, 0x73, 0xFF, 0xDF, 0xBF, 0x78, 0x3D, 0xE0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x78, 0x3D, 0xE0,
  0xF7, 0xE7, 0xCF, 0xFF, 0x3F, 0xFC, 0x3E, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0xF7, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x0F, 0xC1, 0xFF, 0x8F, 0xFC, 0xF9, 0xF7, 0x87, 0xBC, 0x3D,
  0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFF, 0x07, 0xBC,
  0x3D, 0xF1, 0xEF, 0xFF, 0x3F, 0xF0, 0x7E, 0x00, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x3F, 0xEF, 0xFB, 0xFE, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7D, 0x1F, 0xC3, 0xF0,
  0x7C, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xF7, 0xEF, 0xFF, 0x7F, 0xF8, 0xFB, 0xC0, 0xF0, 0x7F, 0xC1, 0xEF, 0x07,
  0x9E, 0x1E, 0x78, 0x71, 0xE3, 0xC3, 0x8F, 0x0F, 0x3C, 0x3C, 0xE0, 0xF7,
  0x81, 0xDE, 0x07, 0x70, 0x1F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x1E, 0x00, 0xF0, 0x70, 0x7F, 0x87, 0x83, 0xBC, 0x3C, 0x3C, 0xE1,
  0xF1, 0xE7, 0x0F, 0x8F, 0x3C, 0xFC, 0x71, 0xE7, 0xE3, 0x8F, 0x3F, 0xBC,
  0x39, 0xDD, 0xE1, 0xDC, 0xEF, 0x0F, 0xE7, 0x70, 0x7F, 0x1F, 0x81, 0xF8,
  0xFC, 0x0F, 0x87, 0xE0, 0x7C, 0x3E, 0x03, 0xE0, 0xF0, 0x0F, 0x07, 0x80,
  0x70, 0x3C, 0x00, 0xF0, 0x79, 0xE1, 0xE7, 0x8F, 0x0F, 0x3C, 0x3D, 0xE0,
  0x7F, 0x81, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x07, 0xF0,
  0x1F, 0xE0, 0xF7, 0x83, 0xCF, 0x1E, 0x3E, 0x78, 0x7B, 0xC1, 0xF0, 0x78,
  0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xE1, 0xE3, 0xC7, 0x87, 0x8F, 0x0F, 0x1E,
  0x0F, 0x38, 0x1E, 0xF0, 0x3D, 0xE0, 0x3B, 0xC0, 0x7F, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x7F, 0xFB,
  0xFF, 0xDF, 0xFE, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07,
  0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x03, 0x83, 0xE1, 0xC1, 0xE0, 0xF0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF1, 0xF0, 0xF0, 0x7C,
  0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xC1,
  0xE0, 0x70, 0x3E, 0x0E, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x0F, 0x07, 0x0F,
  0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78,
  0xF0, 0xE0, 0xC0, 0x1E, 0x07, 0x7F, 0x07, 0x7F, 0x87, 0xFF, 0xFF, 0xE1,
  0xFE, 0xE0, 0xFC, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_Medium35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 25, 9, 2, -25 },
  { 17, 8, 9, 11, 2, -26 },
  { 26, 16, 25, 19, 2, -25 },
  { 76, 14, 32, 18, 2, -29 },
  { 132, 19, 25, 22, 2, -25 },
  { 192, 18, 25, 20, 1, -25 },
  { 249, 4, 9, 6, 1, -26 },
  { 254, 8, 36, 11, 2, -28 },
  { 290, 8, 36, 11, 1, -28 },
  { 326, 15, 15, 16, 0, -25 },
  { 355, 15, 18, 17, 1, -21 },
  { 389, 5, 10, 8, 1, -4 },
  { 396, 8, 3, 11, 1, -12 },
  { 399, 5, 5, 10, 2, -5 },
  { 403, 11, 27, 12, 0, -25 },
  { 441, 14, 25, 18, 2, -25 },
  { 485, 9, 25, 18, 3, -25 },
  { 514, 15, 25, 18, 1, -25 },
  { 561, 15, 25, 18, 1, -25 },
  { 608, 15, 25, 18, 1, -25 },
  { 655, 14, 25, 18, 2, -25 },
  { 699, 14, 25, 18, 2, -25 },
  { 743, 15, 25, 18, 1, -25 },
  { 790, 14, 25, 18, 2, -25 },
  { 834, 13, 25, 18, 2, -25 },
  { 875, 5, 20, 9, 2, -20 },
  { 888, 6, 26, 8, 1, -20 },
  { 908, 12, 16, 16, 1, -19 },
  { 932, 13, 10, 17, 2, -16 },
  { 949, 13, 16, 16, 2, -19 },
  { 975, 13, 25, 15, 1, -25 },
  { 1016, 23, 32, 27, 2, -24 },
  { 1108, 19, 25, 21, 1, -25 },
  { 1168, 16, 25, 19, 2, -25 },
  { 1218, 17, 25, 20, 2, -25 },
  { 1272, 16, 25, 20, 2, -25 },
  { 1322, 14, 25, 17, 2, -25 },
  { 1366, 14, 25, 17, 2, -25 },
  { 1410, 17, 25, 21, 2, -25 },
  { 1464, 17, 25, 22, 2, -25 },
  { 1518, 5, 25, 9, 2, -25 },
  { 1534, 14, 25, 17, 1, -25 },
  { 1578, 17, 25, 19, 2, -25 },
  { 1632, 14, 25, 17, 2, -25 },
  { 1676, 22, 25, 26, 2, -25 },
  { 1745, 17, 25, 22, 2, -25 },
  { 1799, 17, 25, 21, 2, -25 },
  { 1853, 16, 25, 20, 2, -25 },
  { 1903, 17, 29, 21, 2, -25 },
  { 1965, 16, 25, 19, 2, -25 },
  { 2015, 16, 25, 19, 1, -25 },
  { 2065, 17, 25, 19, 1, -25 },
  { 2119, 16, 25, 20, 2, -25 },
  { 2169, 18, 25, 20, 1, -25 },
  { 2226, 25, 25, 26, 1, -25 },
  { 2305, 18, 25, 19, 1, -25 },
  { 2362, 18, 25, 19, 0, -25 },
  { 2419, 16, 25, 18, 1, -25 },
  { 2469, 6, 35, 9, 2, -29 },
  { 2496, 12, 27, 13, 1, -25 },
  { 2537, 6, 35, 9, 1, -29 },
  { 2564, 11, 12, 13, 1, -25 },
  { 2581, 14, 3, 14, 0, 0 },
  { 2587, 8, 5, 11, 1, -26 },
  { 2592, 13, 18, 17, 2, -18 },
  { 2622, 14, 26, 17, 2, -26 },
  { 2668, 14, 18, 16, 1, -18 },
  { 2700, 14, 26, 17, 1, -26 },
  { 2746, 14, 18, 17, 1, -18 },
  { 2778, 10, 26, 11, 1, -26 },
  { 2811, 14, 25, 17, 1, -18 },
  { 2855, 13, 26, 17, 2, -26 },
  { 2898, 4, 25, 8, 2, -25 },
  { 2911, 7, 32, 8, -1, -25 },
  { 2939, 14, 26, 16, 2, -26 },
  { 2985, 4, 26, 8, 2, -26 },
  { 2998, 22, 18, 26, 2, -18 },
  { 3048, 13, 18, 17, 2, -18 },
  { 3078, 15, 18, 17, 1, -18 },
  { 3112, 14, 25, 17, 2, -18 },
  { 3156, 14, 25, 17, 1, -18 },
  { 3200, 8, 18, 11, 2, -18 },
  { 3218, 13, 18, 16, 1, -18 },
  { 3248, 10, 23, 11, 0, -23 },
  { 3277, 13, 18, 17, 2, -18 },
  { 3307, 14, 18, 15, 1, -18 },
  { 3339, 21, 18, 22, 1, -18 },
  { 3387, 14, 18, 16, 1, -18 },
  { 3419, 15, 25, 15, 0, -18 },
  { 3466, 13, 18, 16, 1, -18 },
  { 3496, 9, 33, 11, 1, -27 },
  { 3534, 3, 30, 9, 3, -25 },
  { 3546, 8, 33, 11, 1, -27 },
  { 3579, 16, 7, 20, 2, -14 },
};

const GFXfont RobotoCondensed_Medium35pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium35pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium35pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOCONDENSED_MEDIUM35PT7B_H_
