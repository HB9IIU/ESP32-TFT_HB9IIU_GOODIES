#ifndef _ROBOTOCONDENSED_MEDIUM8PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x15, 0x76, 0x66, 0x06, 0x54, 0x29, 0x60, 0x45, 0x98,
  0x66, 0x8C, 0x66, 0x67, 0xB7, 0xC0, 0x5A, 0x94, 0x95, 0x56, 0x5D, 0x10,
  0x44, 0xF4, 0x40, 0xC0, 0x80, 0x29, 0x29, 0x00, 0x69, 0x99, 0x96, 0x75,
  0x50, 0x69, 0x22, 0x4F, 0x6A, 0x22, 0x96, 0x22, 0x6A, 0xF2, 0x74, 0x61,
  0x96, 0x24, 0xE9, 0x96, 0xF2, 0x22, 0x44, 0x6A, 0x66, 0x96, 0x6A, 0x97,
  0x26, 0x90, 0x00, 0x80, 0x71, 0x80, 0xCC, 0xC7, 0x00, 0x74, 0xA0, 0x80,
  0x31, 0x27, 0x6D, 0xB6, 0xE4, 0x0C, 0x21, 0x14, 0xA7, 0x48, 0xD6, 0xFB,
  0xC0, 0x65, 0x88, 0x97, 0xD6, 0xDB, 0x80, 0xF2, 0x69, 0xC0, 0xF2, 0x69,
  0x00, 0x65, 0x8B, 0x97, 0x36, 0xFB, 0x40, 0xFC, 0x24, 0x9A, 0xC0, 0x3F,
  0x6F, 0x40, 0x12, 0x49, 0xC0, 0x9C, 0xE7, 0xDE, 0xD4, 0xB7, 0xFB, 0x40,
  0x65, 0x99, 0x97, 0xD6, 0xF9, 0x00, 0x65, 0x99, 0x97, 0x10, 0xD6, 0xEB,
  0x40, 0x69, 0x43, 0x97, 0xF2, 0x22, 0x22, 0x99, 0x99, 0x97, 0x99, 0x55,
  0x62, 0x86, 0xD7, 0x9E, 0x69, 0x20, 0x95, 0x66, 0x7D, 0x95, 0x66, 0x22,
  0xF1, 0x24, 0x4F, 0xEA, 0xAA, 0x91, 0x24, 0x40, 0xD5, 0x55, 0x4A, 0x80,
  0xE0, 0x40, 0x6E, 0xB0, 0x88, 0xE9, 0x9E, 0x72, 0x30, 0x11, 0x79, 0x97,
  0x6F, 0x86, 0x49, 0x24, 0x80, 0x79, 0x97, 0x16, 0x93, 0xDB, 0x40, 0xBC,
  0xBF, 0x88, 0xAC, 0xAA, 0xFC, 0xFA, 0x9A, 0x69, 0xF6, 0xD0, 0x69, 0x96,
  0xE9, 0x9E, 0x88, 0x79, 0x97, 0x11, 0xEA, 0x68, 0xB0, 0x55, 0x40, 0xB6,
  0xB0, 0xAD, 0xA0, 0xAD, 0x54, 0xA0, 0x69, 0xD0, 0xAD, 0xA5, 0x00, 0xE9,
  0x70, 0x56, 0x54, 0x7E, 0x95, 0x58, 0x70,
};

const GFXglyph RobotoCondensed_Medium8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 1, -6 },
  { 2, 2, 2, 3, 0, -6 },
  { 3, 4, 6, 4, 0, -6 },
  { 6, 4, 8, 4, 0, -7 },
  { 10, 5, 6, 5, 0, -6 },
  { 14, 4, 6, 5, 0, -6 },
  { 17, 1, 2, 1, 0, -6 },
  { 18, 2, 8, 3, 0, -6 },
  { 20, 2, 8, 3, 0, -6 },
  { 22, 3, 4, 4, 0, -6 },
  { 24, 4, 4, 4, 0, -5 },
  { 26, 1, 2, 2, 0, -1 },
  { 27, 2, 1, 2, 0, -3 },
  { 28, 1, 1, 2, 1, -1 },
  { 29, 3, 6, 3, 0, -6 },
  { 32, 4, 6, 4, 0, -6 },
  { 35, 2, 6, 4, 1, -6 },
  { 37, 4, 6, 4, 0, -6 },
  { 40, 4, 6, 4, 0, -6 },
  { 43, 4, 6, 4, 0, -6 },
  { 46, 4, 6, 4, 0, -6 },
  { 49, 4, 6, 4, 0, -6 },
  { 52, 4, 6, 4, 0, -6 },
  { 55, 4, 6, 4, 0, -6 },
  { 58, 4, 6, 4, 0, -6 },
  { 61, 1, 4, 2, 1, -4 },
  { 62, 2, 5, 2, 0, -4 },
  { 64, 3, 3, 4, 0, -4 },
  { 66, 2, 3, 4, 1, -4 },
  { 67, 3, 3, 4, 0, -4 },
  { 69, 3, 6, 3, 0, -6 },
  { 72, 6, 8, 6, 0, -6 },
  { 78, 5, 6, 5, 0, -6 },
  { 82, 3, 6, 4, 1, -6 },
  { 85, 4, 6, 5, 0, -6 },
  { 88, 3, 6, 5, 1, -6 },
  { 91, 3, 6, 4, 1, -6 },
  { 94, 3, 6, 4, 1, -6 },
  { 97, 4, 6, 5, 0, -6 },
  { 100, 3, 6, 5, 1, -6 },
  { 103, 1, 6, 2, 1, -6 },
  { 104, 3, 6, 4, 0, -6 },
  { 107, 3, 6, 4, 1, -6 },
  { 110, 3, 6, 4, 1, -6 },
  { 113, 5, 6, 6, 1, -6 },
  { 117, 3, 6, 5, 1, -6 },
  { 120, 4, 6, 5, 0, -6 },
  { 123, 3, 6, 5, 1, -6 },
  { 126, 4, 7, 5, 0, -6 },
  { 130, 3, 6, 4, 1, -6 },
  { 133, 4, 6, 4, 0, -6 },
  { 136, 4, 6, 4, 0, -6 },
  { 139, 4, 6, 5, 0, -6 },
  { 142, 4, 6, 5, 0, -6 },
  { 145, 6, 6, 6, 0, -6 },
  { 150, 4, 6, 4, 0, -6 },
  { 153, 4, 6, 4, 0, -6 },
  { 156, 4, 6, 4, 0, -6 },
  { 159, 2, 8, 2, 0, -7 },
  { 161, 3, 6, 3, 0, -6 },
  { 164, 2, 8, 2, 0, -7 },
  { 166, 3, 3, 3, 0, -6 },
  { 168, 3, 1, 3, 0, 0 },
  { 169, 2, 1, 3, 0, -6 },
  { 170, 3, 4, 4, 0, -4 },
  { 172, 4, 6, 4, 0, -6 },
  { 175, 3, 4, 4, 0, -4 },
  { 177, 4, 6, 4, 0, -6 },
  { 180, 4, 4, 4, 0, -4 },
  { 182, 3, 6, 3, 0, -6 },
  { 185, 4, 6, 4, 0, -4 },
  { 188, 3, 6, 4, 0, -6 },
  { 191, 1, 6, 2, 0, -6 },
  { 192, 1, 8, 2, 0, -6 },
  { 193, 4, 6, 4, 0, -6 },
  { 196, 1, 6, 2, 0, -6 },
  { 197, 6, 4, 6, 0, -4 },
  { 200, 3, 4, 4, 0, -4 },
  { 202, 4, 4, 4, 0, -4 },
  { 204, 4, 6, 4, 0, -4 },
  { 207, 4, 6, 4, 0, -4 },
  { 210, 2, 4, 3, 0, -4 },
  { 211, 3, 4, 4, 0, -4 },
  { 213, 2, 5, 2, 0, -5 },
  { 215, 3, 4, 4, 0, -4 },
  { 217, 3, 4, 4, 0, -4 },
  { 219, 5, 4, 5, 0, -4 },
  { 222, 3, 4, 4, 0, -4 },
  { 224, 3, 6, 3, 0, -4 },
  { 227, 3, 4, 4, 0, -4 },
  { 229, 2, 7, 2, 0, -6 },
  { 231, 1, 7, 2, 1, -6 },
  { 232, 2, 7, 2, 0, -6 },
  { 234, 4, 1, 5, 0, -3 },
};

const GFXfont RobotoCondensed_Medium8pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium8pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium8pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOCONDENSED_MEDIUM8PT7B_H_
