#ifndef _ROBOTOCONDENSED_MEDIUM21PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xB6, 0xDB, 0x6C, 0x07, 0xD8, 0xDE, 0xF7, 0xB9, 0x80, 0x09,
  0x06, 0x41, 0x90, 0x6C, 0x7F, 0xDF, 0xF1, 0x30, 0xC8, 0x32, 0x3F, 0xEF,
  0xF8, 0x98, 0x26, 0x09, 0x06, 0x40, 0x08, 0x08, 0x3C, 0x7E, 0x67, 0x63,
  0x63, 0x60, 0x78, 0x3E, 0x0F, 0x03, 0xC3, 0xE3, 0xE3, 0x7F, 0x3E, 0x08,
  0x08, 0x70, 0x1F, 0x03, 0x22, 0x64, 0xCC, 0x91, 0xF6, 0x1C, 0x80, 0x30,
  0x0D, 0xC1, 0x7C, 0x6C, 0x89, 0x93, 0x32, 0x07, 0xC0, 0x70, 0x3C, 0x0F,
  0xC1, 0x98, 0x31, 0x86, 0x60, 0xFC, 0x0F, 0x01, 0xC0, 0x7C, 0xDD, 0xDB,
  0x1E, 0x63, 0xCE, 0x38, 0xFF, 0x0F, 0x70, 0xFF, 0xC0, 0x08, 0xCC, 0x66,
  0x31, 0x8C, 0xE6, 0x31, 0x8C, 0x71, 0x8C, 0x63, 0x0C, 0x61, 0x84, 0x86,
  0x30, 0xC6, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x33, 0x19, 0x8C,
  0x40, 0x0C, 0x06, 0x03, 0x1F, 0x73, 0xF0, 0xE0, 0xD8, 0x66, 0x22, 0x00,
  0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x77, 0x76,
  0x64, 0xFF, 0xC0, 0x7D, 0x80, 0x06, 0x08, 0x30, 0x60, 0x83, 0x06, 0x0C,
  0x30, 0x60, 0xC1, 0x06, 0x0C, 0x10, 0x60, 0x3C, 0x7E, 0x67, 0xE3, 0xE3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0xE3, 0x67, 0x7E, 0x3C, 0x0B, 0xFF,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x60, 0x3C, 0x3F, 0xB9, 0xD8,
  0x6C, 0x30, 0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x06, 0x07, 0xFF,
  0xFE, 0x3C, 0x7E, 0xE7, 0xC3, 0x03, 0x07, 0x1E, 0x1E, 0x07, 0x03, 0x03,
  0xC3, 0xE7, 0x7E, 0x3C, 0x06, 0x07, 0x03, 0x83, 0xC1, 0xE1, 0xB0, 0xD8,
  0xCC, 0x66, 0x63, 0x3F, 0xFF, 0xF0, 0x60, 0x30, 0x18, 0x7F, 0x3F, 0x98,
  0x0C, 0x06, 0x03, 0xF1, 0xFC, 0xCE, 0x03, 0x01, 0xC0, 0xFC, 0x66, 0x33,
  0xF8, 0xF0, 0x0E, 0x1F, 0x0E, 0x0C, 0x06, 0x07, 0xF3, 0xFD, 0xC6, 0xE3,
  0xF1, 0xF8, 0xFC, 0x66, 0x73, 0xF8, 0x70, 0xFF, 0xFF, 0xC0, 0xC0, 0x60,
  0x60, 0x30, 0x38, 0x18, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0x81, 0xC0,
  0x3C, 0x7E, 0x67, 0xE3, 0xE3, 0x67, 0x7E, 0x7E, 0x67, 0xE3, 0xC3, 0xE3,
  0xE7, 0x7F, 0x3C, 0x3C, 0x7E, 0xE7, 0xE3, 0xC3, 0xC3, 0xE3, 0xE7, 0x7F,
  0x3B, 0x03, 0x07, 0x0E, 0x3C, 0x38, 0x7D, 0x80, 0x00, 0x0F, 0xB0, 0x7F,
  0x80, 0x00, 0x01, 0xB7, 0xB4, 0x02, 0x1C, 0xFF, 0x8C, 0x1E, 0x0F, 0x87,
  0x02, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x7C, 0x1F, 0x07,
  0x1F, 0x7C, 0xE0, 0x80, 0x7D, 0xFF, 0x9E, 0x30, 0x61, 0xC7, 0x0C, 0x38,
  0x60, 0x00, 0x01, 0x07, 0x0C, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0x81, 0x8C,
  0x06, 0x63, 0x8D, 0x9F, 0x34, 0x4C, 0x73, 0x31, 0xCC, 0xC7, 0x33, 0x1C,
  0xCC, 0x73, 0x33, 0xCC, 0xCF, 0x3F, 0x6C, 0x67, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0xFC, 0x03, 0xE0, 0x06, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F,
  0x81, 0xD8, 0x19, 0x81, 0x9C, 0x38, 0xC3, 0x0C, 0x3F, 0xE7, 0xFE, 0x70,
  0x66, 0x07, 0xE0, 0x70, 0xFE, 0x3F, 0xEE, 0x3B, 0x86, 0xE1, 0xB8, 0xEF,
  0xF3, 0xFC, 0xE3, 0xB8, 0x6E, 0x1F, 0x86, 0xE3, 0xBF, 0xEF, 0xE0, 0x1F,
  0x0F, 0xE7, 0x1F, 0x87, 0xE0, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x0F, 0x87, 0x71, 0xCF, 0xE1, 0xF0, 0xFE, 0x3F, 0xCE, 0x3B, 0x86, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x86, 0xE3, 0xBF, 0xCF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0xFD, 0xFE, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1F, 0x0F, 0xE7,
  0x1F, 0x87, 0xE0, 0xF8, 0x0E, 0x03, 0x9F, 0xE7, 0xF8, 0x3E, 0x0F, 0x83,
  0x71, 0xCF, 0xF1, 0xF0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xC7, 0xE7, 0xFE, 0x7C, 0xE1, 0xDC,
  0x73, 0x8E, 0x73, 0x8E, 0xE1, 0xDC, 0x3F, 0x07, 0xE0, 0xFE, 0x1E, 0xC3,
  0x9C, 0x71, 0xCE, 0x39, 0xC3, 0xB8, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xF3, 0x7D, 0x9B, 0xEC,
  0xDF, 0x6E, 0xF9, 0xE7, 0xCF, 0x3E, 0x79, 0xF1, 0x8F, 0x8C, 0x60, 0xE0,
  0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF9, 0xFB, 0x3F, 0x77, 0xE6, 0xFC,
  0xFF, 0x8F, 0xF1, 0xFE, 0x1F, 0xC3, 0xF8, 0x38, 0x1F, 0x07, 0xF1, 0xC7,
  0x30, 0x6E, 0x0D, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0x70,
  0x67, 0x1C, 0x7F, 0x07, 0xC0, 0xFF, 0x3F, 0xEE, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0xFE, 0xFF, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00,
  0x1F, 0x07, 0xF1, 0xC7, 0x70, 0x6E, 0x0D, 0xC1, 0xB8, 0x37, 0x06, 0xE0,
  0xDC, 0x1B, 0x83, 0x70, 0x67, 0x1C, 0x7F, 0x07, 0xE0, 0x0E, 0x00, 0xC0,
  0x08, 0xFE, 0x3F, 0xEE, 0x3B, 0x86, 0xE1, 0xF8, 0x6E, 0x3B, 0xFC, 0xFE,
  0x39, 0xCE, 0x33, 0x8E, 0xE3, 0xB8, 0x6E, 0x1C, 0x3E, 0x3F, 0xB8, 0xFC,
  0x3E, 0x1F, 0x01, 0xF0, 0x7E, 0x07, 0x81, 0xF0, 0x7C, 0x3E, 0x3B, 0xF8,
  0xF8, 0xFF, 0xFF, 0xF1, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x61,
  0x9F, 0xE3, 0xE0, 0xE0, 0x76, 0x06, 0x70, 0xE7, 0x0E, 0x30, 0xC3, 0x0C,
  0x39, 0xC1, 0x98, 0x19, 0x81, 0xB8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x06, 0x00, 0xC3, 0x0F, 0x0C, 0x3C, 0x78, 0xF9, 0xE7, 0xE7, 0x9D, 0x9E,
  0x66, 0x79, 0x9B, 0x36, 0x6C, 0xD9, 0xF3, 0xE3, 0xCF, 0x0F, 0x3C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x00, 0xE1, 0xF8, 0x67, 0x39, 0xCC, 0x3F, 0x0F,
  0x81, 0xE0, 0x70, 0x1E, 0x0F, 0x83, 0x71, 0xCC, 0x63, 0xB8, 0x6E, 0x1C,
  0xE0, 0xEE, 0x19, 0xC7, 0x18, 0xC3, 0x98, 0x37, 0x06, 0xC0, 0xF8, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xFF, 0xFF, 0xC0,
  0xE0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x1C, 0x0E, 0x0E, 0x07,
  0xFF, 0xFE, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xFF,
  0xE0, 0x60, 0x60, 0x70, 0x30, 0x30, 0x38, 0x18, 0x18, 0x1C, 0x0C, 0x0C,
  0x0E, 0x06, 0x06, 0x07, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0xFF, 0x30, 0xC7, 0x9E, 0x4F, 0x3C, 0xC0, 0xFF, 0xFF, 0xE6, 0x30,
  0x3C, 0x7E, 0xE7, 0x07, 0x3F, 0x7F, 0xE7, 0xC7, 0xE7, 0xFF, 0x7B, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0xF3, 0xFD, 0xC6, 0xE3, 0x71, 0xF8, 0xFC,
  0x7E, 0x37, 0x1B, 0xFD, 0xBC, 0x3C, 0x7E, 0xE7, 0xC3, 0xC0, 0xC0, 0xC0,
  0xC3, 0xE7, 0x7E, 0x3C, 0x03, 0x03, 0x03, 0x03, 0x03, 0x3B, 0x7F, 0xE7,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0x7F, 0x3B, 0x3C, 0x7E, 0xE7, 0xC3,
  0xFF, 0xFF, 0xC0, 0xC0, 0xE3, 0x7F, 0x3E, 0x3D, 0xF7, 0x18, 0x63, 0xEF,
  0x98, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x3B, 0x7F, 0xE7, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3B, 0x03, 0x47, 0x7F, 0x3C, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xFE, 0xFF, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0x5F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x27, 0x70, 0x07, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0xEE, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x3B, 0xB9, 0xD8, 0xFC, 0x7C, 0x3F, 0x1D, 0x8E, 0xE7, 0x33, 0x9D, 0xC6,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0x77, 0xFF, 0xF9, 0xE7, 0xC6,
  0x3E, 0x31, 0xF1, 0x8F, 0x8C, 0x7C, 0x63, 0xE3, 0x1F, 0x18, 0xF8, 0xC6,
  0xDE, 0xFF, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x3C,
  0x3F, 0xB9, 0xD8, 0x6C, 0x3E, 0x1F, 0x0F, 0x86, 0xE3, 0x3F, 0x8F, 0x00,
  0xDE, 0x7F, 0xB8, 0xDC, 0x6E, 0x3F, 0x1F, 0x8F, 0xC6, 0xE3, 0x7F, 0xBF,
  0x9C, 0x0E, 0x07, 0x03, 0x80, 0x3B, 0x7F, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xE7, 0x7F, 0x3B, 0x03, 0x03, 0x03, 0x03, 0xDF, 0xFD, 0xCE, 0x73,
  0x9C, 0xE7, 0x38, 0x3C, 0x7E, 0xE7, 0xE0, 0xF0, 0x3C, 0x0E, 0xC7, 0xC7,
  0xFE, 0x3C, 0x30, 0xC3, 0x3F, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3C,
  0x70, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0x7F, 0x7B,
  0x63, 0xB1, 0x98, 0xCE, 0x63, 0x71, 0xB0, 0xD8, 0x3C, 0x1C, 0x0E, 0x07,
  0x00, 0x63, 0x1B, 0x39, 0xD9, 0xCC, 0xCE, 0x67, 0x7B, 0x1E, 0xD8, 0xF7,
  0xC7, 0x9C, 0x3C, 0xE0, 0xC7, 0x06, 0x38, 0x63, 0xB9, 0x8D, 0xC7, 0xC1,
  0xC0, 0xE0, 0x78, 0x7C, 0x37, 0x39, 0x98, 0xE0, 0xE3, 0xB1, 0x98, 0xCE,
  0xE3, 0x61, 0xB0, 0xD8, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x83, 0xC1,
  0xC0, 0xFE, 0xFE, 0x0E, 0x0C, 0x1C, 0x38, 0x30, 0x70, 0xE0, 0xFF, 0xFF,
  0x19, 0xCC, 0xE6, 0x31, 0x8C, 0x67, 0x30, 0xC6, 0x31, 0x8C, 0x71, 0x8E,
  0x30, 0xFF, 0xFF, 0xC0, 0x41, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x71,
  0xCE, 0x30, 0xC3, 0x0C, 0x30, 0xC6, 0x10, 0x38, 0xDF, 0x3C, 0xFB, 0x1C,
};

const GFXglyph RobotoCondensed_Medium21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 15, 5, 1, -15 },
  { 7, 5, 5, 7, 1, -16 },
  { 11, 10, 15, 11, 1, -15 },
  { 30, 8, 19, 11, 1, -17 },
  { 49, 11, 15, 13, 1, -15 },
  { 70, 11, 15, 12, 1, -15 },
  { 91, 2, 5, 4, 1, -16 },
  { 93, 5, 22, 7, 1, -17 },
  { 107, 5, 22, 7, 1, -17 },
  { 121, 9, 9, 9, 0, -15 },
  { 132, 8, 10, 10, 1, -12 },
  { 142, 4, 6, 5, 0, -2 },
  { 145, 5, 2, 6, 1, -7 },
  { 147, 3, 3, 6, 1, -3 },
  { 149, 7, 16, 7, 0, -15 },
  { 163, 8, 15, 11, 1, -15 },
  { 178, 5, 15, 11, 2, -15 },
  { 188, 9, 15, 11, 1, -15 },
  { 205, 8, 15, 11, 1, -15 },
  { 220, 9, 15, 11, 1, -15 },
  { 237, 9, 15, 11, 1, -15 },
  { 254, 9, 15, 11, 1, -15 },
  { 271, 9, 15, 11, 1, -15 },
  { 288, 8, 15, 11, 1, -15 },
  { 303, 8, 15, 11, 1, -15 },
  { 318, 3, 12, 5, 1, -12 },
  { 323, 3, 16, 5, 1, -12 },
  { 329, 7, 9, 9, 1, -11 },
  { 337, 8, 6, 10, 1, -10 },
  { 343, 8, 9, 10, 1, -11 },
  { 352, 7, 15, 9, 1, -15 },
  { 366, 14, 20, 16, 1, -15 },
  { 401, 12, 15, 12, 0, -15 },
  { 424, 10, 15, 12, 1, -15 },
  { 443, 10, 15, 12, 1, -15 },
  { 462, 10, 15, 12, 1, -15 },
  { 481, 9, 15, 10, 1, -15 },
  { 498, 8, 15, 10, 1, -15 },
  { 513, 10, 15, 12, 1, -15 },
  { 532, 11, 15, 13, 1, -15 },
  { 553, 3, 15, 5, 1, -15 },
  { 559, 8, 15, 10, 1, -15 },
  { 574, 11, 15, 12, 1, -15 },
  { 595, 8, 15, 10, 1, -15 },
  { 610, 13, 15, 16, 1, -15 },
  { 635, 11, 15, 13, 1, -15 },
  { 656, 11, 15, 13, 1, -15 },
  { 677, 10, 15, 12, 1, -15 },
  { 696, 11, 18, 13, 1, -15 },
  { 721, 10, 15, 11, 1, -15 },
  { 740, 9, 15, 11, 1, -15 },
  { 757, 10, 15, 11, 1, -15 },
  { 776, 10, 15, 12, 1, -15 },
  { 795, 12, 15, 12, 0, -15 },
  { 818, 14, 15, 16, 1, -15 },
  { 845, 10, 15, 12, 1, -15 },
  { 864, 11, 15, 11, 0, -15 },
  { 885, 9, 15, 11, 1, -15 },
  { 902, 4, 20, 5, 1, -17 },
  { 912, 8, 16, 8, 0, -15 },
  { 928, 4, 20, 5, 0, -17 },
  { 938, 6, 7, 8, 1, -15 },
  { 944, 8, 2, 8, 0, 0 },
  { 946, 4, 3, 7, 1, -16 },
  { 948, 8, 11, 10, 1, -11 },
  { 959, 9, 16, 10, 1, -16 },
  { 977, 8, 11, 10, 1, -11 },
  { 988, 8, 16, 10, 1, -16 },
  { 1004, 8, 11, 10, 1, -11 },
  { 1015, 6, 16, 7, 1, -16 },
  { 1027, 8, 15, 10, 1, -11 },
  { 1042, 8, 16, 10, 1, -16 },
  { 1058, 3, 16, 5, 1, -16 },
  { 1064, 4, 20, 5, 0, -16 },
  { 1074, 9, 16, 10, 1, -16 },
  { 1092, 3, 16, 5, 1, -16 },
  { 1098, 13, 11, 16, 1, -11 },
  { 1116, 8, 11, 10, 1, -11 },
  { 1127, 9, 11, 10, 1, -11 },
  { 1140, 9, 15, 10, 1, -11 },
  { 1157, 8, 15, 10, 1, -11 },
  { 1172, 5, 11, 7, 1, -11 },
  { 1179, 8, 11, 10, 1, -11 },
  { 1190, 6, 14, 6, 0, -14 },
  { 1201, 8, 11, 10, 1, -11 },
  { 1212, 9, 11, 9, 0, -11 },
  { 1225, 13, 11, 13, 0, -11 },
  { 1243, 9, 11, 9, 0, -11 },
  { 1256, 9, 15, 9, 0, -11 },
  { 1273, 8, 11, 9, 1, -11 },
  { 1284, 5, 20, 6, 1, -16 },
  { 1297, 1, 18, 5, 2, -15 },
  { 1300, 6, 20, 6, 0, -16 },
  { 1315, 10, 4, 12, 1, -8 },
};

const GFXfont RobotoCondensed_Medium21pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium21pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOCONDENSED_MEDIUM21PT7B_H_
