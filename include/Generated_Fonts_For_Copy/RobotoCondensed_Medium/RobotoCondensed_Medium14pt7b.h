#ifndef _ROBOTOCONDENSED_MEDIUM14PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF8, 0xF0, 0xB6, 0xD0, 0x28, 0xA2, 0xBF, 0x49, 0x6F, 0xD4,
  0x51, 0x40, 0x23, 0xB7, 0x9C, 0x30, 0xE1, 0x8E, 0xDC, 0x40, 0xE1, 0x4A,
  0xA5, 0x4F, 0x03, 0xCA, 0x95, 0x4A, 0x1C, 0x71, 0xB3, 0x66, 0x86, 0x1E,
  0xAD, 0x4E, 0xDC, 0xE8, 0xF0, 0x2D, 0x69, 0x24, 0x93, 0x26, 0x40, 0x84,
  0x62, 0x23, 0x33, 0x32, 0x26, 0x48, 0x10, 0x4F, 0xCC, 0x79, 0x20, 0x21,
  0x09, 0xFF, 0x90, 0x84, 0x57, 0xE0, 0xF0, 0x10, 0x84, 0x62, 0x11, 0x88,
  0x42, 0x20, 0x76, 0xE3, 0x18, 0xC6, 0x31, 0xDB, 0x80, 0x3F, 0xB3, 0x33,
  0x33, 0x33, 0x76, 0xE2, 0x31, 0x98, 0x8C, 0xC7, 0xC0, 0x76, 0xE6, 0x31,
  0xB8, 0x71, 0xDB, 0x80, 0x0C, 0x38, 0x71, 0xE2, 0xCD, 0x93, 0x7F, 0x0C,
  0x18, 0xFE, 0x31, 0xED, 0x84, 0x31, 0xDB, 0x80, 0x33, 0x31, 0xED, 0xC6,
  0x39, 0xDB, 0x80, 0xF8, 0x46, 0x21, 0x18, 0x8C, 0x62, 0x00, 0x76, 0xF7,
  0xBD, 0xBB, 0x71, 0xDB, 0x80, 0x76, 0xE7, 0x18, 0xED, 0xA3, 0x33, 0x00,
  0xF0, 0x0F, 0x6C, 0x00, 0x1B, 0x58, 0x08, 0xDD, 0x87, 0x0C, 0x20, 0xF8,
  0x3E, 0x87, 0x1C, 0x37, 0x72, 0x00, 0x79, 0xEC, 0xC2, 0x18, 0xC3, 0x00,
  0x30, 0xC0, 0x1E, 0x31, 0x90, 0x51, 0x99, 0x4D, 0xA6, 0x93, 0x49, 0xB4,
  0xCD, 0xB0, 0x0C, 0x03, 0xC0, 0x18, 0x18, 0x1C, 0x3C, 0x24, 0x26, 0x66,
  0x7E, 0x43, 0xC3, 0xFB, 0x3C, 0xF3, 0xFB, 0x3C, 0xF3, 0xCF, 0xE0, 0x7B,
  0xBC, 0x60, 0x82, 0x08, 0x31, 0xCD, 0xE0, 0xF3, 0x7C, 0xF1, 0xC7, 0x1C,
  0x73, 0xDF, 0xC0, 0xFE, 0x31, 0x8C, 0x7F, 0x18, 0xC7, 0xC0, 0xFE, 0x31,
  0x8C, 0x7F, 0x18, 0xC6, 0x00, 0x7B, 0xBC, 0x60, 0x82, 0x78, 0x71, 0xED,
  0xE0, 0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xF1, 0xE3, 0xC7, 0x8C, 0xFF, 0xFF,
  0xF0, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xF3, 0x6D, 0xE0, 0xCD, 0x9B, 0x67,
  0x8F, 0x1E, 0x36, 0x6C, 0xCD, 0x98, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7,
  0xC0, 0xC3, 0xE1, 0xF8, 0xF4, 0x7A, 0x7F, 0xAF, 0x57, 0xBB, 0xD9, 0xE4,
  0xC0, 0xC7, 0x8F, 0x9F, 0x3F, 0x7A, 0xF7, 0xE7, 0xCF, 0x8C, 0x79, 0xDB,
  0x14, 0x38, 0x70, 0xE1, 0xE2, 0xEC, 0xF0, 0xFB, 0x3C, 0x71, 0xCF, 0xEC,
  0x30, 0xC3, 0x00, 0x79, 0xDB, 0x14, 0x38, 0x70, 0xE1, 0xE2, 0xEC, 0xF0,
  0x30, 0x20, 0xFB, 0x3C, 0xF3, 0xCF, 0xED, 0xB2, 0xCF, 0x30, 0x7B, 0x68,
  0xF0, 0x70, 0xE0, 0xE3, 0xCD, 0xE0, 0xFE, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xF3, 0xCD, 0xE0, 0xC3,
  0x42, 0x66, 0x66, 0x24, 0x24, 0x3C, 0x3C, 0x18, 0x18, 0xC4, 0x53, 0x34,
  0xED, 0xBB, 0x6A, 0x9A, 0xA3, 0xA8, 0xCE, 0x33, 0x8C, 0x40, 0x66, 0xCC,
  0xB1, 0xE1, 0x83, 0x0F, 0x16, 0x66, 0x8C, 0xC6, 0xCD, 0x91, 0x63, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0xFC, 0x31, 0x84, 0x30, 0x86, 0x30, 0xC3, 0xF0,
  0xEA, 0xAA, 0xAA, 0xC0, 0xC2, 0x18, 0xC2, 0x18, 0xC2, 0x10, 0xC2, 0xED,
  0xB6, 0xDB, 0x6D, 0xBE, 0x21, 0x94, 0xA5, 0x80, 0xF8, 0x62, 0x76, 0xC6,
  0xFD, 0xCF, 0x7F, 0x84, 0x21, 0x6D, 0xC6, 0x31, 0x8E, 0xEC, 0x76, 0xE7,
  0x08, 0x4F, 0x6E, 0x08, 0x42, 0xDD, 0xC6, 0x31, 0x8E, 0xDA, 0x76, 0xE7,
  0x1F, 0xC3, 0x2E, 0x36, 0x6F, 0x66, 0x66, 0x66, 0x60, 0x6E, 0xE3, 0x18,
  0xC7, 0x6D, 0x0C, 0xDC, 0x84, 0x21, 0x6D, 0xCE, 0x73, 0x9C, 0xE6, 0xB2,
  0xAA, 0xA8, 0x48, 0x24, 0x92, 0x49, 0x25, 0x80, 0x84, 0x21, 0x3B, 0x5B,
  0x9E, 0xB4, 0xE6, 0xFF, 0xE0, 0xB7, 0x6E, 0xA6, 0x73, 0x39, 0x9C, 0xCE,
  0x67, 0x33, 0xB6, 0xE7, 0x39, 0xCE, 0x73, 0x76, 0xE3, 0x18, 0xC7, 0x6E,
  0xB6, 0xE3, 0x18, 0xC7, 0x76, 0x84, 0x20, 0x6E, 0xE3, 0x18, 0xC7, 0x6D,
  0x08, 0x42, 0xBE, 0x49, 0x24, 0x76, 0xE1, 0xC3, 0x0E, 0x6E, 0x6F, 0x66,
  0x66, 0x66, 0x30, 0x9C, 0xE7, 0x39, 0xCF, 0x7D, 0xCD, 0x24, 0x9A, 0x78,
  0xC3, 0x0C, 0xC9, 0xA4, 0x97, 0x4A, 0xA7, 0x73, 0xB8, 0xD8, 0x44, 0x4D,
  0xA3, 0x8C, 0x31, 0xE6, 0x93, 0xCD, 0x24, 0x9E, 0x78, 0xC3, 0x0C, 0x30,
  0x86, 0x00, 0xF8, 0x8C, 0x46, 0x62, 0x1F, 0x12, 0x26, 0x66, 0xC6, 0x66,
  0x22, 0x10, 0xFF, 0xF0, 0xC4, 0x66, 0x66, 0x36, 0x66, 0x64, 0xC0, 0x66,
  0xD9, 0x80,
};

const GFXglyph RobotoCondensed_Medium14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 3, 4, 4, 1, -11 },
  { 6, 6, 10, 8, 1, -10 },
  { 14, 5, 12, 7, 1, -11 },
  { 22, 7, 10, 9, 1, -10 },
  { 31, 7, 10, 8, 1, -10 },
  { 40, 1, 4, 2, 1, -11 },
  { 41, 3, 14, 4, 1, -11 },
  { 47, 4, 14, 5, 0, -11 },
  { 54, 6, 6, 6, 0, -10 },
  { 59, 5, 8, 7, 1, -9 },
  { 64, 2, 4, 3, 0, -2 },
  { 65, 3, 1, 4, 1, -5 },
  { 66, 2, 2, 4, 1, -2 },
  { 67, 5, 11, 5, 0, -10 },
  { 74, 5, 10, 7, 1, -10 },
  { 81, 4, 10, 7, 1, -10 },
  { 86, 5, 10, 7, 1, -10 },
  { 93, 5, 10, 7, 1, -10 },
  { 100, 7, 10, 7, 0, -10 },
  { 109, 5, 10, 7, 1, -10 },
  { 116, 5, 10, 7, 1, -10 },
  { 123, 5, 10, 7, 1, -10 },
  { 130, 5, 10, 7, 1, -10 },
  { 137, 5, 10, 7, 1, -10 },
  { 144, 2, 8, 4, 1, -8 },
  { 146, 3, 10, 3, 0, -8 },
  { 150, 5, 7, 6, 0, -8 },
  { 155, 5, 3, 7, 1, -6 },
  { 157, 5, 7, 6, 1, -8 },
  { 162, 6, 10, 6, 0, -10 },
  { 170, 9, 13, 11, 1, -10 },
  { 185, 8, 10, 8, 0, -10 },
  { 195, 6, 10, 8, 1, -10 },
  { 203, 6, 10, 8, 1, -10 },
  { 211, 6, 10, 8, 1, -10 },
  { 219, 5, 10, 7, 1, -10 },
  { 226, 5, 10, 7, 1, -10 },
  { 233, 6, 10, 8, 1, -10 },
  { 241, 7, 10, 9, 1, -10 },
  { 250, 2, 10, 4, 1, -10 },
  { 253, 6, 10, 7, 0, -10 },
  { 261, 7, 10, 8, 1, -10 },
  { 270, 5, 10, 7, 1, -10 },
  { 277, 9, 10, 11, 1, -10 },
  { 289, 7, 10, 9, 1, -10 },
  { 298, 7, 10, 8, 1, -10 },
  { 307, 6, 10, 8, 1, -10 },
  { 315, 7, 12, 8, 1, -10 },
  { 326, 6, 10, 8, 1, -10 },
  { 334, 6, 10, 7, 1, -10 },
  { 342, 7, 10, 7, 0, -10 },
  { 351, 6, 10, 8, 1, -10 },
  { 359, 8, 10, 8, 0, -10 },
  { 369, 10, 10, 11, 0, -10 },
  { 382, 7, 10, 8, 0, -10 },
  { 391, 7, 10, 7, 0, -10 },
  { 400, 6, 10, 7, 1, -10 },
  { 408, 2, 13, 4, 1, -11 },
  { 412, 5, 11, 5, 0, -10 },
  { 419, 3, 13, 4, 0, -11 },
  { 424, 5, 5, 5, 0, -10 },
  { 428, 5, 1, 6, 0, 0 },
  { 429, 4, 2, 4, 0, -10 },
  { 430, 5, 8, 7, 1, -8 },
  { 435, 5, 11, 7, 1, -11 },
  { 442, 5, 8, 6, 1, -8 },
  { 447, 5, 11, 7, 1, -11 },
  { 454, 5, 8, 7, 1, -8 },
  { 459, 4, 11, 5, 0, -11 },
  { 465, 5, 11, 7, 1, -8 },
  { 472, 5, 11, 7, 1, -11 },
  { 479, 2, 11, 3, 1, -11 },
  { 482, 3, 14, 3, 0, -11 },
  { 488, 5, 11, 7, 1, -11 },
  { 495, 1, 11, 3, 1, -11 },
  { 497, 9, 8, 10, 1, -8 },
  { 506, 5, 8, 7, 1, -8 },
  { 511, 5, 8, 7, 1, -8 },
  { 516, 5, 11, 7, 1, -8 },
  { 523, 5, 11, 7, 1, -8 },
  { 530, 3, 8, 4, 1, -8 },
  { 533, 5, 8, 6, 1, -8 },
  { 538, 4, 9, 4, 0, -9 },
  { 543, 5, 8, 7, 1, -8 },
  { 548, 6, 8, 6, 0, -8 },
  { 554, 9, 8, 9, 0, -8 },
  { 563, 6, 8, 6, 0, -8 },
  { 569, 6, 11, 6, 0, -8 },
  { 578, 5, 8, 6, 1, -8 },
  { 583, 4, 13, 4, 0, -11 },
  { 590, 1, 12, 3, 1, -10 },
  { 592, 4, 13, 4, 0, -11 },
  { 599, 6, 3, 8, 1, -6 },
};

const GFXfont RobotoCondensed_Medium14pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium14pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium14pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOCONDENSED_MEDIUM14PT7B_H_
