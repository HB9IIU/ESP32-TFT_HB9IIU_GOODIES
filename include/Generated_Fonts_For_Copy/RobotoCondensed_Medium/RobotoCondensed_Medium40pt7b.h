#ifndef _ROBOTOCONDENSED_MEDIUM40PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBC, 0x00, 0x00, 0x0E, 0xFF, 0xFE, 0xE0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xC0, 0x01, 0xC7, 0x00, 0x71, 0xC0,
  0x3C, 0x70, 0x0E, 0x1C, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E,
  0x38, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x1C, 0x70, 0x07, 0x1C,
  0x01, 0xC7, 0x00, 0x71, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0x0E, 0x38, 0x07, 0x8E, 0x01, 0xC3, 0x80, 0x71,
  0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xFE, 0x7E, 0x3E, 0x7C, 0x1E, 0x7C, 0x1F, 0x78, 0x1F, 0x7C, 0x1F,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8,
  0x07, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x1E, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3C, 0xF0, 0x40, 0xE1, 0xC1, 0xC3,
  0x87, 0x0E, 0x0E, 0x1C, 0x38, 0x38, 0x71, 0xC0, 0xE1, 0xCE, 0x03, 0xC7,
  0x38, 0x07, 0xFD, 0xC0, 0x1F, 0xE7, 0x00, 0x1F, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0xF8, 0x00, 0xE7, 0xF0, 0x07, 0x3F, 0xE0,
  0x1C, 0xE3, 0x80, 0xE7, 0x8F, 0x03, 0x9C, 0x1C, 0x1C, 0x70, 0x70, 0x71,
  0xE1, 0xC3, 0x87, 0x8F, 0x0E, 0x0E, 0x38, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x3E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C,
  0x3C, 0x03, 0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC1, 0xC3, 0xFE, 0x3C, 0x7D, 0xF3, 0xCF, 0x9F, 0x3C,
  0xF0, 0xFB, 0xCF, 0x07, 0xFC, 0xF0, 0x7F, 0x8F, 0x03, 0xF8, 0xF8, 0x1F,
  0x0F, 0xC3, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFB, 0xE0, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x60, 0x3C, 0x1E, 0x07, 0x03,
  0xC1, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x81,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x06, 0x00, 0x80, 0x40, 0x70, 0x3C,
  0x0F, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x07,
  0x07, 0x83, 0x83, 0xC3, 0xC1, 0xC0, 0x40, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE1, 0x87, 0xFD, 0xBF, 0xFF, 0xFF,
  0x3F, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0x70, 0x1C, 0x78,
  0x3C, 0x3C, 0x38, 0x38, 0x08, 0x10, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0xF3, 0xCF, 0x3D, 0xF7, 0x9E, 0xF3, 0xC6, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF7, 0xFF, 0xF7, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x78, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x3F, 0xFC,
  0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x40, 0xF0, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C,
  0x3E, 0xF8, 0x3E, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0xFC, 0x3E, 0xF8, 0x3E, 0xF8,
  0x1E, 0xF0, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x07,
  0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1E, 0xFC, 0x3E, 0x7F,
  0xFE, 0x7F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x3C, 0xF8, 0x0F, 0x3E,
  0x07, 0x8F, 0x81, 0xE3, 0xE0, 0xF0, 0xF8, 0x3C, 0x3E, 0x1E, 0x0F, 0x87,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x3F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7D, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE,
  0x7C, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x3E, 0x3F, 0xFE,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF8,
  0x0F, 0xF8, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x79, 0xF0, 0x7B, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x0F,
  0x78, 0x1F, 0x7C, 0x1F, 0x3E, 0x3E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E,
  0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0x7C, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x07, 0xC0,
  0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7C, 0x7C, 0x78, 0x3E, 0xF8, 0x1E,
  0xF8, 0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x7C, 0x3F, 0x7F, 0xFF, 0x3F, 0xFE, 0x1F, 0xDE, 0x0F, 0x9E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xF8, 0x1F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0xF7, 0xFF, 0xF7, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xB8, 0x3C, 0xFD, 0xFB, 0xE3,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x78, 0xF3, 0xC1, 0x00, 0x00, 0x04, 0x00,
  0x70, 0x03, 0xC0, 0x3F, 0x03, 0xFC, 0x3F, 0xE3, 0xFE, 0x3F, 0xE0, 0xFE,
  0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x1F, 0xC1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0xF0, 0x03, 0x00, 0x08,
  0x00, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xC7, 0xEF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x78, 0x00, 0xF0,
  0x1E, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x3C, 0x0F,
  0x81, 0xC7, 0x03, 0xFC, 0x39, 0xE0, 0xFF, 0x87, 0x38, 0x3C, 0x70, 0x67,
  0x07, 0x0E, 0x0E, 0xE1, 0xE1, 0xC1, 0xFC, 0x38, 0x38, 0x3F, 0x07, 0x07,
  0x07, 0xE1, 0xE0, 0xE0, 0xFC, 0x3C, 0x1C, 0x1F, 0x87, 0x83, 0x83, 0xF0,
  0xF0, 0xF0, 0x7E, 0x1E, 0x1E, 0x0F, 0xC3, 0xC3, 0xC3, 0xB8, 0x78, 0x78,
  0x77, 0x0F, 0x1F, 0x0E, 0xE1, 0xF3, 0xE3, 0x9E, 0x1F, 0xFF, 0xF1, 0xC1,
  0xF9, 0xFC, 0x38, 0x1E, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x1C, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDF,
  0x00, 0x0F, 0x3C, 0x00, 0x7C, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0x87, 0x80,
  0x3E, 0x1E, 0x00, 0xF0, 0x7C, 0x03, 0xC1, 0xF0, 0x1F, 0x03, 0xC0, 0x7C,
  0x0F, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x3C, 0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x07, 0xBE, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F,
  0xFF, 0xEF, 0x03, 0xF7, 0x80, 0xFB, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xBC, 0x07, 0xDF, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF,
  0xF9, 0xE0, 0x3E, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3E, 0xFF, 0xFF, 0x7F, 0xFF,
  0x3F, 0xFF, 0x1F, 0xFE, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xC3, 0xF0, 0xFC, 0xF8, 0x0F, 0x9F, 0x00, 0xFB, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x0F, 0xFC, 0x01, 0xF7, 0x80, 0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xF1,
  0xF0, 0x7E, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF0, 0x3F, 0x3C,
  0x07, 0xCF, 0x00, 0xFB, 0xC0, 0x3E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F, 0xBC,
  0x03, 0xEF, 0x01, 0xF3, 0xC0, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFF, 0xDF,
  0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F,
  0xFF, 0xE3, 0xF0, 0xFC, 0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xF7, 0x80, 0x1E, 0xF8, 0x03, 0xDF, 0x80, 0x79, 0xF8,
  0x3F, 0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0x7C, 0x3E,
  0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xF0, 0x07, 0xDE, 0x01,
  0xFB, 0xC0, 0x7E, 0x78, 0x0F, 0x8F, 0x03, 0xE1, 0xE0, 0xFC, 0x3C, 0x1F,
  0x07, 0x87, 0xC0, 0xF1, 0xF8, 0x1E, 0x3E, 0x03, 0xCF, 0x80, 0x7B, 0xF0,
  0x0F, 0x7C, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0x9F, 0x03, 0xE3, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0xE1, 0xE0, 0x7C,
  0x3C, 0x0F, 0xC7, 0x80, 0xF8, 0xF0, 0x1F, 0x9E, 0x01, 0xFB, 0xC0, 0x1F,
  0x78, 0x03, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFD, 0xE0, 0x7B, 0xFE, 0xF0, 0x3D, 0xFF, 0x7C, 0x1E,
  0xFF, 0x9E, 0x1E, 0x7F, 0xCF, 0x0F, 0x3F, 0xE7, 0x87, 0x9F, 0xF1, 0xE7,
  0xCF, 0xF8, 0xF3, 0xC7, 0xFC, 0x79, 0xE3, 0xFE, 0x1E, 0xF1, 0xFF, 0x0F,
  0xF0, 0xFF, 0x87, 0xF8, 0x7F, 0xC1, 0xFC, 0x3F, 0xE0, 0xFC, 0x1F, 0xF0,
  0x7E, 0x0F, 0xF8, 0x1F, 0x07, 0xFC, 0x0F, 0x03, 0xFE, 0x07, 0x81, 0xF0,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFE, 0xF0, 0x7F,
  0xDF, 0x0F, 0xF9, 0xE1, 0xFF, 0x3E, 0x3F, 0xE3, 0xC7, 0xFC, 0x7C, 0xFF,
  0x87, 0x9F, 0xF0, 0xFB, 0xFE, 0x0F, 0x7F, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0x3E, 0x7C, 0x03,
  0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7,
  0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xF0, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x1F, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3,
  0xFF, 0xFC, 0xF0, 0x1F, 0xBC, 0x03, 0xEF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xBC, 0x07,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFC, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xC0, 0x7E, 0x7C,
  0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xF0, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFC, 0xF0, 0x3F, 0x3C, 0x03, 0xEF, 0x00, 0xFB, 0xC0,
  0x3E, 0xF0, 0x0F, 0xBC, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x7E, 0xF0, 0x3F,
  0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3C, 0x3F, 0x0F,
  0x07, 0xC3, 0xC1, 0xF0, 0xF0, 0x3E, 0x3C, 0x0F, 0x8F, 0x01, 0xF3, 0xC0,
  0x7C, 0xF0, 0x1F, 0xBC, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x1F, 0x07, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7C, 0x1F, 0x3E, 0x03, 0xEF,
  0x80, 0xFB, 0xE0, 0x1E, 0xF8, 0x07, 0xBF, 0x00, 0x07, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xE0, 0x00, 0xFB, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0xF9, 0xF0, 0x7E, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xF7, 0xC0, 0x7D,
  0xF8, 0x3F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F,
  0x3E, 0x00, 0xF8, 0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0,
  0x1E, 0x07, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x78, 0x07, 0x87, 0xC0,
  0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0xF8, 0x01, 0xF7,
  0xC0, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF8, 0x1F, 0x78, 0x0F, 0x81, 0xF7,
  0x80, 0xF8, 0x1F, 0x7C, 0x1F, 0x81, 0xE7, 0xC1, 0xF8, 0x1E, 0x7C, 0x1F,
  0xC3, 0xE3, 0xC1, 0xFC, 0x3E, 0x3C, 0x3F, 0xC3, 0xE3, 0xC3, 0xFC, 0x3C,
  0x3E, 0x3D, 0xC3, 0xC3, 0xE3, 0xDE, 0x3C, 0x1E, 0x39, 0xE3, 0xC1, 0xE7,
  0x9E, 0x7C, 0x1E, 0x79, 0xE7, 0xC1, 0xE7, 0x8E, 0x78, 0x1F, 0x78, 0xF7,
  0x81, 0xF7, 0x0F, 0x78, 0x0F, 0xF0, 0xF7, 0x80, 0xFF, 0x07, 0xF8, 0x0F,
  0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07,
  0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00,
  0x7C, 0x03, 0xE0, 0xFC, 0x01, 0xF7, 0xC0, 0x3E, 0x7E, 0x03, 0xE3, 0xE0,
  0x7C, 0x3F, 0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x8F, 0x80, 0xF9, 0xF0, 0x07,
  0xDF, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x01, 0xF0, 0xF8, 0x1F, 0x0F,
  0x83, 0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xE0, 0x3E, 0x7C, 0x03, 0xFF, 0xC0,
  0x1F, 0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xC3,
  0xE0, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x8F,
  0x80, 0x3C, 0x7C, 0x01, 0xF3, 0xC0, 0x07, 0xBE, 0x00, 0x3D, 0xE0, 0x01,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x3C,
  0x03, 0xE0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x77, 0x87, 0xBC, 0x3C, 0xE1,
  0xC7, 0x9E, 0x3C, 0xF0, 0xE7, 0x07, 0xF8, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x07,
  0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xEF, 0x83, 0xDF, 0x07, 0xFE, 0x0F,
  0x80, 0x1F, 0x0F, 0xFE, 0x7F, 0xFD, 0xFF, 0xFB, 0xE1, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xFF, 0xFD, 0xFF, 0xF9, 0xFF,
  0xF1, 0xF1, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xF0, 0xFF,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0xF9, 0xF0, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xEF, 0xC3,
  0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x07, 0xFC, 0x0F, 0xFC, 0x3E, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x1F, 0x3C, 0xFF, 0x7B, 0xFF, 0xF7, 0xFF, 0xFF, 0x87, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x7D, 0xFF, 0xFB, 0xFF, 0xF3,
  0xFD, 0xE1, 0xF3, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC,
  0x7C, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x04,
  0x7C, 0x0C, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x03, 0xE0,
  0xFC, 0x3F, 0x8F, 0xF1, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x9F, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFC, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0x9F, 0x00, 0x1F,
  0x00, 0x1F, 0x20, 0x1E, 0x30, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8,
  0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF3, 0xE3, 0xEF, 0xE7, 0xFF,
  0xEF, 0xFF, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xC0, 0x77,
  0xFF, 0xF7, 0x00, 0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x80, 0x0E, 0x1F, 0x1F, 0x1F, 0x0E, 0x00,
  0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0xFF, 0xFE, 0xFC, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xF8, 0xF9, 0xF0, 0xF9,
  0xF0, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFD, 0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF0,
  0x7C, 0x3F, 0xFE, 0x3F, 0xCF, 0xFF, 0xDF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFC,
  0x3F, 0x0F, 0xBE, 0x0F, 0xC1, 0xEF, 0x81, 0xE0, 0x7F, 0xE0, 0x78, 0x1F,
  0xF8, 0x1E, 0x07, 0xFE, 0x07, 0x81, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x78,
  0x1F, 0xF8, 0x1E, 0x07, 0xFE, 0x07, 0x81, 0xFF, 0x81, 0xE0, 0x7F, 0xE0,
  0x78, 0x1F, 0xF8, 0x1E, 0x07, 0xFE, 0x07, 0x81, 0xFF, 0x81, 0xE0, 0x7F,
  0xE0, 0x78, 0x1F, 0xF8, 0x1E, 0x07, 0xC0, 0xF9, 0xF1, 0xF7, 0xFB, 0xFF,
  0xF7, 0xFF, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xE0, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xF9, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFC, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xF9, 0xF0, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x0F, 0x9E, 0x7F, 0xBD, 0xFF, 0xFB, 0xFF, 0xFF, 0xC3,
  0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x3E, 0xFF,
  0xFD, 0xFF, 0xF9, 0xFE, 0xF0, 0xF9, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x00, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xEF, 0x87, 0xDF, 0x07,
  0xBE, 0x0F, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xBC, 0x0F, 0xF8, 0x1F, 0xF8, 0x3D, 0xFF, 0xF9, 0xFF,
  0xE1, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03,
  0xF8, 0x7F, 0x0F, 0xE0, 0x7C, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0x7C,
  0x7E, 0xFF, 0xFD, 0xFF, 0xF9, 0xFE, 0xF0, 0xF9, 0xE0, 0xF8, 0x1F, 0xF8,
  0x1E, 0xF8, 0x1E, 0x78, 0x3E, 0x78, 0x3E, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x7C, 0x3C, 0x78, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0xF8, 0x3C, 0x1E, 0xF8, 0x7C, 0x1E,
  0x78, 0x7C, 0x1E, 0x78, 0x7E, 0x3E, 0x78, 0x7E, 0x3E, 0x78, 0xFE, 0x3C,
  0x3C, 0xFE, 0x3C, 0x3C, 0xFF, 0x3C, 0x3C, 0xEF, 0x3C, 0x3D, 0xE7, 0x78,
  0x3D, 0xE7, 0x78, 0x1F, 0xE7, 0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0xC3, 0xF8,
  0x1F, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0x81, 0xE0, 0x0F, 0x01, 0xE0, 0xF8, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E,
  0x3E, 0x7C, 0x3E, 0x78, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8,
  0x1E, 0xF8, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x3E, 0x7C, 0x3E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0x78, 0x3E, 0x78, 0x3C, 0x7C, 0x3C,
  0x7C, 0x7C, 0x3C, 0x7C, 0x3C, 0x78, 0x3E, 0x78, 0x1E, 0xF8, 0x1E, 0xF0,
  0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x78, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x80, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x3F, 0x0F, 0x83, 0xE0,
  0xFC, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x03,
  0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1F, 0x03, 0xF0, 0x7C, 0x1F, 0x0F, 0xC7, 0xC1, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0xC3,
  0xE0, 0xF0, 0x10, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x3D, 0xFF, 0x87, 0xBF,
  0xF9, 0xEF, 0x9F, 0xFD, 0xE1, 0xFF, 0xBC, 0x1F, 0xE0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_Medium40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 28, 10, 3, -28 },
  { 19, 9, 10, 13, 2, -30 },
  { 31, 18, 28, 21, 2, -28 },
  { 94, 16, 36, 20, 2, -32 },
  { 166, 22, 28, 25, 2, -28 },
  { 243, 20, 28, 23, 2, -28 },
  { 313, 3, 10, 7, 2, -30 },
  { 317, 10, 41, 13, 2, -32 },
  { 369, 9, 41, 13, 1, -32 },
  { 416, 16, 17, 18, 1, -28 },
  { 450, 17, 20, 19, 1, -23 },
  { 493, 6, 11, 9, 1, -5 },
  { 502, 9, 4, 12, 2, -14 },
  { 507, 5, 5, 11, 3, -5 },
  { 511, 13, 30, 14, 0, -28 },
  { 560, 16, 28, 20, 2, -28 },
  { 616, 10, 28, 20, 3, -28 },
  { 651, 16, 28, 20, 2, -28 },
  { 707, 16, 28, 20, 2, -28 },
  { 763, 18, 28, 20, 1, -28 },
  { 826, 16, 28, 20, 2, -28 },
  { 882, 16, 28, 20, 2, -28 },
  { 938, 17, 28, 20, 1, -28 },
  { 998, 16, 28, 20, 2, -28 },
  { 1054, 16, 28, 20, 2, -28 },
  { 1110, 5, 22, 10, 3, -22 },
  { 1124, 7, 28, 9, 1, -22 },
  { 1149, 14, 19, 18, 1, -22 },
  { 1183, 14, 12, 20, 3, -19 },
  { 1204, 14, 19, 18, 3, -22 },
  { 1238, 15, 28, 17, 1, -28 },
  { 1291, 27, 37, 31, 2, -28 },
  { 1416, 22, 28, 24, 1, -28 },
  { 1493, 17, 28, 22, 3, -28 },
  { 1553, 19, 28, 23, 2, -28 },
  { 1620, 18, 28, 23, 3, -28 },
  { 1683, 16, 28, 20, 3, -28 },
  { 1739, 15, 28, 19, 3, -28 },
  { 1792, 19, 28, 24, 2, -28 },
  { 1859, 19, 28, 25, 3, -28 },
  { 1926, 5, 28, 10, 3, -28 },
  { 1944, 16, 28, 20, 1, -28 },
  { 2000, 19, 28, 22, 3, -28 },
  { 2067, 15, 28, 19, 3, -28 },
  { 2120, 25, 28, 30, 3, -28 },
  { 2208, 19, 28, 25, 3, -28 },
  { 2275, 20, 28, 24, 2, -28 },
  { 2345, 18, 28, 22, 3, -28 },
  { 2408, 20, 33, 24, 2, -28 },
  { 2491, 18, 28, 22, 3, -28 },
  { 2554, 18, 28, 21, 2, -28 },
  { 2617, 19, 28, 21, 1, -28 },
  { 2684, 18, 28, 23, 2, -28 },
  { 2747, 21, 28, 23, 1, -28 },
  { 2821, 28, 28, 30, 1, -28 },
  { 2919, 20, 28, 22, 1, -28 },
  { 2989, 21, 28, 21, 0, -28 },
  { 3063, 18, 28, 21, 2, -28 },
  { 3126, 7, 39, 10, 2, -33 },
  { 3161, 14, 30, 15, 1, -28 },
  { 3214, 7, 39, 10, 1, -33 },
  { 3249, 13, 14, 15, 1, -28 },
  { 3272, 16, 4, 16, 0, 0 },
  { 3280, 9, 6, 13, 1, -30 },
  { 3287, 15, 21, 19, 2, -21 },
  { 3327, 16, 30, 20, 2, -30 },
  { 3387, 15, 21, 18, 2, -21 },
  { 3427, 15, 30, 20, 2, -30 },
  { 3484, 16, 21, 19, 2, -21 },
  { 3526, 11, 30, 13, 1, -30 },
  { 3568, 16, 29, 20, 2, -21 },
  { 3626, 15, 30, 20, 2, -30 },
  { 3683, 5, 29, 10, 2, -29 },
  { 3702, 8, 37, 9, -1, -29 },
  { 3739, 16, 30, 19, 2, -30 },
  { 3799, 4, 30, 10, 3, -30 },
  { 3814, 26, 21, 30, 2, -21 },
  { 3883, 15, 21, 20, 2, -21 },
  { 3923, 16, 21, 20, 2, -21 },
  { 3965, 16, 29, 20, 2, -21 },
  { 4023, 15, 29, 20, 2, -21 },
  { 4078, 10, 21, 13, 2, -21 },
  { 4105, 15, 21, 18, 2, -21 },
  { 4145, 11, 26, 12, 0, -26 },
  { 4181, 15, 21, 20, 2, -21 },
  { 4221, 16, 21, 18, 1, -21 },
  { 4263, 24, 21, 26, 1, -21 },
  { 4326, 16, 21, 18, 1, -21 },
  { 4368, 16, 29, 17, 1, -21 },
  { 4426, 14, 21, 18, 2, -21 },
  { 4463, 10, 38, 12, 1, -31 },
  { 4511, 4, 33, 10, 3, -28 },
  { 4528, 10, 38, 12, 1, -31 },
  { 4576, 19, 8, 23, 2, -16 },
};

const GFXfont RobotoCondensed_Medium40pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium40pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium40pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOCONDENSED_MEDIUM40PT7B_H_
