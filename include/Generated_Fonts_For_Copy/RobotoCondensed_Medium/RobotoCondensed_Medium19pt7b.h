#ifndef _ROBOTOCONDENSED_MEDIUM19PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0xB6, 0xC8, 0x0F, 0xC0, 0xDD, 0x99, 0x90, 0x1B, 0x09,
  0x04, 0x82, 0x41, 0x23, 0xFC, 0xD8, 0x6C, 0x24, 0x7F, 0x89, 0x0D, 0x86,
  0xC3, 0x60, 0x18, 0x18, 0x3C, 0x7E, 0x66, 0xE6, 0xE0, 0x60, 0x78, 0x1E,
  0x06, 0x07, 0xC7, 0xC6, 0x7E, 0x3C, 0x10, 0x10, 0x70, 0x36, 0x09, 0x92,
  0x6C, 0xDA, 0x1D, 0x80, 0x40, 0x30, 0x0B, 0x86, 0xB1, 0x64, 0xD9, 0x22,
  0xC0, 0xE0, 0x3C, 0x3E, 0x19, 0x8C, 0xC6, 0xC3, 0xE0, 0xE0, 0xF3, 0xDD,
  0xE7, 0xB1, 0xD8, 0xEF, 0xF1, 0xEC, 0xF8, 0x10, 0x8C, 0xC6, 0x23, 0x18,
  0xC6, 0x31, 0x8C, 0x21, 0x8C, 0x30, 0x84, 0x8C, 0xC6, 0x62, 0x33, 0x33,
  0x33, 0x32, 0x66, 0xCC, 0x80, 0x18, 0x08, 0x49, 0xFF, 0x1C, 0x3C, 0x26,
  0x22, 0x18, 0x30, 0x60, 0xCF, 0xFF, 0xC6, 0x0C, 0x18, 0x30, 0x6D, 0xB4,
  0xFF, 0x1F, 0x80, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x0C, 0x30, 0x86, 0x18,
  0x61, 0x0C, 0x00, 0x3C, 0x7E, 0xE6, 0xC6, 0xC6, 0xC7, 0xC7, 0xC7, 0xC7,
  0xC6, 0xC6, 0xE6, 0x7E, 0x3C, 0x09, 0xFF, 0xB1, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x3C, 0x7E, 0xC6, 0xC6, 0x06, 0x06, 0x0E, 0x0C, 0x18, 0x38,
  0x70, 0x60, 0xFF, 0xFF, 0x3C, 0xFF, 0x1E, 0x30, 0x60, 0xCF, 0x1E, 0x06,
  0x0F, 0x1E, 0x3F, 0xE7, 0x80, 0x0E, 0x0E, 0x1E, 0x1E, 0x3E, 0x2E, 0x6E,
  0x6E, 0xCE, 0xFF, 0xFF, 0x0E, 0x0E, 0x0E, 0x7E, 0x7E, 0x60, 0x60, 0x60,
  0x7C, 0xFE, 0x06, 0x07, 0x03, 0xC7, 0xE6, 0x7E, 0x3C, 0x1C, 0x3C, 0x70,
  0x60, 0xC0, 0xDC, 0xFE, 0xE6, 0xC7, 0xC3, 0xC7, 0x66, 0x7E, 0x3C, 0xFF,
  0xFF, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x30, 0x30, 0x30,
  0x60, 0x3C, 0x7E, 0xE6, 0xC6, 0xC6, 0x66, 0x7C, 0x7C, 0xE6, 0xC6, 0xC6,
  0xC6, 0x7E, 0x3C, 0x38, 0xFB, 0x9E, 0x3C, 0x78, 0xF1, 0xBF, 0x3E, 0x0C,
  0x18, 0x63, 0xC6, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x07, 0x60, 0x00,
  0x00, 0x06, 0x66, 0x64, 0x04, 0x77, 0xB8, 0xE1, 0xE1, 0xC1, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x81, 0xC1, 0xF0, 0x70, 0xEF, 0xB8, 0x40, 0x79,
  0xFB, 0x36, 0x70, 0xC1, 0x86, 0x1C, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00,
  0x0F, 0x80, 0xE7, 0x0C, 0x08, 0xC0, 0x24, 0x79, 0x67, 0xCF, 0x32, 0x79,
  0x33, 0x99, 0x9C, 0xCC, 0xE6, 0x65, 0x9F, 0x6C, 0xEE, 0x20, 0x01, 0x80,
  0x07, 0x30, 0x0F, 0x80, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x81, 0xB0, 0x36,
  0x06, 0xE1, 0x8C, 0x31, 0x87, 0xF9, 0xFF, 0x30, 0x66, 0x0D, 0xC1, 0xC0,
  0xFE, 0x7F, 0xB8, 0xDC, 0x6E, 0x37, 0x1B, 0xF9, 0xFC, 0xE3, 0x71, 0xF8,
  0xFC, 0x6F, 0xF7, 0xF0, 0x3E, 0x3F, 0x98, 0xFC, 0x3C, 0x1E, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0xF8, 0x6C, 0x77, 0xF1, 0xF0, 0xFC, 0x7F, 0x38, 0xDC,
  0x6E, 0x3F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF8, 0xDC, 0x6F, 0xE7, 0xE0,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x3E, 0x3F, 0x98, 0xFC, 0x3C, 0x06, 0x03, 0x01,
  0x8F, 0xC7, 0xE0, 0xF8, 0x6C, 0x37, 0xF8, 0xF0, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0xFF, 0xFF, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x63, 0x67, 0x7E, 0x3C, 0xE3, 0xF1, 0xB9, 0xDD,
  0xCE, 0xC7, 0xE3, 0xE1, 0xF8, 0xEC, 0x77, 0x39, 0xDC, 0xEE, 0x3F, 0x0C,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFD, 0x8F, 0xD9,
  0xBD, 0x9B, 0xCD, 0xBC, 0xF3, 0xCF, 0x3C, 0x73, 0xC6, 0x3C, 0x63, 0xE1,
  0xF0, 0xFC, 0x7E, 0x3D, 0x9E, 0xCF, 0x37, 0x9B, 0xCF, 0xE3, 0xF1, 0xF8,
  0x7C, 0x3E, 0x0C, 0x1E, 0x3F, 0x98, 0xFC, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF8, 0x6C, 0x77, 0xF0, 0xF0, 0xFE, 0x7F, 0xB8, 0xFC, 0x3E,
  0x1F, 0x0F, 0x8F, 0xFE, 0xFE, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x3E,
  0x1F, 0xC6, 0x3B, 0x86, 0xC1, 0xB0, 0x6C, 0x1B, 0x06, 0xC1, 0xB0, 0x6E,
  0x19, 0x8E, 0x7F, 0x0F, 0xC0, 0x38, 0x06, 0xFE, 0x7F, 0xB8, 0xDC, 0x6E,
  0x3F, 0x1B, 0x8D, 0xFE, 0xFE, 0x73, 0x39, 0x9C, 0xEE, 0x37, 0x1C, 0x3C,
  0x7E, 0xE3, 0xC3, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x03, 0xC3, 0xC3, 0x7F,
  0x3C, 0xFF, 0xFF, 0xC6, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFC, 0x67, 0xF1, 0xF0, 0xE0, 0xCC, 0x19,
  0x87, 0x38, 0xE3, 0x18, 0x63, 0x0C, 0xE1, 0xD8, 0x1B, 0x03, 0x60, 0x7C,
  0x07, 0x00, 0xE0, 0x1C, 0x00, 0xC6, 0x1E, 0x31, 0xF1, 0xCD, 0x8E, 0x6C,
  0xF3, 0x37, 0x99, 0xB4, 0xCD, 0xB6, 0x69, 0xE3, 0xCF, 0x1E, 0x78, 0x71,
  0xC3, 0x8E, 0x18, 0x60, 0x61, 0xDC, 0x63, 0x38, 0xEC, 0x1B, 0x07, 0x80,
  0xE0, 0x38, 0x1E, 0x06, 0xC3, 0xB0, 0xCE, 0x71, 0x98, 0x70, 0xE1, 0xD8,
  0x67, 0x18, 0xCC, 0x33, 0x07, 0xC1, 0xE0, 0x78, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0x07, 0x06, 0x0C, 0x0C, 0x18, 0x18,
  0x30, 0x70, 0x60, 0xE0, 0xFF, 0xFF, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCF, 0xF0, 0xE0, 0xC1, 0x83, 0x83, 0x06, 0x0C, 0x0C, 0x18,
  0x30, 0x30, 0x60, 0xC0, 0xC1, 0x80, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x3F, 0xF0, 0x31, 0xC7, 0x16, 0xDB, 0x28, 0xC0, 0xFF, 0xFC,
  0x61, 0x86, 0x3C, 0xFF, 0x18, 0x37, 0xFC, 0xF1, 0xE3, 0xFE, 0xEC, 0xC0,
  0xC0, 0xC0, 0xC0, 0xDC, 0xFE, 0xC6, 0xC7, 0xC7, 0xC7, 0xC7, 0xC6, 0xFE,
  0xDC, 0x3C, 0xFF, 0x1E, 0x3C, 0x18, 0x31, 0xE3, 0x7C, 0x70, 0x06, 0x0C,
  0x18, 0x37, 0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3F, 0xEF, 0xC0, 0x3C,
  0xFF, 0x1E, 0x3F, 0xFF, 0xF0, 0x61, 0x7E, 0x78, 0x1C, 0xF3, 0x0C, 0xFF,
  0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x7F, 0xFF, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xFE, 0xFC, 0x18, 0x37, 0xEF, 0x80, 0xC1, 0x83, 0x06, 0x0D,
  0xDF, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xC0, 0xD8, 0x6D, 0xB6,
  0xDB, 0x6C, 0x6C, 0x36, 0xDB, 0x6D, 0xB6, 0xDF, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC6, 0xCC, 0xDC, 0xD8, 0xF8, 0xF8, 0xDC, 0xCC, 0xCE, 0xC6, 0xFF,
  0xFF, 0xFF, 0xF0, 0xDC, 0xEF, 0xFF, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63,
  0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xDD, 0xFF, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8C, 0x3C, 0x7E, 0xC6, 0xC7, 0xC3, 0xC3, 0xC7, 0xC6, 0x7E,
  0x3C, 0xDC, 0xFE, 0xC6, 0xC7, 0xC7, 0xC7, 0xC7, 0xC6, 0xFE, 0xDC, 0xC0,
  0xC0, 0xC0, 0xC0, 0x7F, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xFE, 0xFC,
  0x18, 0x30, 0x60, 0xC0, 0xDF, 0xF9, 0x8C, 0x63, 0x18, 0xC6, 0x00, 0x79,
  0xFB, 0x1F, 0x07, 0x87, 0x83, 0xE3, 0xFE, 0xF0, 0x31, 0x8D, 0xFF, 0x98,
  0xC6, 0x31, 0x8C, 0x73, 0x80, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xFE, 0xFC, 0xE3, 0x67, 0x66, 0x66, 0x36, 0x34, 0x3C, 0x3C, 0x1C, 0x18,
  0x66, 0x36, 0x66, 0x67, 0x66, 0xF6, 0x6F, 0x63, 0xD6, 0x39, 0xC3, 0x9C,
  0x39, 0xC1, 0x8C, 0x67, 0x76, 0x36, 0x3C, 0x1C, 0x1C, 0x3C, 0x36, 0x66,
  0x63, 0xE3, 0x67, 0x66, 0x66, 0x36, 0x3C, 0x3C, 0x3C, 0x1C, 0x18, 0x18,
  0x18, 0x70, 0x60, 0xFF, 0xFC, 0x30, 0xC3, 0x86, 0x18, 0x70, 0xFF, 0xFC,
  0x13, 0x66, 0x66, 0x66, 0xCC, 0x66, 0x66, 0x66, 0x31, 0xFF, 0xFF, 0x80,
  0x43, 0x18, 0x63, 0x18, 0xC6, 0x38, 0xCC, 0x63, 0x18, 0xCC, 0x62, 0x00,
  0x71, 0xBC, 0xF3, 0xD8, 0xE0,
};

const GFXglyph RobotoCondensed_Medium19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 4, 5, 6, 1, -14 },
  { 10, 9, 14, 10, 1, -14 },
  { 26, 8, 18, 10, 1, -16 },
  { 44, 10, 14, 12, 1, -14 },
  { 62, 9, 14, 11, 1, -14 },
  { 78, 1, 5, 3, 1, -14 },
  { 79, 5, 19, 6, 1, -15 },
  { 91, 4, 19, 6, 1, -15 },
  { 101, 8, 8, 8, 0, -14 },
  { 109, 7, 10, 9, 1, -11 },
  { 118, 3, 5, 4, 0, -2 },
  { 120, 4, 2, 6, 1, -7 },
  { 121, 3, 3, 5, 1, -3 },
  { 123, 6, 15, 7, 0, -14 },
  { 135, 8, 14, 10, 1, -14 },
  { 149, 5, 14, 10, 1, -14 },
  { 158, 8, 14, 10, 1, -14 },
  { 172, 7, 14, 10, 1, -14 },
  { 185, 8, 14, 10, 1, -14 },
  { 199, 8, 14, 10, 1, -14 },
  { 213, 8, 14, 10, 1, -14 },
  { 227, 8, 14, 10, 1, -14 },
  { 241, 8, 14, 10, 1, -14 },
  { 255, 7, 14, 10, 1, -14 },
  { 268, 3, 11, 5, 1, -11 },
  { 273, 4, 14, 4, 0, -11 },
  { 280, 6, 8, 8, 1, -10 },
  { 286, 7, 6, 9, 1, -9 },
  { 292, 7, 8, 9, 1, -10 },
  { 299, 7, 14, 8, 1, -14 },
  { 312, 13, 17, 15, 1, -13 },
  { 340, 11, 14, 11, 0, -14 },
  { 360, 9, 14, 11, 1, -14 },
  { 376, 9, 14, 11, 1, -14 },
  { 392, 9, 14, 11, 1, -14 },
  { 408, 8, 14, 9, 1, -14 },
  { 422, 8, 14, 9, 1, -14 },
  { 436, 9, 14, 11, 1, -14 },
  { 452, 9, 14, 12, 1, -14 },
  { 468, 3, 14, 5, 1, -14 },
  { 474, 8, 14, 9, 0, -14 },
  { 488, 9, 14, 10, 1, -14 },
  { 504, 8, 14, 9, 1, -14 },
  { 518, 12, 14, 14, 1, -14 },
  { 539, 9, 14, 12, 1, -14 },
  { 555, 9, 14, 11, 1, -14 },
  { 571, 9, 14, 11, 1, -14 },
  { 587, 10, 16, 11, 1, -14 },
  { 607, 9, 14, 10, 1, -14 },
  { 623, 8, 14, 10, 1, -14 },
  { 637, 9, 14, 10, 1, -14 },
  { 653, 9, 14, 11, 1, -14 },
  { 669, 11, 14, 11, 0, -14 },
  { 689, 13, 14, 14, 1, -14 },
  { 712, 10, 14, 11, 0, -14 },
  { 730, 10, 14, 10, 0, -14 },
  { 748, 8, 14, 10, 1, -14 },
  { 762, 4, 19, 5, 1, -16 },
  { 772, 7, 15, 7, 0, -14 },
  { 786, 4, 19, 5, 0, -16 },
  { 796, 6, 7, 7, 1, -14 },
  { 802, 7, 2, 8, 0, 0 },
  { 804, 5, 3, 6, 0, -14 },
  { 806, 7, 10, 9, 1, -10 },
  { 815, 8, 14, 9, 1, -14 },
  { 829, 7, 10, 9, 1, -10 },
  { 838, 7, 14, 9, 1, -14 },
  { 851, 7, 10, 9, 1, -10 },
  { 860, 6, 14, 6, 0, -14 },
  { 871, 7, 14, 9, 1, -10 },
  { 884, 7, 14, 9, 1, -14 },
  { 897, 3, 13, 5, 1, -13 },
  { 902, 3, 17, 4, 0, -13 },
  { 909, 8, 14, 9, 1, -14 },
  { 923, 2, 14, 5, 1, -14 },
  { 927, 12, 10, 14, 1, -10 },
  { 942, 7, 10, 9, 1, -10 },
  { 951, 8, 10, 9, 1, -10 },
  { 961, 8, 14, 9, 1, -10 },
  { 975, 7, 14, 9, 1, -10 },
  { 988, 5, 10, 6, 1, -10 },
  { 995, 7, 10, 9, 1, -10 },
  { 1004, 5, 13, 6, 0, -13 },
  { 1013, 7, 10, 9, 1, -10 },
  { 1022, 8, 10, 8, 0, -10 },
  { 1032, 12, 10, 12, 0, -10 },
  { 1047, 8, 10, 8, 0, -10 },
  { 1057, 8, 14, 8, 0, -10 },
  { 1071, 7, 10, 8, 1, -10 },
  { 1080, 4, 18, 6, 1, -15 },
  { 1089, 1, 17, 5, 2, -14 },
  { 1092, 5, 18, 6, 0, -15 },
  { 1104, 9, 4, 11, 1, -8 },
};

const GFXfont RobotoCondensed_Medium19pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium19pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium19pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOCONDENSED_MEDIUM19PT7B_H_
