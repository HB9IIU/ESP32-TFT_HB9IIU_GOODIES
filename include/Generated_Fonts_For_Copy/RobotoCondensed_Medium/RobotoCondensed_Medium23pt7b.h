#ifndef _ROBOTOCONDENSED_MEDIUM23PT7B_H_
#define _ROBOTOCONDENSED_MEDIUM23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Medium.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Medium23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0xDE, 0xF7, 0xBD, 0xEC, 0x0C, 0x81,
  0xB0, 0x26, 0x04, 0xC1, 0x98, 0xFF, 0xDF, 0xF8, 0xC8, 0x1B, 0x02, 0x63,
  0xFF, 0x7F, 0xE3, 0x30, 0x64, 0x0C, 0x81, 0xB0, 0x26, 0x00, 0x0C, 0x06,
  0x07, 0x87, 0xE7, 0x3B, 0x1D, 0x86, 0xC0, 0x70, 0x1E, 0x07, 0xC1, 0xF0,
  0x38, 0x0F, 0x87, 0xC3, 0x73, 0xBF, 0x8F, 0x81, 0x80, 0xC0, 0x78, 0x03,
  0xE0, 0x33, 0x11, 0x99, 0x8C, 0xC8, 0x66, 0xC1, 0xF4, 0x0F, 0x60, 0x02,
  0x00, 0x37, 0x03, 0x7C, 0x1B, 0x21, 0x91, 0x8C, 0x8C, 0xC6, 0x40, 0x3E,
  0x00, 0xE0, 0x1E, 0x03, 0xF0, 0x73, 0x07, 0x30, 0x73, 0x07, 0x30, 0x3E,
  0x03, 0xC0, 0x3C, 0x07, 0xE6, 0xEE, 0xEE, 0x7E, 0xE3, 0xCE, 0x3C, 0xF3,
  0xC7, 0xFE, 0x3E, 0xE0, 0xFF, 0xF0, 0x08, 0x31, 0x8C, 0x31, 0xC6, 0x18,
  0x63, 0x8E, 0x38, 0xE3, 0x86, 0x18, 0x61, 0xC3, 0x0C, 0x18, 0x30, 0x80,
  0x86, 0x38, 0xC7, 0x18, 0xC7, 0x38, 0xC6, 0x31, 0x8C, 0xE7, 0x31, 0x9C,
  0xCE, 0x62, 0x00, 0x0C, 0x03, 0x00, 0xC1, 0xB7, 0xFF, 0xC7, 0x81, 0xE0,
  0xEC, 0x33, 0x88, 0x40, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC7, 0xFF, 0xFE,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x33, 0x77, 0x64, 0xFF, 0xC0, 0xDF,
  0x00, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0xC1, 0x83,
  0x0E, 0x18, 0x30, 0x61, 0x80, 0x1E, 0x1F, 0x9C, 0xEC, 0x7E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1B, 0x1D, 0xCE, 0x7E, 0x1E,
  0x00, 0x0C, 0xFF, 0xFF, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x3E, 0x1F, 0xCF, 0x3B, 0x8E, 0xE3, 0x80, 0xE0, 0x38, 0x0C,
  0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x07, 0x03, 0xFF, 0xFF, 0xC0,
  0x3E, 0x3F, 0xB8, 0xFC, 0x70, 0x38, 0x1C, 0x0C, 0x3E, 0x1F, 0x01, 0xC0,
  0xE0, 0x3E, 0x1F, 0x1F, 0xCE, 0xFE, 0x3E, 0x00, 0x07, 0x01, 0xC0, 0xF0,
  0x3C, 0x1B, 0x06, 0xC3, 0x30, 0xCC, 0x63, 0x18, 0xCE, 0x33, 0xFF, 0xFF,
  0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x7F, 0x9F, 0xE7, 0x01, 0xC0, 0x70,
  0x18, 0x06, 0xE1, 0xFC, 0x63, 0x80, 0x60, 0x18, 0x07, 0xE1, 0x98, 0x67,
  0x38, 0xFC, 0x1E, 0x00, 0x0E, 0x07, 0x83, 0xC1, 0xC0, 0x70, 0x18, 0x06,
  0xE3, 0xFE, 0xF3, 0xB8, 0x6E, 0x1B, 0x87, 0xE1, 0x98, 0x67, 0x38, 0xFC,
  0x1E, 0x00, 0xFF, 0xFF, 0xF0, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18,
  0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x00,
  0x1E, 0x3F, 0x9C, 0xEC, 0x76, 0x3B, 0x1D, 0xCC, 0x7E, 0x3F, 0x39, 0xF8,
  0xFC, 0x3E, 0x1F, 0x1D, 0xCE, 0xFE, 0x1E, 0x00, 0x1E, 0x3F, 0x9D, 0xDC,
  0x7E, 0x3F, 0x0F, 0x87, 0xC7, 0x73, 0xBF, 0xCF, 0x60, 0x70, 0x38, 0x38,
  0x3C, 0x7C, 0x38, 0x00, 0x6F, 0x60, 0x00, 0x00, 0x00, 0x6F, 0x60, 0x7D,
  0x80, 0x00, 0x01, 0xB7, 0xF6, 0x01, 0x07, 0x1F, 0x7C, 0xE0, 0xE0, 0x7C,
  0x1F, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x78,
  0x3F, 0x03, 0xE0, 0x78, 0x3C, 0x7D, 0xF8, 0xF0, 0x40, 0x00, 0x3C, 0xFE,
  0xE7, 0xC7, 0x07, 0x07, 0x07, 0x0E, 0x1C, 0x18, 0x18, 0x38, 0x00, 0x00,
  0x18, 0x38, 0x18, 0x03, 0xE0, 0x0F, 0xF8, 0x18, 0x1C, 0x30, 0x0C, 0x30,
  0x06, 0x61, 0xC6, 0x63, 0xE2, 0x46, 0x63, 0xC6, 0x63, 0xCC, 0x63, 0xCC,
  0x63, 0xCC, 0x62, 0xCC, 0x62, 0xCE, 0xE6, 0xC7, 0xFC, 0x67, 0x38, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1F, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x38,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x06, 0xE0, 0x37, 0x03, 0x98, 0x1C, 0xE0,
  0xC7, 0x0E, 0x18, 0x7F, 0xC3, 0xFF, 0x38, 0x39, 0xC0, 0xCE, 0x07, 0x60,
  0x38, 0xFE, 0x3F, 0xCC, 0x3B, 0x0E, 0xC1, 0xB0, 0xEC, 0x3B, 0xFC, 0xFF,
  0x30, 0xEC, 0x1B, 0x07, 0xC1, 0xF0, 0x6C, 0x3B, 0xFC, 0xFE, 0x00, 0x1F,
  0x07, 0xF9, 0xE7, 0x38, 0x7E, 0x0F, 0xC1, 0xF8, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x7E, 0x0E, 0xE1, 0xDE, 0x71, 0xFE, 0x1F, 0x00, 0xFC,
  0x3F, 0xCC, 0x7B, 0x0E, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0xEC, 0x7B, 0xFC, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0xFE, 0xFF, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1F, 0x87,
  0xF9, 0xE7, 0xB8, 0x7E, 0x07, 0xC0, 0x38, 0x07, 0x00, 0xE3, 0xFC, 0x7F,
  0x81, 0xF0, 0x3E, 0x06, 0xE0, 0xDE, 0x79, 0xFE, 0x0F, 0x80, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x7C, 0x3F, 0x1F, 0x9C, 0xFE, 0x3C, 0x00, 0xC1,
  0xD8, 0x73, 0x0E, 0x63, 0x8C, 0xE1, 0x9C, 0x37, 0x07, 0xC0, 0xFC, 0x1F,
  0xC3, 0xB8, 0x63, 0x8C, 0x71, 0x87, 0x30, 0xE6, 0x0E, 0xC1, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x1F, 0xF0,
  0x7F, 0xE1, 0xFF, 0x87, 0xF6, 0x3F, 0xD8, 0xDF, 0x73, 0x7C, 0xDD, 0xF3,
  0x67, 0xCF, 0x9F, 0x1E, 0x7C, 0x71, 0xF1, 0xC7, 0xC3, 0x1C, 0xC0, 0xFC,
  0x1F, 0x83, 0xF8, 0x7F, 0x0F, 0xF1, 0xF6, 0x3E, 0xE7, 0xCC, 0xF9, 0xDF,
  0x1B, 0xE3, 0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xC0, 0xE0, 0x1F, 0x03,
  0xFC, 0x79, 0xE7, 0x0E, 0xE0, 0x6E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x67, 0x0E, 0x79, 0xE3, 0xFC, 0x1F, 0x00,
  0xFE, 0x3F, 0xEC, 0x3B, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xBF,
  0xEF, 0xE3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x1F, 0x03,
  0xFC, 0x79, 0xE7, 0x0E, 0xE0, 0x6E, 0x06, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x06, 0xE0, 0x67, 0x0E, 0x79, 0xE3, 0xFC, 0x1F, 0xC0,
  0x1E, 0x00, 0xE0, 0x04, 0xFE, 0x3F, 0xCC, 0x3B, 0x06, 0xC1, 0xF0, 0x6C,
  0x3B, 0x0E, 0xFF, 0x3F, 0x8C, 0x73, 0x1C, 0xC7, 0x30, 0xEC, 0x3B, 0x07,
  0xC1, 0xC0, 0x1F, 0x1F, 0xE7, 0x3F, 0x87, 0xE1, 0xF8, 0x07, 0x01, 0xF8,
  0x1F, 0x01, 0xE0, 0x1C, 0x07, 0xE0, 0xF8, 0x7F, 0x1D, 0xFE, 0x1F, 0x00,
  0xFF, 0xFF, 0xFC, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0xC1, 0xDC, 0x71, 0xFE, 0x1F, 0x00,
  0xE0, 0x3B, 0x83, 0x9C, 0x1C, 0xE0, 0xE3, 0x06, 0x1C, 0x70, 0xE3, 0x83,
  0x1C, 0x18, 0xC0, 0xEE, 0x07, 0x70, 0x1B, 0x00, 0xD8, 0x07, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0xC1, 0x87, 0xE3, 0x87, 0xE3, 0x86, 0xE3, 0xC6,
  0xE3, 0xCE, 0x63, 0xCE, 0x67, 0xCE, 0x76, 0xCC, 0x76, 0xEC, 0x76, 0x6C,
  0x36, 0x7C, 0x3C, 0x7C, 0x3C, 0x7C, 0x3C, 0x78, 0x3C, 0x38, 0x3C, 0x38,
  0x18, 0x38, 0xE0, 0xFC, 0x39, 0xC7, 0x38, 0xC3, 0xB8, 0x76, 0x07, 0xC0,
  0xF8, 0x0E, 0x03, 0xE0, 0x7C, 0x1D, 0xC3, 0xB8, 0xE3, 0x9C, 0x77, 0x0F,
  0xE0, 0xE0, 0xE0, 0x77, 0x0E, 0x70, 0xE3, 0x8E, 0x39, 0xC1, 0x9C, 0x1D,
  0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xFF, 0xFF, 0xF0, 0x1C, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEF, 0xF0, 0x60, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x1C,
  0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xFF,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xF0, 0x38,
  0x70, 0xE3, 0x66, 0xCD, 0xB1, 0xE3, 0xFF, 0xFF, 0xC0, 0xE3, 0x8E, 0x3E,
  0x3F, 0xB8, 0xDC, 0x70, 0x39, 0xFD, 0xFF, 0xC7, 0xE3, 0xF3, 0xFF, 0xE7,
  0x70, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xBD, 0xFF, 0xF3, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE7, 0xFF, 0xF7, 0x80, 0x3E, 0x3F,
  0xB8, 0xDC, 0x7E, 0x3F, 0x03, 0x81, 0xC0, 0xE3, 0xF1, 0xDF, 0xC7, 0xC0,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0xFE, 0xFF, 0xF3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xE7, 0x7F, 0x9E, 0xC0, 0x3E, 0x3F, 0x9C,
  0xFC, 0x7E, 0x1F, 0xFF, 0xFF, 0xC0, 0xE0, 0x38, 0xDF, 0xE7, 0xC0, 0x1C,
  0xF7, 0x1C, 0x71, 0xCF, 0xFF, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC0, 0x3D, 0xBF, 0xFC, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF9,
  0xDF, 0xE7, 0xB0, 0x18, 0x1D, 0x8E, 0xFE, 0x3E, 0x00, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0xB9, 0xFE, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xC0, 0x7D, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x37, 0x30, 0x07, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0xFE,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x3B, 0x9C, 0xEE, 0x3B,
  0x8F, 0xC3, 0xF0, 0xFC, 0x3B, 0x8E, 0x73, 0x9C, 0xE3, 0xB8, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xEE, 0x39, 0xFE, 0xFB, 0xCF, 0x3F,
  0x1C, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7,
  0x1F, 0x8E, 0x3F, 0x1C, 0x70, 0xEF, 0x7F, 0xBC, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x70, 0x3E, 0x1F, 0xC7, 0x3B, 0x86,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0x9C, 0xE7, 0xF0, 0xF8, 0xEF, 0x7F,
  0xFC, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF9, 0xFF, 0xFD, 0xCE,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x3D, 0xBF, 0xFC, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xDF, 0xE7, 0xF0, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x80, 0xEF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x3E,
  0x3F, 0xB9, 0xDC, 0x6F, 0x03, 0xE0, 0x7C, 0x0E, 0xC3, 0x71, 0x9F, 0xC7,
  0xC0, 0x38, 0xE3, 0xBF, 0xFC, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xF1,
  0xC0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3,
  0xDF, 0xE7, 0xF0, 0x61, 0xD8, 0x67, 0x39, 0xCE, 0x33, 0x0C, 0xC3, 0xF0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x30, 0x63, 0x0D, 0x8E, 0x77, 0x39, 0xDD,
  0xE6, 0x77, 0x98, 0xDB, 0x63, 0x6F, 0x8F, 0xBE, 0x3C, 0xF0, 0x71, 0xC1,
  0xC7, 0x06, 0x1C, 0x71, 0x9C, 0xE3, 0xB0, 0xFC, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x3F, 0x0E, 0xC7, 0x39, 0xC7, 0xE1, 0x98, 0x67, 0x39, 0xCE, 0x33,
  0x0C, 0xC3, 0xF0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x30, 0x0C, 0x07, 0x01,
  0x81, 0xE0, 0x70, 0x00, 0xFF, 0xFF, 0x07, 0x0E, 0x0C, 0x1C, 0x38, 0x38,
  0x70, 0xE0, 0xFF, 0xFF, 0x08, 0xCC, 0x67, 0x39, 0xCE, 0x73, 0x39, 0xC6,
  0x39, 0xCE, 0x73, 0x8C, 0x61, 0x84, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x86,
  0x18, 0xC6, 0x31, 0x8C, 0x73, 0x8E, 0x77, 0x39, 0x8C, 0x63, 0x18, 0xCC,
  0x40, 0x38, 0x6F, 0x8D, 0xBB, 0xE3, 0xEC, 0x38,
};

const GFXglyph RobotoCondensed_Medium23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 17, 6, 2, -17 },
  { 6, 5, 6, 7, 1, -17 },
  { 10, 11, 17, 12, 1, -17 },
  { 34, 9, 21, 12, 1, -19 },
  { 58, 13, 17, 15, 1, -17 },
  { 86, 12, 17, 13, 1, -17 },
  { 112, 2, 6, 4, 1, -17 },
  { 114, 6, 23, 7, 1, -18 },
  { 132, 5, 23, 7, 1, -18 },
  { 147, 10, 10, 10, 0, -17 },
  { 160, 9, 12, 11, 1, -14 },
  { 174, 4, 6, 5, 0, -3 },
  { 177, 5, 2, 7, 1, -8 },
  { 179, 3, 3, 6, 2, -3 },
  { 181, 7, 18, 8, 0, -17 },
  { 197, 9, 17, 12, 1, -17 },
  { 217, 6, 17, 12, 2, -17 },
  { 230, 10, 17, 12, 1, -17 },
  { 252, 9, 17, 12, 1, -17 },
  { 272, 10, 17, 12, 1, -17 },
  { 294, 10, 17, 12, 1, -17 },
  { 316, 10, 17, 12, 1, -17 },
  { 338, 10, 17, 12, 1, -17 },
  { 360, 9, 17, 12, 1, -17 },
  { 380, 9, 17, 12, 1, -17 },
  { 400, 4, 13, 6, 1, -13 },
  { 407, 3, 16, 5, 1, -13 },
  { 413, 8, 10, 10, 1, -12 },
  { 423, 8, 7, 11, 2, -11 },
  { 430, 9, 10, 11, 1, -12 },
  { 442, 8, 17, 10, 1, -17 },
  { 459, 16, 21, 18, 1, -16 },
  { 501, 13, 17, 14, 0, -17 },
  { 529, 10, 17, 13, 2, -17 },
  { 551, 11, 17, 13, 1, -17 },
  { 575, 10, 17, 13, 2, -17 },
  { 597, 9, 17, 11, 2, -17 },
  { 617, 8, 17, 11, 2, -17 },
  { 634, 11, 17, 14, 1, -17 },
  { 658, 11, 17, 14, 2, -17 },
  { 682, 2, 17, 6, 2, -17 },
  { 687, 9, 17, 11, 1, -17 },
  { 707, 11, 17, 13, 2, -17 },
  { 731, 8, 17, 11, 2, -17 },
  { 748, 14, 17, 17, 2, -17 },
  { 778, 11, 17, 14, 2, -17 },
  { 802, 12, 17, 14, 1, -17 },
  { 828, 10, 17, 13, 2, -17 },
  { 850, 12, 20, 14, 1, -17 },
  { 880, 10, 17, 12, 2, -17 },
  { 902, 10, 17, 12, 1, -17 },
  { 924, 11, 17, 12, 1, -17 },
  { 948, 11, 17, 13, 1, -17 },
  { 972, 13, 17, 13, 0, -17 },
  { 1000, 16, 17, 17, 1, -17 },
  { 1034, 11, 17, 13, 1, -17 },
  { 1058, 12, 17, 12, 0, -17 },
  { 1084, 10, 17, 12, 1, -17 },
  { 1106, 4, 23, 6, 1, -19 },
  { 1118, 9, 18, 9, 0, -17 },
  { 1139, 4, 23, 6, 0, -19 },
  { 1151, 7, 8, 9, 1, -17 },
  { 1158, 9, 2, 9, 0, 0 },
  { 1161, 5, 3, 7, 1, -17 },
  { 1163, 9, 12, 11, 1, -12 },
  { 1177, 9, 18, 11, 1, -18 },
  { 1198, 9, 12, 11, 1, -12 },
  { 1212, 9, 18, 11, 1, -18 },
  { 1233, 9, 12, 11, 1, -12 },
  { 1247, 6, 18, 7, 1, -18 },
  { 1261, 9, 17, 11, 1, -12 },
  { 1281, 9, 18, 11, 1, -18 },
  { 1302, 3, 17, 6, 1, -17 },
  { 1309, 4, 22, 5, 0, -17 },
  { 1320, 10, 18, 11, 1, -18 },
  { 1343, 3, 18, 6, 1, -18 },
  { 1350, 15, 12, 17, 1, -12 },
  { 1373, 9, 12, 11, 1, -12 },
  { 1387, 10, 12, 11, 1, -12 },
  { 1402, 9, 17, 11, 1, -12 },
  { 1422, 9, 17, 11, 1, -12 },
  { 1442, 6, 12, 7, 1, -12 },
  { 1451, 9, 12, 10, 1, -12 },
  { 1465, 6, 15, 7, 0, -15 },
  { 1477, 9, 12, 11, 1, -12 },
  { 1491, 10, 12, 10, 0, -12 },
  { 1506, 14, 12, 15, 0, -12 },
  { 1527, 10, 12, 10, 0, -12 },
  { 1542, 10, 17, 10, 0, -12 },
  { 1564, 8, 12, 10, 1, -12 },
  { 1576, 5, 22, 7, 1, -18 },
  { 1590, 2, 20, 6, 2, -17 },
  { 1595, 5, 22, 7, 1, -18 },
  { 1609, 11, 5, 13, 1, -9 },
};

const GFXfont RobotoCondensed_Medium23pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Medium23pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Medium23pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _ROBOTOCONDENSED_MEDIUM23PT7B_H_
