#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC33PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0xC1,
  0x02, 0x04, 0x08, 0x20, 0x40, 0x00, 0x00, 0x08, 0x10, 0x60, 0x22, 0x45,
  0x9A, 0x24, 0x48, 0x91, 0x44, 0x88, 0x01, 0x08, 0x08, 0xC0, 0x44, 0x06,
  0x20, 0x21, 0x01, 0x10, 0x18, 0x87, 0xFF, 0x04, 0x40, 0x22, 0x02, 0x10,
  0x11, 0x80, 0x88, 0x08, 0x40, 0x46, 0x1F, 0xFC, 0x21, 0x01, 0x08, 0x08,
  0x80, 0xC4, 0x04, 0x20, 0x22, 0x01, 0x10, 0x10, 0x80, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x7F, 0x09, 0x11, 0x10, 0x11, 0x01, 0x10, 0x11, 0x01, 0x20,
  0x1A, 0x00, 0xA0, 0x06, 0x00, 0x20, 0x05, 0x00, 0x58, 0x04, 0x80, 0x4C,
  0x08, 0xC0, 0x8C, 0x08, 0x80, 0x98, 0xEF, 0x03, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x00, 0x1C, 0x08, 0xD8, 0x22, 0x21, 0x10, 0x84, 0x42, 0x23, 0x08,
  0x88, 0x64, 0x21, 0x10, 0x84, 0x82, 0x12, 0x08, 0xD3, 0xE2, 0x49, 0x8A,
  0x46, 0x49, 0x16, 0x48, 0x41, 0x21, 0x08, 0x84, 0x26, 0x11, 0x10, 0x44,
  0x42, 0x21, 0x08, 0x84, 0x64, 0x11, 0x10, 0x38, 0x03, 0x80, 0xD8, 0x31,
  0x04, 0x20, 0x84, 0x11, 0x82, 0x20, 0x44, 0x09, 0x01, 0x60, 0x38, 0x06,
  0x01, 0xC0, 0x68, 0x19, 0x9A, 0x12, 0xC2, 0x50, 0x5A, 0x06, 0x40, 0xC8,
  0x11, 0x07, 0x31, 0x23, 0xE4, 0x25, 0xA4, 0x94, 0x80, 0x00, 0x80, 0x80,
  0x80, 0xC0, 0x40, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x04, 0x02,
  0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x08, 0x06, 0x00, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10,
  0x08, 0x06, 0x03, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02,
  0x01, 0x01, 0x80, 0x80, 0x40, 0x60, 0x20, 0x30, 0x10, 0x10, 0x08, 0x08,
  0x08, 0x08, 0x00, 0x08, 0x08, 0x88, 0x69, 0x1F, 0x18, 0x68, 0xC4, 0x06,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x07, 0xFF, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x33, 0x26, 0x44,
  0x80, 0xFF, 0xFC, 0x5C, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x98, 0x21, 0x0C, 0x21, 0x06, 0x60, 0xC8, 0x19, 0x02, 0x60, 0x48, 0x09,
  0x01, 0x20, 0x2C, 0x0D, 0x01, 0xA0, 0x24, 0x04, 0x81, 0x90, 0x22, 0x04,
  0x41, 0x88, 0x21, 0x0C, 0x33, 0x03, 0xC0, 0x0C, 0x73, 0x9A, 0x88, 0x61,
  0x84, 0x10, 0x43, 0x08, 0x20, 0x82, 0x18, 0x41, 0x04, 0x10, 0xC2, 0x08,
  0x20, 0x03, 0xC0, 0x31, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0,
  0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30,
  0x03, 0x00, 0x1F, 0xF0, 0x03, 0xC0, 0x71, 0x81, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x0E, 0x00,
  0x38, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x42, 0x0C, 0x1F, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x0C,
  0x00, 0xA0, 0x0D, 0x00, 0x58, 0x04, 0x80, 0x24, 0x02, 0x20, 0x31, 0x01,
  0x18, 0x10, 0x80, 0x84, 0x08, 0x20, 0xC1, 0x04, 0x18, 0x40, 0x83, 0xFF,
  0x3F, 0xF8, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0xF8,
  0x3F, 0xC1, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x07, 0xE0, 0x21, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x42, 0x0C, 0x1F,
  0xC0, 0x01, 0xE0, 0xE4, 0x30, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x60, 0x08, 0x01, 0x7C, 0x30, 0xCC, 0x09, 0x81, 0x20, 0x24, 0x04, 0x80,
  0x90, 0x12, 0x02, 0x40, 0xC8, 0x11, 0x06, 0x31, 0x83, 0xE0, 0x3F, 0xF3,
  0xFF, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x03, 0xC0,
  0x66, 0x08, 0x31, 0x81, 0x10, 0x11, 0x01, 0x10, 0x31, 0x02, 0x18, 0x60,
  0x8C, 0x0D, 0x80, 0x60, 0x0F, 0x03, 0x10, 0x60, 0x84, 0x08, 0x80, 0xC8,
  0x04, 0x80, 0x48, 0x0C, 0x80, 0x88, 0x08, 0x41, 0x03, 0xE0, 0x03, 0x80,
  0xC8, 0x20, 0x8C, 0x11, 0x02, 0x60, 0x48, 0x09, 0x01, 0x20, 0x24, 0x04,
  0x81, 0x90, 0x32, 0x0E, 0x26, 0x83, 0x90, 0x02, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0x80, 0x30, 0x04, 0x01, 0x07, 0xC0, 0x08, 0xC6, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0xC6, 0x00, 0x02, 0x04, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x10, 0x20, 0x81,
  0x04, 0x18, 0x00, 0x00, 0x20, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x40, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x03, 0x00, 0xC0, 0x60,
  0x30, 0x1C, 0x06, 0x01, 0x00, 0x00, 0x0F, 0x06, 0x60, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x06, 0x01, 0x00, 0x80, 0x60, 0x30, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x00, 0x00, 0x00, 0x00, 0x10, 0x0C, 0x03, 0x00,
  0x00, 0x70, 0x01, 0x8C, 0x02, 0x06, 0x04, 0x02, 0x08, 0x02, 0x10, 0x01,
  0x10, 0x01, 0x20, 0xF1, 0x21, 0x11, 0x62, 0x21, 0x42, 0x23, 0x44, 0x22,
  0x44, 0x22, 0x8C, 0x42, 0x88, 0x42, 0x88, 0x44, 0x88, 0xC4, 0x88, 0xCC,
  0x89, 0x48, 0x87, 0x70, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x21, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x50,
  0x0A, 0x03, 0x40, 0x48, 0x09, 0x02, 0x20, 0x44, 0x18, 0x82, 0x10, 0x42,
  0x10, 0x43, 0xF8, 0xC1, 0x10, 0x26, 0x04, 0x80, 0x90, 0x16, 0x02, 0x80,
  0x70, 0x0C, 0x01, 0x07, 0x80, 0x3F, 0x81, 0x04, 0x18, 0x30, 0x80, 0x84,
  0x04, 0x20, 0x61, 0x02, 0x18, 0x10, 0x81, 0x04, 0x18, 0x3F, 0x03, 0x0C,
  0x18, 0x20, 0x81, 0x84, 0x04, 0x20, 0x23, 0x01, 0x18, 0x18, 0x80, 0x84,
  0x04, 0x20, 0x43, 0x0C, 0x1F, 0xC0, 0x00, 0xF0, 0x18, 0x41, 0x80, 0x18,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x30,
  0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x07, 0xE0, 0x07, 0x00, 0x3F,
  0x01, 0x04, 0x18, 0x30, 0x80, 0x84, 0x04, 0x20, 0x21, 0x01, 0x18, 0x08,
  0x80, 0x44, 0x02, 0x20, 0x13, 0x01, 0x98, 0x0C, 0x80, 0x44, 0x02, 0x20,
  0x33, 0x01, 0x10, 0x18, 0x80, 0x84, 0x0C, 0x20, 0xC3, 0x1C, 0x1F, 0x80,
  0x07, 0xF8, 0x3F, 0xC1, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x3F, 0x83, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC1, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0xFC,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x00, 0xF8, 0x07, 0x1C, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x0F, 0x98, 0x03, 0x30, 0x04, 0x40, 0x08,
  0x80, 0x11, 0x00, 0x63, 0x00, 0x86, 0x01, 0x04, 0x02, 0x0C, 0x04, 0x0C,
  0x18, 0x0F, 0xE0, 0x04, 0x02, 0x08, 0x04, 0x10, 0x08, 0x60, 0x30, 0x80,
  0x41, 0x00, 0x82, 0x01, 0x04, 0x02, 0x18, 0x0C, 0x20, 0x10, 0x40, 0x20,
  0xFF, 0xC3, 0x01, 0x86, 0x03, 0x08, 0x04, 0x10, 0x08, 0x20, 0x10, 0xC0,
  0x61, 0x00, 0x82, 0x01, 0x04, 0x02, 0x08, 0x04, 0x30, 0x18, 0x40, 0x20,
  0x07, 0xC0, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x03, 0xF0, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x09, 0x80, 0xC0, 0x00,
  0x04, 0x04, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x20, 0x21, 0x80, 0x8C,
  0x02, 0x20, 0x19, 0x00, 0x4C, 0x01, 0x60, 0x05, 0x80, 0x3A, 0x00, 0xC8,
  0x02, 0x20, 0x08, 0xC0, 0x21, 0x01, 0x84, 0x04, 0x10, 0x10, 0x60, 0x41,
  0x81, 0x02, 0x0C, 0x08, 0x20, 0x30, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08,
  0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60,
  0x40, 0x40, 0x40, 0x40, 0xC0, 0xFF, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06,
  0x00, 0x70, 0xE0, 0x07, 0x0A, 0x00, 0xE0, 0xA0, 0x0A, 0x0A, 0x01, 0xA0,
  0xA0, 0x12, 0x1A, 0x01, 0x61, 0x20, 0x24, 0x12, 0x02, 0x41, 0x20, 0x44,
  0x32, 0x04, 0xC2, 0x20, 0x8C, 0x23, 0x08, 0x82, 0x31, 0x08, 0x23, 0x10,
  0x86, 0x13, 0x18, 0x41, 0x21, 0x04, 0x16, 0x10, 0x41, 0x41, 0x04, 0x1C,
  0x10, 0xC1, 0x83, 0x08, 0x18, 0x20, 0x06, 0x01, 0x06, 0x01, 0x06, 0x03,
  0x0E, 0x02, 0x0A, 0x02, 0x0A, 0x02, 0x0B, 0x02, 0x09, 0x06, 0x19, 0x04,
  0x11, 0x04, 0x11, 0x04, 0x11, 0x84, 0x30, 0x8C, 0x30, 0x88, 0x20, 0x88,
  0x20, 0x88, 0x20, 0x98, 0x60, 0xD0, 0x40, 0x50, 0x40, 0x50, 0x40, 0x50,
  0x40, 0x70, 0xC0, 0x60, 0x80, 0x20, 0x01, 0xE0, 0x19, 0x81, 0x06, 0x10,
  0x11, 0x80, 0x88, 0x04, 0xC0, 0x24, 0x01, 0x20, 0x0B, 0x00, 0x50, 0x02,
  0x80, 0x14, 0x01, 0xE0, 0x0F, 0x00, 0x58, 0x02, 0x80, 0x34, 0x01, 0x20,
  0x09, 0x00, 0xCC, 0x04, 0x20, 0x41, 0x84, 0x07, 0xC0, 0x07, 0x80, 0x7E,
  0x04, 0x30, 0xC1, 0x08, 0x10, 0x81, 0x08, 0x10, 0x81, 0x18, 0x11, 0x03,
  0x10, 0x21, 0x06, 0x31, 0xC3, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x01, 0xE0, 0x19,
  0x81, 0x06, 0x10, 0x11, 0x80, 0x88, 0x04, 0xC0, 0x24, 0x01, 0x20, 0x0B,
  0x00, 0x50, 0x02, 0x80, 0x14, 0x01, 0xE0, 0x0F, 0x00, 0x58, 0x02, 0x80,
  0x34, 0x01, 0x20, 0x09, 0x00, 0x8C, 0x04, 0x20, 0x41, 0x86, 0x07, 0xC0,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x07, 0x00,
  0x7E, 0x04, 0x30, 0xC1, 0x08, 0x10, 0x81, 0x08, 0x10, 0x81, 0x18, 0x11,
  0x03, 0x10, 0x21, 0x04, 0x3F, 0x83, 0xE0, 0x23, 0x02, 0x30, 0x21, 0x06,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x84, 0x08, 0xC0, 0x88, 0x08, 0x01, 0xF0,
  0x38, 0xC1, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x62, 0x06, 0x1F,
  0xE0, 0x7F, 0xEF, 0xF8, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40,
  0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x08, 0x04,
  0x20, 0x11, 0x80, 0xC6, 0x02, 0x10, 0x08, 0x40, 0x21, 0x01, 0x8C, 0x04,
  0x20, 0x10, 0x80, 0x42, 0x01, 0x08, 0x0C, 0x60, 0x21, 0x00, 0x84, 0x02,
  0x10, 0x18, 0xC0, 0x43, 0x01, 0x08, 0x04, 0x20, 0x30, 0x80, 0x83, 0x06,
  0x04, 0x10, 0x0F, 0x80, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x28, 0x0D, 0x01,
  0x20, 0x64, 0x08, 0x81, 0x10, 0x62, 0x08, 0x43, 0x08, 0x41, 0x08, 0x22,
  0x04, 0x40, 0x98, 0x12, 0x02, 0xC0, 0x50, 0x0A, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x40, 0x20, 0x1A, 0x01, 0x00, 0x90, 0x18, 0x0C, 0x80, 0xC0, 0x44,
  0x0E, 0x02, 0x20, 0x50, 0x31, 0x02, 0x81, 0x08, 0x34, 0x18, 0x41, 0x20,
  0x82, 0x09, 0x04, 0x10, 0x88, 0x40, 0x84, 0x42, 0x04, 0x62, 0x30, 0x22,
  0x11, 0x01, 0x10, 0x88, 0x09, 0x04, 0x80, 0x48, 0x24, 0x02, 0xC1, 0x60,
  0x34, 0x0A, 0x01, 0xA0, 0x50, 0x0E, 0x03, 0x00, 0x70, 0x38, 0x03, 0x81,
  0xC0, 0x18, 0x0C, 0x00, 0x02, 0x06, 0x04, 0x08, 0x08, 0x30, 0x10, 0x40,
  0x21, 0x80, 0x62, 0x00, 0x48, 0x00, 0x90, 0x01, 0x40, 0x02, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x50, 0x01, 0xA0, 0x02, 0x40, 0x0C, 0x80,
  0x11, 0x00, 0x42, 0x00, 0x84, 0x02, 0x08, 0x0C, 0x18, 0x10, 0x30, 0x60,
  0x20, 0x40, 0x68, 0x09, 0x03, 0x20, 0x44, 0x18, 0x82, 0x10, 0xC3, 0x10,
  0x66, 0x04, 0x80, 0xB0, 0x14, 0x03, 0x80, 0x60, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x04, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x1F,
  0xF0, 0x03, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xFC, 0x00, 0xC2, 0x10, 0x84,
  0x21, 0x0C, 0x21, 0x08, 0x42, 0x10, 0xC2, 0x10, 0x84, 0x21, 0x0C, 0x21,
  0x03, 0xF0, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFC, 0x00, 0x02, 0x00, 0x60, 0x07,
  0x00, 0x90, 0x09, 0x81, 0x08, 0x10, 0x82, 0x04, 0x20, 0x44, 0x06, 0x40,
  0x28, 0x03, 0xFF, 0x80, 0x99, 0x12, 0x07, 0x10, 0xDA, 0x18, 0x63, 0x06,
  0x20, 0x66, 0x06, 0x40, 0x44, 0x04, 0xC0, 0x4C, 0x0C, 0x80, 0x88, 0x08,
  0x80, 0x88, 0x18, 0x81, 0x88, 0x30, 0xC5, 0x07, 0xD0, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x8C, 0x0B, 0x61, 0xC2,
  0x18, 0x31, 0x83, 0x10, 0x31, 0x03, 0x30, 0x32, 0x02, 0x20, 0x22, 0x02,
  0x20, 0x66, 0x04, 0x60, 0x46, 0x0C, 0x60, 0x8A, 0x10, 0x9E, 0x00, 0x03,
  0x86, 0x44, 0x06, 0x02, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x3E, 0x00, 0x00, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0xE6, 0x0D, 0xA0, 0xC3,
  0x0C, 0x18, 0x40, 0xC6, 0x04, 0x20, 0x21, 0x01, 0x18, 0x08, 0xC0, 0xC4,
  0x04, 0x20, 0x21, 0x01, 0x08, 0x18, 0x40, 0xC2, 0x0C, 0x18, 0xA0, 0x79,
  0x00, 0x07, 0x03, 0x61, 0x08, 0xC3, 0x20, 0x98, 0x24, 0x19, 0x0C, 0xCE,
  0x3C, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC2, 0x1F, 0x80,
  0x00, 0x3C, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x24, 0x03, 0xE0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x01, 0xC4,
  0x0D, 0xA0, 0x61, 0x83, 0x06, 0x08, 0x18, 0x60, 0x41, 0x01, 0x04, 0x04,
  0x10, 0x10, 0xC0, 0xC2, 0x02, 0x08, 0x08, 0x20, 0x20, 0x81, 0x82, 0x06,
  0x08, 0x30, 0x31, 0x40, 0x79, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x40, 0xC6, 0x01, 0xF0, 0x00, 0x06, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x4E, 0x0A, 0xE3, 0x84, 0x60, 0x8C,
  0x11, 0x02, 0x20, 0xCC, 0x11, 0x02, 0x20, 0x44, 0x08, 0x83, 0x30, 0x44,
  0x08, 0x81, 0x10, 0x22, 0x0C, 0xC1, 0x00, 0x04, 0x10, 0x40, 0x00, 0x00,
  0x02, 0x18, 0x41, 0x04, 0x10, 0xC2, 0x08, 0x20, 0x86, 0x10, 0x41, 0x0C,
  0x20, 0x00, 0x40, 0x0C, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x0C, 0x07, 0x00, 0x06, 0x00, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x63, 0x08, 0x42,
  0x08, 0xC1, 0x30, 0x24, 0x0D, 0x01, 0x70, 0x3E, 0x06, 0x40, 0x88, 0x21,
  0x04, 0x20, 0x86, 0x10, 0xC6, 0x08, 0x81, 0x00, 0x06, 0x08, 0x10, 0x20,
  0xC1, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40,
  0x83, 0x04, 0x08, 0x10, 0x60, 0x80, 0x01, 0x87, 0x07, 0x36, 0xC7, 0x0C,
  0x23, 0x04, 0x11, 0x02, 0x08, 0x83, 0x04, 0x41, 0x02, 0x60, 0x83, 0x20,
  0x41, 0x90, 0x20, 0x88, 0x30, 0x44, 0x10, 0x26, 0x08, 0x32, 0x04, 0x11,
  0x06, 0x08, 0x83, 0x04, 0xC1, 0x02, 0x40, 0x83, 0x00, 0x01, 0xC1, 0xDC,
  0x70, 0x8C, 0x11, 0x82, 0x20, 0x44, 0x19, 0x82, 0x20, 0x44, 0x08, 0x81,
  0x10, 0x66, 0x08, 0x81, 0x10, 0x22, 0x04, 0xC1, 0x90, 0x20, 0x07, 0x03,
  0x61, 0x04, 0xC1, 0x20, 0x58, 0x14, 0x05, 0x01, 0xC0, 0x70, 0x18, 0x0E,
  0x02, 0x80, 0xA0, 0x68, 0x12, 0x0C, 0xC6, 0x1F, 0x00, 0x00, 0xE0, 0x29,
  0x83, 0x84, 0x18, 0x30, 0xC1, 0x84, 0x04, 0x20, 0x63, 0x03, 0x10, 0x18,
  0x80, 0x84, 0x04, 0x20, 0x23, 0x02, 0x18, 0x10, 0xC1, 0x86, 0x08, 0x30,
  0x83, 0x78, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x00, 0x07, 0x10, 0xDA, 0x10, 0x63, 0x06, 0x20, 0x66,
  0x04, 0x40, 0x44, 0x04, 0x40, 0x4C, 0x0C, 0x80, 0x88, 0x08, 0x80, 0x88,
  0x18, 0x81, 0x88, 0x30, 0xC5, 0x07, 0x90, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x01, 0x85, 0xC5, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00,
  0x80, 0xC0, 0x40, 0x00, 0x03, 0x81, 0x9C, 0x60, 0x08, 0x01, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x82, 0x1F, 0xC0, 0x08, 0x61, 0x04, 0x11, 0xF2, 0x08, 0x20,
  0x86, 0x10, 0x41, 0x04, 0x30, 0x82, 0x08, 0x20, 0x83, 0x80, 0x10, 0x66,
  0x08, 0x81, 0x10, 0x22, 0x04, 0x41, 0x98, 0x22, 0x04, 0x40, 0x88, 0x13,
  0x06, 0x40, 0x88, 0x11, 0x06, 0x20, 0xC4, 0x38, 0xFA, 0x00, 0x81, 0xC0,
  0xA0, 0xD0, 0x48, 0x24, 0x22, 0x11, 0x18, 0x88, 0x4C, 0x24, 0x12, 0x0A,
  0x05, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x81, 0x03, 0x06, 0x0A, 0x0C, 0x14,
  0x18, 0x28, 0x50, 0x90, 0xA1, 0x22, 0x46, 0x44, 0x88, 0x89, 0x11, 0x22,
  0x42, 0x44, 0x85, 0x0B, 0x0A, 0x14, 0x14, 0x28, 0x30, 0x60, 0x60, 0xC0,
  0x81, 0x80, 0x08, 0x30, 0x86, 0x08, 0x40, 0xC8, 0x04, 0x80, 0x50, 0x07,
  0x00, 0x60, 0x06, 0x00, 0xA0, 0x0A, 0x01, 0x20, 0x32, 0x02, 0x30, 0x41,
  0x0C, 0x10, 0x81, 0x00, 0x01, 0x03, 0x01, 0x02, 0x01, 0x04, 0x01, 0x04,
  0x01, 0x0C, 0x01, 0x08, 0x01, 0x18, 0x01, 0x10, 0x01, 0x30, 0x01, 0x20,
  0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x20, 0x18, 0x04, 0x03,
  0x00, 0x80, 0x60, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x18, 0x04,
  0x03, 0x00, 0xFE, 0x00, 0x00, 0x20, 0x3C, 0x0C, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x20, 0x38,
  0x03, 0x00, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x30, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x02, 0x00, 0x70, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x03, 0x00, 0x38, 0x0E, 0x03,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x0C, 0x0E, 0x00, 0x78, 0x30, 0xCE, 0x07, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 24, 7, 0, -24 },
  { 22, 7, 9, 9, 3, -24 },
  { 30, 13, 24, 12, 0, -24 },
  { 69, 12, 27, 12, 0, -25 },
  { 110, 14, 24, 18, 2, -24 },
  { 152, 11, 24, 11, 0, -24 },
  { 185, 3, 9, 5, 3, -24 },
  { 189, 9, 29, 8, 1, -24 },
  { 222, 9, 29, 8, -2, -24 },
  { 255, 8, 9, 11, 4, -25 },
  { 264, 11, 15, 13, 1, -19 },
  { 285, 4, 7, 5, -1, -3 },
  { 289, 7, 2, 9, 1, -10 },
  { 291, 2, 3, 5, 0, -3 },
  { 292, 14, 24, 10, -2, -24 },
  { 334, 11, 24, 12, 1, -24 },
  { 367, 6, 24, 12, 4, -24 },
  { 385, 13, 24, 12, -1, -24 },
  { 424, 13, 24, 12, -1, -24 },
  { 463, 13, 24, 12, -1, -24 },
  { 502, 13, 24, 12, -1, -24 },
  { 541, 11, 24, 12, 1, -24 },
  { 574, 12, 24, 12, 1, -24 },
  { 610, 12, 24, 12, 0, -24 },
  { 646, 11, 24, 12, 0, -24 },
  { 679, 5, 18, 5, 0, -18 },
  { 691, 7, 22, 5, -2, -18 },
  { 711, 11, 14, 13, 1, -19 },
  { 731, 11, 8, 13, 1, -16 },
  { 742, 11, 14, 13, 1, -19 },
  { 762, 10, 24, 8, 0, -24 },
  { 792, 16, 27, 17, 1, -24 },
  { 846, 11, 24, 11, -2, -24 },
  { 879, 13, 24, 13, 0, -24 },
  { 918, 13, 24, 11, 1, -24 },
  { 957, 13, 24, 14, 0, -24 },
  { 996, 13, 24, 11, 0, -24 },
  { 1035, 13, 24, 11, 0, -24 },
  { 1074, 15, 24, 15, 1, -24 },
  { 1119, 15, 24, 15, 0, -24 },
  { 1164, 10, 24, 6, -2, -24 },
  { 1194, 11, 30, 5, -5, -24 },
  { 1236, 14, 24, 12, 0, -24 },
  { 1278, 8, 24, 10, 0, -24 },
  { 1302, 20, 24, 20, 0, -24 },
  { 1362, 16, 24, 16, 0, -24 },
  { 1410, 13, 24, 15, 1, -24 },
  { 1449, 12, 24, 12, 0, -24 },
  { 1485, 13, 30, 15, 1, -24 },
  { 1534, 12, 24, 12, 0, -24 },
  { 1570, 13, 24, 11, -1, -24 },
  { 1609, 11, 24, 10, 2, -24 },
  { 1642, 14, 24, 14, 1, -24 },
  { 1684, 11, 24, 12, 3, -24 },
  { 1717, 21, 24, 20, 2, -24 },
  { 1780, 15, 24, 10, -2, -24 },
  { 1825, 11, 24, 10, 2, -24 },
  { 1858, 13, 24, 10, -1, -24 },
  { 1897, 12, 29, 9, -1, -24 },
  { 1941, 5, 24, 11, 3, -24 },
  { 1956, 12, 29, 9, -2, -24 },
  { 2000, 12, 12, 13, 1, -24 },
  { 2018, 9, 1, 9, -3, 3 },
  { 2020, 3, 5, 7, 5, -25 },
  { 2022, 12, 18, 13, 1, -18 },
  { 2049, 12, 25, 13, 0, -25 },
  { 2087, 9, 18, 9, 1, -18 },
  { 2108, 13, 25, 13, 1, -25 },
  { 2149, 10, 18, 11, 1, -18 },
  { 2172, 14, 33, 6, -4, -25 },
  { 2230, 14, 26, 13, -1, -18 },
  { 2276, 11, 25, 12, 0, -25 },
  { 2311, 6, 24, 5, 0, -24 },
  { 2329, 11, 32, 6, -4, -24 },
  { 2373, 11, 25, 10, 0, -25 },
  { 2408, 7, 25, 5, 0, -25 },
  { 2430, 17, 18, 18, 0, -18 },
  { 2469, 11, 18, 12, 0, -18 },
  { 2494, 10, 18, 12, 1, -18 },
  { 2517, 13, 26, 13, -1, -18 },
  { 2560, 12, 26, 13, 1, -18 },
  { 2599, 9, 18, 8, 0, -18 },
  { 2620, 11, 18, 9, -1, -18 },
  { 2645, 6, 22, 6, 1, -22 },
  { 2662, 11, 17, 12, 1, -17 },
  { 2686, 9, 17, 9, 2, -17 },
  { 2706, 15, 17, 16, 2, -17 },
  { 2738, 12, 17, 10, -1, -17 },
  { 2764, 16, 25, 10, -4, -17 },
  { 2814, 10, 17, 8, -1, -17 },
  { 2836, 11, 29, 10, 1, -24 },
  { 2876, 1, 33, 11, 5, -25 },
  { 2881, 11, 29, 10, -2, -24 },
  { 2921, 11, 3, 13, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC33PT7B_H_
