#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC34PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x18, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0xC1,
  0x02, 0x04, 0x08, 0x20, 0x40, 0x00, 0x00, 0x08, 0x10, 0x60, 0x22, 0x45,
  0x8A, 0x34, 0x48, 0x91, 0x42, 0x88, 0x01, 0x88, 0x08, 0x40, 0x44, 0x06,
  0x20, 0x21, 0x01, 0x18, 0x18, 0x87, 0xFF, 0x04, 0x60, 0x22, 0x02, 0x10,
  0x10, 0x80, 0x88, 0x08, 0x40, 0x42, 0x1F, 0xFC, 0x31, 0x01, 0x08, 0x08,
  0xC0, 0xC4, 0x04, 0x20, 0x23, 0x01, 0x10, 0x10, 0x80, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x07, 0xE0, 0xC9, 0x8C, 0x40, 0x44, 0x02, 0x20, 0x11, 0x00,
  0x88, 0x04, 0x40, 0x14, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0xB0, 0x04,
  0x80, 0x26, 0x01, 0x10, 0x08, 0x80, 0x84, 0x04, 0x42, 0x26, 0x1F, 0xE0,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x08, 0x00, 0x3C, 0x18, 0x88,
  0x23, 0x10, 0xC4, 0x21, 0x08, 0x46, 0x30, 0x88, 0x41, 0x30, 0x86, 0x41,
  0x09, 0x82, 0x12, 0x74, 0x6D, 0xB8, 0x92, 0x33, 0x68, 0x7C, 0x90, 0xA3,
  0x61, 0x04, 0x82, 0x19, 0x0C, 0x22, 0x10, 0xC4, 0x21, 0x18, 0x46, 0x31,
  0x08, 0x62, 0x30, 0x48, 0x40, 0xF0, 0x01, 0x00, 0xF8, 0x11, 0x06, 0x20,
  0x84, 0x10, 0x82, 0x10, 0x44, 0x08, 0x81, 0x20, 0x3C, 0x03, 0x00, 0xC0,
  0x28, 0x0D, 0x83, 0x11, 0x42, 0x78, 0x4A, 0x05, 0x40, 0xC8, 0x19, 0x03,
  0x20, 0xA6, 0x34, 0x7C, 0xC0, 0x25, 0xA4, 0x94, 0x80, 0x01, 0x80, 0x80,
  0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x10, 0x18, 0x08, 0x04, 0x06,
  0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x08, 0x06, 0x00, 0x02, 0x00, 0x80, 0x40, 0x20, 0x18,
  0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02,
  0x01, 0x00, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x08,
  0x08, 0x08, 0x00, 0x0C, 0x04, 0x22, 0x19, 0x03, 0xF8, 0xC0, 0xA0, 0x88,
  0x86, 0x01, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x13, 0x26, 0x44, 0x80, 0xFE, 0xB8, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x01, 0x00, 0xF8, 0x31, 0x84, 0x31,
  0x02, 0x20, 0x4C, 0x09, 0x01, 0x60, 0x6C, 0x0D, 0x01, 0xA0, 0x24, 0x05,
  0x80, 0xA0, 0x34, 0x06, 0x80, 0x90, 0x12, 0x06, 0x40, 0x88, 0x11, 0x04,
  0x21, 0x86, 0x20, 0x78, 0x00, 0x0C, 0x76, 0xF2, 0x88, 0x21, 0x84, 0x10,
  0x41, 0x0C, 0x20, 0x82, 0x18, 0x61, 0x04, 0x10, 0xC3, 0x08, 0x20, 0x00,
  0xC0, 0x3F, 0x81, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80,
  0x18, 0x00, 0xFF, 0x80, 0x00, 0xC0, 0x3F, 0x81, 0x06, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x01, 0x80,
  0x70, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x02, 0x10, 0x30, 0xFE, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x0A, 0x00, 0x70, 0x05, 0x00, 0x68, 0x02, 0x40, 0x26, 0x01, 0x20,
  0x11, 0x01, 0x88, 0x08, 0x40, 0x86, 0x0C, 0x20, 0x41, 0x06, 0x08, 0x20,
  0xC2, 0x06, 0x3F, 0xFC, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x03, 0xF8, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x07, 0xE0, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x42, 0x04, 0x1F, 0xC0, 0x00, 0x60, 0x3F, 0x06, 0x00, 0xC0, 0x18,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x4F, 0x05, 0x98, 0x60,
  0x8C, 0x0C, 0xC0, 0xC8, 0x0C, 0x80, 0xC8, 0x0C, 0x80, 0x88, 0x08, 0x81,
  0x88, 0x10, 0x83, 0x04, 0x20, 0x7C, 0x00, 0x3F, 0xF0, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x80, 0x7E, 0x0C, 0x30,
  0x81, 0x10, 0x11, 0x01, 0x10, 0x11, 0x01, 0x18, 0x20, 0x86, 0x0C, 0xC0,
  0x58, 0x06, 0x01, 0x90, 0x31, 0x86, 0x08, 0xC0, 0xC8, 0x04, 0x80, 0x48,
  0x04, 0x80, 0x48, 0x0C, 0x80, 0x84, 0x18, 0x3E, 0x00, 0x01, 0x80, 0x7E,
  0x0C, 0x20, 0x83, 0x10, 0x31, 0x01, 0x30, 0x12, 0x03, 0x20, 0x32, 0x03,
  0x20, 0x32, 0x02, 0x20, 0x63, 0x0A, 0x1F, 0x60, 0x64, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0xF8, 0x00, 0x08,
  0xC2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0xC6, 0x00, 0x03,
  0x02, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x10, 0x10, 0x20, 0x20, 0x40, 0xC0, 0x00, 0x10, 0x06,
  0x01, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00,
  0x60, 0x08, 0x00, 0x02, 0x07, 0xE0, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x0C,
  0x02, 0x01, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x00, 0x00, 0x00, 0x04, 0x03, 0x00, 0xC0, 0x00, 0x00,
  0xFC, 0x03, 0x02, 0x04, 0x03, 0x0C, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10,
  0x21, 0x20, 0xF1, 0x21, 0x11, 0x62, 0x11, 0x42, 0x21, 0x44, 0x21, 0x44,
  0x23, 0xC4, 0x62, 0x8C, 0x42, 0x88, 0x42, 0x88, 0xC4, 0x88, 0xC4, 0x8D,
  0x48, 0x87, 0x30, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x80, 0x1F, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x50, 0x0A,
  0x03, 0x40, 0x48, 0x19, 0x02, 0x20, 0x44, 0x18, 0x82, 0x10, 0xC2, 0x10,
  0x43, 0xF8, 0xC1, 0x10, 0x26, 0x04, 0x80, 0x90, 0x16, 0x02, 0x80, 0x70,
  0x0C, 0x01, 0x07, 0xF0, 0x20, 0xC1, 0x02, 0x18, 0x10, 0x80, 0x84, 0x04,
  0x20, 0x21, 0x03, 0x18, 0x10, 0x81, 0x04, 0x30, 0x3F, 0x01, 0x04, 0x18,
  0x10, 0x80, 0x84, 0x04, 0x20, 0x23, 0x01, 0x18, 0x08, 0x80, 0xC4, 0x04,
  0x20, 0x63, 0x0E, 0x1F, 0xC0, 0x00, 0x60, 0x0F, 0xC1, 0x80, 0x08, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x10, 0xC0, 0x41, 0x83, 0x02, 0x08, 0x0C, 0x20, 0x30, 0x80, 0xC2, 0x03,
  0x18, 0x0C, 0x40, 0x31, 0x00, 0x84, 0x02, 0x30, 0x08, 0xC0, 0x22, 0x01,
  0x88, 0x04, 0x20, 0x11, 0x80, 0xC6, 0x02, 0x10, 0x18, 0x40, 0xC1, 0x06,
  0x0C, 0x70, 0x3F, 0x00, 0x07, 0xF8, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x3F, 0x83,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x20, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x03, 0xFC, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x03, 0xFC, 0x0C, 0x08, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x1F,
  0x30, 0x02, 0x60, 0x0C, 0xC0, 0x11, 0x80, 0x23, 0x00, 0x46, 0x01, 0x8C,
  0x03, 0x08, 0x04, 0x18, 0x08, 0x18, 0x10, 0x1F, 0xE0, 0x04, 0x03, 0x04,
  0x02, 0x04, 0x02, 0x0C, 0x02, 0x08, 0x06, 0x08, 0x06, 0x08, 0x04, 0x08,
  0x04, 0x18, 0x04, 0x10, 0x0C, 0x10, 0x08, 0x1F, 0xF8, 0x30, 0x08, 0x30,
  0x08, 0x20, 0x18, 0x20, 0x10, 0x20, 0x10, 0x60, 0x10, 0x40, 0x10, 0x40,
  0x30, 0x40, 0x20, 0x40, 0x20, 0xC0, 0x20, 0x80, 0x60, 0x07, 0xE0, 0x20,
  0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x07, 0xE0, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x98, 0x0F, 0x00, 0x04, 0x06, 0x08, 0x10, 0x10, 0x60, 0x61, 0x80, 0x82,
  0x01, 0x08, 0x02, 0x30, 0x04, 0x40, 0x19, 0x00, 0x26, 0x00, 0x58, 0x00,
  0xB0, 0x03, 0xA0, 0x06, 0x60, 0x08, 0xC0, 0x10, 0x80, 0x21, 0x00, 0xC2,
  0x01, 0x86, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x30, 0x30, 0x40, 0x60,
  0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10,
  0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xFF,
  0x06, 0x00, 0x18, 0x30, 0x01, 0xC1, 0x80, 0x0C, 0x1C, 0x00, 0xA0, 0xA0,
  0x05, 0x05, 0x00, 0x58, 0x28, 0x02, 0x81, 0x40, 0x34, 0x1A, 0x01, 0x20,
  0x98, 0x19, 0x04, 0xC0, 0x98, 0x26, 0x0C, 0x83, 0x30, 0x44, 0x18, 0x86,
  0x20, 0x84, 0x23, 0x04, 0x23, 0x18, 0x21, 0x10, 0x83, 0x09, 0x84, 0x10,
  0x48, 0x20, 0x82, 0x43, 0x04, 0x14, 0x10, 0x20, 0xA0, 0x83, 0x06, 0x04,
  0x10, 0x30, 0x60, 0x06, 0x01, 0x83, 0x00, 0x81, 0x80, 0x41, 0xC0, 0x60,
  0xB0, 0x30, 0x48, 0x10, 0x24, 0x08, 0x12, 0x04, 0x19, 0x06, 0x08, 0xC2,
  0x04, 0x61, 0x02, 0x10, 0x83, 0x08, 0x41, 0x84, 0x60, 0x82, 0x20, 0x41,
  0x90, 0x20, 0x48, 0x30, 0x24, 0x18, 0x16, 0x08, 0x0A, 0x04, 0x07, 0x02,
  0x03, 0x83, 0x00, 0xC1, 0x00, 0x60, 0x00, 0x60, 0x0F, 0xC0, 0x61, 0x83,
  0x02, 0x08, 0x0C, 0x40, 0x31, 0x00, 0xCC, 0x03, 0x20, 0x0C, 0x80, 0x36,
  0x00, 0xD0, 0x02, 0x40, 0x09, 0x00, 0x2C, 0x00, 0xB0, 0x06, 0xC0, 0x13,
  0x00, 0x48, 0x03, 0x30, 0x08, 0xC0, 0x63, 0x01, 0x04, 0x0C, 0x18, 0x60,
  0x3F, 0x00, 0x07, 0xE0, 0x21, 0x81, 0x04, 0x18, 0x30, 0x81, 0x84, 0x0C,
  0x20, 0x61, 0x03, 0x18, 0x10, 0x81, 0x84, 0x08, 0x20, 0xC3, 0x38, 0x1F,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x00, 0x00, 0x60, 0x0F, 0xC0, 0x61, 0x83, 0x02,
  0x08, 0x0C, 0x40, 0x31, 0x00, 0xCC, 0x03, 0x20, 0x0C, 0x80, 0x36, 0x00,
  0xD0, 0x02, 0x40, 0x09, 0x00, 0x2C, 0x00, 0xB0, 0x06, 0xC0, 0x13, 0x00,
  0x48, 0x03, 0x30, 0x08, 0xC0, 0x63, 0x01, 0x04, 0x0C, 0x18, 0x60, 0x3E,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x07, 0xE0, 0x21, 0x81, 0x04, 0x18, 0x30, 0xC1, 0x84, 0x0C, 0x20, 0x61,
  0x02, 0x18, 0x10, 0x81, 0x84, 0x08, 0x21, 0x83, 0xF8, 0x19, 0x80, 0x84,
  0x04, 0x20, 0x21, 0x03, 0x08, 0x18, 0x60, 0x83, 0x04, 0x08, 0x20, 0x43,
  0x02, 0x10, 0x18, 0x00, 0xC0, 0x0F, 0xF0, 0x60, 0x43, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x20, 0x60, 0xFF, 0x00, 0x7F,
  0xE0, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x08, 0x04, 0x20, 0x11,
  0x80, 0x46, 0x03, 0x10, 0x08, 0x40, 0x21, 0x00, 0x8C, 0x06, 0x20, 0x18,
  0x80, 0x42, 0x01, 0x08, 0x04, 0x60, 0x31, 0x00, 0x84, 0x02, 0x10, 0x08,
  0xC0, 0x23, 0x01, 0x88, 0x04, 0x20, 0x10, 0x80, 0xC3, 0x02, 0x04, 0x10,
  0x0F, 0x80, 0x80, 0x38, 0x02, 0x80, 0x68, 0x04, 0x80, 0xC8, 0x08, 0x80,
  0x88, 0x18, 0x81, 0x08, 0x30, 0x82, 0x08, 0x60, 0x84, 0x08, 0x40, 0x8C,
  0x08, 0x80, 0x98, 0x09, 0x00, 0x90, 0x0A, 0x00, 0xA0, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x30, 0x0A, 0x01, 0x80, 0xD0, 0x14, 0x04, 0x80, 0xE0,
  0x64, 0x07, 0x02, 0x20, 0x58, 0x11, 0x02, 0x81, 0x88, 0x34, 0x08, 0x41,
  0x20, 0xC2, 0x09, 0x04, 0x10, 0x88, 0x20, 0x84, 0x43, 0x04, 0x62, 0x10,
  0x22, 0x11, 0x81, 0x10, 0x88, 0x09, 0x84, 0x40, 0x48, 0x24, 0x02, 0xC1,
  0x20, 0x14, 0x0B, 0x00, 0xA0, 0x50, 0x07, 0x02, 0x80, 0x30, 0x18, 0x01,
  0x80, 0xC0, 0x18, 0x06, 0x00, 0x02, 0x06, 0x04, 0x08, 0x0C, 0x30, 0x18,
  0x40, 0x11, 0x80, 0x22, 0x00, 0x48, 0x00, 0x90, 0x01, 0x40, 0x02, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x50, 0x01, 0xA0, 0x02, 0x40, 0x0C,
  0x80, 0x11, 0x00, 0x43, 0x00, 0x86, 0x02, 0x0C, 0x0C, 0x08, 0x10, 0x10,
  0x60, 0x20, 0x40, 0x68, 0x09, 0x03, 0x20, 0x44, 0x18, 0xC2, 0x18, 0xC1,
  0x10, 0x26, 0x04, 0x80, 0xB0, 0x14, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x07,
  0xFC, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x08, 0x00, 0x3F, 0xE0, 0x03, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xFC,
  0x00, 0xC2, 0x10, 0x84, 0x21, 0x84, 0x21, 0x08, 0x42, 0x18, 0x42, 0x10,
  0x84, 0x21, 0x84, 0x21, 0x03, 0xF0, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0xFC, 0x00,
  0x02, 0x00, 0x50, 0x05, 0x00, 0x98, 0x08, 0x81, 0x0C, 0x30, 0x42, 0x04,
  0x60, 0x64, 0x02, 0xC0, 0x38, 0x01, 0xFF, 0xC0, 0x99, 0x12, 0x07, 0x90,
  0x85, 0x10, 0x63, 0x06, 0x20, 0x66, 0x06, 0x40, 0x64, 0x04, 0xC0, 0x4C,
  0x04, 0x80, 0xC8, 0x0C, 0x80, 0x88, 0x18, 0x81, 0x8C, 0x28, 0x47, 0x07,
  0xD0, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x0B, 0xE0, 0xE3, 0x1C, 0x11, 0x81, 0x18, 0x11, 0x01, 0x10, 0x13,
  0x01, 0x20, 0x32, 0x03, 0x20, 0x22, 0x02, 0x60, 0x66, 0x04, 0x60, 0xC6,
  0x08, 0xE1, 0x89, 0xF0, 0x07, 0x84, 0x04, 0x06, 0x02, 0x03, 0x01, 0x00,
  0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0x40, 0x3E,
  0x00, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x07, 0x90, 0x21, 0xC1, 0x06, 0x0C, 0x18, 0x20, 0x61,
  0x81, 0x84, 0x06, 0x10, 0x10, 0xC0, 0x43, 0x01, 0x08, 0x0C, 0x20, 0x20,
  0x80, 0x82, 0x06, 0x08, 0x18, 0x30, 0xE0, 0x47, 0x01, 0xF4, 0x00, 0x07,
  0x86, 0x31, 0x04, 0xC1, 0x20, 0xD8, 0x24, 0x19, 0x0C, 0xFE, 0x38, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0x42, 0x1F, 0x80, 0x00, 0x1E,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x03, 0xF0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x01,
  0xC0, 0x00, 0x01, 0xE4, 0x08, 0x50, 0x41, 0x83, 0x06, 0x08, 0x18, 0x60,
  0x61, 0x01, 0x84, 0x04, 0x30, 0x10, 0xC0, 0x42, 0x03, 0x08, 0x08, 0x20,
  0x20, 0x81, 0x82, 0x06, 0x0C, 0x38, 0x11, 0xC0, 0x7D, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x40, 0x83, 0x01, 0xF0, 0x00,
  0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x0B, 0xE0, 0xE2, 0x1C, 0x31, 0x82, 0x18, 0x21, 0x02, 0x10, 0x23, 0x06,
  0x20, 0x62, 0x04, 0x20, 0x42, 0x04, 0x60, 0xC4, 0x08, 0x40, 0x84, 0x08,
  0x40, 0x8C, 0x18, 0x06, 0x08, 0x00, 0x00, 0x00, 0x02, 0x04, 0x18, 0x20,
  0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x41, 0x82, 0x04, 0x08, 0x30, 0x60,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x07, 0x00, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x30, 0x86, 0x18,
  0x41, 0x08, 0x11, 0x01, 0x30, 0x12, 0x03, 0x60, 0x2A, 0x03, 0x20, 0x32,
  0x02, 0x20, 0x62, 0x04, 0x30, 0x41, 0x04, 0x10, 0xC1, 0x08, 0x10, 0x02,
  0x0C, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x60, 0x81, 0x02, 0x04,
  0x18, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x00, 0x0B, 0xE7,
  0x83, 0x0A, 0x31, 0x83, 0x04, 0x60, 0xC1, 0x10, 0x20, 0x44, 0x08, 0x31,
  0x06, 0x08, 0xC1, 0x02, 0x20, 0x40, 0x88, 0x10, 0x62, 0x04, 0x18, 0x83,
  0x04, 0x60, 0x81, 0x10, 0x20, 0x44, 0x08, 0x31, 0x06, 0x08, 0xC1, 0x82,
  0x30, 0x40, 0x80, 0x0B, 0xE1, 0x84, 0x70, 0x8C, 0x11, 0x82, 0x20, 0x44,
  0x09, 0x83, 0x20, 0x64, 0x08, 0x81, 0x10, 0x26, 0x0C, 0x81, 0x10, 0x22,
  0x04, 0xC0, 0x98, 0x30, 0x0F, 0x83, 0x18, 0x41, 0x18, 0x32, 0x06, 0xC0,
  0xD0, 0x1A, 0x02, 0xC0, 0x58, 0x0A, 0x01, 0x40, 0x68, 0x09, 0x01, 0x20,
  0x46, 0x18, 0xC2, 0x0F, 0x80, 0x04, 0xF0, 0x28, 0xC3, 0x82, 0x18, 0x10,
  0xC0, 0x84, 0x04, 0x20, 0x23, 0x01, 0x10, 0x18, 0x80, 0xC4, 0x04, 0x20,
  0x23, 0x03, 0x18, 0x10, 0xC1, 0x86, 0x08, 0x30, 0xC3, 0x7C, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x00,
  0x07, 0x90, 0x87, 0x10, 0x63, 0x06, 0x20, 0x66, 0x06, 0x40, 0x64, 0x04,
  0x40, 0x4C, 0x04, 0x80, 0xC8, 0x0C, 0x80, 0x88, 0x18, 0x81, 0x8C, 0x38,
  0xC7, 0x07, 0xD0, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x0B, 0xC3, 0x81, 0xC0, 0x60, 0x18, 0x04, 0x01, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0,
  0x30, 0x00, 0x07, 0xE1, 0x04, 0x60, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x83, 0x1F, 0xC0, 0x08, 0x61, 0x04, 0x7C, 0xC3, 0x08, 0x20, 0x86, 0x10,
  0x41, 0x04, 0x30, 0x82, 0x08, 0x20, 0x83, 0x80, 0x10, 0x22, 0x04, 0xC1,
  0x90, 0x22, 0x04, 0x40, 0x88, 0x13, 0x06, 0x40, 0x88, 0x11, 0x02, 0x60,
  0x4C, 0x19, 0x02, 0x20, 0xC4, 0x18, 0x85, 0x0F, 0x60, 0x80, 0xC0, 0xE0,
  0x50, 0x28, 0x24, 0x12, 0x19, 0x08, 0x8C, 0x44, 0x26, 0x12, 0x09, 0x05,
  0x02, 0x81, 0xC0, 0xC0, 0x60, 0x00, 0x81, 0x83, 0x81, 0x82, 0x83, 0x82,
  0x82, 0x84, 0x82, 0x84, 0x84, 0x8C, 0x84, 0x88, 0x8C, 0x88, 0x88, 0x90,
  0x88, 0x90, 0x91, 0xB0, 0x91, 0xA0, 0xB1, 0xA0, 0xA1, 0xC0, 0xA1, 0x40,
  0xC1, 0x40, 0xC1, 0x80, 0xC1, 0x80, 0x04, 0x08, 0x20, 0x81, 0x0C, 0x0C,
  0x40, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0x40,
  0x0A, 0x00, 0x90, 0x0C, 0xC0, 0x42, 0x04, 0x10, 0x60, 0x86, 0x06, 0x00,
  0x01, 0x01, 0x01, 0x02, 0x01, 0x02, 0x01, 0x06, 0x01, 0x04, 0x01, 0x0C,
  0x01, 0x08, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20,
  0x01, 0x60, 0x01, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x10, 0x08, 0x06, 0x01, 0x00, 0xC0,
  0x20, 0x18, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x06, 0x01, 0x00,
  0xC0, 0x3F, 0x80, 0x00, 0xF0, 0x18, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x00,
  0xE0, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x01, 0x00,
  0x18, 0x0C, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x0F, 0x00, 0x10, 0x07, 0xC1, 0x83,
  0xE0, 0x08,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 24, 7, 0, -24 },
  { 22, 7, 9, 9, 3, -24 },
  { 30, 13, 24, 13, 0, -24 },
  { 69, 13, 28, 12, 0, -26 },
  { 115, 15, 25, 18, 2, -25 },
  { 162, 11, 25, 12, 0, -25 },
  { 197, 3, 9, 5, 3, -24 },
  { 201, 9, 29, 8, 1, -24 },
  { 234, 9, 29, 8, -2, -24 },
  { 267, 9, 10, 11, 4, -26 },
  { 279, 12, 16, 14, 1, -20 },
  { 303, 4, 7, 6, -1, -3 },
  { 307, 7, 1, 9, 1, -10 },
  { 308, 2, 3, 6, 1, -3 },
  { 309, 15, 24, 10, -2, -24 },
  { 354, 11, 25, 12, 1, -25 },
  { 389, 6, 24, 12, 4, -24 },
  { 407, 13, 25, 12, -1, -25 },
  { 448, 13, 25, 12, -1, -25 },
  { 489, 13, 25, 12, -1, -25 },
  { 530, 13, 24, 12, -1, -24 },
  { 569, 12, 25, 12, 1, -25 },
  { 607, 12, 24, 12, 1, -24 },
  { 643, 12, 25, 12, 0, -25 },
  { 681, 12, 25, 12, 0, -25 },
  { 719, 5, 18, 6, 0, -18 },
  { 731, 8, 22, 6, -2, -18 },
  { 753, 12, 14, 14, 1, -19 },
  { 774, 12, 8, 14, 1, -16 },
  { 786, 12, 14, 14, 1, -19 },
  { 807, 10, 25, 9, 0, -25 },
  { 839, 16, 27, 18, 1, -24 },
  { 893, 11, 24, 12, -2, -24 },
  { 926, 13, 24, 13, 0, -24 },
  { 965, 13, 25, 12, 1, -25 },
  { 1006, 14, 24, 14, 0, -24 },
  { 1048, 13, 24, 12, 0, -24 },
  { 1087, 13, 24, 11, 0, -24 },
  { 1126, 15, 25, 16, 1, -25 },
  { 1173, 16, 24, 15, 0, -24 },
  { 1221, 11, 24, 6, -2, -24 },
  { 1254, 12, 30, 6, -5, -24 },
  { 1299, 15, 24, 12, 0, -24 },
  { 1344, 8, 24, 11, 0, -24 },
  { 1368, 21, 24, 20, 0, -24 },
  { 1431, 17, 24, 16, 0, -24 },
  { 1482, 14, 25, 15, 1, -25 },
  { 1526, 13, 24, 12, 0, -24 },
  { 1565, 14, 31, 15, 1, -25 },
  { 1620, 13, 24, 13, 0, -24 },
  { 1659, 14, 25, 12, -1, -25 },
  { 1703, 11, 24, 10, 2, -24 },
  { 1736, 14, 24, 15, 1, -24 },
  { 1778, 12, 24, 12, 3, -24 },
  { 1814, 21, 24, 21, 2, -24 },
  { 1877, 15, 24, 11, -2, -24 },
  { 1922, 11, 24, 10, 2, -24 },
  { 1955, 14, 24, 11, -1, -24 },
  { 1997, 12, 29, 9, -1, -24 },
  { 2041, 5, 24, 11, 3, -24 },
  { 2056, 12, 29, 9, -2, -24 },
  { 2100, 12, 12, 13, 1, -24 },
  { 2118, 10, 1, 9, -3, 3 },
  { 2120, 3, 5, 7, 5, -26 },
  { 2122, 12, 18, 13, 1, -18 },
  { 2149, 12, 26, 13, 0, -26 },
  { 2188, 9, 18, 9, 1, -18 },
  { 2209, 14, 26, 13, 1, -26 },
  { 2255, 10, 18, 11, 1, -18 },
  { 2278, 15, 34, 7, -4, -26 },
  { 2342, 14, 26, 13, -1, -18 },
  { 2388, 12, 26, 13, 0, -26 },
  { 2427, 7, 24, 6, 0, -24 },
  { 2448, 11, 32, 6, -4, -24 },
  { 2492, 12, 26, 11, 0, -26 },
  { 2531, 7, 26, 5, 0, -26 },
  { 2554, 18, 18, 19, 0, -18 },
  { 2595, 11, 18, 13, 0, -18 },
  { 2620, 11, 18, 13, 1, -18 },
  { 2645, 13, 26, 13, -1, -18 },
  { 2688, 12, 26, 13, 1, -18 },
  { 2727, 10, 18, 8, 0, -18 },
  { 2750, 11, 18, 10, -1, -18 },
  { 2775, 6, 22, 7, 1, -22 },
  { 2792, 11, 18, 13, 1, -18 },
  { 2817, 9, 18, 10, 2, -18 },
  { 2838, 16, 18, 16, 2, -18 },
  { 2874, 13, 18, 10, -2, -18 },
  { 2904, 16, 26, 10, -4, -18 },
  { 2956, 10, 18, 8, -1, -18 },
  { 2979, 12, 29, 11, 1, -24 },
  { 3023, 1, 34, 12, 5, -26 },
  { 3028, 11, 29, 11, -2, -24 },
  { 3068, 12, 4, 14, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC34PT7B_H_
