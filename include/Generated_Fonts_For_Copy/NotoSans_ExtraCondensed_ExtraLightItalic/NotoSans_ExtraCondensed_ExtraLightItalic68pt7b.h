#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC68PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x1C, 0x1C, 0x60, 0x73, 0x81, 0x8E, 0x06, 0x38, 0x38,
  0xC0, 0xE3, 0x03, 0x1C, 0x0C, 0x70, 0x31, 0x81, 0xC6, 0x06, 0x18, 0x18,
  0x60, 0x63, 0x01, 0x8C, 0x0C, 0x30, 0x30, 0xC0, 0xC2, 0x03, 0x00, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x30, 0x1C,
  0x00, 0x06, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x30, 0x1C, 0x00, 0x06,
  0x03, 0x00, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x06, 0x03, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x38, 0x1C, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x38, 0x0C, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0x60, 0x00,
  0x38, 0x0C, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x38, 0x0C,
  0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0x60, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x01, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0,
  0x70, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0, 0x70, 0x00,
  0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x0C,
  0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x3E, 0x67, 0xC0, 0x1C, 0x10, 0x30, 0x0E, 0x0C, 0x00, 0x03, 0x03, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0E, 0x30, 0x00,
  0x01, 0xC8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x1C, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x04, 0x0E,
  0x00, 0x03, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x0C,
  0x0C, 0x00, 0x02, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x60, 0xE0, 0x10,
  0x18, 0x70, 0x0F, 0x06, 0x78, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x18, 0x03, 0xF8, 0x00, 0x60, 0x0E, 0x38, 0x00, 0xC0, 0x38,
  0x30, 0x03, 0x00, 0xE0, 0x60, 0x06, 0x01, 0x80, 0xC0, 0x18, 0x07, 0x01,
  0x80, 0x30, 0x0E, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x70, 0x0C,
  0x06, 0x00, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0x30, 0x30, 0x03, 0x00, 0xE0,
  0x60, 0x0E, 0x01, 0xC1, 0x80, 0x18, 0x03, 0x03, 0x00, 0x30, 0x06, 0x0C,
  0x00, 0x60, 0x0C, 0x18, 0x00, 0xC0, 0x38, 0x60, 0x03, 0x80, 0x70, 0xC0,
  0x07, 0x00, 0xC3, 0x01, 0x0E, 0x01, 0x86, 0x1F, 0x98, 0x07, 0x18, 0x7F,
  0xB0, 0x0C, 0x31, 0xC3, 0xE0, 0x38, 0xC3, 0x07, 0xC0, 0x61, 0x8C, 0x07,
  0xC1, 0xC6, 0x18, 0x0D, 0x83, 0x0C, 0x60, 0x1B, 0x8E, 0x30, 0xC0, 0x37,
  0xF8, 0x63, 0x80, 0x67, 0xC1, 0x86, 0x01, 0xC0, 0x03, 0x0C, 0x03, 0x80,
  0x0C, 0x38, 0x07, 0x00, 0x18, 0x70, 0x0C, 0x00, 0x60, 0xC0, 0x18, 0x00,
  0xC1, 0x80, 0x30, 0x03, 0x03, 0x00, 0xE0, 0x06, 0x0E, 0x01, 0xC0, 0x18,
  0x1C, 0x03, 0x00, 0x30, 0x30, 0x06, 0x00, 0xC0, 0x60, 0x1C, 0x01, 0x80,
  0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x01, 0xC0, 0x30, 0x06,
  0x03, 0x00, 0x60, 0x0C, 0x0E, 0x01, 0x80, 0x18, 0x18, 0x03, 0x00, 0x38,
  0x70, 0x0C, 0x00, 0x3B, 0xC0, 0x38, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0xE0,
  0xC0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x38, 0x0E,
  0x00, 0x70, 0x18, 0x00, 0xE0, 0x30, 0x01, 0x80, 0xE0, 0x03, 0x01, 0xC0,
  0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x30, 0x00,
  0x70, 0xE0, 0x00, 0xE3, 0x80, 0x01, 0xC6, 0x00, 0x01, 0x9C, 0x00, 0x03,
  0x70, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xB8, 0x00, 0x0E, 0x30, 0x00, 0x38, 0x60, 0x00, 0x70, 0xE0,
  0x61, 0xC1, 0xC1, 0xC7, 0x01, 0x83, 0x8C, 0x03, 0x06, 0x38, 0x07, 0x1C,
  0x60, 0x0E, 0x39, 0xC0, 0x0C, 0x63, 0x80, 0x19, 0xC6, 0x00, 0x3B, 0x0C,
  0x00, 0x76, 0x38, 0x00, 0x78, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1F, 0x06, 0x00, 0x6E, 0x0E, 0x01,
  0xCC, 0x1E, 0x07, 0x18, 0x1F, 0xFC, 0x38, 0x1F, 0xF0, 0x70, 0x0E, 0x00,
  0x00, 0x1C, 0x63, 0x8E, 0x38, 0xC3, 0x0C, 0x71, 0x86, 0x18, 0x63, 0x0C,
  0x30, 0xC2, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x06,
  0x06, 0x03, 0x83, 0x00, 0xF1, 0x81, 0x1E, 0x87, 0x83, 0xFF, 0xC0, 0x7C,
  0x00, 0x78, 0x00, 0x64, 0x00, 0x63, 0x00, 0xE0, 0xC0, 0xE0, 0x60, 0xE0,
  0x18, 0x20, 0x0C, 0x00, 0x07, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x03, 0x81, 0xC0, 0xC0,
  0xE0, 0x70, 0x70, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x06, 0x03, 0x03,
  0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x78, 0xE0, 0x01, 0xC0, 0xE0, 0x07, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0E,
  0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x18, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x70, 0x00, 0x30, 0xE0, 0x00, 0xE1, 0x80, 0x01, 0xC3, 0x00,
  0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x60, 0x00,
  0x70, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x0E, 0x00, 0x06,
  0x1C, 0x00, 0x1C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC3,
  0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x38,
  0x00, 0x60, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x0E, 0x01, 0x80,
  0x1C, 0x03, 0x00, 0x70, 0x07, 0x00, 0xC0, 0x0E, 0x03, 0x80, 0x0E, 0x1E,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x18,
  0x03, 0xC0, 0x3E, 0x03, 0xF0, 0x3B, 0x03, 0x98, 0x79, 0xC7, 0x8E, 0x70,
  0x73, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xE0, 0xF0, 0x00, 0xC0, 0x1E, 0x00, 0x20, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xE0, 0xF0, 0x01, 0xE0, 0x0E, 0x00,
  0x20, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x20, 0x00, 0xE0, 0x0E, 0x00, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x67, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x18,
  0x60, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x0E,
  0x0E, 0x00, 0x06, 0x06, 0x00, 0x06, 0x03, 0x00, 0x07, 0x03, 0x80, 0x03,
  0x01, 0xC0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x60, 0x01, 0x80, 0x30, 0x01,
  0xC0, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x70, 0x03, 0x80, 0x30, 0x01, 0xC0, 0x38, 0x00, 0xC0,
  0x38, 0x00, 0x60, 0x18, 0x00, 0x70, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xBF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x20, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0x02, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x30, 0xFF,
  0x00, 0x33, 0xFF, 0x80, 0x77, 0x01, 0xC0, 0x76, 0x00, 0xE0, 0x7C, 0x00,
  0xE0, 0x78, 0x00, 0xE0, 0x70, 0x00, 0x60, 0xF0, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x60, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x00,
  0xE0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x01,
  0x80, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x0E, 0x00, 0x78, 0x3C, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xE0, 0xF0,
  0x01, 0xE0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0x60, 0x0C, 0x00,
  0x18, 0x03, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C,
  0x00, 0x1C, 0x07, 0x00, 0x06, 0x01, 0xC0, 0x01, 0x80, 0x70, 0x00, 0xE0,
  0x1C, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x0E,
  0x78, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x30, 0x00,
  0x38, 0x1C, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x81, 0x80, 0x00, 0x60, 0xE0,
  0x00, 0x18, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x01, 0xC0, 0x01,
  0xC0, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x3C, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x06, 0x03, 0x80, 0x06, 0x03, 0x80, 0x06,
  0x03, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07,
  0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0E,
  0x0C, 0x00, 0x1E, 0x0C, 0x00, 0x1E, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x3C,
  0x0E, 0x00, 0x6C, 0x07, 0x00, 0xDC, 0x07, 0x83, 0x9C, 0x03, 0xFF, 0x18,
  0x00, 0xFC, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x80, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1E, 0x1F, 0x01, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0xFC, 0x0E, 0x1C, 0x01, 0xFF, 0x07, 0x0C, 0x01, 0xC3, 0x03, 0x86, 0x01,
  0x81, 0x81, 0xC7, 0x01, 0xC1, 0xC0, 0xC3, 0x01, 0xC0, 0xE0, 0x61, 0x80,
  0xC0, 0x60, 0x31, 0xC0, 0xE0, 0x30, 0x18, 0xC0, 0x60, 0x38, 0x0C, 0x60,
  0x30, 0x1C, 0x0E, 0x70, 0x38, 0x0C, 0x07, 0x38, 0x18, 0x06, 0x03, 0x18,
  0x0C, 0x07, 0x01, 0x8C, 0x0E, 0x03, 0x80, 0xC6, 0x06, 0x01, 0x80, 0xE7,
  0x03, 0x00, 0xC0, 0x63, 0x81, 0x80, 0xE0, 0x31, 0x80, 0xC0, 0x70, 0x38,
  0xC0, 0xE0, 0x30, 0x18, 0x60, 0x70, 0x38, 0x0C, 0x30, 0x38, 0x1C, 0x0E,
  0x18, 0x1C, 0x1E, 0x06, 0x0C, 0x0E, 0x0F, 0x07, 0x06, 0x03, 0x0D, 0x83,
  0x03, 0x01, 0x8E, 0xC3, 0x01, 0x80, 0xFE, 0x3F, 0x00, 0xC0, 0x3E, 0x1F,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x10, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x37, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x67, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xC7, 0x00,
  0x01, 0xC7, 0x00, 0x01, 0x87, 0x00, 0x01, 0x87, 0x00, 0x03, 0x87, 0x00,
  0x03, 0x07, 0x00, 0x07, 0x07, 0x00, 0x06, 0x07, 0x00, 0x06, 0x07, 0x00,
  0x0E, 0x07, 0x00, 0x0C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x18, 0x07, 0x00,
  0x18, 0x07, 0x00, 0x38, 0x07, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xC0, 0x07, 0x01,
  0xC0, 0x07, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03,
  0x00, 0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x07, 0x38,
  0x00, 0x07, 0x38, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x18, 0x03, 0xC0, 0x03, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x1C, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0x00, 0x70, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80,
  0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80,
  0x30, 0x00, 0x70, 0x06, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x0E,
  0x00, 0x60, 0x01, 0xC0, 0x1C, 0x00, 0x18, 0x03, 0x80, 0x03, 0x00, 0x60,
  0x00, 0x70, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x38,
  0x0E, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x38, 0x0E, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x06, 0x00, 0x07, 0x00,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x78, 0x07, 0x00, 0x1E, 0x00, 0xC0, 0x07,
  0x80, 0x18, 0x07, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xF8, 0x18, 0x00, 0xF8,
  0x02, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x20, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x18, 0x07, 0x80, 0x03, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x07, 0x00, 0x60,
  0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x30,
  0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x18, 0x0E, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x38, 0x18, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x18, 0x18,
  0x00, 0x07, 0x03, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03,
  0x03, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0,
  0x30, 0x00, 0x18, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x30, 0x00,
  0x38, 0x06, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x00, 0xC0, 0x1E, 0x00, 0x18, 0x3F, 0x80, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x78, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x40, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0xFF, 0x81, 0xC0, 0x01, 0xFF, 0x03, 0x00, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0x80, 0x38, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x60, 0x01, 0xC0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0xE0, 0x0F, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x70, 0x01, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x01, 0xC0, 0x06, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x01, 0x80, 0x0E, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x07, 0x00, 0x18, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x38, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x01, 0x9E, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x0E, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x60, 0x07, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x60, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x0C, 0xF0, 0x00, 0x00,
  0x67, 0x80, 0x00, 0x07, 0x6C, 0x00, 0x00, 0x3E, 0x60, 0x00, 0x01, 0xB3,
  0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x01, 0x80,
  0x38, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xE0, 0x06, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x30, 0x01, 0xC0, 0x01, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x70, 0x01, 0x80,
  0x03, 0x80, 0x1C, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x6C, 0x00, 0x00, 0x3B, 0x00,
  0x3B, 0x00, 0x00, 0x0D, 0xC0, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x03, 0xB8,
  0x00, 0x01, 0x98, 0x00, 0xCE, 0x00, 0x00, 0xE6, 0x00, 0x33, 0x80, 0x00,
  0x33, 0x80, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x07, 0x38, 0x00, 0x06, 0x38,
  0x01, 0xCE, 0x00, 0x03, 0x8C, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x18,
  0x60, 0x00, 0x71, 0xC0, 0x0E, 0x18, 0x00, 0x18, 0x70, 0x03, 0x86, 0x00,
  0x0E, 0x1C, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x30, 0x60, 0x01, 0xC1,
  0x80, 0x0C, 0x18, 0x00, 0x70, 0xE0, 0x07, 0x06, 0x00, 0x38, 0x38, 0x01,
  0xC1, 0x80, 0x0E, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18,
  0x01, 0xC0, 0xC0, 0x0E, 0x06, 0x00, 0x60, 0x70, 0x03, 0x81, 0x80, 0x38,
  0x1C, 0x00, 0xE0, 0x70, 0x0C, 0x06, 0x00, 0x30, 0x1C, 0x07, 0x01, 0x80,
  0x0C, 0x07, 0x01, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x01, 0xC0,
  0x70, 0x30, 0x0E, 0x00, 0x60, 0x1C, 0x1C, 0x03, 0x00, 0x18, 0x07, 0x06,
  0x00, 0xC0, 0x06, 0x00, 0xC3, 0x80, 0x70, 0x03, 0x80, 0x30, 0xC0, 0x1C,
  0x00, 0xE0, 0x0C, 0x70, 0x07, 0x00, 0x30, 0x03, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0xCE, 0x00, 0x60, 0x03, 0x00, 0x33, 0x80, 0x38, 0x01, 0xC0, 0x0D,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x70, 0x03, 0x00, 0x18, 0x00, 0xF8, 0x00,
  0xC0, 0x06, 0x00, 0x3E, 0x00, 0x70, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x1E,
  0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x60, 0x03,
  0xC0, 0x00, 0x30, 0x03, 0xE0, 0x00, 0x18, 0x01, 0xF8, 0x00, 0x1C, 0x00,
  0xDC, 0x00, 0x0E, 0x00, 0x66, 0x00, 0x06, 0x00, 0x73, 0x00, 0x03, 0x00,
  0x39, 0x80, 0x03, 0x80, 0x1C, 0xE0, 0x01, 0xC0, 0x0C, 0x70, 0x00, 0xE0,
  0x06, 0x38, 0x00, 0x60, 0x07, 0x0C, 0x00, 0x30, 0x03, 0x86, 0x00, 0x38,
  0x01, 0xC3, 0x00, 0x1C, 0x00, 0xC1, 0xC0, 0x0C, 0x00, 0x60, 0xE0, 0x06,
  0x00, 0x70, 0x30, 0x03, 0x00, 0x38, 0x18, 0x03, 0x80, 0x18, 0x0C, 0x01,
  0xC0, 0x0C, 0x07, 0x00, 0xC0, 0x06, 0x03, 0x80, 0x60, 0x07, 0x01, 0xC0,
  0x30, 0x03, 0x80, 0x60, 0x38, 0x01, 0x80, 0x30, 0x1C, 0x00, 0xC0, 0x18,
  0x0C, 0x00, 0xE0, 0x0E, 0x06, 0x00, 0x70, 0x07, 0x07, 0x00, 0x38, 0x03,
  0x83, 0x80, 0x18, 0x00, 0xC1, 0xC0, 0x0C, 0x00, 0x60, 0xC0, 0x0E, 0x00,
  0x38, 0x60, 0x07, 0x00, 0x1C, 0x70, 0x03, 0x80, 0x0E, 0x38, 0x01, 0x80,
  0x03, 0x18, 0x00, 0xC0, 0x01, 0x8C, 0x00, 0xE0, 0x00, 0xC6, 0x00, 0x70,
  0x00, 0x77, 0x00, 0x30, 0x00, 0x3B, 0x80, 0x18, 0x00, 0x1D, 0x80, 0x0C,
  0x00, 0x06, 0xC0, 0x0E, 0x00, 0x03, 0x60, 0x07, 0x00, 0x01, 0xF0, 0x03,
  0x00, 0x00, 0xF8, 0x01, 0x80, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0x07, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x0C, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x60, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0x70, 0x00, 0x70, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xC0,
  0x78, 0x00, 0x30, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x06, 0x00, 0x60, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C,
  0x03, 0x80, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x1C, 0x00,
  0x18, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x60, 0x00, 0xE0, 0x18,
  0x00, 0x30, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x03, 0x80,
  0x30, 0x01, 0xC0, 0x0C, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x01, 0xC0, 0x7C,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0x07, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x0C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x60,
  0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x06, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0x70, 0x00, 0x70, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0x1C, 0x07, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xC0, 0x78, 0x00, 0x30, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x01, 0x80, 0x38, 0x00, 0x70, 0x0E,
  0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x60,
  0x1C, 0x00, 0x18, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x60, 0x00,
  0xE0, 0x18, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0xE0,
  0x03, 0x80, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x06, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x30, 0x1C, 0x00, 0x0C, 0x07,
  0x00, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x0E, 0x00, 0x18,
  0x03, 0x80, 0x06, 0x00, 0xE0, 0x03, 0x80, 0x18, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x01, 0xC0, 0x07,
  0x00, 0x70, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0E, 0x03, 0x80,
  0x03, 0x80, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xC0, 0x06, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x38, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x60, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x38, 0x06, 0x00, 0x01, 0x80, 0x70, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0xE0, 0x1C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xE0, 0x18, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x30, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xC0, 0x1C, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x00,
  0x38, 0x00, 0x38, 0x01, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0E,
  0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C,
  0xC0, 0x00, 0x38, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x01, 0xC0,
  0xC0, 0x01, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x00,
  0xC0, 0x07, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x38, 0x00,
  0xC0, 0x38, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0x60, 0x00,
  0xC0, 0xE0, 0x00, 0xC0, 0xC0, 0x00, 0xC1, 0xC0, 0x00, 0xC1, 0xC0, 0x00,
  0xC1, 0x80, 0x00, 0xC3, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0xCE, 0x00, 0x00, 0xCE, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x00, 0x00,
  0xEC, 0x00, 0x03, 0x80, 0x00, 0xE6, 0x00, 0x03, 0xC0, 0x00, 0x73, 0x00,
  0x01, 0xE0, 0x00, 0x31, 0x80, 0x00, 0xF0, 0x00, 0x38, 0xC0, 0x00, 0xD8,
  0x00, 0x1C, 0x60, 0x00, 0x6C, 0x00, 0x0C, 0x30, 0x00, 0x76, 0x00, 0x0E,
  0x18, 0x00, 0x33, 0x00, 0x06, 0x0C, 0x00, 0x19, 0x80, 0x07, 0x06, 0x00,
  0x1C, 0xC0, 0x03, 0x83, 0x00, 0x0C, 0x60, 0x01, 0x81, 0x80, 0x0E, 0x30,
  0x01, 0xC0, 0xC0, 0x06, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x0C, 0x00, 0xE0,
  0x70, 0x03, 0x86, 0x00, 0x70, 0x38, 0x01, 0x83, 0x00, 0x30, 0x1C, 0x01,
  0xC1, 0x80, 0x38, 0x0E, 0x00, 0xC0, 0xC0, 0x18, 0x07, 0x00, 0x60, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x38, 0x06, 0x00,
  0xE0, 0x38, 0x1C, 0x07, 0x00, 0x70, 0x1C, 0x0E, 0x03, 0x00, 0x38, 0x0C,
  0x07, 0x03, 0x80, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x0E, 0x06, 0x01, 0xC0,
  0xC0, 0x07, 0x03, 0x00, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x60, 0x60, 0x01,
  0xC1, 0x80, 0x30, 0x70, 0x00, 0xE1, 0xC0, 0x18, 0x38, 0x00, 0x70, 0xC0,
  0x0C, 0x18, 0x00, 0x38, 0x60, 0x06, 0x1C, 0x00, 0x1C, 0x70, 0x03, 0x0C,
  0x00, 0x0E, 0x30, 0x01, 0x8E, 0x00, 0x07, 0x38, 0x00, 0xC7, 0x00, 0x03,
  0x98, 0x00, 0x63, 0x00, 0x01, 0xCC, 0x00, 0x33, 0x80, 0x00, 0xCE, 0x00,
  0x19, 0x80, 0x00, 0x66, 0x00, 0x0D, 0xC0, 0x00, 0x37, 0x00, 0x06, 0xE0,
  0x00, 0x1B, 0x80, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x80, 0x0E,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x60, 0x0E, 0x00,
  0x01, 0x80, 0x38, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x38, 0x06, 0x00, 0x01,
  0xC0, 0x18, 0x00, 0x07, 0x00, 0x60, 0x00, 0x38, 0x01, 0x80, 0x00, 0xC0,
  0x06, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x73, 0x00, 0x01, 0x8C, 0x00, 0x0E,
  0x30, 0x00, 0x30, 0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38,
  0x01, 0xC0, 0xE0, 0x07, 0x01, 0x80, 0x38, 0x06, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0x60, 0x1C, 0x01, 0x80, 0xE0, 0x06, 0x03, 0x80, 0x1C, 0x1C, 0x00,
  0x70, 0x60, 0x01, 0xC3, 0x80, 0x07, 0x0C, 0x00, 0x0C, 0x70, 0x00, 0x31,
  0x80, 0x00, 0xCE, 0x00, 0x03, 0x30, 0x00, 0x0D, 0xC0, 0x00, 0x36, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xC0, 0x60, 0x38, 0x1C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x1C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x70, 0x38, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x1C,
  0x06, 0x03, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x70, 0x00, 0x01, 0x98, 0x00, 0x01, 0x8E, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x60, 0x30, 0x00,
  0x70, 0x1C, 0x00, 0x30, 0x06, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x1C, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x0C, 0x06, 0x00, 0x07,
  0x07, 0x00, 0x01, 0x87, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x73, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC1, 0x83,
  0x83, 0x07, 0x06, 0x0C, 0x0C, 0x08, 0x18, 0x00, 0x02, 0x00, 0x00, 0x3F,
  0xC3, 0x00, 0x7F, 0xE7, 0x00, 0xE0, 0x66, 0x01, 0xC0, 0x36, 0x03, 0x80,
  0x36, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0C, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x38, 0x00,
  0x18, 0x38, 0x00, 0x38, 0x30, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x30, 0x70, 0x00, 0x30, 0x60, 0x00, 0x70, 0x60, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00,
  0xE0, 0xE0, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x03,
  0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0xE0, 0x0D, 0x80, 0x70, 0x1D,
  0x80, 0x78, 0x39, 0x80, 0x3F, 0xF3, 0x80, 0x1F, 0xE3, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0xC3, 0xF8, 0x00, 0xCF, 0xFC, 0x01, 0xDC, 0x1E, 0x01, 0xD8,
  0x0E, 0x01, 0xB0, 0x07, 0x01, 0xE0, 0x07, 0x01, 0xE0, 0x07, 0x03, 0xC0,
  0x03, 0x03, 0x80, 0x03, 0x03, 0x80, 0x03, 0x03, 0x80, 0x03, 0x07, 0x00,
  0x03, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00,
  0x0E, 0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x1C, 0x00,
  0x1C, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x30, 0x38, 0x00, 0x70, 0x38, 0x00, 0x60, 0x7C, 0x00, 0xE0, 0x6C, 0x01,
  0xC0, 0x6C, 0x03, 0xC0, 0x66, 0x07, 0x80, 0x67, 0xFF, 0x00, 0xC3, 0xFC,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x70, 0x20, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x20, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x38, 0x00, 0x3F, 0xC7, 0x00, 0x0F, 0xFC, 0xC0,
  0x03, 0x81, 0x98, 0x00, 0xE0, 0x1B, 0x00, 0x38, 0x03, 0xE0, 0x0E, 0x00,
  0x3C, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x03,
  0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0C, 0x00, 0x0C, 0x03, 0x80, 0x03,
  0x80, 0x70, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70,
  0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x38,
  0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x03, 0x00, 0x07, 0x00,
  0x70, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x80, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x6C, 0x00, 0x70, 0x1D, 0x80, 0x0F, 0x07, 0x30, 0x00,
  0xFF, 0xCE, 0x00, 0x0F, 0xF1, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x1E, 0x0E, 0x01, 0xC0, 0x70, 0x38,
  0x07, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x06, 0x1C,
  0x00, 0x61, 0x80, 0x0E, 0x38, 0x00, 0xC3, 0x00, 0x1C, 0x30, 0x03, 0x87,
  0x00, 0x70, 0x70, 0x1E, 0x06, 0x0F, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x04, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0x0C, 0x00, 0x3F, 0xF3, 0x00, 0x0E,
  0x06, 0x60, 0x03, 0x80, 0x6C, 0x00, 0xE0, 0x0D, 0x80, 0x38, 0x00, 0xF0,
  0x07, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x30, 0x00, 0x70, 0x0E, 0x00,
  0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x01,
  0xC0, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x18, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0x80, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x01, 0xC0,
  0x07, 0x80, 0x38, 0x00, 0xF0, 0x07, 0x00, 0x3E, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x01, 0xB0, 0x01, 0xC0, 0x76, 0x00, 0x3C, 0x1D, 0xC0, 0x03, 0xFF,
  0x38, 0x00, 0x3F, 0xC6, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x10, 0x01, 0xC0,
  0x03, 0x80, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x20, 0x00, 0xC7, 0xF8,
  0x01, 0x9F, 0xF8, 0x07, 0x70, 0x78, 0x0F, 0x80, 0x70, 0x1A, 0x00, 0xE0,
  0x3C, 0x00, 0xC0, 0x70, 0x03, 0x81, 0xE0, 0x07, 0x03, 0x80, 0x0E, 0x07,
  0x00, 0x1C, 0x0E, 0x00, 0x30, 0x18, 0x00, 0x60, 0x70, 0x01, 0xC0, 0xE0,
  0x03, 0x81, 0x80, 0x07, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x1C, 0x00,
  0x70, 0x38, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0xC0, 0x03, 0x03, 0x80, 0x06,
  0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0,
  0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x18, 0x0C,
  0x00, 0x30, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xC0, 0x03, 0x81, 0x80,
  0x06, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x10, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x07, 0x00,
  0xC0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x01, 0x80, 0x30, 0x01,
  0x80, 0x70, 0x01, 0x80, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x03,
  0x03, 0x80, 0x03, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07,
  0x1C, 0x00, 0x06, 0x38, 0x00, 0x06, 0x78, 0x00, 0x0E, 0xF8, 0x00, 0x0E,
  0xDC, 0x00, 0x0D, 0x9C, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x0C, 0x00, 0x1E,
  0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x0E, 0x00, 0x38,
  0x0E, 0x00, 0x38, 0x06, 0x00, 0x38, 0x06, 0x00, 0x30, 0x06, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x03, 0x00, 0x60,
  0x03, 0x00, 0x60, 0x03, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0x06, 0x00, 0x0C, 0x7F, 0x83, 0xFC,
  0x00, 0xCF, 0xF8, 0x7F, 0xE0, 0x1D, 0x81, 0xCC, 0x0E, 0x01, 0xB0, 0x0D,
  0x80, 0x70, 0x1E, 0x00, 0xF0, 0x07, 0x01, 0xC0, 0x0F, 0x00, 0x70, 0x1C,
  0x00, 0xE0, 0x07, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x38, 0x00, 0xC0, 0x07,
  0x03, 0x80, 0x0C, 0x00, 0x60, 0x30, 0x01, 0xC0, 0x06, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x70, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x60,
  0x01, 0x80, 0x0C, 0x06, 0x00, 0x38, 0x00, 0xC0, 0xE0, 0x03, 0x80, 0x1C,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0xE0, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0xC0, 0x07, 0x00, 0x18, 0x1C, 0x00, 0x70, 0x03, 0x81, 0xC0,
  0x06, 0x00, 0x38, 0x18, 0x00, 0x60, 0x03, 0x81, 0x80, 0x0E, 0x00, 0x30,
  0x18, 0x00, 0xE0, 0x03, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x38, 0x00, 0xC0,
  0x07, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x30, 0x01, 0xC0, 0x06, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x70, 0x01, 0x80, 0x0E, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x60, 0x03, 0x80, 0x0C, 0x06, 0x00, 0x38, 0x00, 0xC0, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x00, 0x00, 0x40, 0x01, 0x8F, 0xF0, 0x03, 0x3F, 0xF0, 0x0E,
  0xE0, 0xF0, 0x1B, 0x00, 0xE0, 0x34, 0x01, 0xC0, 0x78, 0x03, 0x80, 0xE0,
  0x07, 0x03, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00,
  0x60, 0x70, 0x00, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x00, 0x0E,
  0x06, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0,
  0xC0, 0x03, 0x01, 0x80, 0x06, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x38, 0x18,
  0x00, 0x70, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x81, 0xC0, 0x07, 0x03, 0x80,
  0x0E, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x30, 0x38, 0x00, 0x60, 0x70, 0x01,
  0xC0, 0xE0, 0x03, 0x81, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x0E, 0x00, 0x38,
  0x00, 0x00, 0x02, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xC1, 0xE0,
  0x3C, 0x07, 0x01, 0xC0, 0x1C, 0x1C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00,
  0x18, 0xE0, 0x00, 0xC7, 0x00, 0x06, 0x30, 0x00, 0x33, 0x80, 0x01, 0x9C,
  0x00, 0x0C, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01,
  0xD8, 0x00, 0x0E, 0xC0, 0x00, 0x6E, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80,
  0x01, 0xDC, 0x00, 0x0C, 0xE0, 0x00, 0xE6, 0x00, 0x07, 0x30, 0x00, 0x31,
  0x80, 0x03, 0x8C, 0x00, 0x1C, 0x70, 0x00, 0xC3, 0x80, 0x0E, 0x1C, 0x00,
  0xE0, 0xE0, 0x07, 0x03, 0x80, 0x70, 0x1E, 0x0F, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0x0F, 0xE0,
  0x00, 0x67, 0xFE, 0x00, 0x1C, 0xC1, 0xE0, 0x03, 0x30, 0x1C, 0x00, 0x6C,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x78, 0x00, 0x60,
  0x0F, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0x80, 0x38, 0x00, 0x30, 0x06, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x60, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C,
  0x00, 0x0C, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0C, 0x00, 0x0C,
  0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x01, 0xC0,
  0x03, 0x00, 0x3C, 0x00, 0xE0, 0x0F, 0x80, 0x38, 0x01, 0xF0, 0x0F, 0x00,
  0x33, 0x03, 0xC0, 0x06, 0x7F, 0xF0, 0x00, 0xC7, 0xF8, 0x00, 0x38, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xC3, 0x00, 0x7F,
  0xE6, 0x00, 0xE0, 0x66, 0x01, 0xC0, 0x36, 0x03, 0x80, 0x36, 0x07, 0x00,
  0x3E, 0x06, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x38, 0x00, 0x18, 0x38, 0x00,
  0x38, 0x30, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x30, 0x70, 0x00,
  0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x60, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xC0, 0x01,
  0xC0, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x03,
  0xC0, 0xE0, 0x07, 0x80, 0xE0, 0x0D, 0x80, 0x70, 0x1D, 0x80, 0x78, 0x3B,
  0x80, 0x3F, 0xF3, 0x80, 0x1F, 0xE3, 0x00, 0x07, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x18, 0xFC,
  0x03, 0x3F, 0x80, 0xCE, 0x00, 0x1B, 0x80, 0x03, 0x60, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0x80, 0x60, 0x38, 0x01,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x04, 0x00, 0xF0, 0x30, 0x0F, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x7F, 0xF1, 0xFF, 0x80, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x06,
  0x00, 0x1C, 0x18, 0x00, 0x60, 0xE0, 0x01, 0x83, 0x80, 0x0E, 0x0E, 0x00,
  0x38, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x07, 0x00, 0x0C, 0x1C, 0x00, 0x70,
  0x60, 0x01, 0xC1, 0x80, 0x06, 0x06, 0x00, 0x18, 0x38, 0x00, 0xE0, 0xE0,
  0x03, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x30, 0x70, 0x00, 0xC1, 0xC0, 0x07,
  0x07, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x60, 0x01, 0x83, 0x80, 0x0E, 0x0E,
  0x00, 0x38, 0x38, 0x00, 0xE0, 0xC0, 0x07, 0x03, 0x00, 0x1C, 0x0C, 0x00,
  0xF0, 0x30, 0x06, 0xC0, 0xE0, 0x1F, 0x03, 0x81, 0xD8, 0x07, 0xFE, 0x60,
  0x0F, 0xF1, 0x80, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x3B, 0x00,
  0x07, 0x60, 0x00, 0xCC, 0x00, 0x39, 0x80, 0x06, 0x30, 0x01, 0xC6, 0x00,
  0x30, 0xC0, 0x0E, 0x18, 0x01, 0xC3, 0x00, 0x30, 0x60, 0x0E, 0x0C, 0x01,
  0x81, 0x80, 0x70, 0x30, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x1C,
  0x03, 0x03, 0x80, 0x60, 0x60, 0x0C, 0x1C, 0x01, 0x83, 0x00, 0x30, 0xE0,
  0x06, 0x18, 0x00, 0xC7, 0x00, 0x18, 0xE0, 0x03, 0x18, 0x00, 0x67, 0x00,
  0x0C, 0xC0, 0x01, 0xB8, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0xE0, 0x03, 0xC0, 0x0E, 0xE0, 0x03, 0xC0, 0x0E, 0xE0, 0x03, 0xC0, 0x0C,
  0xE0, 0x07, 0xC0, 0x1C, 0xE0, 0x07, 0x80, 0x18, 0xE0, 0x0F, 0x80, 0x18,
  0xE0, 0x0D, 0x80, 0x38, 0xE0, 0x0D, 0x80, 0x30, 0xE0, 0x19, 0x80, 0x70,
  0xC0, 0x19, 0x80, 0x60, 0xC0, 0x39, 0x80, 0x60, 0xC0, 0x31, 0x80, 0xE0,
  0xC0, 0x71, 0x80, 0xC0, 0xC0, 0x61, 0x81, 0xC0, 0xC0, 0x61, 0x81, 0x80,
  0xC0, 0xE1, 0x81, 0x80, 0xC0, 0xC1, 0x83, 0x80, 0xC1, 0xC1, 0x83, 0x00,
  0xC1, 0x81, 0x83, 0x00, 0xC1, 0x81, 0x86, 0x00, 0xC3, 0x81, 0x86, 0x00,
  0xC3, 0x01, 0x8E, 0x00, 0xC7, 0x01, 0x8C, 0x00, 0xC6, 0x01, 0x8C, 0x00,
  0xC6, 0x01, 0x9C, 0x00, 0xCE, 0x01, 0x98, 0x00, 0xCC, 0x01, 0xB8, 0x00,
  0xDC, 0x01, 0xB0, 0x00, 0xD8, 0x01, 0xB0, 0x00, 0xD8, 0x01, 0xF0, 0x00,
  0xF8, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x30, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0xE0,
  0x03, 0x80, 0xE0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x70, 0x00, 0x30, 0x30,
  0x00, 0x1C, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x18, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0x60, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x9C, 0x00, 0x01, 0x8E, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0x60, 0x00,
  0x60, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x06, 0x00, 0x38, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x18, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x60, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x03, 0x80, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x20, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x08,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x3F, 0xF0, 0x01, 0x78, 0xFC, 0x07,
  0xE0, 0x1F, 0x1E, 0x80, 0x07, 0xFC, 0x80, 0x01, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 14, 49, 14, 1, -49 },
  { 87, 14, 18, 19, 7, -49 },
  { 119, 27, 49, 26, 0, -49 },
  { 285, 26, 56, 24, -1, -52 },
  { 467, 31, 50, 37, 3, -49 },
  { 661, 23, 50, 23, -1, -49 },
  { 805, 6, 18, 10, 7, -49 },
  { 819, 18, 59, 17, 2, -48 },
  { 952, 19, 59, 17, -5, -48 },
  { 1093, 17, 20, 22, 8, -52 },
  { 1136, 24, 32, 28, 2, -40 },
  { 1232, 9, 15, 11, -3, -6 },
  { 1249, 15, 3, 18, 1, -20 },
  { 1255, 4, 5, 11, 1, -5 },
  { 1258, 28, 48, 20, -3, -48 },
  { 1426, 23, 50, 24, 1, -49 },
  { 1570, 13, 49, 24, 7, -49 },
  { 1650, 26, 49, 24, -2, -49 },
  { 1810, 26, 50, 24, -2, -49 },
  { 1973, 25, 49, 24, -1, -49 },
  { 2127, 26, 50, 24, -2, -49 },
  { 2290, 24, 50, 24, 2, -49 },
  { 2440, 25, 49, 24, 2, -49 },
  { 2594, 26, 50, 24, -1, -49 },
  { 2757, 24, 50, 24, 0, -49 },
  { 2907, 11, 36, 11, 0, -36 },
  { 2957, 14, 45, 11, -3, -36 },
  { 3036, 24, 28, 28, 2, -38 },
  { 3120, 24, 17, 28, 2, -32 },
  { 3171, 24, 28, 28, 2, -38 },
  { 3255, 19, 49, 17, 1, -49 },
  { 3372, 33, 55, 36, 2, -49 },
  { 3599, 24, 49, 23, -5, -49 },
  { 3746, 27, 49, 26, 0, -49 },
  { 3912, 26, 50, 24, 3, -49 },
  { 4075, 27, 49, 29, 0, -49 },
  { 4241, 26, 49, 23, 0, -49 },
  { 4401, 26, 49, 22, 0, -49 },
  { 4561, 31, 50, 31, 2, -49 },
  { 4755, 32, 49, 31, 0, -49 },
  { 4951, 21, 49, 13, -4, -49 },
  { 5080, 23, 61, 11, -10, -49 },
  { 5256, 29, 49, 24, 0, -49 },
  { 5434, 16, 49, 21, 0, -49 },
  { 5532, 42, 49, 41, 0, -49 },
  { 5790, 33, 49, 32, 0, -49 },
  { 5993, 28, 50, 31, 2, -49 },
  { 6168, 26, 49, 25, 0, -49 },
  { 6328, 28, 61, 31, 2, -49 },
  { 6542, 26, 49, 25, 0, -49 },
  { 6702, 28, 50, 24, -2, -49 },
  { 6877, 22, 49, 21, 4, -49 },
  { 7012, 29, 50, 29, 2, -49 },
  { 7194, 24, 49, 24, 6, -49 },
  { 7341, 41, 49, 41, 5, -49 },
  { 7593, 30, 49, 22, -4, -49 },
  { 7777, 22, 49, 21, 4, -49 },
  { 7912, 28, 49, 21, -3, -49 },
  { 8084, 24, 60, 19, -1, -49 },
  { 8264, 9, 49, 22, 7, -49 },
  { 8320, 24, 60, 19, -4, -49 },
  { 8500, 25, 23, 27, 1, -48 },
  { 8572, 18, 2, 18, -5, 6 },
  { 8577, 7, 11, 15, 10, -52 },
  { 8587, 24, 38, 26, 2, -37 },
  { 8701, 24, 53, 26, 0, -52 },
  { 8860, 19, 38, 19, 2, -37 },
  { 8951, 27, 53, 26, 2, -52 },
  { 9130, 20, 38, 23, 2, -37 },
  { 9225, 30, 68, 13, -9, -52 },
  { 9480, 27, 53, 26, -1, -37 },
  { 9659, 23, 52, 25, 0, -52 },
  { 9809, 13, 49, 11, 0, -49 },
  { 9889, 23, 65, 11, -9, -49 },
  { 10076, 24, 52, 21, 0, -52 },
  { 10232, 14, 52, 11, 0, -52 },
  { 10323, 36, 37, 38, 0, -37 },
  { 10490, 23, 37, 25, 0, -37 },
  { 10597, 21, 38, 25, 2, -37 },
  { 10697, 27, 53, 26, -3, -37 },
  { 10876, 24, 53, 26, 2, -37 },
  { 11035, 19, 37, 16, 0, -37 },
  { 11123, 21, 38, 19, -1, -37 },
  { 11223, 14, 46, 13, 1, -45 },
  { 11304, 22, 37, 25, 2, -36 },
  { 11406, 19, 36, 19, 4, -36 },
  { 11492, 32, 36, 32, 4, -36 },
  { 11636, 25, 36, 20, -3, -36 },
  { 11749, 32, 53, 21, -8, -36 },
  { 11961, 21, 36, 16, -2, -36 },
  { 12056, 24, 60, 21, 2, -49 },
  { 12236, 3, 69, 24, 10, -52 },
  { 12262, 23, 60, 21, -4, -49 },
  { 12435, 24, 6, 28, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC68PT7B_H_
