#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC59PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x38, 0x33, 0x87, 0x30, 0x63, 0x06, 0x30, 0x67,
  0x06, 0x60, 0xE6, 0x0C, 0x60, 0xC6, 0x0C, 0xC0, 0xCC, 0x08, 0xC1, 0x8C,
  0x18, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x0C, 0x0C, 0x00, 0x30, 0x10, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01,
  0x81, 0x80, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0x18, 0x18, 0x00, 0x60,
  0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x0C,
  0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80,
  0x03, 0x06, 0x00, 0x0C, 0x0C, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x00,
  0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18,
  0x18, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x03,
  0x00, 0x06, 0x04, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80,
  0x38, 0x8F, 0x01, 0x86, 0x08, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x01, 0x81,
  0x00, 0x06, 0x04, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00,
  0x06, 0x08, 0x00, 0x18, 0x60, 0x00, 0x31, 0x80, 0x00, 0xE6, 0x00, 0x01,
  0x98, 0x00, 0x03, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x02, 0xE0, 0x00, 0x19, 0xC0, 0x00, 0x63, 0x00,
  0x01, 0x8E, 0x00, 0x04, 0x18, 0x00, 0x10, 0x60, 0x00, 0xC1, 0x80, 0x03,
  0x06, 0x00, 0x0C, 0x18, 0x00, 0x20, 0x60, 0x01, 0x83, 0x80, 0x06, 0x0C,
  0x00, 0x18, 0x70, 0x20, 0x43, 0x80, 0xF1, 0x7C, 0x03, 0xFF, 0xC0, 0x00,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x80, 0xFC, 0x00, 0xC0, 0x73,
  0x00, 0x30, 0x30, 0xE0, 0x18, 0x1C, 0x18, 0x06, 0x06, 0x06, 0x03, 0x03,
  0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x18, 0x1C, 0x06, 0x0C,
  0x06, 0x03, 0x03, 0x01, 0x80, 0xC1, 0x80, 0x60, 0x30, 0x60, 0x38, 0x0C,
  0x30, 0x0C, 0x03, 0x0C, 0x03, 0x00, 0xC6, 0x00, 0xC0, 0x61, 0x80, 0x30,
  0x18, 0xC1, 0xCC, 0x06, 0x31, 0xFB, 0x03, 0x18, 0xE7, 0xC0, 0xC6, 0x30,
  0xF0, 0x73, 0x18, 0x3C, 0x18, 0xC6, 0x0F, 0x0C, 0x63, 0x03, 0xE7, 0x18,
  0xC0, 0xDF, 0x8C, 0x60, 0x31, 0x83, 0x18, 0x0C, 0x01, 0x86, 0x03, 0x00,
  0x61, 0x80, 0xC0, 0x30, 0xC0, 0x30, 0x0C, 0x30, 0x0C, 0x06, 0x0C, 0x06,
  0x01, 0x83, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x18, 0x18,
  0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x60,
  0x0C, 0x18, 0x18, 0x03, 0x0C, 0x0C, 0x00, 0xE6, 0x03, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFC, 0x00, 0x39, 0xC0, 0x03,
  0x0E, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0xE0, 0x60, 0x0C, 0x06, 0x00,
  0xC0, 0xE0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xC1, 0x80,
  0x0C, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x0E, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xB0,
  0x00, 0x33, 0x00, 0x06, 0x38, 0x00, 0xE1, 0x83, 0x1C, 0x18, 0x31, 0x81,
  0x87, 0x30, 0x1C, 0x63, 0x00, 0xC6, 0x70, 0x0C, 0xE6, 0x00, 0xCC, 0x60,
  0x06, 0xC6, 0x00, 0x78, 0xE0, 0x07, 0x8E, 0x00, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0x70, 0x60, 0x0F, 0x06, 0x01, 0xB8, 0x70, 0x31, 0x83, 0xDF, 0x18,
  0x1F, 0xC1, 0xC0, 0x20, 0x00, 0x39, 0xCC, 0x63, 0x39, 0x8C, 0x63, 0x11,
  0x8C, 0x62, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x08, 0x18, 0x1C, 0x30, 0x1C, 0x40, 0x8E,
  0x9F, 0x07, 0xF8, 0x06, 0x00, 0x3E, 0x00, 0xC4, 0x03, 0x0C, 0x0C, 0x0C,
  0x30, 0x18, 0x00, 0x18, 0x00, 0x20, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x0C, 0x38, 0x60, 0xC3, 0x86, 0x1C, 0x30, 0x61, 0x82,
  0x0C, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x5F, 0xFE, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x01, 0xFC, 0x00, 0x79, 0xC0, 0x06, 0x0E, 0x00, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x30, 0x07, 0x03, 0x00, 0x70, 0x60, 0x07, 0x06, 0x00,
  0x70, 0xE0, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x06, 0x1C, 0x00, 0x61, 0x80,
  0x06, 0x18, 0x00, 0x63, 0x80, 0x06, 0x38, 0x00, 0x63, 0x00, 0x0E, 0x30,
  0x00, 0xE3, 0x00, 0x0C, 0x70, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x01, 0xC6,
  0x00, 0x1C, 0x60, 0x01, 0x86, 0x00, 0x18, 0xE0, 0x03, 0x8E, 0x00, 0x30,
  0xE0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x0E,
  0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0E, 0x01, 0x80, 0x60, 0x38, 0x06, 0x03,
  0x00, 0x70, 0x60, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x40, 0x00, 0x00,
  0x70, 0x1E, 0x03, 0xE0, 0x76, 0x0E, 0xE1, 0xCC, 0x70, 0xC6, 0x0C, 0x41,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xE0, 0x01, 0xF3, 0xE0, 0x03,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x80,
  0x0F, 0x8F, 0x00, 0x70, 0x0E, 0x00, 0x80, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x11, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x80, 0x3C, 0x03, 0xC7,
  0xE0, 0x0F, 0xFE, 0x00, 0x05, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0x60,
  0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x63, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x70, 0x00, 0x61, 0x80, 0x03, 0x86,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83, 0x80, 0x0C, 0x0C, 0x00,
  0x70, 0x30, 0x01, 0x80, 0xC0, 0x0C, 0x07, 0x00, 0x30, 0x18, 0x01, 0x80,
  0x60, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x38, 0x06, 0x00, 0xC0,
  0x30, 0x03, 0x01, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x20, 0x0F, 0x00, 0xFB, 0xF8, 0x03, 0xFF,
  0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x07,
  0x86, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC3, 0xC0, 0x0E, 0x7F, 0x80, 0x67, 0x0E, 0x03, 0x60, 0x38,
  0x1E, 0x00, 0xC1, 0xE0, 0x06, 0x0F, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80,
  0x0E, 0x18, 0x00, 0x70, 0xC0, 0x03, 0x86, 0x00, 0x1C, 0x70, 0x00, 0xC3,
  0x80, 0x06, 0x1C, 0x00, 0x30, 0xE0, 0x01, 0x87, 0x00, 0x1C, 0x38, 0x00,
  0xC1, 0xC0, 0x06, 0x0E, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x38, 0x0E,
  0x03, 0x80, 0x30, 0x38, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x04, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xCF,
  0x80, 0x38, 0x0E, 0x00, 0xC0, 0x1C, 0x07, 0x00, 0x30, 0x18, 0x00, 0xC0,
  0x60, 0x03, 0x03, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0,
  0x03, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x60, 0x18, 0x03, 0x80, 0x60, 0x0C,
  0x01, 0xC0, 0x60, 0x03, 0x03, 0x00, 0x06, 0x38, 0x00, 0x1D, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0xE1, 0x80, 0x07, 0x03,
  0x00, 0x30, 0x0E, 0x01, 0x80, 0x18, 0x0E, 0x00, 0x70, 0x30, 0x00, 0xC1,
  0xC0, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xE0, 0x00, 0xE3, 0x80,
  0x03, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xE0, 0x00, 0xC1, 0x80, 0x07,
  0x06, 0x00, 0x18, 0x1C, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x7D, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFC, 0x00, 0xF9,
  0xE0, 0x0C, 0x06, 0x01, 0x80, 0x70, 0x38, 0x03, 0x03, 0x00, 0x30, 0x70,
  0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x0E, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x03, 0x1C, 0x00, 0x31, 0xC0, 0x03, 0x18, 0x00, 0x31,
  0x80, 0x07, 0x18, 0x00, 0x71, 0x80, 0x07, 0x1C, 0x00, 0xF1, 0xC0, 0x1E,
  0x0C, 0x01, 0xE0, 0xE0, 0x36, 0x07, 0x8E, 0xE0, 0x3F, 0xCC, 0x00, 0xE0,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x0E,
  0xFC, 0x00, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x0E, 0x0F, 0x07, 0x03, 0x80, 0x00, 0x30, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xE0, 0x07, 0xFC, 0x0F, 0x1E, 0x04, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x30, 0x00, 0x18,
  0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x18,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x1F,
  0xC1, 0x86, 0x01, 0xEE, 0x0C, 0x30, 0x18, 0x30, 0x61, 0x81, 0x83, 0x03,
  0x18, 0x1C, 0x18, 0x18, 0xC0, 0xC0, 0xC0, 0xC6, 0x0E, 0x06, 0x06, 0x60,
  0x60, 0x60, 0x63, 0x03, 0x03, 0x03, 0x18, 0x30, 0x18, 0x18, 0xC1, 0x80,
  0xC0, 0xCC, 0x0C, 0x0C, 0x04, 0x60, 0x60, 0x60, 0x63, 0x06, 0x03, 0x03,
  0x18, 0x30, 0x38, 0x18, 0xC1, 0x81, 0x81, 0x86, 0x0C, 0x0C, 0x0C, 0x30,
  0x60, 0xE0, 0x41, 0x83, 0x07, 0x06, 0x08, 0x18, 0x78, 0x60, 0xC0, 0xC2,
  0x43, 0x06, 0x03, 0xF3, 0xF0, 0x30, 0x1F, 0x1F, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x20, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xB0, 0x00, 0x1B, 0x00, 0x01, 0xB0, 0x00,
  0x33, 0x00, 0x03, 0x30, 0x00, 0x73, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00,
  0x0C, 0x30, 0x00, 0xC3, 0x00, 0x1C, 0x30, 0x01, 0x83, 0x00, 0x18, 0x30,
  0x03, 0x03, 0x00, 0x30, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0x80,
  0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x70, 0x03, 0x06, 0x00, 0x30, 0xE0,
  0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x1C, 0x00, 0x31, 0x80, 0x03, 0x38,
  0x00, 0x33, 0x00, 0x03, 0x70, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x3E,
  0x00, 0x03, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0x80, 0xE0, 0x06,
  0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x30, 0x01, 0x80, 0xE0,
  0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x38, 0x0C, 0x00,
  0x70, 0x38, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x06, 0x01, 0x80, 0x1C,
  0x03, 0x00, 0x30, 0x0E, 0x01, 0xC0, 0x18, 0x0F, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x30, 0x06, 0x00, 0x70, 0x0C,
  0x00, 0x60, 0x18, 0x00, 0xC0, 0x70, 0x01, 0xC0, 0xC0, 0x03, 0x81, 0x80,
  0x07, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x30, 0x00,
  0x60, 0x60, 0x01, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x0E, 0x07, 0x00, 0x18,
  0x0C, 0x00, 0x70, 0x18, 0x01, 0xC0, 0x30, 0x0F, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0x78,
  0x01, 0xC0, 0x20, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3F, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x1C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x06, 0x01, 0xC0, 0x06, 0x01, 0x80,
  0x07, 0x01, 0x80, 0x07, 0x01, 0x80, 0x07, 0x01, 0x80, 0x07, 0x03, 0x80,
  0x07, 0x03, 0x00, 0x07, 0x03, 0x00, 0x07, 0x03, 0x00, 0x07, 0x03, 0x00,
  0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x0C, 0x00,
  0x0C, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x38, 0x18, 0x00, 0x30, 0x38, 0x00, 0x70, 0x30, 0x00,
  0x60, 0x30, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x70, 0x01, 0x80, 0x60, 0x03,
  0x80, 0x60, 0x07, 0x00, 0x60, 0x1E, 0x00, 0x60, 0x78, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x01, 0xF8, 0x7C, 0x00, 0xF0, 0x03, 0x00, 0x70, 0x00, 0x40, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x1F, 0xE1, 0x80, 0x0F, 0xF0,
  0xE0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x18, 0x03, 0x00, 0x06,
  0x00, 0xE0, 0x01, 0x80, 0x1E, 0x00, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C,
  0x03, 0x80, 0x01, 0x80, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x0C, 0x01, 0x80,
  0x01, 0x80, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x01, 0x80, 0x01, 0xC0,
  0x30, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x38, 0x00,
  0x18, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x03,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0xE0, 0x18, 0x00, 0x18, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x1C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x70, 0x00, 0x70,
  0x0C, 0x00, 0x0E, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x30, 0x06, 0x00,
  0x06, 0x01, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0xC0, 0x38, 0x00, 0x18, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x60, 0x18,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x60, 0x03, 0x80, 0x30, 0x01,
  0x80, 0x38, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0xC0, 0x03, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0x80, 0x60, 0x00, 0xC0,
  0x60, 0x00, 0x60, 0x70, 0x00, 0x30, 0x70, 0x00, 0x38, 0x30, 0x00, 0x18,
  0x38, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x6F, 0x00, 0x00,
  0x7D, 0xC0, 0x00, 0x34, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x18, 0x00,
  0x06, 0x0C, 0x00, 0x07, 0x07, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x30, 0x06,
  0x00, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0E, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x07, 0x00, 0xE0,
  0x03, 0x80, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x36, 0x00,
  0xF0, 0x00, 0x03, 0x60, 0x1D, 0x80, 0x00, 0x6E, 0x01, 0x98, 0x00, 0x06,
  0xC0, 0x19, 0x80, 0x00, 0xEC, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x19, 0x80,
  0x01, 0xCC, 0x03, 0x98, 0x00, 0x19, 0xC0, 0x31, 0x80, 0x03, 0x98, 0x03,
  0x18, 0x00, 0x31, 0x80, 0x31, 0x80, 0x07, 0x18, 0x03, 0x18, 0x00, 0x61,
  0x80, 0x61, 0x80, 0x0E, 0x38, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x61, 0x80,
  0x0C, 0x30, 0x06, 0x18, 0x01, 0x83, 0x00, 0xE1, 0x80, 0x18, 0x70, 0x0C,
  0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x06, 0x06,
  0x00, 0xC1, 0x80, 0x60, 0x60, 0x1C, 0x1C, 0x0C, 0x0E, 0x01, 0x81, 0xC0,
  0xC0, 0xC0, 0x18, 0x0C, 0x1C, 0x0C, 0x01, 0x80, 0xC1, 0x80, 0xC0, 0x18,
  0x0C, 0x38, 0x0C, 0x03, 0x00, 0xC3, 0x01, 0xC0, 0x30, 0x0C, 0x70, 0x18,
  0x03, 0x00, 0xC6, 0x01, 0x80, 0x30, 0x0C, 0xE0, 0x18, 0x07, 0x00, 0xCC,
  0x01, 0x80, 0x60, 0x0D, 0xC0, 0x30, 0x06, 0x00, 0xD8, 0x03, 0x00, 0x60,
  0x0D, 0x80, 0x30, 0x06, 0x00, 0xF0, 0x03, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x01,
  0x80, 0x3C, 0x00, 0x0C, 0x01, 0xE0, 0x00, 0x60, 0x0F, 0x80, 0x03, 0x00,
  0x6C, 0x00, 0x38, 0x03, 0x60, 0x01, 0x80, 0x3B, 0x00, 0x0C, 0x01, 0x98,
  0x00, 0x60, 0x0C, 0xC0, 0x07, 0x00, 0x63, 0x00, 0x30, 0x03, 0x18, 0x01,
  0x80, 0x38, 0xC0, 0x0C, 0x01, 0x86, 0x00, 0x60, 0x0C, 0x30, 0x07, 0x00,
  0x61, 0xC0, 0x30, 0x03, 0x06, 0x01, 0x80, 0x38, 0x30, 0x0C, 0x01, 0x81,
  0x80, 0x60, 0x0C, 0x0C, 0x07, 0x00, 0x60, 0x60, 0x30, 0x07, 0x01, 0x81,
  0x80, 0x30, 0x0C, 0x0C, 0x01, 0x80, 0x60, 0x60, 0x0C, 0x03, 0x06, 0x00,
  0x60, 0x18, 0x30, 0x07, 0x00, 0xE1, 0x80, 0x30, 0x03, 0x0C, 0x01, 0x80,
  0x18, 0xE0, 0x0C, 0x00, 0xC6, 0x00, 0x60, 0x06, 0x30, 0x07, 0x00, 0x31,
  0x80, 0x30, 0x01, 0xCC, 0x01, 0x80, 0x06, 0xE0, 0x0C, 0x00, 0x36, 0x00,
  0xE0, 0x01, 0xB0, 0x06, 0x00, 0x0D, 0x80, 0x30, 0x00, 0x7C, 0x01, 0x80,
  0x01, 0xE0, 0x0C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x06, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x78, 0x00,
  0x70, 0x1C, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x06, 0x01, 0x80, 0x06, 0x03,
  0x00, 0x06, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C,
  0x00, 0x07, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x07, 0x18,
  0x00, 0x06, 0x38, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x70, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0xC0, 0xE0, 0x01, 0xC0, 0x60, 0x01, 0x80, 0x60, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x0E, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x0E, 0x07, 0x00, 0x38,
  0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x70, 0x03,
  0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x03,
  0x80, 0x0C, 0x0C, 0x00, 0x70, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00,
  0x38, 0x1C, 0x00, 0xC0, 0x60, 0x07, 0x01, 0x80, 0x38, 0x06, 0x01, 0xC0,
  0x38, 0x1E, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x70, 0x1C, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x06, 0x01, 0x80, 0x06, 0x03, 0x00, 0x06, 0x07, 0x00,
  0x07, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x0C, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x07, 0x18, 0x00, 0x07, 0x38, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x70, 0x00,
  0x06, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x70, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xC0, 0xE0, 0x01,
  0xC0, 0x60, 0x01, 0x80, 0x60, 0x03, 0x00, 0x70, 0x07, 0x00, 0x38, 0x0E,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x0E, 0x07, 0x00, 0x38, 0x0E,
  0x00, 0xC0, 0x1C, 0x03, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x70, 0x03, 0x01,
  0x80, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x80,
  0x1C, 0x0C, 0x00, 0x70, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x38,
  0x1C, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x38, 0x06, 0x03, 0xC0, 0x3F,
  0xFE, 0x00, 0xFF, 0xE0, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x70,
  0x01, 0xC1, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x01,
  0x80, 0xC0, 0x0E, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x1C, 0x01, 0x80, 0x60, 0x07, 0x01, 0x80, 0x1C, 0x06, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x3E, 0x1F, 0x00, 0x78, 0x02, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x0F, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x05, 0xC0, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x03, 0x81,
  0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x18, 0x00, 0x38, 0x1C, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06,
  0x03, 0x00, 0x03, 0x01, 0x80, 0x03, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x70, 0x38, 0x00, 0x30, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x80,
  0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xE0, 0x30,
  0x00, 0x60, 0x38, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x0E, 0x07, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80,
  0xC0, 0x01, 0xC0, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x70,
  0x0C, 0x00, 0x30, 0x07, 0x00, 0x38, 0x01, 0x80, 0x38, 0x00, 0xE0, 0x38,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0xCC, 0x00, 0x0E,
  0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00,
  0x1C, 0x30, 0x00, 0xC1, 0x80, 0x0E, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x03,
  0x00, 0x38, 0x18, 0x01, 0x80, 0xC0, 0x1C, 0x06, 0x00, 0xC0, 0x30, 0x0E,
  0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x38, 0x03, 0x01, 0x80, 0x18,
  0x1C, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00,
  0x0C, 0x38, 0x00, 0x61, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xC6,
  0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0xB8, 0x00, 0x0D, 0x80, 0x00,
  0x6C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x36, 0x00, 0x07, 0x00, 0x07, 0x60,
  0x00, 0x70, 0x00, 0x66, 0x00, 0x0F, 0x00, 0x0E, 0x60, 0x00, 0xF0, 0x00,
  0xC6, 0x00, 0x1B, 0x00, 0x0C, 0x60, 0x01, 0xB0, 0x01, 0xC6, 0x00, 0x1B,
  0x00, 0x18, 0x60, 0x03, 0x30, 0x03, 0x86, 0x00, 0x32, 0x00, 0x30, 0x60,
  0x07, 0x20, 0x03, 0x06, 0x00, 0x66, 0x00, 0x70, 0x60, 0x06, 0x60, 0x06,
  0x06, 0x00, 0xC6, 0x00, 0xE0, 0x60, 0x0C, 0x60, 0x0C, 0x06, 0x01, 0xC6,
  0x00, 0xC0, 0x60, 0x18, 0x60, 0x1C, 0x06, 0x01, 0x86, 0x01, 0x80, 0x60,
  0x30, 0x60, 0x18, 0x06, 0x03, 0x06, 0x03, 0x00, 0x60, 0x30, 0x60, 0x30,
  0x06, 0x06, 0x06, 0x07, 0x00, 0x60, 0x60, 0x60, 0x60, 0x06, 0x0C, 0x06,
  0x06, 0x00, 0x60, 0xC0, 0x60, 0xC0, 0x06, 0x0C, 0x06, 0x0C, 0x00, 0x61,
  0x80, 0x61, 0xC0, 0x06, 0x18, 0x06, 0x18, 0x00, 0x63, 0x80, 0x61, 0x80,
  0x06, 0x30, 0x06, 0x30, 0x00, 0xE3, 0x00, 0x63, 0x00, 0x0E, 0x60, 0x06,
  0x70, 0x00, 0xE6, 0x00, 0x66, 0x00, 0x0E, 0xE0, 0x06, 0x60, 0x00, 0xCC,
  0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x7C, 0x00,
  0x0D, 0x80, 0x05, 0x80, 0x00, 0xD8, 0x00, 0x58, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x30, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x0C,
  0x00, 0x38, 0x06, 0x00, 0x06, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60,
  0x70, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0E, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x07, 0x30, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x0E, 0x60, 0x00, 0x03, 0x1C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0xC0, 0x30, 0x00, 0x70, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x0C,
  0x00, 0xE0, 0x03, 0x00, 0x38, 0x01, 0x80, 0x06, 0x00, 0xE0, 0x01, 0x80,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xEC, 0x00, 0x19, 0x80, 0x06, 0x30,
  0x00, 0xC6, 0x00, 0x30, 0xE0, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x03, 0x00, 0x60,
  0x60, 0x0C, 0x18, 0x01, 0x87, 0x00, 0x30, 0xC0, 0x03, 0x38, 0x00, 0x66,
  0x00, 0x0D, 0xC0, 0x01, 0xB0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x60,
  0x60, 0x60, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x66, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83,
  0x80, 0x0C, 0x06, 0x00, 0x30, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x30, 0x03, 0x80, 0xC0, 0x06, 0x06, 0x00, 0x1C, 0x38, 0x00, 0x30, 0xC0,
  0x00, 0xE7, 0x00, 0x01, 0x98, 0x00, 0x06, 0xE0, 0x00, 0x1C, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC3, 0x06, 0x18, 0x30, 0xC1, 0x06, 0x0C, 0x00, 0x1C, 0x00,
  0x0F, 0xE3, 0x01, 0xE7, 0x30, 0x38, 0x1B, 0x07, 0x00, 0xB0, 0xE0, 0x0E,
  0x0C, 0x00, 0xE1, 0xC0, 0x0E, 0x18, 0x00, 0xE3, 0x80, 0x0E, 0x30, 0x00,
  0xC3, 0x00, 0x0C, 0x70, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x01, 0xC6, 0x00,
  0x18, 0xE0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00, 0x30, 0xC0,
  0x03, 0x0C, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x0E, 0x0C,
  0x00, 0xE0, 0xC0, 0x1E, 0x0C, 0x01, 0x60, 0xE0, 0x36, 0x06, 0x06, 0xC0,
  0x7F, 0xCC, 0x03, 0xF8, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC3, 0xC0, 0x06, 0x7F, 0x80,
  0x77, 0x1E, 0x03, 0x60, 0x70, 0x1B, 0x01, 0x80, 0xF0, 0x0E, 0x07, 0x00,
  0x30, 0x78, 0x01, 0x83, 0x80, 0x0C, 0x1C, 0x00, 0x60, 0xC0, 0x03, 0x06,
  0x00, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x70, 0xC0, 0x03,
  0x06, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x60, 0xC0,
  0x03, 0x0E, 0x00, 0x18, 0x70, 0x01, 0xC3, 0x80, 0x0C, 0x1C, 0x00, 0xE0,
  0xE0, 0x06, 0x0F, 0x00, 0x70, 0x78, 0x03, 0x03, 0x40, 0x38, 0x1B, 0x03,
  0x80, 0x8E, 0xF8, 0x0C, 0x7F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0xFF, 0x01, 0xE3, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7D, 0xE0, 0x3F,
  0xE0, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x03, 0x86, 0x00, 0x3F, 0x8C, 0x00, 0xF3,
  0x98, 0x03, 0x81, 0xB0, 0x0E, 0x01, 0x60, 0x38, 0x03, 0x80, 0x60, 0x07,
  0x01, 0xC0, 0x0E, 0x03, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x18, 0x00, 0x60,
  0x30, 0x00, 0xC0, 0xE0, 0x01, 0x81, 0x80, 0x07, 0x03, 0x00, 0x0E, 0x06,
  0x00, 0x18, 0x1C, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x01, 0xC0, 0xC0,
  0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x38, 0x0C, 0x00,
  0x70, 0x18, 0x01, 0xC0, 0x30, 0x03, 0x80, 0x60, 0x0F, 0x00, 0xC0, 0x16,
  0x01, 0xC0, 0x6C, 0x01, 0x81, 0xB0, 0x03, 0xFE, 0x60, 0x03, 0xF8, 0xC0,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x7F, 0x00, 0x71, 0xC0, 0x70,
  0x70, 0x70, 0x18, 0x70, 0x0C, 0x30, 0x06, 0x30, 0x03, 0x18, 0x03, 0x98,
  0x01, 0x8C, 0x01, 0xCE, 0x00, 0xC6, 0x00, 0xE3, 0x00, 0xE1, 0x81, 0xE1,
  0xFF, 0xC0, 0xFF, 0x80, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x81, 0xF3, 0xC0, 0x3F, 0xE0,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x71,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0x8C, 0x00, 0xF3, 0x98,
  0x03, 0x81, 0xB0, 0x0E, 0x01, 0x60, 0x38, 0x03, 0x80, 0x60, 0x07, 0x01,
  0xC0, 0x0E, 0x03, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x18, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0xE0, 0x01, 0x81, 0x80, 0x07, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0x18, 0x1C, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x01, 0xC0, 0xC0, 0x03,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x70,
  0x18, 0x01, 0xC0, 0x30, 0x03, 0x80, 0x60, 0x0F, 0x00, 0xC0, 0x16, 0x01,
  0xC0, 0x7C, 0x01, 0x81, 0xB0, 0x03, 0xFE, 0x60, 0x03, 0xF8, 0xC0, 0x00,
  0x81, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x02, 0x00, 0x60, 0x06, 0x03, 0x80, 0x0F, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x78, 0x01, 0x9F, 0xE0, 0x1B, 0x8E, 0x03, 0x60, 0x70, 0x3C,
  0x03, 0x03, 0x80, 0x30, 0x38, 0x03, 0x03, 0x00, 0x30, 0x70, 0x03, 0x07,
  0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0xE0, 0x06, 0x0C, 0x00, 0x60,
  0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x1C, 0x00, 0xC1, 0x80, 0x1C,
  0x18, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x83, 0x80, 0x18, 0x30, 0x03,
  0x83, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00,
  0x70, 0x60, 0x06, 0x06, 0x00, 0x60, 0xE0, 0x06, 0x00, 0x00, 0x60, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x30, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x30, 0x1C, 0x03, 0x01, 0x80, 0x30, 0x30, 0x07, 0x06,
  0x00, 0x60, 0xE0, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0xE7,
  0x00, 0x0C, 0xE0, 0x00, 0xCF, 0x00, 0x0D, 0xB0, 0x00, 0xF3, 0x00, 0x1E,
  0x30, 0x01, 0xE3, 0x00, 0x1C, 0x30, 0x01, 0x83, 0x80, 0x38, 0x18, 0x03,
  0x01, 0x80, 0x30, 0x18, 0x03, 0x01, 0x80, 0x30, 0x18, 0x07, 0x01, 0xC0,
  0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x0C,
  0x00, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0xF0, 0x03, 0x3F, 0x87, 0xF8, 0x0C, 0xE3, 0x9C, 0x78, 0x1B, 0x03, 0x60,
  0x70, 0x3C, 0x07, 0x80, 0x60, 0x70, 0x0F, 0x00, 0xC0, 0xE0, 0x1C, 0x01,
  0x83, 0x80, 0x38, 0x03, 0x07, 0x00, 0x60, 0x06, 0x0C, 0x00, 0xC0, 0x1C,
  0x18, 0x01, 0x80, 0x30, 0x30, 0x07, 0x00, 0x60, 0xE0, 0x0C, 0x00, 0xC1,
  0x80, 0x18, 0x01, 0x83, 0x00, 0x30, 0x07, 0x06, 0x00, 0x60, 0x0C, 0x0C,
  0x01, 0xC0, 0x18, 0x38, 0x03, 0x00, 0x30, 0x60, 0x06, 0x00, 0x60, 0xC0,
  0x0C, 0x01, 0xC1, 0x80, 0x18, 0x03, 0x07, 0x00, 0x70, 0x06, 0x0C, 0x00,
  0xC0, 0x0C, 0x18, 0x01, 0x80, 0x18, 0x30, 0x03, 0x00, 0x70, 0x60, 0x0E,
  0x00, 0xC1, 0xC0, 0x18, 0x01, 0x83, 0x00, 0x30, 0x03, 0x06, 0x00, 0x60,
  0x06, 0x0C, 0x00, 0xC0, 0x18, 0x18, 0x03, 0x80, 0x30, 0x70, 0x06, 0x00,
  0x60, 0x00, 0x07, 0x80, 0x19, 0xFE, 0x03, 0x38, 0xE0, 0x36, 0x07, 0x03,
  0xC0, 0x30, 0x38, 0x03, 0x03, 0x80, 0x30, 0x70, 0x03, 0x07, 0x00, 0x70,
  0x70, 0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x0E, 0x00, 0x60, 0xC0, 0x0E,
  0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xC1, 0xC0, 0x0C, 0x18, 0x01,
  0xC1, 0x80, 0x18, 0x18, 0x01, 0x83, 0x80, 0x18, 0x30, 0x01, 0x83, 0x00,
  0x38, 0x30, 0x03, 0x03, 0x00, 0x30, 0x70, 0x03, 0x06, 0x00, 0x70, 0x60,
  0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x0E, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x3F, 0xC0, 0x1C, 0x78, 0x0C, 0x06, 0x06, 0x01, 0xC3, 0x80, 0x70, 0xC0,
  0x0C, 0x60, 0x03, 0x18, 0x00, 0xCE, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03,
  0x70, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x1D, 0x80, 0x07, 0xE0, 0x01, 0xB0,
  0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03, 0xB0, 0x00, 0xCC, 0x00,
  0x33, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x8C, 0x00, 0xC3, 0x00, 0x70,
  0xE0, 0x38, 0x18, 0x1C, 0x07, 0xDE, 0x00, 0xFF, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0xC7, 0xF0, 0x01, 0x38, 0xF0, 0x06, 0x60, 0xE0,
  0x0D, 0x80, 0xC0, 0x1E, 0x01, 0xC0, 0x38, 0x01, 0x80, 0xF0, 0x03, 0x01,
  0xC0, 0x06, 0x03, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x38,
  0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x81, 0x80, 0x06, 0x03, 0x00,
  0x0C, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0xE0, 0x60, 0x01,
  0x80, 0xC0, 0x03, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x18, 0x0E, 0x00, 0x70,
  0x1C, 0x00, 0xC0, 0x78, 0x03, 0x80, 0xF0, 0x06, 0x01, 0xA0, 0x1C, 0x03,
  0x60, 0x70, 0x06, 0x77, 0xC0, 0x1C, 0xFE, 0x00, 0x30, 0x60, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x0F, 0xE3, 0x01, 0xE7, 0x30, 0x38, 0x1B, 0x07,
  0x01, 0xB0, 0xE0, 0x0E, 0x0C, 0x00, 0xE1, 0xC0, 0x0E, 0x18, 0x00, 0xE3,
  0x80, 0x0E, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x70, 0x00, 0xC6, 0x00, 0x0C,
  0x60, 0x01, 0xC6, 0x00, 0x18, 0xE0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01,
  0x8C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00,
  0x70, 0xC0, 0x0E, 0x0C, 0x00, 0xE0, 0xC0, 0x1E, 0x0C, 0x01, 0x60, 0xE0,
  0x3E, 0x06, 0x06, 0xC0, 0x7F, 0xCC, 0x03, 0xF8, 0xC0, 0x04, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x07, 0x80, 0xCF,
  0xC0, 0xCF, 0x20, 0x6C, 0x00, 0x34, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x1C, 0x3C, 0x0C,
  0x02, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x20, 0x1C, 0x0F,
  0xBF, 0x01, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x1F, 0xF3, 0xFE, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0F, 0x40, 0x7C, 0x01, 0x80, 0x06, 0x00, 0x61, 0xC0, 0x0C,
  0x30, 0x03, 0x86, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x87, 0x00, 0x30,
  0xC0, 0x0E, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x18, 0x00, 0xC3,
  0x00, 0x38, 0x60, 0x06, 0x0C, 0x00, 0xC3, 0x80, 0x18, 0x60, 0x03, 0x0C,
  0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x0E, 0x00, 0x61, 0x80, 0x1C, 0x30,
  0x03, 0x06, 0x00, 0x60, 0xC0, 0x1C, 0x18, 0x03, 0x83, 0x00, 0xF0, 0x60,
  0x3C, 0x0C, 0x0D, 0x81, 0xEF, 0xB0, 0x1F, 0xC6, 0x00, 0x40, 0x00, 0xC0,
  0x03, 0xE0, 0x01, 0xB0, 0x01, 0xD8, 0x00, 0xCC, 0x00, 0xE6, 0x00, 0x63,
  0x80, 0x31, 0xC0, 0x30, 0xE0, 0x18, 0x70, 0x18, 0x38, 0x0C, 0x1C, 0x0E,
  0x0E, 0x06, 0x07, 0x07, 0x03, 0x83, 0x01, 0xC1, 0x80, 0xE1, 0x80, 0x70,
  0xC0, 0x18, 0xE0, 0x0C, 0x60, 0x06, 0x70, 0x03, 0x30, 0x01, 0x98, 0x00,
  0xD8, 0x00, 0x6C, 0x00, 0x3C, 0x00, 0x16, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0x60, 0x07, 0x00, 0x76, 0x00, 0x70, 0x06,
  0x60, 0x0F, 0x00, 0x66, 0x00, 0xF0, 0x0C, 0x60, 0x0B, 0x00, 0xC6, 0x01,
  0xB0, 0x1C, 0x60, 0x1B, 0x01, 0x86, 0x03, 0x30, 0x18, 0x60, 0x33, 0x03,
  0x06, 0x07, 0x30, 0x30, 0x60, 0x63, 0x03, 0x06, 0x06, 0x30, 0x60, 0x60,
  0xC2, 0x06, 0x06, 0x0C, 0x20, 0xC0, 0x61, 0x82, 0x0C, 0x06, 0x18, 0x20,
  0xC0, 0x61, 0x82, 0x18, 0x06, 0x30, 0x21, 0x80, 0x63, 0x06, 0x30, 0x06,
  0x60, 0x63, 0x00, 0x66, 0x06, 0x30, 0x0C, 0x60, 0x66, 0x00, 0xCC, 0x06,
  0x60, 0x0C, 0xC0, 0x66, 0x00, 0xD8, 0x06, 0xC0, 0x0D, 0x80, 0x6C, 0x00,
  0xD8, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x0E, 0x00,
  0x70, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x38, 0x0C, 0x00, 0x60, 0x70, 0x01, 0x81, 0x80, 0x06,
  0x0C, 0x00, 0x18, 0x70, 0x00, 0x61, 0x80, 0x00, 0xCE, 0x00, 0x03, 0x30,
  0x00, 0x0D, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x0C, 0xC0, 0x00, 0x33,
  0x00, 0x01, 0x8C, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xC0, 0x01, 0x81, 0x80,
  0x0E, 0x06, 0x00, 0x30, 0x18, 0x01, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x30,
  0x03, 0x01, 0xC0, 0x0C, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x38,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0x04, 0x00, 0x03, 0xF8, 0x01, 0x7B, 0xE0, 0x1C, 0x07,
  0x87, 0x80, 0x1F, 0xE8, 0x00, 0x78,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 12, 42, 12, 1, -42 },
  { 64, 12, 15, 16, 6, -42 },
  { 87, 23, 42, 22, 0, -42 },
  { 208, 22, 48, 21, 0, -45 },
  { 340, 26, 44, 32, 3, -43 },
  { 483, 20, 44, 20, -1, -43 },
  { 593, 5, 15, 9, 6, -42 },
  { 603, 17, 51, 14, 1, -42 },
  { 712, 16, 51, 14, -4, -42 },
  { 814, 15, 17, 19, 7, -45 },
  { 846, 20, 27, 24, 2, -34 },
  { 914, 7, 14, 10, -2, -6 },
  { 927, 13, 2, 15, 1, -17 },
  { 931, 3, 5, 10, 1, -5 },
  { 933, 25, 42, 18, -3, -42 },
  { 1065, 20, 44, 21, 1, -43 },
  { 1175, 12, 42, 21, 6, -42 },
  { 1238, 23, 43, 21, -2, -43 },
  { 1362, 22, 44, 21, -1, -43 },
  { 1483, 22, 43, 21, -1, -43 },
  { 1602, 22, 43, 21, -1, -42 },
  { 1721, 21, 44, 21, 1, -43 },
  { 1837, 21, 42, 21, 2, -42 },
  { 1948, 22, 44, 21, -1, -43 },
  { 2069, 20, 44, 21, 0, -43 },
  { 2179, 9, 31, 10, 0, -31 },
  { 2214, 13, 39, 10, -3, -31 },
  { 2278, 20, 24, 24, 2, -33 },
  { 2338, 20, 15, 24, 2, -28 },
  { 2376, 20, 24, 24, 2, -33 },
  { 2436, 16, 43, 15, 1, -43 },
  { 2522, 29, 47, 31, 1, -42 },
  { 2693, 20, 42, 20, -4, -42 },
  { 2798, 23, 42, 23, 0, -42 },
  { 2919, 23, 44, 20, 2, -43 },
  { 3046, 24, 42, 25, 0, -42 },
  { 3172, 23, 42, 20, 0, -42 },
  { 3293, 23, 42, 19, 0, -42 },
  { 3414, 26, 44, 27, 2, -43 },
  { 3557, 27, 42, 26, 0, -42 },
  { 3699, 18, 42, 11, -3, -42 },
  { 3794, 19, 52, 10, -8, -42 },
  { 3918, 25, 42, 21, 0, -42 },
  { 4050, 14, 42, 18, 0, -42 },
  { 4124, 36, 42, 35, 0, -42 },
  { 4313, 29, 42, 28, 0, -42 },
  { 4466, 24, 44, 27, 2, -43 },
  { 4598, 22, 42, 21, 0, -42 },
  { 4714, 24, 53, 27, 2, -43 },
  { 4873, 22, 42, 22, 0, -42 },
  { 4989, 24, 44, 21, -2, -43 },
  { 5121, 18, 42, 18, 4, -42 },
  { 5216, 25, 43, 26, 2, -42 },
  { 5351, 21, 42, 21, 5, -42 },
  { 5462, 36, 42, 36, 4, -42 },
  { 5651, 26, 42, 19, -3, -42 },
  { 5788, 19, 42, 18, 4, -42 },
  { 5888, 24, 42, 18, -2, -42 },
  { 6014, 21, 51, 16, -1, -42 },
  { 6148, 8, 42, 19, 6, -42 },
  { 6190, 21, 51, 16, -4, -42 },
  { 6324, 22, 21, 23, 1, -42 },
  { 6382, 16, 2, 16, -5, 5 },
  { 6386, 6, 9, 13, 9, -45 },
  { 6393, 20, 33, 23, 2, -32 },
  { 6476, 21, 46, 22, 0, -45 },
  { 6597, 16, 33, 16, 2, -32 },
  { 6663, 23, 46, 23, 2, -45 },
  { 6796, 17, 33, 20, 2, -32 },
  { 6867, 26, 59, 11, -8, -45 },
  { 7059, 23, 46, 23, -1, -32 },
  { 7192, 20, 45, 22, 0, -45 },
  { 7305, 12, 42, 10, 0, -42 },
  { 7368, 20, 56, 10, -8, -42 },
  { 7508, 20, 45, 18, 0, -45 },
  { 7621, 12, 45, 9, 0, -45 },
  { 7689, 31, 32, 33, 0, -32 },
  { 7813, 20, 32, 22, 0, -32 },
  { 7893, 18, 33, 22, 2, -32 },
  { 7968, 23, 46, 23, -2, -32 },
  { 8101, 20, 46, 23, 2, -32 },
  { 8216, 17, 32, 14, 0, -32 },
  { 8284, 18, 33, 17, -1, -32 },
  { 8359, 12, 40, 11, 1, -39 },
  { 8419, 19, 32, 22, 2, -31 },
  { 8495, 17, 31, 17, 3, -31 },
  { 8561, 28, 31, 28, 3, -31 },
  { 8670, 22, 31, 17, -3, -31 },
  { 8756, 28, 45, 18, -7, -31 },
  { 8914, 18, 31, 14, -2, -31 },
  { 8984, 20, 51, 19, 2, -42 },
  { 9112, 2, 59, 21, 9, -45 },
  { 9127, 20, 51, 18, -4, -42 },
  { 9255, 20, 6, 24, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC59PT7B_H_
