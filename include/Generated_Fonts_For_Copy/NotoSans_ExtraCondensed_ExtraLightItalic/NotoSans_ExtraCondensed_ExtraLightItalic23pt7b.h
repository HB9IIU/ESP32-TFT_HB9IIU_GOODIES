#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC23PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x44, 0x21, 0x08, 0x84, 0x21, 0x08, 0x80, 0x01, 0x18, 0x4A,
  0x55, 0x29, 0x48, 0x04, 0x84, 0x42, 0x41, 0x23, 0xF8, 0x90, 0x48, 0x24,
  0x24, 0x12, 0x3F, 0x89, 0x04, 0x82, 0x42, 0x21, 0x20, 0x02, 0x07, 0x05,
  0x64, 0x82, 0x41, 0x40, 0xA0, 0x30, 0x08, 0x06, 0x05, 0x02, 0x41, 0x20,
  0x90, 0x51, 0xF0, 0x20, 0x10, 0x00, 0x10, 0x4A, 0x24, 0x89, 0x24, 0x89,
  0x22, 0x88, 0xA2, 0x53, 0x95, 0x6A, 0x94, 0xA4, 0x49, 0x14, 0x49, 0x12,
  0x45, 0x12, 0x43, 0x00, 0x0C, 0x12, 0x12, 0x12, 0x12, 0x14, 0x14, 0x18,
  0x10, 0x29, 0x4A, 0x8A, 0x8A, 0x84, 0x84, 0x8C, 0xF4, 0x56, 0xA0, 0x0C,
  0x21, 0x08, 0x21, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x10, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x10,
  0x20, 0x41, 0x02, 0x08, 0x10, 0x41, 0x04, 0x00, 0x22, 0x87, 0xD8, 0x90,
  0x40, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x25,
  0x28, 0xF8, 0x70, 0x00, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10,
  0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x06, 0x09, 0x11,
  0x11, 0x21, 0x21, 0x41, 0x41, 0x41, 0x42, 0x42, 0x82, 0x82, 0x84, 0x84,
  0x48, 0x70, 0x19, 0x94, 0x21, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0x18,
  0x06, 0x04, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01,
  0x01, 0x01, 0x00, 0x80, 0x80, 0x80, 0xFE, 0x00, 0x06, 0x0C, 0xC0, 0x20,
  0x10, 0x08, 0x04, 0x04, 0x06, 0x1C, 0x01, 0x00, 0x80, 0x20, 0x10, 0x10,
  0x08, 0x08, 0xF8, 0x00, 0x01, 0x03, 0x03, 0x05, 0x0A, 0x0A, 0x12, 0x12,
  0x22, 0x44, 0x44, 0x84, 0xFE, 0x04, 0x08, 0x08, 0x08, 0x0F, 0x84, 0x04,
  0x02, 0x01, 0x00, 0x80, 0xF0, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x10, 0x19, 0xF0, 0x07, 0x18, 0x20, 0x20, 0x40, 0x40, 0x40, 0xB8, 0xC4,
  0x84, 0x84, 0x84, 0x84, 0x84, 0x88, 0x88, 0xF0, 0x7F, 0x02, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x80,
  0x0E, 0x11, 0x21, 0x21, 0x21, 0x21, 0x22, 0x14, 0x18, 0x24, 0x44, 0x82,
  0x82, 0x82, 0x82, 0x84, 0x78, 0x0C, 0x12, 0x21, 0x21, 0x21, 0x41, 0x41,
  0x41, 0x43, 0x26, 0x1A, 0x02, 0x02, 0x04, 0x04, 0x08, 0xF0, 0x32, 0x00,
  0x00, 0x00, 0x00, 0x88, 0x18, 0x80, 0x00, 0x00, 0x00, 0x00, 0x08, 0x84,
  0x22, 0x00, 0x01, 0x06, 0x18, 0x60, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x06,
  0x08, 0x30, 0xC0, 0x80, 0x18, 0x48, 0x08, 0x10, 0x20, 0x82, 0x04, 0x10,
  0x40, 0x82, 0x04, 0x00, 0x00, 0x20, 0xC0, 0x03, 0x01, 0x98, 0x41, 0x10,
  0x12, 0x02, 0x8E, 0x52, 0x4C, 0x49, 0x92, 0x32, 0x4A, 0x49, 0x51, 0x2A,
  0x49, 0x37, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0xE0, 0x00, 0x01, 0x03,
  0x03, 0x03, 0x05, 0x05, 0x09, 0x09, 0x11, 0x1F, 0x11, 0x21, 0x21, 0x41,
  0x41, 0xC1, 0x1F, 0x08, 0x44, 0x22, 0x12, 0x09, 0x08, 0x88, 0x78, 0x22,
  0x20, 0x90, 0x48, 0x24, 0x22, 0x12, 0x11, 0xF0, 0x07, 0x04, 0x44, 0x04,
  0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x78, 0x00, 0x1F, 0x08, 0x44, 0x22, 0x12, 0x09, 0x04, 0x82,
  0x41, 0x20, 0xA0, 0x50, 0x48, 0x24, 0x24, 0x12, 0x31, 0xE0, 0x1F, 0x88,
  0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x7C, 0x20, 0x20, 0x10, 0x08, 0x04,
  0x04, 0x02, 0x01, 0xF8, 0x1F, 0x88, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x3E, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x07, 0x82,
  0x11, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x21, 0xE8, 0x12,
  0x04, 0x81, 0x20, 0x48, 0x21, 0x08, 0x7E, 0x00, 0x10, 0x22, 0x08, 0x41,
  0x08, 0x22, 0x04, 0x41, 0x08, 0x21, 0xFC, 0x20, 0x88, 0x11, 0x04, 0x20,
  0x84, 0x11, 0x02, 0x20, 0x44, 0x10, 0x1E, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x78, 0x02, 0x04, 0x08, 0x10,
  0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20,
  0x87, 0x00, 0x10, 0xC4, 0x21, 0x10, 0x48, 0x24, 0x09, 0x02, 0x80, 0xE0,
  0x28, 0x12, 0x04, 0x81, 0x10, 0x44, 0x21, 0x08, 0x42, 0x08, 0x10, 0x84,
  0x22, 0x10, 0x84, 0x22, 0x10, 0x84, 0x42, 0x1F, 0x18, 0x0C, 0x60, 0x31,
  0x81, 0x46, 0x06, 0x28, 0x28, 0xA0, 0xA2, 0x84, 0x8A, 0x12, 0x28, 0x51,
  0x22, 0x44, 0x89, 0x12, 0x44, 0x49, 0x22, 0x18, 0x88, 0x62, 0x21, 0x08,
  0x18, 0x23, 0x04, 0x60, 0x8C, 0x22, 0x44, 0x48, 0x89, 0x11, 0x22, 0x24,
  0x88, 0x91, 0x0A, 0x21, 0x44, 0x29, 0x06, 0x20, 0xC4, 0x08, 0x06, 0x0C,
  0x84, 0x24, 0x14, 0x0A, 0x05, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x50, 0x28,
  0x14, 0x12, 0x09, 0x08, 0x78, 0x00, 0x1F, 0x08, 0x84, 0x22, 0x12, 0x09,
  0x08, 0x84, 0x44, 0x3C, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00,
  0x06, 0x0C, 0x84, 0x24, 0x14, 0x0A, 0x05, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x50, 0x28, 0x14, 0x12, 0x09, 0x08, 0x78, 0x08, 0x02, 0x01, 0x00, 0x80,
  0x1F, 0x08, 0x84, 0x22, 0x12, 0x09, 0x08, 0x84, 0x44, 0x3C, 0x24, 0x11,
  0x08, 0x84, 0x44, 0x22, 0x11, 0x08, 0x07, 0x02, 0x31, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40,
  0x20, 0x08, 0xFC, 0x00, 0x7F, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x20, 0x90, 0x48, 0x24,
  0x14, 0x12, 0x09, 0x04, 0x82, 0x81, 0x41, 0x20, 0x90, 0x48, 0x24, 0x22,
  0x10, 0xF0, 0x81, 0x82, 0x82, 0x84, 0x84, 0x84, 0x88, 0x88, 0x90, 0x90,
  0xA0, 0xA0, 0xA0, 0xC0, 0xC0, 0x80, 0x82, 0x0E, 0x08, 0x28, 0x60, 0xA1,
  0x84, 0x8A, 0x12, 0x28, 0x88, 0xA2, 0x24, 0x88, 0x92, 0x42, 0x89, 0x0A,
  0x28, 0x28, 0xA0, 0xC2, 0x83, 0x0C, 0x08, 0x30, 0x20, 0x80, 0x08, 0xC2,
  0x20, 0x90, 0x24, 0x0A, 0x02, 0x80, 0xC0, 0x30, 0x0C, 0x05, 0x01, 0x40,
  0x90, 0x24, 0x11, 0x08, 0x42, 0x10, 0x43, 0x42, 0x44, 0x44, 0x48, 0x48,
  0x50, 0x30, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x0F, 0xC0,
  0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x03, 0xF0, 0x0F, 0x10, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80,
  0x80, 0xF0, 0x84, 0x44, 0x44, 0x44, 0x22, 0x22, 0x22, 0x21, 0x0F, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x10, 0xF0, 0x0C, 0x06, 0x04, 0x82, 0x42, 0x11,
  0x09, 0x05, 0x81, 0xFC, 0x89, 0x10, 0x3D, 0x22, 0x42, 0x42, 0x82, 0x82,
  0x84, 0x84, 0x84, 0x8C, 0x88, 0xF8, 0x18, 0x10, 0x10, 0x10, 0x10, 0x2F,
  0x31, 0x21, 0x21, 0x21, 0x41, 0x41, 0x41, 0x42, 0x42, 0xC4, 0xB8, 0x3C,
  0x84, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3C, 0x00, 0x80, 0x40, 0x40,
  0x20, 0x11, 0xE8, 0x88, 0x84, 0x42, 0x41, 0x20, 0x90, 0x88, 0x44, 0x22,
  0x31, 0x10, 0xF8, 0x00, 0x3C, 0x94, 0x61, 0x8B, 0xC8, 0x20, 0x82, 0x08,
  0x3E, 0x00, 0xC0, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0xF0, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x03, 0x00, 0x1E, 0x88, 0x88, 0x44, 0x24,
  0x12, 0x09, 0x08, 0x84, 0x42, 0x23, 0x11, 0x0F, 0x80, 0x40, 0x20, 0x10,
  0x10, 0x90, 0x30, 0x00, 0x08, 0x10, 0x10, 0x10, 0x10, 0x2F, 0x31, 0x21,
  0x21, 0x22, 0x42, 0x42, 0x42, 0x42, 0x44, 0x84, 0x84, 0x18, 0x00, 0x22,
  0x10, 0x84, 0x22, 0x10, 0x84, 0x22, 0x10, 0x03, 0x00, 0x00, 0x00, 0x02,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0xC0, 0x08, 0x10, 0x10, 0x10, 0x10, 0x21, 0x22,
  0x24, 0x28, 0x28, 0x58, 0x68, 0x48, 0x48, 0x48, 0x88, 0x84, 0x08, 0x84,
  0x21, 0x10, 0x84, 0x21, 0x10, 0x84, 0x21, 0x10, 0x80, 0x2E, 0xF3, 0x11,
  0x21, 0x12, 0x21, 0x22, 0x14, 0x21, 0x42, 0x24, 0x22, 0x44, 0x24, 0x42,
  0x84, 0x48, 0x44, 0x2F, 0x31, 0x21, 0x21, 0x22, 0x42, 0x42, 0x42, 0x42,
  0x44, 0x84, 0x84, 0x3C, 0x85, 0x0A, 0x18, 0x30, 0x60, 0xC2, 0x85, 0x0A,
  0x27, 0x80, 0x17, 0x8C, 0x44, 0x22, 0x11, 0x09, 0x04, 0x82, 0x41, 0x21,
  0x10, 0x98, 0x8B, 0x84, 0x02, 0x01, 0x01, 0x00, 0x80, 0x00, 0x3D, 0x22,
  0x42, 0x42, 0x82, 0x82, 0x84, 0x84, 0x84, 0x8C, 0x88, 0xF8, 0x08, 0x08,
  0x08, 0x08, 0x10, 0x2E, 0x60, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82,
  0x04, 0x00, 0x3E, 0x81, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x10, 0x27,
  0x80, 0x10, 0x84, 0xF2, 0x10, 0x88, 0x42, 0x10, 0x88, 0x41, 0x80, 0x62,
  0x85, 0x0A, 0x14, 0x50, 0xA1, 0x42, 0x89, 0x12, 0x67, 0x40, 0x87, 0x0A,
  0x14, 0x48, 0x92, 0x24, 0x50, 0xA1, 0x43, 0x06, 0x00, 0x84, 0x30, 0x8A,
  0x31, 0x46, 0x29, 0x49, 0x29, 0x25, 0x45, 0x28, 0xA5, 0x18, 0xC3, 0x18,
  0x42, 0x00, 0x11, 0x88, 0x84, 0x82, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x24,
  0x22, 0x11, 0x10, 0x80, 0x04, 0x20, 0x88, 0x11, 0x02, 0x20, 0x48, 0x09,
  0x01, 0x40, 0x28, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x80, 0x30, 0x18, 0x00, 0x1E, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10,
  0x20, 0x81, 0x07, 0xC0, 0x07, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20,
  0x20, 0xC0, 0x40, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x50, 0x20,
  0xFF, 0xFF, 0xFF, 0x06, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x01, 0x06, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x30, 0xC0, 0xF1,
  0x8E,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 16, 5, 0, -16 },
  { 11, 5, 6, 6, 2, -16 },
  { 15, 9, 16, 9, 0, -16 },
  { 33, 9, 18, 8, 0, -17 },
  { 54, 10, 17, 12, 1, -17 },
  { 76, 8, 17, 8, 0, -17 },
  { 93, 2, 6, 4, 2, -16 },
  { 95, 6, 20, 6, 1, -16 },
  { 110, 7, 20, 6, -2, -16 },
  { 128, 6, 6, 8, 3, -17 },
  { 133, 8, 10, 9, 1, -13 },
  { 143, 3, 5, 4, -1, -2 },
  { 145, 5, 1, 6, 0, -7 },
  { 146, 2, 2, 4, 0, -2 },
  { 147, 9, 16, 7, -1, -16 },
  { 165, 8, 17, 8, 0, -17 },
  { 182, 5, 16, 8, 2, -16 },
  { 192, 9, 17, 8, -1, -17 },
  { 212, 9, 17, 8, -1, -17 },
  { 232, 8, 17, 8, 0, -17 },
  { 249, 9, 16, 8, -1, -16 },
  { 267, 8, 17, 8, 1, -17 },
  { 284, 8, 16, 8, 1, -16 },
  { 300, 8, 17, 8, 0, -17 },
  { 317, 8, 17, 8, 0, -17 },
  { 334, 4, 12, 4, 0, -12 },
  { 340, 5, 15, 4, -1, -12 },
  { 350, 8, 10, 9, 1, -13 },
  { 360, 8, 6, 9, 1, -11 },
  { 366, 8, 10, 9, 1, -13 },
  { 376, 7, 17, 6, 0, -17 },
  { 391, 11, 19, 12, 1, -17 },
  { 418, 8, 16, 8, -2, -16 },
  { 434, 9, 16, 9, 0, -16 },
  { 452, 9, 17, 8, 1, -17 },
  { 472, 9, 16, 10, 0, -16 },
  { 490, 9, 16, 8, 0, -16 },
  { 508, 9, 16, 7, 0, -16 },
  { 526, 10, 17, 11, 1, -17 },
  { 548, 11, 16, 10, 0, -16 },
  { 570, 7, 16, 4, -1, -16 },
  { 584, 7, 20, 4, -3, -16 },
  { 602, 10, 16, 8, 0, -16 },
  { 622, 5, 16, 7, 0, -16 },
  { 632, 14, 16, 14, 0, -16 },
  { 660, 11, 16, 11, 0, -16 },
  { 682, 9, 17, 10, 1, -17 },
  { 702, 9, 16, 8, 0, -16 },
  { 720, 9, 21, 10, 1, -17 },
  { 744, 9, 16, 8, 0, -16 },
  { 762, 10, 17, 8, -1, -17 },
  { 784, 8, 16, 7, 1, -16 },
  { 800, 9, 16, 10, 1, -16 },
  { 818, 8, 16, 8, 2, -16 },
  { 834, 14, 16, 14, 2, -16 },
  { 862, 10, 16, 7, -1, -16 },
  { 882, 8, 16, 7, 1, -16 },
  { 898, 10, 16, 7, -1, -16 },
  { 918, 8, 20, 6, 0, -16 },
  { 938, 4, 16, 7, 2, -16 },
  { 946, 8, 20, 6, -1, -16 },
  { 966, 9, 8, 9, 0, -16 },
  { 975, 6, 1, 6, -2, 2 },
  { 976, 3, 4, 5, 3, -18 },
  { 978, 8, 12, 9, 1, -12 },
  { 990, 8, 17, 9, 0, -17 },
  { 1007, 6, 12, 6, 1, -12 },
  { 1016, 9, 17, 9, 1, -17 },
  { 1036, 6, 12, 8, 1, -12 },
  { 1045, 10, 24, 4, -3, -18 },
  { 1075, 9, 18, 9, 0, -12 },
  { 1096, 8, 17, 8, 0, -17 },
  { 1113, 5, 16, 4, 0, -16 },
  { 1123, 8, 22, 4, -3, -16 },
  { 1145, 8, 17, 7, 0, -17 },
  { 1162, 5, 17, 4, 0, -17 },
  { 1173, 12, 12, 13, 0, -12 },
  { 1191, 8, 12, 8, 0, -12 },
  { 1203, 7, 12, 8, 1, -12 },
  { 1214, 9, 17, 9, -1, -12 },
  { 1234, 8, 17, 9, 1, -12 },
  { 1251, 7, 12, 6, 0, -12 },
  { 1262, 7, 12, 7, 0, -12 },
  { 1273, 5, 15, 4, 0, -15 },
  { 1283, 7, 12, 8, 1, -12 },
  { 1294, 7, 12, 7, 1, -12 },
  { 1305, 11, 12, 11, 1, -12 },
  { 1322, 9, 12, 7, -1, -12 },
  { 1336, 11, 18, 7, -3, -12 },
  { 1361, 7, 12, 6, -1, -12 },
  { 1372, 8, 20, 7, 1, -16 },
  { 1392, 1, 24, 8, 3, -18 },
  { 1395, 8, 20, 7, -2, -16 },
  { 1415, 8, 2, 9, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC23PT7B_H_
