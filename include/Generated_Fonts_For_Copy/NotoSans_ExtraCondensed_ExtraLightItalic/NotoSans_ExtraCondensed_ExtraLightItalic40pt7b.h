#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC40PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08,
  0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x60, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0x80, 0x21, 0x23, 0x63, 0x63, 0x42, 0x42,
  0x42, 0xC6, 0x84, 0x84, 0x84, 0x00, 0x43, 0x00, 0x42, 0x00, 0xC2, 0x00,
  0x86, 0x00, 0x84, 0x01, 0x84, 0x01, 0x0C, 0x01, 0x0C, 0x03, 0x08, 0x1F,
  0xFF, 0x02, 0x18, 0x06, 0x10, 0x06, 0x10, 0x04, 0x30, 0x04, 0x20, 0x0C,
  0x20, 0x08, 0x60, 0x08, 0x40, 0xFF, 0xF8, 0xFF, 0xF8, 0x10, 0x80, 0x30,
  0x80, 0x21, 0x80, 0x21, 0x80, 0x61, 0x00, 0x61, 0x00, 0x43, 0x00, 0x42,
  0x00, 0xC2, 0x00, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x0F, 0xC0, 0x74,
  0xE1, 0x88, 0x02, 0x10, 0x0C, 0x20, 0x18, 0xC0, 0x31, 0x00, 0x62, 0x00,
  0x44, 0x00, 0xC8, 0x00, 0xA0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x07,
  0x80, 0x09, 0x80, 0x11, 0x00, 0x23, 0x00, 0x46, 0x01, 0x8C, 0x02, 0x18,
  0x04, 0x20, 0x08, 0xC2, 0x13, 0x07, 0xFC, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x0F, 0x01, 0x86, 0x40, 0x41, 0x18, 0x30, 0x86, 0x08,
  0x21, 0x86, 0x18, 0x61, 0x04, 0x18, 0xC1, 0x04, 0x20, 0xC1, 0x18, 0x30,
  0x44, 0x08, 0x33, 0x02, 0x0C, 0x80, 0x82, 0x67, 0xA0, 0x93, 0x38, 0x4C,
  0x86, 0x32, 0x41, 0xD9, 0x90, 0x5C, 0x4C, 0x30, 0x32, 0x0C, 0x08, 0x83,
  0x06, 0x20, 0x81, 0x18, 0x20, 0xC6, 0x08, 0x21, 0x86, 0x18, 0x41, 0x04,
  0x10, 0x43, 0x06, 0x20, 0x81, 0x98, 0x60, 0x3C, 0x00, 0x01, 0xE0, 0x1D,
  0x80, 0x8C, 0x0C, 0x20, 0x41, 0x02, 0x18, 0x10, 0xC0, 0x84, 0x04, 0x20,
  0x23, 0x01, 0x30, 0x09, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x60, 0x13,
  0x01, 0x08, 0xD8, 0x46, 0x83, 0x2C, 0x1B, 0x40, 0x52, 0x02, 0x90, 0x1C,
  0x80, 0xC4, 0x06, 0x30, 0x59, 0x86, 0xC7, 0xE2, 0x00, 0x25, 0xB4, 0x96,
  0x92, 0x00, 0x00, 0x60, 0x10, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00,
  0x40, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00,
  0x60, 0x08, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x20, 0x18, 0x00,
  0x04, 0x01, 0x08, 0x43, 0x20, 0x39, 0xC3, 0x81, 0x40, 0x90, 0x42, 0x20,
  0x80, 0x10, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x0C, 0x21,
  0x84, 0x10, 0xC2, 0x10, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xE0,
  0x1F, 0x81, 0x86, 0x08, 0x30, 0xC1, 0x8C, 0x0C, 0x60, 0x62, 0x03, 0x30,
  0x19, 0x80, 0xC8, 0x06, 0xC0, 0x36, 0x01, 0x20, 0x09, 0x00, 0x48, 0x06,
  0xC0, 0x36, 0x01, 0x30, 0x09, 0x00, 0xC8, 0x06, 0x40, 0x22, 0x03, 0x10,
  0x18, 0x80, 0x84, 0x0C, 0x30, 0xC0, 0x8C, 0x07, 0xC0, 0x00, 0x03, 0x07,
  0x0E, 0x1A, 0x72, 0xC6, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08,
  0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60,
  0x40, 0x40, 0xC0, 0x00, 0xF0, 0x0F, 0x78, 0x08, 0x18, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF8,
  0x07, 0x38, 0x18, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x03, 0x00, 0x3C,
  0x01, 0xF0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x04, 0x0E, 0x0F, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0x40, 0x04, 0x80, 0x19, 0x00, 0x26, 0x00, 0xCC, 0x01, 0x10,
  0x04, 0x20, 0x18, 0xC0, 0x21, 0x80, 0xC2, 0x01, 0x04, 0x04, 0x08, 0x18,
  0x30, 0x20, 0x60, 0xC0, 0x83, 0x01, 0x04, 0x02, 0x1F, 0xFF, 0x80, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x01, 0xFE, 0x07, 0xFC, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0xFC,
  0x01, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x04, 0x0C, 0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xB0, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x40, 0x6F, 0xC1, 0x61, 0x87, 0x02, 0x18, 0x0C, 0xC0,
  0x33, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0x80, 0x22, 0x00, 0x88, 0x06, 0x20,
  0x18, 0x80, 0x43, 0x03, 0x0C, 0x18, 0x18, 0xC0, 0x3E, 0x00, 0x1F, 0xFE,
  0x3F, 0xFC, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF0, 0x07, 0x70, 0x18, 0x30, 0x60,
  0x20, 0x80, 0x41, 0x00, 0xC2, 0x01, 0x04, 0x02, 0x08, 0x0C, 0x10, 0x10,
  0x30, 0x60, 0x21, 0x80, 0x66, 0x00, 0x70, 0x01, 0xE0, 0x06, 0x60, 0x30,
  0x40, 0xC0, 0xC1, 0x00, 0x86, 0x01, 0x88, 0x03, 0x10, 0x06, 0x20, 0x0C,
  0x40, 0x18, 0x80, 0x31, 0x00, 0x43, 0x01, 0x83, 0x06, 0x03, 0xF8, 0x00,
  0x01, 0xE0, 0x0E, 0xE0, 0x61, 0x83, 0x03, 0x08, 0x0C, 0x60, 0x31, 0x80,
  0xC4, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x18, 0xC0,
  0x63, 0x03, 0x86, 0x0E, 0x1D, 0xD8, 0x3E, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x21,
  0x80, 0xFC, 0x00, 0x0C, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x30, 0xC0, 0x03, 0x81, 0x80, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x06, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x20, 0x00, 0x0F, 0x87, 0xB8, 0x41, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00,
  0xC0, 0x10, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x60, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xF0,
  0x06, 0x03, 0x01, 0x80, 0x20, 0x20, 0x06, 0x08, 0x00, 0x43, 0x00, 0x08,
  0x40, 0x01, 0x18, 0x18, 0x22, 0x0F, 0xC4, 0xC3, 0x10, 0x90, 0x42, 0x12,
  0x10, 0xC2, 0xC2, 0x18, 0x50, 0xC2, 0x1A, 0x10, 0x43, 0x42, 0x18, 0x58,
  0xC3, 0x0B, 0x18, 0x43, 0x62, 0x18, 0x48, 0x43, 0x09, 0x08, 0x62, 0x21,
  0x94, 0xC4, 0x1C, 0xF0, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x08, 0x00, 0xFE, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x05, 0x00, 0x34, 0x00,
  0x90, 0x02, 0x40, 0x19, 0x00, 0x44, 0x03, 0x10, 0x08, 0x40, 0x21, 0x01,
  0x84, 0x04, 0x30, 0x30, 0xC0, 0x83, 0x06, 0x0C, 0x1F, 0xF0, 0x40, 0xC3,
  0x03, 0x08, 0x0C, 0x60, 0x31, 0x80, 0xC4, 0x03, 0x30, 0x0C, 0x80, 0x36,
  0x00, 0xD8, 0x03, 0xC0, 0x0C, 0x03, 0xE0, 0x03, 0xFC, 0x02, 0x06, 0x06,
  0x02, 0x06, 0x02, 0x06, 0x03, 0x04, 0x03, 0x04, 0x02, 0x0C, 0x02, 0x0C,
  0x06, 0x0C, 0x04, 0x08, 0x0C, 0x08, 0x18, 0x1F, 0xF0, 0x1F, 0xE0, 0x10,
  0x30, 0x10, 0x18, 0x10, 0x08, 0x30, 0x08, 0x30, 0x08, 0x20, 0x08, 0x20,
  0x08, 0x60, 0x18, 0x60, 0x18, 0x60, 0x10, 0x40, 0x30, 0x40, 0x60, 0xC3,
  0xC0, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0xF7, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x38, 0x40, 0x1F,
  0xC0, 0x03, 0xE0, 0x03, 0xF8, 0x02, 0x0E, 0x06, 0x06, 0x06, 0x03, 0x06,
  0x03, 0x04, 0x03, 0x04, 0x01, 0x0C, 0x01, 0x0C, 0x01, 0x0C, 0x03, 0x08,
  0x03, 0x08, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10, 0x02, 0x10, 0x02, 0x10,
  0x06, 0x30, 0x06, 0x30, 0x04, 0x20, 0x0C, 0x20, 0x0C, 0x60, 0x18, 0x60,
  0x10, 0x60, 0x30, 0x40, 0x60, 0x40, 0xC0, 0xCF, 0x80, 0xFE, 0x00, 0x03,
  0xFE, 0x07, 0xFC, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03,
  0xFE, 0x07, 0xFC, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x02, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0F, 0xF8,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x3C, 0xF0, 0x18, 0x04, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0xFC, 0x40, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x04,
  0x30, 0x01, 0x04, 0x00, 0x41, 0x00, 0x30, 0x60, 0x0C, 0x18, 0x02, 0x03,
  0x00, 0x80, 0x60, 0x60, 0x0F, 0xF8, 0x00, 0x03, 0x00, 0x60, 0x40, 0x08,
  0x08, 0x01, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x01, 0x00, 0x20,
  0x20, 0x04, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x20, 0x04, 0x04, 0x00, 0x80,
  0x80, 0x10, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x80, 0x10, 0x10, 0x02, 0x02,
  0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x02, 0x00, 0x40, 0x40, 0x08, 0x18,
  0x03, 0x03, 0x00, 0x60, 0x60, 0x08, 0x08, 0x01, 0x01, 0x00, 0x20, 0x60,
  0x0C, 0x0C, 0x01, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0xFC, 0x00,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x09,
  0xC0, 0x3E, 0x00, 0x03, 0x00, 0x81, 0x00, 0xC0, 0x80, 0xC0, 0xC0, 0xC0,
  0x60, 0x40, 0x30, 0x60, 0x10, 0x60, 0x08, 0x60, 0x0C, 0x20, 0x06, 0x30,
  0x02, 0x30, 0x01, 0x30, 0x00, 0x98, 0x00, 0xD8, 0x00, 0x7C, 0x00, 0x2B,
  0x00, 0x19, 0x80, 0x08, 0xC0, 0x0C, 0x20, 0x06, 0x10, 0x02, 0x0C, 0x01,
  0x06, 0x01, 0x81, 0x00, 0xC0, 0x80, 0x60, 0x60, 0x20, 0x30, 0x10, 0x18,
  0x18, 0x04, 0x0C, 0x03, 0x00, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30,
  0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10,
  0x08, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18,
  0x0F, 0xF8, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x01, 0xC0,
  0xE0, 0x00, 0xE0, 0x70, 0x00, 0xF0, 0x28, 0x00, 0x58, 0x16, 0x00, 0x68,
  0x0B, 0x00, 0x24, 0x0D, 0x80, 0x36, 0x06, 0xC0, 0x13, 0x02, 0x60, 0x19,
  0x01, 0x30, 0x0C, 0x80, 0x98, 0x04, 0x40, 0xC4, 0x06, 0x60, 0x62, 0x02,
  0x30, 0x21, 0x03, 0x10, 0x10, 0x81, 0x08, 0x08, 0x41, 0x8C, 0x0C, 0x20,
  0x86, 0x06, 0x10, 0xC3, 0x02, 0x08, 0x41, 0x01, 0x04, 0x60, 0x81, 0x82,
  0x20, 0xC0, 0xC1, 0x30, 0x60, 0x40, 0x90, 0x20, 0x20, 0x78, 0x10, 0x10,
  0x38, 0x08, 0x18, 0x1C, 0x0C, 0x0C, 0x0C, 0x06, 0x00, 0x03, 0x00, 0x20,
  0x60, 0x04, 0x0C, 0x00, 0x83, 0xC0, 0x30, 0x78, 0x06, 0x0F, 0x00, 0x81,
  0x20, 0x10, 0x24, 0x06, 0x0C, 0x80, 0xC1, 0x98, 0x18, 0x23, 0x02, 0x04,
  0x20, 0x40, 0x84, 0x18, 0x30, 0x83, 0x06, 0x10, 0x60, 0x83, 0x08, 0x10,
  0x61, 0x02, 0x04, 0x60, 0xC0, 0x8C, 0x18, 0x11, 0x02, 0x03, 0x20, 0x40,
  0x64, 0x18, 0x0D, 0x83, 0x00, 0xB0, 0x60, 0x14, 0x08, 0x02, 0x81, 0x00,
  0x70, 0x60, 0x0E, 0x0C, 0x00, 0xC0, 0x00, 0x78, 0x01, 0xFE, 0x03, 0x03,
  0x06, 0x03, 0x04, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x18, 0x01, 0x10, 0x01,
  0x30, 0x01, 0x30, 0x01, 0x20, 0x01, 0x20, 0x03, 0x60, 0x03, 0x60, 0x03,
  0x60, 0x03, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x04,
  0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0x40, 0x10, 0x40, 0x30, 0x60, 0x60,
  0x30, 0xC0, 0x1F, 0x80, 0x03, 0xC0, 0x07, 0xF0, 0x08, 0x30, 0x30, 0x30,
  0x60, 0x60, 0xC0, 0xC1, 0x01, 0x82, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30,
  0x18, 0x40, 0x20, 0x80, 0xC3, 0x03, 0x06, 0x0C, 0x08, 0xF0, 0x1F, 0x80,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x78, 0x01, 0xFE, 0x03, 0x03, 0x06, 0x03, 0x04, 0x01, 0x0C, 0x01, 0x08,
  0x01, 0x18, 0x01, 0x10, 0x01, 0x30, 0x01, 0x30, 0x01, 0x20, 0x01, 0x20,
  0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x40, 0x02, 0x40, 0x02, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0x40,
  0x10, 0x40, 0x30, 0x60, 0x60, 0x30, 0xC0, 0x1F, 0x80, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x03,
  0xC0, 0x07, 0xF0, 0x08, 0x30, 0x30, 0x30, 0x60, 0x60, 0xC0, 0xC1, 0x01,
  0x82, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x10, 0x40, 0x60, 0x80, 0xC3,
  0x03, 0x06, 0x0C, 0x0F, 0xF0, 0x11, 0x80, 0x21, 0x00, 0xC2, 0x01, 0x84,
  0x02, 0x0C, 0x04, 0x18, 0x18, 0x30, 0x30, 0x20, 0x60, 0x40, 0x80, 0xC1,
  0x01, 0x86, 0x03, 0x0C, 0x02, 0x00, 0x00, 0xFC, 0x01, 0xEF, 0x03, 0x01,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0xC1, 0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x82, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x20, 0xC0, 0x10, 0x40,
  0x08, 0x20, 0x0C, 0x30, 0x06, 0x18, 0x02, 0x0C, 0x01, 0x04, 0x01, 0x82,
  0x00, 0xC3, 0x00, 0x61, 0x80, 0x20, 0x80, 0x10, 0x40, 0x18, 0x20, 0x0C,
  0x30, 0x04, 0x18, 0x02, 0x08, 0x01, 0x04, 0x01, 0x86, 0x00, 0xC3, 0x00,
  0x41, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x10, 0x10, 0x18, 0x0C, 0x18, 0x03,
  0xF8, 0x00, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x02, 0xC0, 0x1B, 0x00,
  0x4C, 0x03, 0x30, 0x08, 0xC0, 0x63, 0x01, 0x8C, 0x04, 0x30, 0x30, 0xC0,
  0x83, 0x06, 0x0C, 0x10, 0x30, 0xC0, 0xC3, 0x03, 0x08, 0x0C, 0x60, 0x31,
  0x00, 0xCC, 0x03, 0x20, 0x0C, 0x80, 0x36, 0x00, 0xD0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0xC0, 0x08, 0x01, 0xC0, 0x18, 0x03, 0xC0,
  0x18, 0x02, 0xC0, 0x38, 0x06, 0xC0, 0x28, 0x06, 0xC0, 0x28, 0x04, 0xC0,
  0x68, 0x0C, 0xC0, 0x48, 0x08, 0xC0, 0x48, 0x18, 0xC0, 0xC8, 0x18, 0xC0,
  0x98, 0x10, 0xC1, 0x98, 0x30, 0xC1, 0x18, 0x20, 0xC1, 0x18, 0x20, 0xC3,
  0x18, 0x60, 0xC2, 0x18, 0x40, 0xC6, 0x18, 0xC0, 0xC4, 0x18, 0x80, 0xC4,
  0x18, 0x80, 0xCC, 0x19, 0x80, 0x88, 0x11, 0x00, 0x98, 0x13, 0x00, 0x90,
  0x12, 0x00, 0x90, 0x12, 0x00, 0xB0, 0x16, 0x00, 0xA0, 0x14, 0x00, 0xE0,
  0x1C, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x00, 0xC0, 0x40,
  0x60, 0x10, 0x10, 0x04, 0x0C, 0x01, 0x82, 0x00, 0x61, 0x80, 0x18, 0x40,
  0x06, 0x30, 0x00, 0x88, 0x00, 0x26, 0x00, 0x0B, 0x00, 0x02, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x40, 0x00, 0xD0,
  0x00, 0x24, 0x00, 0x19, 0x80, 0x0C, 0x60, 0x02, 0x18, 0x01, 0x86, 0x00,
  0x41, 0x80, 0x30, 0x20, 0x08, 0x08, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0x20, 0x00, 0xC0, 0x1C, 0x03, 0xC0, 0x24, 0x06, 0x40, 0x44, 0x0C, 0x40,
  0x84, 0x18, 0x41, 0x06, 0x30, 0x62, 0x06, 0x60, 0x64, 0x02, 0xC0, 0x28,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFE, 0x03, 0xF8, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0xF8, 0x00, 0xC3, 0x0C, 0x10, 0x41, 0x04, 0x18,
  0x61, 0x82, 0x08, 0x20, 0x83, 0x0C, 0x30, 0x41, 0x04, 0x10, 0x61, 0x86,
  0x08, 0x20, 0x82, 0x0C, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x0F, 0xE0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xB0, 0x06, 0x40, 0x11, 0x80, 0xC2, 0x02, 0x0C, 0x18, 0x30, 0x40, 0x43,
  0x01, 0x98, 0x02, 0x60, 0x0F, 0x00, 0x30, 0xFF, 0xE0, 0x8C, 0x46, 0x22,
  0x10, 0x00, 0x80, 0x0F, 0x90, 0xE3, 0x43, 0x07, 0x18, 0x18, 0x40, 0x63,
  0x01, 0x88, 0x06, 0x60, 0x19, 0x80, 0x44, 0x01, 0x10, 0x0C, 0xC0, 0x33,
  0x00, 0xCC, 0x02, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x8C, 0x0C, 0x30, 0x50,
  0x63, 0x40, 0xF9, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x20, 0x17, 0xE0, 0xD0, 0xC3,
  0x83, 0x0C, 0x04, 0x30, 0x11, 0x80, 0x46, 0x01, 0x18, 0x04, 0x40, 0x31,
  0x00, 0xCC, 0x03, 0x30, 0x08, 0x80, 0x22, 0x01, 0x88, 0x06, 0x60, 0x11,
  0x80, 0xC6, 0x02, 0x1C, 0x18, 0x50, 0xC3, 0x7E, 0x00, 0x00, 0x80, 0x7C,
  0x38, 0x04, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20,
  0x06, 0x10, 0x7E, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x84, 0x03, 0xE4,
  0x0E, 0x3C, 0x08, 0x1C, 0x18, 0x18, 0x10, 0x18, 0x30, 0x18, 0x20, 0x18,
  0x60, 0x18, 0x60, 0x10, 0x40, 0x10, 0x40, 0x30, 0xC0, 0x30, 0xC0, 0x30,
  0xC0, 0x20, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0xC0, 0xC1, 0x40,
  0x63, 0x40, 0x3E, 0x40, 0x00, 0x80, 0x7E, 0x0C, 0x30, 0x83, 0x18, 0x33,
  0x03, 0x20, 0x26, 0x06, 0x60, 0x44, 0x0C, 0x47, 0x0F, 0xC0, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x83,
  0xF0, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x7F,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0xF9, 0x03, 0x8D, 0x02,
  0x07, 0x06, 0x06, 0x04, 0x06, 0x0C, 0x06, 0x08, 0x06, 0x18, 0x06, 0x18,
  0x04, 0x10, 0x04, 0x10, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x08, 0x30,
  0x18, 0x30, 0x18, 0x30, 0x38, 0x30, 0x30, 0x30, 0x50, 0x18, 0xD0, 0x0F,
  0xB0, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x81, 0x80, 0xFF, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x20, 0x17, 0xE0, 0xF0, 0x82, 0x83, 0x0C, 0x0C, 0x30, 0x20, 0x80, 0x86,
  0x02, 0x18, 0x18, 0x40, 0x61, 0x01, 0x0C, 0x04, 0x30, 0x10, 0x80, 0xC2,
  0x03, 0x08, 0x08, 0x60, 0x21, 0x81, 0x84, 0x06, 0x10, 0x18, 0x40, 0x43,
  0x01, 0x00, 0x02, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x0C,
  0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20,
  0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x00, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x78, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x30, 0xC1, 0x83, 0x0C, 0x08, 0x20, 0x21, 0x01,
  0x8C, 0x06, 0x60, 0x1B, 0x00, 0x4C, 0x01, 0x70, 0x0F, 0x40, 0x39, 0x00,
  0xC4, 0x02, 0x18, 0x08, 0x60, 0x61, 0x81, 0x82, 0x04, 0x08, 0x10, 0x20,
  0xC0, 0xC3, 0x03, 0x00, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04,
  0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30,
  0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0x00, 0x40,
  0x40, 0x6F, 0x8F, 0x83, 0xC6, 0x86, 0x14, 0x18, 0x10, 0xC0, 0xC0, 0x86,
  0x04, 0x04, 0x60, 0x60, 0x63, 0x03, 0x03, 0x18, 0x18, 0x10, 0x80, 0x80,
  0x84, 0x04, 0x04, 0x60, 0x60, 0x63, 0x03, 0x03, 0x10, 0x10, 0x10, 0x80,
  0x80, 0x84, 0x04, 0x0C, 0x60, 0x60, 0x63, 0x03, 0x03, 0x10, 0x10, 0x10,
  0x80, 0x80, 0x84, 0x0C, 0x0C, 0x60, 0x60, 0x60, 0x00, 0x20, 0x37, 0xE0,
  0xF0, 0x82, 0x83, 0x0C, 0x08, 0x30, 0x21, 0x80, 0x86, 0x02, 0x18, 0x18,
  0x40, 0x61, 0x01, 0x0C, 0x04, 0x30, 0x10, 0x80, 0xC2, 0x03, 0x08, 0x08,
  0x60, 0x21, 0x81, 0x84, 0x06, 0x10, 0x10, 0x40, 0x43, 0x01, 0x00, 0x00,
  0x80, 0x3F, 0x03, 0x0C, 0x30, 0x21, 0x81, 0x18, 0x0C, 0xC0, 0x64, 0x03,
  0x60, 0x1B, 0x00, 0x90, 0x04, 0x80, 0x2C, 0x03, 0x60, 0x1B, 0x00, 0x98,
  0x04, 0xC0, 0x66, 0x02, 0x30, 0x31, 0x83, 0x06, 0x30, 0x1F, 0x00, 0x00,
  0x08, 0x01, 0x3E, 0x03, 0x43, 0x02, 0x83, 0x03, 0x01, 0x03, 0x01, 0x06,
  0x01, 0x06, 0x01, 0x06, 0x01, 0x04, 0x01, 0x04, 0x03, 0x0C, 0x03, 0x0C,
  0x03, 0x0C, 0x02, 0x08, 0x06, 0x08, 0x06, 0x18, 0x04, 0x18, 0x0C, 0x18,
  0x08, 0x1C, 0x18, 0x14, 0x30, 0x37, 0xE0, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x1F, 0x90, 0xC3, 0x42, 0x07, 0x18, 0x18, 0x40, 0x63,
  0x01, 0x88, 0x06, 0x60, 0x19, 0x80, 0x44, 0x01, 0x10, 0x04, 0xC0, 0x33,
  0x00, 0xCC, 0x02, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x8C, 0x0C, 0x30, 0x50,
  0x63, 0x40, 0xFB, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x00, 0x21, 0xBC, 0x3C,
  0x05, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18,
  0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x3F, 0xC3, 0x04, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x0C,
  0x38, 0x7F, 0x80, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x7F, 0x18, 0x10, 0x10,
  0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0,
  0x80, 0x80, 0x80, 0x80, 0xF0, 0x18, 0x08, 0xC0, 0x46, 0x06, 0x20, 0x31,
  0x01, 0x18, 0x08, 0xC0, 0x44, 0x06, 0x20, 0x31, 0x01, 0x18, 0x08, 0xC0,
  0xC4, 0x06, 0x20, 0x33, 0x01, 0x18, 0x18, 0xC0, 0xC6, 0x0E, 0x30, 0x61,
  0x85, 0x07, 0xC8, 0x00, 0xC0, 0x38, 0x0F, 0x01, 0x60, 0x6C, 0x09, 0x83,
  0x30, 0x46, 0x18, 0xC3, 0x18, 0x43, 0x18, 0x62, 0x0C, 0xC1, 0x90, 0x36,
  0x06, 0xC0, 0xD0, 0x1E, 0x03, 0x80, 0x70, 0x0C, 0x00, 0xC0, 0x60, 0x78,
  0x1C, 0x0B, 0x03, 0x83, 0x60, 0x70, 0x4C, 0x1E, 0x09, 0x82, 0xC3, 0x30,
  0xD8, 0x46, 0x13, 0x18, 0xC2, 0x62, 0x18, 0xCC, 0x43, 0x11, 0x98, 0x66,
  0x22, 0x0C, 0x84, 0x41, 0x90, 0x98, 0x36, 0x12, 0x06, 0x82, 0xC0, 0xF0,
  0x50, 0x1C, 0x0A, 0x03, 0x81, 0xC0, 0x70, 0x30, 0x0C, 0x06, 0x00, 0x06,
  0x06, 0x0C, 0x08, 0x08, 0x30, 0x10, 0xC0, 0x21, 0x00, 0x66, 0x00, 0xC8,
  0x00, 0xA0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x28, 0x00,
  0x90, 0x03, 0x30, 0x04, 0x60, 0x18, 0x40, 0x60, 0x80, 0x81, 0x03, 0x03,
  0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x18, 0x18, 0x06, 0x06,
  0x01, 0x81, 0x00, 0x60, 0xC0, 0x18, 0x20, 0x06, 0x18, 0x01, 0x84, 0x00,
  0x63, 0x00, 0x18, 0x80, 0x06, 0x20, 0x01, 0x98, 0x00, 0x64, 0x00, 0x1B,
  0x00, 0x06, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0xF0, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xFF, 0x00, 0x00, 0x0C, 0x01,
  0xF0, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x03, 0xC0, 0x0F, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x80, 0x03,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x70, 0x03, 0xC0, 0x18, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x30, 0x0F, 0x80, 0x00, 0x3C,
  0x05, 0xBC, 0x18, 0x1F, 0xE0, 0x08,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 29, 8, 1, -29 },
  { 30, 8, 11, 11, 4, -29 },
  { 41, 16, 29, 15, 0, -29 },
  { 99, 15, 32, 14, 0, -30 },
  { 159, 18, 29, 22, 2, -29 },
  { 225, 13, 29, 14, 0, -29 },
  { 273, 3, 11, 6, 4, -29 },
  { 278, 11, 34, 10, 1, -28 },
  { 325, 11, 34, 10, -3, -28 },
  { 372, 10, 11, 13, 5, -30 },
  { 386, 14, 18, 16, 1, -23 },
  { 418, 6, 9, 7, -2, -4 },
  { 425, 8, 2, 10, 1, -12 },
  { 427, 2, 3, 7, 1, -3 },
  { 428, 17, 29, 12, -2, -29 },
  { 490, 13, 29, 14, 1, -29 },
  { 538, 8, 29, 14, 4, -29 },
  { 567, 15, 29, 14, -1, -29 },
  { 622, 15, 29, 14, -1, -29 },
  { 677, 15, 29, 14, -1, -29 },
  { 732, 15, 29, 14, -1, -29 },
  { 787, 14, 29, 14, 1, -29 },
  { 838, 15, 29, 14, 1, -29 },
  { 893, 15, 29, 14, 0, -29 },
  { 948, 14, 29, 14, 0, -29 },
  { 999, 6, 21, 7, 0, -21 },
  { 1015, 9, 26, 7, -2, -21 },
  { 1045, 14, 16, 16, 1, -22 },
  { 1073, 14, 10, 16, 1, -19 },
  { 1091, 14, 16, 16, 1, -22 },
  { 1119, 11, 29, 10, 1, -29 },
  { 1159, 19, 33, 21, 1, -29 },
  { 1238, 14, 29, 14, -3, -29 },
  { 1289, 16, 29, 15, 0, -29 },
  { 1347, 16, 29, 14, 1, -29 },
  { 1405, 16, 29, 17, 0, -29 },
  { 1463, 15, 29, 14, 0, -29 },
  { 1518, 15, 29, 13, 0, -29 },
  { 1573, 18, 29, 18, 1, -29 },
  { 1639, 19, 29, 18, 0, -29 },
  { 1708, 12, 29, 7, -2, -29 },
  { 1752, 14, 36, 7, -6, -29 },
  { 1815, 17, 29, 14, 0, -29 },
  { 1877, 9, 29, 12, 0, -29 },
  { 1910, 25, 29, 24, 0, -29 },
  { 2001, 19, 29, 19, 0, -29 },
  { 2070, 16, 29, 18, 1, -29 },
  { 2128, 15, 29, 15, 0, -29 },
  { 2183, 16, 36, 18, 1, -29 },
  { 2255, 15, 29, 15, 0, -29 },
  { 2310, 16, 29, 14, -1, -29 },
  { 2368, 12, 29, 12, 3, -29 },
  { 2412, 17, 29, 17, 1, -29 },
  { 2474, 14, 29, 14, 3, -29 },
  { 2525, 24, 29, 24, 3, -29 },
  { 2612, 18, 29, 13, -2, -29 },
  { 2678, 12, 29, 12, 3, -29 },
  { 2722, 17, 29, 12, -2, -29 },
  { 2784, 15, 35, 11, -1, -29 },
  { 2850, 6, 29, 13, 4, -29 },
  { 2872, 14, 35, 11, -2, -29 },
  { 2934, 14, 14, 16, 1, -29 },
  { 2959, 11, 1, 11, -3, 4 },
  { 2961, 4, 7, 9, 6, -31 },
  { 2965, 14, 22, 16, 1, -22 },
  { 3004, 14, 30, 15, 0, -30 },
  { 3057, 11, 22, 11, 1, -22 },
  { 3088, 16, 30, 16, 1, -30 },
  { 3148, 12, 22, 13, 1, -22 },
  { 3181, 17, 41, 8, -5, -31 },
  { 3269, 16, 32, 15, -1, -22 },
  { 3333, 14, 30, 15, 0, -30 },
  { 3386, 8, 29, 7, 0, -29 },
  { 3415, 13, 39, 7, -5, -29 },
  { 3479, 14, 30, 12, 0, -30 },
  { 3532, 8, 30, 6, 0, -30 },
  { 3562, 21, 22, 22, 0, -22 },
  { 3620, 14, 22, 15, 0, -22 },
  { 3659, 13, 22, 15, 1, -22 },
  { 3695, 16, 31, 15, -2, -22 },
  { 3757, 14, 31, 16, 1, -22 },
  { 3812, 11, 22, 10, 0, -22 },
  { 3843, 13, 22, 11, -1, -22 },
  { 3879, 8, 26, 8, 1, -26 },
  { 3905, 13, 21, 15, 1, -21 },
  { 3940, 11, 21, 11, 2, -21 },
  { 3969, 19, 21, 19, 2, -21 },
  { 4019, 15, 21, 12, -2, -21 },
  { 4059, 18, 31, 12, -4, -21 },
  { 4129, 12, 21, 10, -1, -21 },
  { 4161, 14, 35, 13, 1, -29 },
  { 4223, 2, 40, 14, 6, -30 },
  { 4233, 14, 35, 12, -3, -29 },
  { 4295, 14, 4, 16, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC40PT7B_H_
