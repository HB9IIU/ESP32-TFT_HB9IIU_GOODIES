#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC50PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x00, 0x30, 0xCC,
  0x33, 0x0C, 0x83, 0x60, 0x98, 0x66, 0x19, 0x86, 0x41, 0x30, 0x4C, 0x33,
  0x0C, 0x82, 0x00, 0x00, 0x18, 0x30, 0x01, 0x02, 0x00, 0x30, 0x60, 0x03,
  0x06, 0x00, 0x30, 0x40, 0x02, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x08, 0x00,
  0x41, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x00, 0xFF, 0xFF, 0x01, 0x83, 0x00,
  0x18, 0x30, 0x01, 0x02, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x20, 0x40,
  0x02, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x08, 0x00, 0x41, 0x80, 0x0C, 0x18,
  0x0F, 0xFF, 0xF0, 0x08, 0x30, 0x01, 0x83, 0x00, 0x18, 0x20, 0x01, 0x06,
  0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x20, 0x40, 0x06, 0x0C, 0x00, 0x60,
  0xC0, 0x06, 0x08, 0x00, 0x41, 0x80, 0x0C, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xC0,
  0xE6, 0x30, 0x30, 0xC0, 0x06, 0x10, 0x01, 0x82, 0x00, 0x30, 0x40, 0x06,
  0x18, 0x00, 0xC3, 0x00, 0x18, 0x40, 0x03, 0x08, 0x00, 0x31, 0x00, 0x06,
  0x60, 0x00, 0x6C, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x01,
  0xE0, 0x00, 0x2E, 0x00, 0x04, 0xC0, 0x00, 0x8C, 0x00, 0x31, 0x80, 0x06,
  0x18, 0x00, 0x83, 0x00, 0x10, 0x60, 0x02, 0x08, 0x00, 0xC3, 0x00, 0x18,
  0x60, 0x02, 0x18, 0x10, 0x47, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0xC0, 0x08, 0x0F, 0xC0, 0x30, 0x31, 0x80, 0x40, 0xC1, 0x01, 0x81, 0x82,
  0x02, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x10, 0x18, 0x10, 0x60, 0x60, 0x60,
  0x80, 0xC0, 0xC3, 0x01, 0x81, 0x84, 0x03, 0x03, 0x18, 0x04, 0x04, 0x20,
  0x08, 0x18, 0xC0, 0x30, 0x31, 0x0E, 0x60, 0x66, 0x3E, 0xC1, 0x88, 0xC7,
  0x83, 0x33, 0x0F, 0x0C, 0x44, 0x1A, 0x19, 0x98, 0x37, 0xE2, 0x30, 0x67,
  0x8C, 0xC0, 0xC0, 0x11, 0x81, 0x80, 0x63, 0x03, 0x00, 0x84, 0x04, 0x03,
  0x18, 0x18, 0x04, 0x30, 0x30, 0x18, 0x60, 0x60, 0x20, 0xC0, 0xC0, 0xC1,
  0x83, 0x01, 0x03, 0x06, 0x06, 0x06, 0x08, 0x08, 0x0C, 0x30, 0x30, 0x18,
  0x40, 0x40, 0x31, 0x81, 0x80, 0x3E, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3E,
  0x00, 0x3B, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x06,
  0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x31, 0x80,
  0x18, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0xCC, 0x00, 0xC6, 0x00, 0xC3, 0x0C, 0x60, 0x86, 0x60,
  0x63, 0x30, 0x33, 0x30, 0x19, 0x98, 0x04, 0x8C, 0x03, 0xC4, 0x01, 0xC6,
  0x00, 0xE3, 0x00, 0x71, 0x80, 0x38, 0x60, 0x3C, 0x30, 0x32, 0x1C, 0x71,
  0x87, 0xF0, 0xC0, 0x40, 0x00, 0x33, 0x32, 0x66, 0x66, 0x44, 0xCC, 0x80,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x18, 0x00, 0xC1, 0x04, 0x0C, 0x20, 0x39, 0x08, 0x6F, 0xE0, 0xE0, 0x0E,
  0x00, 0xD8, 0x0C, 0x41, 0xC3, 0x04, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x1F, 0xFF, 0xF0, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0E, 0x18,
  0x30, 0x41, 0x83, 0x0C, 0x18, 0x60, 0xC3, 0x00, 0xFF, 0xE0, 0x5F, 0xE0,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x60,
  0xC0, 0x60, 0x60, 0x30, 0x30, 0x30, 0x08, 0x18, 0x04, 0x18, 0x03, 0x0C,
  0x01, 0x0C, 0x00, 0x86, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18,
  0xC0, 0x0C, 0x60, 0x06, 0x60, 0x03, 0x30, 0x01, 0x18, 0x01, 0x8C, 0x00,
  0xC6, 0x00, 0x62, 0x00, 0x33, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60,
  0x06, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x06, 0x01, 0x83, 0x00, 0xC1,
  0x80, 0xC0, 0xC0, 0xC0, 0x30, 0x60, 0x1C, 0xE0, 0x07, 0xE0, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0xF0, 0x78, 0x3E, 0x19, 0x8C, 0x66, 0x19, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xFC, 0x00, 0xC0, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0E, 0x07, 0x00,
  0x80, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x09,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x10, 0x06,
  0x03, 0x83, 0x80, 0x7F, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x05, 0x00, 0x01, 0xE0, 0x00, 0x2C, 0x00, 0x0D, 0x80, 0x03,
  0x30, 0x00, 0x4C, 0x00, 0x19, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x30,
  0x80, 0x04, 0x30, 0x01, 0x86, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x02,
  0x00, 0x40, 0xC0, 0x18, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x18,
  0x04, 0x03, 0x01, 0x80, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x03, 0xFF, 0xFE,
  0x7F, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x7F, 0x80,
  0x0F, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x10, 0x06, 0x03, 0x87, 0x80, 0x7F, 0xE0, 0x00,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x1E, 0x00,
  0xDF, 0xE0, 0x2C, 0x1C, 0x1A, 0x03, 0x07, 0x00, 0x61, 0xC0, 0x18, 0x60,
  0x06, 0x18, 0x01, 0x8E, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01,
  0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x06, 0x0C, 0x01, 0x83,
  0x00, 0xE0, 0x60, 0x30, 0x18, 0x18, 0x03, 0x9C, 0x00, 0x7E, 0x00, 0x04,
  0x00, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0xF0, 0x07, 0x03, 0x00, 0xC0, 0x30, 0x30, 0x06, 0x06,
  0x00, 0xC0, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x08,
  0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x06, 0x07, 0x00, 0x61, 0xC0, 0x06,
  0x60, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x0E, 0xC0, 0x03, 0x8C, 0x00, 0xC0,
  0xC0, 0x30, 0x1C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x60, 0x03, 0x0C, 0x00,
  0x61, 0x80, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01,
  0x83, 0x00, 0x30, 0x60, 0x0C, 0x06, 0x03, 0x80, 0xF0, 0xE0, 0x07, 0xF8,
  0x00, 0x10, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0xE0, 0xC0, 0x60, 0x30,
  0x60, 0x18, 0x30, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x8C, 0x00,
  0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30,
  0x07, 0x18, 0x03, 0x8C, 0x03, 0x86, 0x01, 0xC1, 0x83, 0x60, 0xFF, 0x30,
  0x3F, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x21, 0xE0, 0x1F, 0xC0, 0x03, 0x00, 0x00, 0x02, 0x07,
  0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0,
  0xC0, 0x00, 0x40, 0x30, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0xC0, 0x81, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x38, 0x0C, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x02, 0x01,
  0x80, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x01, 0x06, 0x00, 0x01, 0x04,
  0x00, 0x01, 0x0C, 0x03, 0xC1, 0x08, 0x0F, 0xE1, 0x18, 0x18, 0xC1, 0x18,
  0x30, 0xC1, 0x10, 0x20, 0xC1, 0x30, 0x60, 0x83, 0x30, 0x41, 0x83, 0x20,
  0xC1, 0x83, 0x60, 0x81, 0x83, 0x61, 0x81, 0x02, 0x61, 0x83, 0x06, 0x61,
  0x83, 0x06, 0x41, 0x83, 0x06, 0x41, 0x02, 0x04, 0xC1, 0x06, 0x0C, 0xC1,
  0x06, 0x08, 0xC1, 0x0E, 0x18, 0xC1, 0x8A, 0x10, 0xC1, 0x9B, 0x70, 0xC0,
  0xF1, 0xE0, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x58, 0x00, 0x6C, 0x00, 0x36, 0x00,
  0x33, 0x00, 0x19, 0x80, 0x08, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x06, 0x18,
  0x03, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xC0, 0xC0, 0x60,
  0x60, 0x60, 0x30, 0x30, 0x18, 0x1F, 0xFC, 0x18, 0x06, 0x0C, 0x03, 0x0C,
  0x01, 0x86, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x31, 0x80, 0x19, 0x80, 0x0C,
  0xC0, 0x06, 0xE0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x30, 0x00, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0x81, 0xC0, 0x18, 0x0E, 0x01,
  0x80, 0x60, 0x10, 0x06, 0x03, 0x00, 0x30, 0x30, 0x02, 0x03, 0x00, 0x60,
  0x30, 0x06, 0x02, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0xC0, 0x60, 0x0C,
  0x06, 0x01, 0x80, 0xC0, 0x70, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0C, 0x1E,
  0x00, 0xC0, 0x60, 0x18, 0x03, 0x01, 0x80, 0x30, 0x18, 0x01, 0x81, 0x80,
  0x18, 0x10, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x03, 0x00, 0x30, 0x30,
  0x03, 0x02, 0x00, 0x30, 0x60, 0x06, 0x06, 0x00, 0xE0, 0x60, 0x1C, 0x06,
  0x03, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xFC,
  0x03, 0x80, 0x80, 0xE0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xF1, 0x80, 0x0F, 0xF0, 0x00, 0x10, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0xF8, 0x01, 0x83, 0xC0, 0x18, 0x0E, 0x01, 0x80, 0x60,
  0x10, 0x07, 0x03, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x30, 0x03,
  0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00,
  0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0x80,
  0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x10,
  0x00, 0xC3, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x38, 0x30, 0x03, 0x06,
  0x00, 0x60, 0x60, 0x0E, 0x06, 0x01, 0xC0, 0x60, 0x38, 0x04, 0x0F, 0x00,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFC,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xF0, 0x0E, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0xFE, 0x30, 0x03, 0xF8, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x04, 0x0C, 0x00, 0x30, 0x18, 0x00,
  0xC0, 0x70, 0x03, 0x00, 0xE0, 0x0C, 0x01, 0xE0, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x20, 0x01, 0x80, 0xC0, 0x03, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x08, 0x06, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x02, 0x01, 0x80, 0x0C, 0x06, 0x00,
  0x18, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x30, 0x01, 0x80, 0x40, 0x03,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x10, 0x0C, 0x00, 0x60,
  0x10, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x04, 0x03,
  0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60,
  0x03, 0x00, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x1F, 0x80, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x1C, 0x06, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80,
  0xE0, 0x04, 0x03, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x07, 0x00,
  0x0C, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18,
  0xC0, 0x00, 0x66, 0x00, 0x03, 0x38, 0x00, 0x0C, 0xC0, 0x00, 0x37, 0x00,
  0x00, 0xF6, 0x00, 0x02, 0x98, 0x00, 0x1C, 0x60, 0x00, 0x61, 0x80, 0x01,
  0x82, 0x00, 0x06, 0x0C, 0x00, 0x10, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30,
  0x03, 0x80, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x03, 0xC0, 0x2C, 0x00, 0x0D, 0x80, 0xD8, 0x00, 0x1A, 0x01,
  0xB0, 0x00, 0x6C, 0x03, 0x60, 0x00, 0xD8, 0x06, 0xC0, 0x03, 0x30, 0x19,
  0x80, 0x06, 0x60, 0x33, 0x00, 0x09, 0x80, 0x66, 0x00, 0x33, 0x00, 0xCC,
  0x00, 0x46, 0x01, 0x18, 0x01, 0x8C, 0x06, 0x30, 0x03, 0x18, 0x0C, 0x60,
  0x0C, 0x60, 0x18, 0xC0, 0x18, 0xC0, 0x31, 0x80, 0x61, 0x80, 0x41, 0x00,
  0xC3, 0x01, 0x82, 0x03, 0x04, 0x03, 0x04, 0x06, 0x18, 0x06, 0x08, 0x18,
  0x30, 0x0C, 0x10, 0x30, 0x60, 0x10, 0x30, 0xC0, 0xC0, 0x60, 0x61, 0x81,
  0x00, 0xC0, 0xC6, 0x06, 0x01, 0x81, 0x8C, 0x0C, 0x03, 0x03, 0x30, 0x18,
  0x0C, 0x06, 0x60, 0x30, 0x18, 0x0C, 0x80, 0xC0, 0x30, 0x1B, 0x01, 0x80,
  0x60, 0x34, 0x03, 0x00, 0x80, 0x78, 0x06, 0x03, 0x00, 0xF0, 0x08, 0x06,
  0x01, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x01, 0xC0,
  0x03, 0x01, 0xE0, 0x03, 0x01, 0xE0, 0x02, 0x01, 0x60, 0x06, 0x03, 0x60,
  0x06, 0x03, 0x60, 0x06, 0x03, 0x20, 0x06, 0x03, 0x30, 0x04, 0x06, 0x30,
  0x0C, 0x06, 0x30, 0x0C, 0x06, 0x30, 0x0C, 0x06, 0x10, 0x0C, 0x06, 0x18,
  0x18, 0x0C, 0x18, 0x18, 0x0C, 0x18, 0x18, 0x0C, 0x18, 0x18, 0x0C, 0x18,
  0x10, 0x08, 0x08, 0x30, 0x18, 0x0C, 0x30, 0x18, 0x0C, 0x30, 0x18, 0x0C,
  0x30, 0x18, 0x0C, 0x20, 0x10, 0x0C, 0x60, 0x30, 0x04, 0x60, 0x30, 0x06,
  0x60, 0x30, 0x06, 0x60, 0x30, 0x06, 0x40, 0x60, 0x06, 0xC0, 0x60, 0x02,
  0xC0, 0x60, 0x03, 0xC0, 0x60, 0x03, 0xC0, 0x40, 0x03, 0x80, 0xC0, 0x03,
  0x80, 0xC0, 0x03, 0x80, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01, 0xC0, 0xC0,
  0x38, 0x06, 0x03, 0x00, 0x60, 0x60, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00,
  0x33, 0x00, 0x03, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0,
  0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C,
  0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0xC0,
  0x60, 0x18, 0x06, 0x03, 0x80, 0x38, 0xF0, 0x01, 0xFC, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x3F, 0xE0, 0x06, 0x0E, 0x00, 0xC0, 0xE0, 0x18,
  0x0C, 0x02, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0x60,
  0x0C, 0x18, 0x01, 0x83, 0x00, 0x20, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80,
  0x70, 0x60, 0x0C, 0x0C, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x78, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01, 0xC0, 0xC0, 0x38,
  0x06, 0x03, 0x00, 0x60, 0x60, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x18,
  0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x33,
  0x00, 0x03, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06,
  0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00,
  0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00,
  0x30, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0xC0, 0x60,
  0x18, 0x06, 0x03, 0x80, 0x38, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x00, 0x3F,
  0xE0, 0x06, 0x0E, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x02, 0x00, 0xC0, 0xC0,
  0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x18, 0x01, 0x83, 0x00,
  0x60, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x60, 0x0C, 0x0C, 0x03,
  0x01, 0x80, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0x86, 0x00, 0x30, 0xC0,
  0x06, 0x0C, 0x00, 0xC1, 0x80, 0x10, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0,
  0x18, 0x08, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x08, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x00, 0x00, 0x3F,
  0xC0, 0x0F, 0xFF, 0x01, 0xC0, 0x20, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x08, 0x03, 0x80, 0xF0,
  0xF0, 0x0F, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x18, 0x30, 0x00,
  0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x40, 0x03, 0x06, 0x00, 0x18, 0x30,
  0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x10,
  0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00,
  0x10, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x08, 0x00, 0x60, 0xC0, 0x03, 0x06,
  0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x02,
  0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x40, 0x40,
  0x06, 0x02, 0x00, 0x30, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x07, 0x01, 0x80,
  0x1E, 0x38, 0x00, 0x7F, 0x80, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00,
  0x63, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x01, 0x83, 0x00, 0x60,
  0xC0, 0x18, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x30,
  0x03, 0x0C, 0x00, 0xC2, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x30, 0x00,
  0xCC, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xB0, 0x01, 0xC0, 0x06, 0xC0, 0x07, 0x00,
  0x33, 0x00, 0x3C, 0x00, 0xCC, 0x00, 0xF0, 0x03, 0x30, 0x06, 0xC0, 0x18,
  0xC0, 0x1B, 0x00, 0x63, 0x00, 0x4C, 0x03, 0x0C, 0x03, 0x30, 0x0C, 0x30,
  0x0C, 0xC0, 0x30, 0xC0, 0x23, 0x01, 0x83, 0x01, 0x8C, 0x06, 0x0C, 0x06,
  0x30, 0x30, 0x30, 0x30, 0xC0, 0xC0, 0xC0, 0xC3, 0x03, 0x03, 0x02, 0x0C,
  0x18, 0x0C, 0x18, 0x30, 0x60, 0x30, 0x60, 0xC3, 0x00, 0xC3, 0x03, 0x0C,
  0x03, 0x0C, 0x08, 0x30, 0x0C, 0x20, 0x21, 0x80, 0x31, 0x80, 0x86, 0x00,
  0xC6, 0x02, 0x10, 0x03, 0x30, 0x08, 0xC0, 0x0C, 0xC0, 0x23, 0x00, 0x32,
  0x00, 0x98, 0x00, 0xD8, 0x02, 0x60, 0x03, 0x60, 0x09, 0x00, 0x0B, 0x00,
  0x6C, 0x00, 0x2C, 0x01, 0xB0, 0x00, 0xB0, 0x07, 0x80, 0x03, 0x80, 0x1E,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x30, 0x01,
  0x80, 0xC0, 0x02, 0x06, 0x00, 0x08, 0x10, 0x00, 0x30, 0xC0, 0x00, 0xC6,
  0x00, 0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xD8, 0x00,
  0x03, 0x60, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x68, 0x00, 0x03, 0x20, 0x00, 0x0C, 0x80,
  0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0xC0, 0x01,
  0x83, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x01,
  0x00, 0x30, 0x04, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x30, 0x01, 0x80,
  0x60, 0x03, 0x60, 0x03, 0x60, 0x06, 0x60, 0x06, 0x20, 0x0C, 0x20, 0x0C,
  0x30, 0x18, 0x30, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x30, 0x60,
  0x30, 0xC0, 0x30, 0xC0, 0x31, 0x80, 0x11, 0x00, 0x13, 0x00, 0x12, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xC1, 0x83, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x81,
  0x03, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x40, 0xC1, 0x83, 0x06, 0x0C, 0x08,
  0x10, 0x30, 0x60, 0xC1, 0x83, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0x98,
  0x00, 0x66, 0x00, 0x30, 0xC0, 0x08, 0x30, 0x06, 0x0C, 0x01, 0x01, 0x80,
  0xC0, 0x60, 0x60, 0x0C, 0x18, 0x03, 0x0C, 0x00, 0x63, 0x00, 0x19, 0x80,
  0x06, 0x60, 0x00, 0xF0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0x18,
  0x63, 0x08, 0x21, 0x00, 0x78, 0x00, 0x7F, 0x30, 0x38, 0x6C, 0x18, 0x0A,
  0x0E, 0x02, 0x83, 0x00, 0xE1, 0x80, 0x38, 0x60, 0x0E, 0x30, 0x03, 0x0C,
  0x00, 0xC3, 0x00, 0x30, 0x80, 0x0C, 0x60, 0x02, 0x18, 0x01, 0x86, 0x00,
  0x61, 0x80, 0x18, 0x60, 0x06, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30,
  0xC0, 0x1C, 0x30, 0x07, 0x06, 0x03, 0x81, 0x80, 0xA0, 0x60, 0x58, 0x0E,
  0x76, 0x03, 0xF1, 0x80, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x78, 0x02, 0x7F, 0x01,
  0xB0, 0xE0, 0x68, 0x18, 0x1C, 0x03, 0x07, 0x00, 0xC1, 0x80, 0x30, 0xE0,
  0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x80, 0x08, 0x60, 0x06,
  0x18, 0x01, 0x86, 0x00, 0x61, 0x00, 0x18, 0xC0, 0x04, 0x30, 0x03, 0x0C,
  0x00, 0xC3, 0x00, 0x30, 0xC0, 0x18, 0x70, 0x06, 0x1C, 0x03, 0x07, 0x01,
  0xC1, 0x60, 0xE0, 0x4C, 0x70, 0x33, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x7C,
  0x07, 0xF0, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xE3, 0x01, 0xFC, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x07, 0x8C, 0x01, 0xFC, 0xC0, 0x38, 0x6C, 0x06, 0x02,
  0x80, 0xE0, 0x38, 0x0C, 0x03, 0x81, 0x80, 0x38, 0x18, 0x03, 0x83, 0x00,
  0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x20, 0x03, 0x06, 0x00, 0x20, 0x60,
  0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x0C,
  0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x01, 0xC0, 0xC0, 0x1C, 0x06, 0x03, 0x80,
  0x60, 0x38, 0x06, 0x05, 0x80, 0x39, 0xD8, 0x03, 0xF1, 0x80, 0x04, 0x00,
  0x00, 0x00, 0x78, 0x03, 0xF8, 0x0C, 0x38, 0x30, 0x30, 0xC0, 0x61, 0x80,
  0xC6, 0x01, 0x8C, 0x03, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x63, 0x03, 0x86,
  0x1E, 0x0F, 0xF0, 0x1C, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x20,
  0x70, 0xC0, 0x7F, 0x80, 0x10, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x10, 0x00, 0x7F, 0x80, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x07, 0xF3, 0x00, 0xE1, 0xB0, 0x18, 0x0A, 0x03, 0x80,
  0xA0, 0x30, 0x0E, 0x06, 0x00, 0xE0, 0x60, 0x0E, 0x0C, 0x00, 0xC0, 0xC0,
  0x0C, 0x0C, 0x00, 0xC0, 0x80, 0x0C, 0x18, 0x00, 0x81, 0x80, 0x18, 0x18,
  0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x83, 0x00, 0x30, 0x30, 0x03, 0x03,
  0x00, 0x30, 0x30, 0x07, 0x03, 0x00, 0x70, 0x10, 0x0E, 0x01, 0x80, 0xE0,
  0x18, 0x16, 0x00, 0xC7, 0x60, 0x0F, 0xC6, 0x00, 0x10, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x80, 0xE0, 0x0F, 0xFC, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x63, 0xC0, 0x27, 0xF0, 0x36, 0x1C, 0x1E, 0x06, 0x0E, 0x03,
  0x06, 0x01, 0x83, 0x00, 0xC3, 0x80, 0x61, 0x80, 0x20, 0xC0, 0x30, 0x60,
  0x18, 0x20, 0x0C, 0x30, 0x06, 0x18, 0x02, 0x0C, 0x03, 0x06, 0x01, 0x82,
  0x00, 0xC3, 0x00, 0x61, 0x80, 0x60, 0xC0, 0x30, 0x40, 0x18, 0x60, 0x0C,
  0x30, 0x04, 0x18, 0x06, 0x0C, 0x03, 0x04, 0x01, 0x86, 0x00, 0xC0, 0x00,
  0xC0, 0x70, 0x1C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x70, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x18, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x18,
  0x06, 0x0C, 0x02, 0x0C, 0x03, 0x0C, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x66,
  0x00, 0x67, 0x00, 0x37, 0x80, 0x1A, 0xC0, 0x0F, 0x60, 0x07, 0x10, 0x07,
  0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x40, 0xC0, 0x60, 0x20,
  0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x04, 0x03, 0x06, 0x01, 0x80, 0x00,
  0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x00, 0x00,
  0x1C, 0x0F, 0x00, 0x9F, 0xCF, 0xF0, 0x6C, 0x36, 0x0C, 0x1C, 0x05, 0x03,
  0x07, 0x01, 0x80, 0x41, 0x80, 0x60, 0x10, 0x60, 0x18, 0x0C, 0x30, 0x0C,
  0x03, 0x0C, 0x03, 0x00, 0xC3, 0x00, 0xC0, 0x30, 0xC0, 0x30, 0x08, 0x60,
  0x08, 0x06, 0x18, 0x06, 0x01, 0x86, 0x01, 0x80, 0x61, 0x80, 0x60, 0x18,
  0x60, 0x18, 0x04, 0x30, 0x0C, 0x03, 0x0C, 0x03, 0x00, 0xC3, 0x00, 0xC0,
  0x30, 0xC0, 0x30, 0x0C, 0x20, 0x08, 0x02, 0x18, 0x06, 0x01, 0x86, 0x01,
  0x80, 0x61, 0x80, 0x60, 0x18, 0x60, 0x18, 0x04, 0x10, 0x04, 0x03, 0x0C,
  0x03, 0x00, 0xC0, 0x00, 0x1E, 0x01, 0x3F, 0x81, 0xB0, 0xE0, 0xF0, 0x30,
  0x70, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x1C, 0x03, 0x0C, 0x01, 0x06, 0x01,
  0x83, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x30, 0x60, 0x18, 0x30,
  0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x03, 0x06, 0x01, 0x82, 0x00, 0xC3,
  0x00, 0x61, 0x80, 0x20, 0xC0, 0x30, 0x60, 0x18, 0x20, 0x0C, 0x30, 0x06,
  0x00, 0x00, 0x78, 0x01, 0xFC, 0x03, 0x06, 0x06, 0x06, 0x0C, 0x03, 0x0C,
  0x03, 0x18, 0x03, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x60,
  0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x06, 0x60, 0x06, 0x40, 0x06, 0xC0,
  0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x40, 0x18, 0x60,
  0x30, 0x60, 0x60, 0x39, 0xC0, 0x1F, 0x80, 0x04, 0x00, 0x00, 0x07, 0x80,
  0x09, 0xFC, 0x01, 0xB0, 0xE0, 0x1A, 0x06, 0x01, 0xC0, 0x30, 0x1C, 0x03,
  0x01, 0x80, 0x30, 0x38, 0x03, 0x03, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00,
  0x30, 0x20, 0x03, 0x06, 0x00, 0x20, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60,
  0x06, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C,
  0x01, 0x81, 0xC0, 0x18, 0x1C, 0x03, 0x01, 0xC0, 0x70, 0x1E, 0x0E, 0x01,
  0x31, 0xC0, 0x33, 0xF8, 0x03, 0x04, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F,
  0x30, 0x30, 0x6C, 0x18, 0x0A, 0x0C, 0x03, 0x83, 0x00, 0xE1, 0x80, 0x38,
  0x60, 0x0E, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x60,
  0x02, 0x18, 0x00, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x10, 0x03,
  0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x1C, 0x30, 0x07, 0x04, 0x03, 0x81,
  0x80, 0xE0, 0x60, 0x58, 0x0C, 0x76, 0x03, 0xF1, 0x80, 0x10, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x09, 0xF0, 0x6C, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xF8, 0x03, 0xFF, 0x07, 0x02, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x80, 0x60, 0xE1, 0xC0, 0x7F, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x20,
  0x18, 0x06, 0x01, 0x80, 0x40, 0xFF, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x10,
  0x78, 0x08, 0x00, 0x06, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x41, 0x80, 0x60,
  0xC0, 0x30, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x0C, 0x18, 0x06, 0x08, 0x03,
  0x0C, 0x01, 0x86, 0x00, 0x83, 0x00, 0xC1, 0x80, 0x60, 0x80, 0x30, 0xC0,
  0x18, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x08, 0x03, 0x0C, 0x03, 0x86,
  0x01, 0x83, 0x01, 0xC1, 0x81, 0xE0, 0x71, 0xB0, 0x1F, 0x98, 0x02, 0x00,
  0x00, 0xC0, 0x1F, 0x00, 0x6C, 0x01, 0x30, 0x0C, 0xC0, 0x33, 0x01, 0x8C,
  0x06, 0x30, 0x30, 0xC0, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0x40, 0xC3, 0x03,
  0x0C, 0x0C, 0x60, 0x31, 0x80, 0xCC, 0x03, 0x30, 0x0C, 0x80, 0x36, 0x00,
  0xD8, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xC0,
  0x18, 0x07, 0x80, 0x70, 0x0B, 0x00, 0xE0, 0x36, 0x03, 0xC0, 0x6C, 0x07,
  0x81, 0x98, 0x0B, 0x03, 0x30, 0x36, 0x04, 0x60, 0x4C, 0x18, 0xC1, 0x98,
  0x31, 0x83, 0x30, 0xC3, 0x0C, 0x61, 0x86, 0x18, 0xC2, 0x0C, 0x21, 0x8C,
  0x18, 0xC3, 0x18, 0x31, 0x86, 0x20, 0x66, 0x0C, 0xC0, 0xCC, 0x19, 0x01,
  0x90, 0x36, 0x03, 0x60, 0x6C, 0x06, 0xC0, 0x90, 0x0F, 0x01, 0x60, 0x1E,
  0x02, 0xC0, 0x38, 0x05, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x18, 0x01, 0x80,
  0x30, 0x00, 0x03, 0x00, 0xE0, 0x60, 0x30, 0x04, 0x06, 0x00, 0x81, 0x80,
  0x18, 0x20, 0x03, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x00, 0x98, 0x00,
  0x1A, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x1B, 0x00, 0x03, 0x20, 0x00, 0xC4, 0x00, 0x30, 0xC0, 0x06,
  0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x0C, 0x04, 0x03, 0x00, 0xC0, 0x60,
  0x18, 0x18, 0x03, 0x00, 0x00, 0x30, 0x07, 0x00, 0x30, 0x06, 0x00, 0x30,
  0x04, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x30,
  0x18, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x31,
  0x80, 0x00, 0x31, 0x80, 0x00, 0x33, 0x00, 0x00, 0x33, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x34, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x07, 0xC0,
  0x03, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x3E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x3F, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x70, 0x78, 0xF0,
  0x0F, 0xE0, 0x00, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 36, 10, 1, -36 },
  { 46, 10, 13, 14, 5, -36 },
  { 63, 20, 36, 19, 0, -36 },
  { 153, 19, 41, 18, 0, -38 },
  { 251, 23, 37, 27, 2, -36 },
  { 358, 17, 37, 17, -1, -36 },
  { 437, 4, 13, 8, 5, -36 },
  { 444, 14, 44, 12, 1, -36 },
  { 521, 14, 44, 12, -4, -36 },
  { 598, 13, 14, 16, 6, -38 },
  { 621, 17, 23, 20, 2, -29 },
  { 670, 7, 11, 8, -2, -5 },
  { 680, 11, 1, 13, 1, -14 },
  { 682, 3, 4, 8, 1, -4 },
  { 684, 20, 36, 15, -2, -36 },
  { 774, 17, 37, 18, 1, -36 },
  { 853, 10, 36, 18, 5, -36 },
  { 898, 20, 36, 18, -2, -36 },
  { 988, 19, 37, 18, -1, -36 },
  { 1076, 19, 36, 18, -1, -36 },
  { 1162, 19, 37, 18, -1, -36 },
  { 1250, 18, 37, 18, 1, -36 },
  { 1334, 18, 36, 18, 2, -36 },
  { 1415, 19, 37, 18, -1, -36 },
  { 1503, 17, 37, 18, 0, -36 },
  { 1582, 8, 27, 8, 0, -27 },
  { 1609, 10, 33, 8, -2, -27 },
  { 1651, 17, 21, 20, 2, -28 },
  { 1696, 17, 13, 20, 2, -24 },
  { 1724, 17, 21, 20, 2, -28 },
  { 1769, 14, 36, 13, 1, -36 },
  { 1832, 24, 40, 26, 1, -36 },
  { 1952, 17, 36, 17, -3, -36 },
  { 2029, 20, 36, 19, 0, -36 },
  { 2119, 19, 37, 17, 2, -36 },
  { 2207, 20, 36, 21, 0, -36 },
  { 2297, 19, 36, 17, 0, -36 },
  { 2383, 19, 36, 16, 0, -36 },
  { 2469, 22, 37, 23, 2, -36 },
  { 2571, 23, 36, 22, 0, -36 },
  { 2675, 16, 36, 9, -3, -36 },
  { 2747, 17, 45, 8, -7, -36 },
  { 2843, 22, 36, 18, 0, -36 },
  { 2942, 12, 36, 15, 0, -36 },
  { 2996, 31, 36, 30, 0, -36 },
  { 3136, 24, 36, 24, 0, -36 },
  { 3244, 20, 37, 23, 2, -36 },
  { 3337, 19, 36, 18, 0, -36 },
  { 3423, 20, 45, 23, 2, -36 },
  { 3536, 19, 36, 18, 0, -36 },
  { 3622, 20, 37, 17, -1, -36 },
  { 3715, 16, 36, 15, 3, -36 },
  { 3787, 21, 37, 22, 2, -36 },
  { 3885, 18, 36, 18, 4, -36 },
  { 3966, 30, 36, 30, 4, -36 },
  { 4101, 22, 36, 16, -3, -36 },
  { 4200, 16, 36, 15, 3, -36 },
  { 4272, 21, 36, 16, -2, -36 },
  { 4367, 18, 44, 14, -1, -36 },
  { 4466, 7, 36, 16, 5, -36 },
  { 4498, 18, 44, 14, -3, -36 },
  { 4597, 18, 18, 20, 1, -36 },
  { 4638, 14, 2, 14, -4, 4 },
  { 4642, 5, 8, 11, 7, -38 },
  { 4647, 18, 28, 19, 1, -27 },
  { 4710, 18, 39, 19, 0, -38 },
  { 4798, 14, 28, 14, 1, -27 },
  { 4847, 20, 39, 19, 1, -38 },
  { 4945, 15, 28, 17, 1, -27 },
  { 4998, 22, 50, 10, -6, -38 },
  { 5136, 20, 39, 19, -1, -27 },
  { 5234, 17, 38, 18, 0, -38 },
  { 5315, 10, 36, 8, 0, -36 },
  { 5360, 17, 48, 8, -7, -36 },
  { 5462, 17, 38, 15, 0, -38 },
  { 5543, 10, 38, 8, 0, -38 },
  { 5591, 26, 27, 28, 0, -27 },
  { 5679, 17, 27, 18, 0, -27 },
  { 5737, 16, 28, 18, 1, -27 },
  { 5793, 20, 38, 19, -2, -27 },
  { 5888, 18, 39, 19, 1, -27 },
  { 5976, 14, 27, 12, 0, -27 },
  { 6024, 16, 28, 14, -1, -27 },
  { 6080, 10, 34, 10, 1, -33 },
  { 6123, 17, 27, 18, 1, -26 },
  { 6181, 14, 26, 14, 3, -26 },
  { 6227, 23, 26, 24, 3, -26 },
  { 6302, 19, 26, 15, -2, -26 },
  { 6364, 24, 38, 15, -6, -26 },
  { 6478, 16, 26, 12, -2, -26 },
  { 6530, 17, 44, 16, 2, -36 },
  { 6624, 1, 50, 17, 8, -38 },
  { 6631, 17, 44, 16, -3, -36 },
  { 6725, 17, 5, 20, 2, -20 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC50PT7B_H_
