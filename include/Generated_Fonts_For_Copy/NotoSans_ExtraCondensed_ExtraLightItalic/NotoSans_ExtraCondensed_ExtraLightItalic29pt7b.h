#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC29PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x43, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x20, 0x82,
  0x08, 0x00, 0x00, 0x10, 0xC0, 0x45, 0x34, 0x92, 0x8A, 0x29, 0x24, 0x02,
  0x20, 0x44, 0x08, 0x82, 0x20, 0x44, 0x08, 0x8F, 0xF8, 0x44, 0x08, 0x81,
  0x10, 0x44, 0x08, 0x81, 0x11, 0xFF, 0x08, 0x81, 0x10, 0x44, 0x08, 0x81,
  0x10, 0x24, 0x08, 0x80, 0x01, 0x00, 0x20, 0x0C, 0x06, 0xF1, 0x20, 0x24,
  0x08, 0x81, 0x10, 0x12, 0x02, 0x80, 0x30, 0x02, 0x00, 0x60, 0x16, 0x02,
  0x40, 0x48, 0x09, 0x01, 0x20, 0x44, 0x4B, 0x07, 0x80, 0x20, 0x04, 0x01,
  0x00, 0x1C, 0x18, 0x90, 0x88, 0x8C, 0x44, 0x44, 0x26, 0x21, 0x21, 0x13,
  0x08, 0x90, 0x85, 0x94, 0x2B, 0x62, 0xD2, 0xB5, 0x17, 0x68, 0x82, 0x44,
  0x34, 0x21, 0x21, 0x19, 0x08, 0x88, 0x8C, 0x44, 0x42, 0x46, 0x0E, 0x00,
  0x07, 0x06, 0xC2, 0x21, 0x11, 0x18, 0x88, 0x44, 0x34, 0x0E, 0x06, 0x06,
  0x04, 0x86, 0x4A, 0x26, 0x13, 0x06, 0x83, 0x41, 0x20, 0x90, 0xA7, 0x90,
  0x55, 0xAA, 0x01, 0x02, 0x04, 0x08, 0x08, 0x10, 0x30, 0x20, 0x60, 0x40,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x40, 0x40, 0x40, 0x04, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08,
  0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0x08, 0x08, 0xC8, 0x2F, 0x10, 0x28,
  0x44, 0x04, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x0F, 0xFC, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x32, 0x24, 0x48, 0x80, 0xFC,
  0x70, 0x00, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x00, 0x07, 0x04, 0xC4,
  0x26, 0x12, 0x09, 0x05, 0x02, 0x81, 0x40, 0xE0, 0x60, 0x70, 0x28, 0x14,
  0x0A, 0x0D, 0x04, 0x82, 0x42, 0x21, 0x11, 0x07, 0x00, 0x0C, 0x62, 0x92,
  0x88, 0x61, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x30,
  0x80, 0x07, 0xC1, 0x8C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x80, 0x20, 0x0F, 0xF0, 0x07, 0xC1, 0x8C, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x38, 0x00, 0xC0, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x41, 0x8F, 0xC0, 0x00,
  0x20, 0x0C, 0x02, 0x80, 0x50, 0x14, 0x02, 0x80, 0x90, 0x22, 0x04, 0x41,
  0x10, 0x22, 0x08, 0x42, 0x08, 0x43, 0x10, 0x47, 0xFE, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x07, 0xE0, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10,
  0x06, 0x00, 0x80, 0x10, 0x03, 0xE0, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x10, 0x06, 0x00, 0x80, 0x10, 0x04, 0x41, 0x8F, 0xC0, 0x03, 0xC3, 0x01,
  0x80, 0x40, 0x20, 0x08, 0x06, 0x01, 0x00, 0x4C, 0x1C, 0x8C, 0x13, 0x04,
  0x81, 0x20, 0x48, 0x12, 0x04, 0x83, 0x20, 0x88, 0x22, 0x10, 0x78, 0x00,
  0x3F, 0xC0, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x00, 0x07, 0x81, 0x18, 0x41, 0x08, 0x31, 0x04, 0x20, 0x84,
  0x10, 0x84, 0x19, 0x81, 0x40, 0x30, 0x19, 0x06, 0x11, 0x82, 0x20, 0x44,
  0x04, 0x81, 0x90, 0x22, 0x04, 0x61, 0x07, 0xC0, 0x07, 0x82, 0x21, 0x04,
  0x41, 0x20, 0x48, 0x12, 0x04, 0x81, 0x20, 0x48, 0x32, 0x08, 0xC6, 0x1E,
  0x80, 0x20, 0x10, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30, 0xF8, 0x00, 0x18,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63, 0x00, 0x0C, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x82, 0x10, 0x42, 0x08, 0x00,
  0x00, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x20, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x18, 0x18, 0x08, 0x0C,
  0x0C, 0x02, 0x00, 0x3E, 0x11, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0x04,
  0x08, 0x18, 0x10, 0x20, 0x20, 0x20, 0x40, 0x00, 0x00, 0x00, 0x40, 0xC0,
  0x01, 0xE0, 0x18, 0x40, 0xC0, 0x82, 0x02, 0x10, 0x04, 0x80, 0x12, 0x1C,
  0x50, 0x91, 0x44, 0x45, 0x11, 0x18, 0x88, 0xA2, 0x22, 0x88, 0x8A, 0x46,
  0x29, 0x11, 0x24, 0x44, 0x8A, 0xA2, 0x33, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x20, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x05, 0x01,
  0x40, 0x90, 0x24, 0x09, 0x04, 0x41, 0x10, 0x84, 0x21, 0x0F, 0xC4, 0x11,
  0x04, 0xC1, 0x20, 0x58, 0x14, 0x05, 0x01, 0x80, 0x40, 0x0F, 0x01, 0x08,
  0x20, 0x84, 0x10, 0x82, 0x20, 0x44, 0x08, 0x83, 0x10, 0x46, 0x70, 0xFC,
  0x10, 0x42, 0x08, 0x40, 0x98, 0x12, 0x06, 0x40, 0x88, 0x11, 0x04, 0x41,
  0x8F, 0xC0, 0x03, 0xE0, 0xC4, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x03, 0xE0, 0x0F, 0x00, 0x8C, 0x08, 0x20,
  0x82, 0x08, 0x31, 0x01, 0x10, 0x11, 0x03, 0x10, 0x33, 0x02, 0x20, 0x22,
  0x02, 0x20, 0x22, 0x06, 0x60, 0x44, 0x04, 0x40, 0x84, 0x18, 0x43, 0x08,
  0x60, 0xF8, 0x00, 0x0F, 0xE1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x06, 0x00, 0xFE, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x0F, 0xE0, 0x0F, 0xE1, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x82, 0x1F,
  0x82, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x00, 0x01, 0xF0, 0x30, 0xC2, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x03, 0xC8, 0x02, 0x40, 0x22,
  0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x10, 0x20, 0xC1, 0x03, 0xF8, 0x00,
  0x0C, 0x08, 0x40, 0x42, 0x02, 0x10, 0x10, 0x81, 0x88, 0x08, 0x40, 0x42,
  0x02, 0x10, 0x11, 0x81, 0x8F, 0xF8, 0x40, 0x42, 0x02, 0x10, 0x11, 0x81,
  0x08, 0x08, 0x40, 0x42, 0x02, 0x10, 0x31, 0x01, 0x08, 0x08, 0x00, 0x07,
  0x81, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x06, 0x0F, 0x80, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x38, 0x00, 0x0C, 0x18, 0x41, 0x82,
  0x08, 0x10, 0x80, 0x88, 0x08, 0xC0, 0x44, 0x02, 0x40, 0x16, 0x01, 0xA0,
  0x0B, 0x00, 0x68, 0x02, 0x60, 0x11, 0x01, 0x88, 0x08, 0x40, 0x42, 0x02,
  0x18, 0x10, 0x41, 0x02, 0x08, 0x10, 0x00, 0x0C, 0x10, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x10, 0x60, 0x81, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x04,
  0x0F, 0xE0, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x18, 0x30, 0x06, 0x0C,
  0x02, 0x85, 0x00, 0xA1, 0x40, 0x58, 0x50, 0x14, 0x14, 0x09, 0x0D, 0x02,
  0x42, 0x41, 0x10, 0x88, 0x48, 0x22, 0x22, 0x08, 0x88, 0x86, 0x26, 0x21,
  0x09, 0x08, 0x42, 0xC4, 0x10, 0xA1, 0x04, 0x28, 0x42, 0x0C, 0x10, 0x83,
  0x0C, 0x00, 0x0C, 0x04, 0x30, 0x10, 0xC0, 0x43, 0x02, 0x0A, 0x08, 0x48,
  0x21, 0x20, 0x84, 0x82, 0x12, 0x10, 0xC8, 0x42, 0x11, 0x08, 0x44, 0x21,
  0x30, 0x84, 0x86, 0x12, 0x10, 0x68, 0x40, 0xA1, 0x03, 0x04, 0x0C, 0x20,
  0x30, 0x80, 0xC0, 0x03, 0xC0, 0xC6, 0x08, 0x21, 0x03, 0x30, 0x32, 0x03,
  0x20, 0x34, 0x03, 0x40, 0x24, 0x02, 0x40, 0x28, 0x02, 0x80, 0x28, 0x04,
  0x80, 0x48, 0x04, 0x80, 0x88, 0x08, 0xC1, 0x04, 0x20, 0x7C, 0x00, 0x0F,
  0x01, 0x18, 0x21, 0x84, 0x10, 0x82, 0x20, 0x44, 0x08, 0x83, 0x10, 0x46,
  0x18, 0x86, 0x1F, 0x82, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x00, 0x03, 0xC0, 0xC6, 0x08, 0x21, 0x03, 0x30, 0x32,
  0x03, 0x20, 0x34, 0x03, 0x40, 0x24, 0x02, 0x40, 0x28, 0x02, 0x80, 0x28,
  0x04, 0x80, 0x48, 0x04, 0x80, 0x88, 0x08, 0xC1, 0x04, 0x20, 0x3C, 0x00,
  0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x0F, 0x01, 0x18, 0x21, 0x84,
  0x10, 0x82, 0x20, 0x44, 0x08, 0x82, 0x10, 0x46, 0x18, 0x86, 0x1F, 0x02,
  0x60, 0x44, 0x18, 0x82, 0x10, 0x42, 0x08, 0x41, 0x04, 0x40, 0x88, 0x10,
  0x03, 0xE0, 0x41, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x88, 0x30, 0xFE, 0x00, 0x7F, 0xC4, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x00, 0x10, 0x11, 0x01, 0x10,
  0x11, 0x02, 0x30, 0x22, 0x02, 0x20, 0x22, 0x02, 0x20, 0x44, 0x04, 0x40,
  0x44, 0x04, 0x40, 0xCC, 0x08, 0x80, 0x88, 0x08, 0x81, 0x88, 0x10, 0x81,
  0x0C, 0x20, 0x7C, 0x00, 0xC0, 0x78, 0x0B, 0x01, 0x60, 0x4C, 0x09, 0x82,
  0x30, 0x46, 0x18, 0xC2, 0x18, 0x42, 0x10, 0x42, 0x08, 0x81, 0x10, 0x26,
  0x04, 0x80, 0x90, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x00, 0xC0, 0x40, 0x70,
  0x30, 0x28, 0x0C, 0x0A, 0x05, 0x06, 0x81, 0x41, 0x20, 0x50, 0x48, 0x24,
  0x22, 0x0A, 0x08, 0x84, 0x86, 0x21, 0x21, 0x08, 0x48, 0x42, 0x22, 0x20,
  0x88, 0x88, 0x24, 0x26, 0x09, 0x09, 0x02, 0x42, 0x40, 0xA0, 0xA0, 0x28,
  0x28, 0x0E, 0x0E, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x00, 0x04, 0x08, 0x10,
  0xC0, 0x84, 0x04, 0x60, 0x22, 0x01, 0x20, 0x09, 0x00, 0x50, 0x02, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x50, 0x02, 0x80, 0x24, 0x03, 0x20, 0x11,
  0x01, 0x0C, 0x08, 0x20, 0x81, 0x0C, 0x08, 0x00, 0xC0, 0xA0, 0xD0, 0x48,
  0x64, 0x22, 0x31, 0x10, 0x90, 0x48, 0x28, 0x14, 0x0C, 0x02, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x00, 0x0F, 0xF0, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x44, 0x1F, 0x00, 0x88, 0x88, 0x44, 0x44, 0x44, 0x42, 0x22, 0x22,
  0x22, 0x11, 0x10, 0x07, 0xE0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x1F, 0x00, 0x04, 0x03, 0x00, 0xA0, 0x48, 0x11, 0x08, 0x42, 0x19,
  0x02, 0x40, 0xA0, 0x10, 0xFF, 0xC9, 0x10, 0x04, 0x06, 0xD3, 0x14, 0x82,
  0x60, 0x90, 0x24, 0x0A, 0x06, 0x81, 0x20, 0x48, 0x12, 0x0C, 0x83, 0x21,
  0x88, 0x61, 0xE8, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x10,
  0x5B, 0x18, 0x44, 0x11, 0x04, 0xC1, 0x20, 0x48, 0x12, 0x05, 0x81, 0x40,
  0x90, 0x24, 0x19, 0x04, 0xA2, 0x2F, 0x80, 0x06, 0x19, 0x30, 0x20, 0x40,
  0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x78, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x81, 0x10, 0xDA, 0x31, 0x44,
  0x11, 0x82, 0x20, 0x44, 0x09, 0x03, 0x20, 0x44, 0x08, 0x81, 0x10, 0x62,
  0x0C, 0x43, 0x08, 0x60, 0xF4, 0x00, 0x06, 0x1B, 0x31, 0x21, 0x41, 0x41,
  0xC2, 0x8C, 0xE0, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x7C, 0x00, 0x38,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x7C, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x0E, 0x00, 0x00, 0x01, 0x00,
  0x6D, 0x0C, 0x50, 0x82, 0x18, 0x21, 0x02, 0x10, 0x22, 0x06, 0x20, 0x42,
  0x04, 0x20, 0x42, 0x0C, 0x20, 0xC2, 0x18, 0x21, 0x81, 0xE8, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x10, 0x02, 0x08, 0x60, 0x7C, 0x00, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x10, 0x5F, 0x18, 0x44, 0x11, 0x04, 0xC2,
  0x20, 0x88, 0x22, 0x08, 0x82, 0x41, 0x10, 0x44, 0x11, 0x04, 0xC3, 0x20,
  0x80, 0x0C, 0x30, 0x00, 0x00, 0x01, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82,
  0x10, 0x41, 0x04, 0x30, 0x80, 0x00, 0x40, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x03, 0x03, 0x80, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x43, 0x10, 0x84, 0x41, 0x20, 0x90, 0x2C, 0x0B, 0x03, 0x41, 0x90,
  0x44, 0x11, 0x04, 0x61, 0x08, 0x82, 0x20, 0x80, 0x04, 0x30, 0x82, 0x08,
  0x21, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x18, 0x41, 0x04, 0x10, 0x82,
  0x00, 0x01, 0x0C, 0x2F, 0x6C, 0x61, 0x08, 0x82, 0x11, 0x0C, 0x26, 0x10,
  0x48, 0x20, 0x90, 0x43, 0x20, 0x84, 0xC2, 0x09, 0x04, 0x12, 0x08, 0x24,
  0x10, 0x88, 0x61, 0x30, 0x82, 0x41, 0x04, 0x01, 0x05, 0xE1, 0x84, 0x41,
  0x10, 0x4C, 0x22, 0x08, 0x82, 0x20, 0x98, 0x24, 0x11, 0x04, 0x41, 0x10,
  0x4C, 0x32, 0x08, 0x04, 0x0D, 0x8C, 0x64, 0x14, 0x0A, 0x05, 0x03, 0x01,
  0x81, 0xC0, 0xA0, 0x50, 0x28, 0x24, 0x12, 0x10, 0xF0, 0x00, 0x81, 0x6C,
  0x30, 0x86, 0x10, 0x82, 0x30, 0x44, 0x08, 0x81, 0x10, 0x22, 0x04, 0x81,
  0x10, 0x22, 0x04, 0x41, 0x1C, 0x42, 0xF8, 0x40, 0x08, 0x01, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x20, 0x00, 0x04, 0x06, 0xD3, 0x14, 0x82, 0x40, 0x90,
  0x24, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x12, 0x0C, 0x83, 0x21, 0x88, 0x61,
  0xE8, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x03, 0x17,
  0x18, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40,
  0xC0, 0x80, 0x04, 0x1B, 0x20, 0x20, 0x20, 0x20, 0x20, 0x10, 0x08, 0x0C,
  0x04, 0x04, 0x04, 0x04, 0x8C, 0xF8, 0x08, 0x20, 0x84, 0x3C, 0x41, 0x08,
  0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x43, 0x07, 0x00, 0x20, 0x90, 0x48,
  0x24, 0x14, 0x12, 0x09, 0x04, 0x82, 0xC3, 0x41, 0x20, 0x90, 0x48, 0x64,
  0x53, 0xD0, 0x83, 0x82, 0x84, 0x84, 0x8C, 0x88, 0x88, 0x90, 0x90, 0xA0,
  0xA0, 0xE0, 0xC0, 0xC0, 0x80, 0x82, 0x0C, 0x30, 0xA1, 0x85, 0x0C, 0x28,
  0xA2, 0x45, 0x12, 0x49, 0x12, 0x48, 0xA2, 0x45, 0x14, 0x28, 0xA1, 0x85,
  0x0C, 0x30, 0x41, 0x82, 0x08, 0x00, 0x18, 0x61, 0x10, 0x22, 0x04, 0x80,
  0x90, 0x14, 0x01, 0x00, 0x60, 0x0C, 0x02, 0x80, 0x48, 0x11, 0x04, 0x20,
  0x84, 0x20, 0x80, 0x04, 0x08, 0x20, 0x81, 0x04, 0x08, 0x60, 0x42, 0x02,
  0x10, 0x11, 0x00, 0x88, 0x04, 0x80, 0x24, 0x01, 0x40, 0x0A, 0x00, 0x50,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03,
  0x00, 0x70, 0x00, 0x1F, 0x80, 0x80, 0x40, 0x40, 0x60, 0x20, 0x20, 0x10,
  0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x03, 0xF0, 0x00, 0xC0, 0xC0, 0x40,
  0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0xE0,
  0x38, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x70, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0xE0,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0xC0, 0x60, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x00, 0x80, 0x60, 0x70, 0x20, 0x00, 0x20, 0x37, 0x18, 0x78,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 21, 6, 0, -21 },
  { 17, 6, 8, 8, 3, -21 },
  { 23, 11, 21, 11, 0, -21 },
  { 52, 11, 24, 10, 0, -22 },
  { 85, 13, 21, 16, 1, -21 },
  { 120, 9, 21, 10, 0, -21 },
  { 144, 2, 8, 4, 3, -21 },
  { 146, 8, 26, 7, 1, -21 },
  { 172, 8, 26, 7, -2, -21 },
  { 198, 8, 8, 9, 3, -22 },
  { 206, 10, 13, 12, 1, -17 },
  { 223, 4, 7, 5, -1, -3 },
  { 227, 6, 1, 8, 1, -8 },
  { 228, 2, 2, 5, 0, -2 },
  { 229, 12, 21, 9, -1, -21 },
  { 261, 9, 21, 10, 1, -21 },
  { 285, 6, 21, 10, 3, -21 },
  { 301, 11, 21, 10, -1, -21 },
  { 330, 11, 21, 10, -1, -21 },
  { 359, 11, 21, 10, -1, -21 },
  { 388, 11, 21, 10, -1, -21 },
  { 417, 10, 21, 10, 1, -21 },
  { 444, 10, 21, 10, 1, -21 },
  { 471, 11, 21, 10, 0, -21 },
  { 500, 10, 21, 10, 0, -21 },
  { 527, 5, 15, 5, 0, -15 },
  { 537, 6, 19, 5, -1, -15 },
  { 552, 10, 12, 12, 1, -16 },
  { 567, 10, 7, 12, 1, -14 },
  { 576, 10, 12, 12, 1, -16 },
  { 591, 8, 21, 7, 0, -21 },
  { 612, 14, 24, 15, 1, -21 },
  { 654, 10, 21, 10, -2, -21 },
  { 681, 11, 21, 11, 0, -21 },
  { 710, 11, 21, 10, 1, -21 },
  { 739, 12, 21, 12, 0, -21 },
  { 771, 11, 21, 10, 0, -21 },
  { 800, 11, 21, 9, 0, -21 },
  { 829, 13, 21, 13, 1, -21 },
  { 864, 13, 21, 13, 0, -21 },
  { 899, 9, 21, 5, -2, -21 },
  { 923, 10, 26, 5, -4, -21 },
  { 956, 13, 21, 10, 0, -21 },
  { 991, 7, 21, 9, 0, -21 },
  { 1010, 18, 21, 17, 0, -21 },
  { 1058, 14, 21, 14, 0, -21 },
  { 1095, 12, 21, 13, 1, -21 },
  { 1127, 11, 21, 11, 0, -21 },
  { 1156, 12, 26, 13, 1, -21 },
  { 1195, 11, 21, 11, 0, -21 },
  { 1224, 12, 21, 10, -1, -21 },
  { 1256, 9, 21, 9, 2, -21 },
  { 1280, 12, 21, 13, 1, -21 },
  { 1312, 11, 21, 10, 2, -21 },
  { 1341, 18, 21, 18, 2, -21 },
  { 1389, 13, 21, 9, -2, -21 },
  { 1424, 9, 21, 9, 2, -21 },
  { 1448, 12, 21, 9, -1, -21 },
  { 1480, 11, 26, 8, -1, -21 },
  { 1516, 4, 21, 9, 3, -21 },
  { 1527, 11, 26, 8, -2, -21 },
  { 1563, 10, 10, 11, 1, -21 },
  { 1576, 8, 1, 8, -2, 3 },
  { 1577, 3, 4, 6, 4, -22 },
  { 1579, 10, 16, 11, 1, -16 },
  { 1599, 10, 22, 11, 0, -22 },
  { 1627, 8, 16, 8, 1, -16 },
  { 1643, 11, 22, 11, 1, -22 },
  { 1674, 8, 16, 10, 1, -16 },
  { 1690, 13, 29, 6, -4, -22 },
  { 1738, 12, 23, 11, -1, -16 },
  { 1773, 10, 22, 11, 0, -22 },
  { 1801, 6, 21, 5, 0, -21 },
  { 1817, 10, 28, 5, -4, -21 },
  { 1852, 10, 22, 9, 0, -22 },
  { 1880, 6, 22, 5, 0, -22 },
  { 1897, 15, 16, 16, 0, -16 },
  { 1927, 10, 16, 11, 0, -16 },
  { 1947, 9, 16, 11, 1, -16 },
  { 1965, 11, 23, 11, -1, -16 },
  { 1997, 10, 23, 11, 1, -16 },
  { 2026, 8, 16, 7, 0, -16 },
  { 2042, 8, 16, 8, 0, -16 },
  { 2058, 6, 19, 6, 0, -19 },
  { 2073, 9, 15, 11, 1, -15 },
  { 2090, 8, 15, 8, 2, -15 },
  { 2105, 13, 15, 14, 2, -15 },
  { 2130, 11, 15, 9, -1, -15 },
  { 2151, 13, 22, 9, -3, -15 },
  { 2187, 9, 15, 7, -1, -15 },
  { 2204, 10, 26, 9, 1, -21 },
  { 2237, 1, 29, 10, 4, -22 },
  { 2241, 10, 26, 9, -2, -21 },
  { 2274, 10, 3, 12, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC29PT7B_H_
