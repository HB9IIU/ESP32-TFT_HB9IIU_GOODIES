#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC51PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x00, 0x30, 0xE6,
  0x18, 0xC3, 0x18, 0x66, 0x08, 0xC3, 0x18, 0x63, 0x0C, 0x41, 0x18, 0x23,
  0x04, 0x61, 0x88, 0x30, 0x00, 0x18, 0x30, 0x01, 0x02, 0x00, 0x30, 0x60,
  0x03, 0x06, 0x00, 0x30, 0x40, 0x02, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C,
  0x00, 0x40, 0x80, 0x0C, 0x18, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x01, 0x83,
  0x00, 0x18, 0x30, 0x01, 0x02, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30,
  0x40, 0x02, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x41, 0x80, 0x0C,
  0x18, 0x0F, 0xFF, 0xF8, 0x08, 0x10, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01,
  0x02, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x40, 0x06, 0x0C, 0x00,
  0x60, 0xC0, 0x06, 0x0C, 0x00, 0x41, 0x80, 0x0C, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x01, 0xFF,
  0x80, 0x72, 0x38, 0x18, 0x41, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x30, 0x40,
  0x06, 0x08, 0x00, 0xC1, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x31, 0x00,
  0x06, 0x20, 0x00, 0x6C, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00, 0x8C, 0x00, 0x11, 0x80,
  0x02, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x02, 0x0C, 0x00, 0x41, 0x80,
  0x08, 0x20, 0x03, 0x0C, 0x00, 0x43, 0x82, 0x08, 0xE0, 0x7F, 0xF8, 0x03,
  0xF8, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x04, 0x0F, 0xC0, 0x10, 0x30, 0x80, 0x60, 0x61,
  0x80, 0x81, 0x83, 0x03, 0x03, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18, 0x18,
  0x20, 0x30, 0x20, 0xC0, 0xC0, 0x41, 0x01, 0x81, 0x86, 0x03, 0x03, 0x08,
  0x06, 0x06, 0x30, 0x08, 0x0C, 0x40, 0x10, 0x31, 0x80, 0x60, 0x62, 0x1E,
  0xC0, 0xCC, 0x67, 0x83, 0x11, 0x8F, 0x06, 0x66, 0x0E, 0x18, 0x8C, 0x16,
  0x33, 0x30, 0x2F, 0xC4, 0x60, 0x4E, 0x18, 0x80, 0x80, 0x23, 0x03, 0x00,
  0xC6, 0x06, 0x01, 0x8C, 0x0C, 0x06, 0x10, 0x18, 0x0C, 0x20, 0x20, 0x30,
  0xC0, 0xC0, 0x61, 0x81, 0x81, 0x83, 0x03, 0x03, 0x06, 0x0C, 0x0C, 0x0C,
  0x18, 0x18, 0x18, 0x20, 0x60, 0x30, 0xC0, 0xC0, 0x33, 0x03, 0x00, 0x7C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x06, 0x30, 0x03,
  0x0C, 0x00, 0xC1, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x83,
  0x00, 0x60, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x01, 0x8C, 0x00, 0x63, 0x00,
  0x19, 0x80, 0x02, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0D,
  0x80, 0x06, 0x60, 0x03, 0x18, 0x31, 0x82, 0x18, 0xE0, 0xC6, 0x30, 0x31,
  0x8C, 0x0C, 0x46, 0x01, 0x31, 0x80, 0x6C, 0x60, 0x1E, 0x10, 0x07, 0x8C,
  0x00, 0xC3, 0x00, 0x70, 0xE0, 0x1C, 0x18, 0x0D, 0x06, 0x06, 0x61, 0xE3,
  0x18, 0x3F, 0x86, 0x01, 0x00, 0x00, 0x33, 0x33, 0x66, 0x66, 0x44, 0xCC,
  0x80, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x80, 0x07, 0x00, 0x00, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x0C,
  0x20, 0x39, 0x00, 0x69, 0xE0, 0xFC, 0x06, 0x00, 0xD8, 0x0C, 0x40, 0xC3,
  0x0C, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x0E, 0x18, 0x30,
  0x61, 0x83, 0x0C, 0x18, 0x60, 0xC3, 0x04, 0x00, 0xFF, 0xFF, 0xFC, 0x7F,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x3F, 0x00, 0x30, 0xC0, 0x30, 0x60, 0x30, 0x18, 0x30,
  0x0C, 0x18, 0x06, 0x08, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xC6, 0x00, 0x63,
  0x00, 0x31, 0x80, 0x19, 0x80, 0x08, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03,
  0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x63, 0x00, 0x31, 0x00,
  0x19, 0x80, 0x0C, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x03, 0x0C,
  0x01, 0x86, 0x00, 0xC3, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x60, 0x60, 0x30,
  0x18, 0x30, 0x0E, 0x70, 0x03, 0xF0, 0x00, 0x40, 0x00, 0x03, 0x83, 0xC3,
  0x67, 0x67, 0x37, 0x1A, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x00, 0xE0, 0xE0, 0x08, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x1F, 0xF0, 0x0F, 0x07, 0x00, 0x80, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x02, 0x00, 0xE0, 0x70, 0x70,
  0x0F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xB0, 0x00, 0x34, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00,
  0x66, 0x00, 0x08, 0xC0, 0x03, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x06,
  0x18, 0x00, 0x82, 0x00, 0x30, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x60,
  0x60, 0x18, 0x18, 0x03, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x01,
  0x81, 0x80, 0x60, 0x30, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xE0, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x78, 0x00, 0x7F, 0xC0,
  0x04, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x10, 0x06, 0x03, 0x87, 0x80, 0x7F, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xCF, 0xE0, 0x37, 0xBC, 0x1B, 0x03, 0x07, 0x80, 0x61, 0xC0, 0x18, 0x70,
  0x06, 0x18, 0x01, 0x86, 0x00, 0x63, 0x80, 0x18, 0xC0, 0x06, 0x30, 0x01,
  0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3,
  0x00, 0x60, 0xC0, 0x18, 0x18, 0x0C, 0x06, 0x06, 0x00, 0xE7, 0x80, 0x1F,
  0x80, 0x01, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x07, 0xF8, 0x00, 0xE0, 0xC0, 0x18, 0x06, 0x03,
  0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x30, 0x20, 0x02, 0x06, 0x00, 0x60,
  0x60, 0x06, 0x02, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x18,
  0x01, 0x83, 0x00, 0x1C, 0x70, 0x00, 0xDC, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x39, 0x80, 0x06, 0x1C, 0x00, 0xC0, 0xC0, 0x18, 0x06, 0x03, 0x00,
  0x60, 0x30, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0xC0,
  0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x60, 0x06, 0x06,
  0x00, 0x60, 0x30, 0x0C, 0x03, 0xC3, 0x80, 0x0F, 0xF0, 0x00, 0x10, 0x00,
  0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x1C, 0x30, 0x0C, 0x06, 0x07, 0x01, 0x81,
  0x80, 0x20, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC6, 0x00, 0x31, 0x80,
  0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06,
  0x18, 0x03, 0x86, 0x00, 0xE1, 0x80, 0x78, 0x70, 0x34, 0x0C, 0x1B, 0x01,
  0xFC, 0xC0, 0x3E, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x02, 0x1E, 0x00, 0xFE, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x07, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0xE0, 0xE0, 0xC0, 0x00, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x0C,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x00,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x30, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x18, 0x00, 0x04, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x04, 0x00, 0x00,
  0x03, 0xE0, 0x7F, 0xC0, 0x81, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x06, 0x00, 0x18,
  0x06, 0x00, 0x04, 0x06, 0x00, 0x03, 0x02, 0x00, 0x01, 0x83, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x61, 0x80, 0xFC, 0x30, 0x80, 0xC6, 0x18, 0xC0, 0xC2,
  0x0C, 0x60, 0xC3, 0x06, 0x60, 0xC1, 0x83, 0x30, 0x60, 0xC1, 0x98, 0x20,
  0x40, 0x88, 0x30, 0x60, 0xCC, 0x18, 0x30, 0x66, 0x08, 0x18, 0x33, 0x0C,
  0x08, 0x19, 0x86, 0x0C, 0x08, 0x83, 0x06, 0x0C, 0x41, 0x83, 0x06, 0x60,
  0xC3, 0x86, 0x30, 0x41, 0x83, 0x18, 0x31, 0xC3, 0x0C, 0x18, 0xB1, 0x86,
  0x0E, 0xDF, 0x83, 0x03, 0xC7, 0x81, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x30, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x2C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x19,
  0x80, 0x0C, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x03, 0x0C, 0x01,
  0x86, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x60, 0x60, 0x30, 0x30,
  0x30, 0x18, 0x1F, 0xFC, 0x0F, 0xFE, 0x0C, 0x03, 0x06, 0x01, 0x86, 0x00,
  0xC3, 0x00, 0x63, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x06, 0x60,
  0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x18,
  0x00, 0xFF, 0x80, 0x18, 0x3C, 0x01, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80,
  0x30, 0x10, 0x03, 0x03, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x30,
  0x07, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x70, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0C, 0x0E, 0x00,
  0xC0, 0x30, 0x18, 0x03, 0x01, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x18,
  0x10, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x18, 0x30, 0x03,
  0x02, 0x00, 0x30, 0x60, 0x07, 0x06, 0x00, 0x60, 0x60, 0x0C, 0x06, 0x03,
  0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x00,
  0x70, 0x20, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC3, 0x00,
  0x0F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0xFF, 0x00, 0x0C, 0x3E, 0x00, 0x60,
  0x38, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0xC0,
  0x60, 0x06, 0x03, 0x00, 0x38, 0x18, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00,
  0x30, 0x60, 0x03, 0x83, 0x00, 0x18, 0x18, 0x00, 0xC1, 0x80, 0x06, 0x0C,
  0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0xE1, 0x80, 0x06,
  0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x18, 0x10, 0x00, 0xC1, 0x80,
  0x06, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x30, 0x30, 0x03, 0x81,
  0x80, 0x38, 0x0C, 0x03, 0x80, 0x60, 0x38, 0x03, 0x07, 0x80, 0x3F, 0xF8,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xC0,
  0x78, 0x06, 0x00, 0x20, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x7F, 0x0C, 0x00, 0xFE, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x10, 0x60, 0x00,
  0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x30, 0x00, 0xC0,
  0x60, 0x03, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xF0, 0x78, 0x00,
  0xFF, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x06,
  0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x01, 0x00, 0x04,
  0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C,
  0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18,
  0x06, 0x00, 0x10, 0x0C, 0x00, 0x30, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x0C, 0x00, 0x30, 0x08, 0x00, 0x20, 0x18, 0x00, 0x60, 0x18, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x18, 0x00, 0x60, 0x10, 0x00, 0xC0, 0x30, 0x00, 0xC0,
  0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80,
  0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xFF, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x80, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0xC0, 0x1C, 0x06, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0xC0, 0x04, 0x03, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0xC0, 0x03, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0,
  0x01, 0x86, 0x00, 0x06, 0x38, 0x00, 0x18, 0xC0, 0x00, 0x66, 0x00, 0x03,
  0x30, 0x00, 0x0C, 0xC0, 0x00, 0x35, 0x80, 0x00, 0xF6, 0x00, 0x03, 0x98,
  0x00, 0x1C, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00,
  0x10, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30,
  0x18, 0x01, 0x80, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0C, 0x00, 0xE0, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xB0, 0x1E, 0x00, 0x03, 0xC0, 0x2C,
  0x00, 0x07, 0x80, 0xD8, 0x00, 0x1B, 0x01, 0xB0, 0x00, 0x36, 0x03, 0x60,
  0x00, 0xC8, 0x06, 0xC0, 0x01, 0xB0, 0x19, 0x80, 0x06, 0x60, 0x33, 0x00,
  0x0C, 0xC0, 0x66, 0x00, 0x31, 0x80, 0xCC, 0x00, 0x66, 0x01, 0x98, 0x01,
  0x8C, 0x06, 0x10, 0x03, 0x18, 0x0C, 0x20, 0x0C, 0x30, 0x18, 0x40, 0x18,
  0x60, 0x30, 0x80, 0x61, 0x80, 0x41, 0x80, 0xC3, 0x01, 0x83, 0x03, 0x06,
  0x03, 0x06, 0x06, 0x0C, 0x06, 0x0C, 0x08, 0x10, 0x0C, 0x18, 0x30, 0x60,
  0x10, 0x30, 0x60, 0xC0, 0x60, 0x61, 0x81, 0x80, 0xC0, 0xC3, 0x03, 0x01,
  0x81, 0x8C, 0x04, 0x03, 0x03, 0x18, 0x18, 0x0C, 0x06, 0x60, 0x30, 0x18,
  0x0C, 0xC0, 0x60, 0x30, 0x1B, 0x00, 0xC0, 0x60, 0x36, 0x03, 0x00, 0x80,
  0x78, 0x06, 0x03, 0x00, 0xF0, 0x0C, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0xF0, 0x00, 0x80, 0x78, 0x00, 0xC0, 0x3C, 0x00, 0x60,
  0x1E, 0x00, 0x30, 0x0B, 0x00, 0x18, 0x0C, 0x80, 0x18, 0x06, 0x60, 0x0C,
  0x03, 0x30, 0x06, 0x01, 0x98, 0x03, 0x01, 0x8C, 0x01, 0x80, 0xC6, 0x01,
  0x80, 0x61, 0x00, 0xC0, 0x30, 0xC0, 0x60, 0x18, 0x60, 0x30, 0x18, 0x30,
  0x10, 0x0C, 0x18, 0x18, 0x06, 0x04, 0x0C, 0x03, 0x03, 0x06, 0x01, 0x01,
  0x83, 0x01, 0x80, 0xC1, 0x00, 0xC0, 0x61, 0x80, 0x60, 0x30, 0xC0, 0x30,
  0x08, 0x60, 0x10, 0x06, 0x30, 0x18, 0x03, 0x30, 0x0C, 0x01, 0x98, 0x06,
  0x00, 0xCC, 0x03, 0x00, 0x26, 0x03, 0x00, 0x1A, 0x01, 0x80, 0x0F, 0x00,
  0xC0, 0x07, 0x80, 0x60, 0x03, 0xC0, 0x30, 0x01, 0xE0, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x00, 0xE0, 0xE0,
  0x18, 0x06, 0x03, 0x00, 0x70, 0x70, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x33, 0x80, 0x03, 0x30, 0x00,
  0x33, 0x00, 0x03, 0x30, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00,
  0x02, 0x60, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x8C,
  0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00, 0x60,
  0xC0, 0x0C, 0x06, 0x01, 0xC0, 0x70, 0x38, 0x03, 0x8F, 0x00, 0x1F, 0xC0,
  0x00, 0x20, 0x00, 0x00, 0xFF, 0x00, 0x31, 0xF0, 0x06, 0x07, 0x00, 0xC0,
  0x70, 0x18, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00,
  0x60, 0x60, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x0C, 0x0C, 0x01,
  0x81, 0x80, 0x30, 0x60, 0x0C, 0x0C, 0x03, 0x81, 0x80, 0xE0, 0x30, 0x78,
  0x07, 0xFC, 0x01, 0xF8, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x00, 0xE0,
  0xE0, 0x18, 0x06, 0x03, 0x00, 0x70, 0x70, 0x03, 0x06, 0x00, 0x30, 0xC0,
  0x03, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x33, 0x80, 0x03, 0x30,
  0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36,
  0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01,
  0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00,
  0x60, 0xC0, 0x0C, 0x06, 0x01, 0xC0, 0x70, 0x38, 0x03, 0x8F, 0x00, 0x1F,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0x00, 0x30, 0xF0, 0x06, 0x07, 0x00, 0xC0, 0x70, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C,
  0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x70,
  0x60, 0x0C, 0x0C, 0x03, 0x01, 0x81, 0xC0, 0x3F, 0xF0, 0x07, 0xF0, 0x01,
  0x83, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x10, 0x30, 0x06,
  0x06, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18,
  0x06, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x30, 0x60,
  0x06, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x00, 0xE0, 0x70, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x80, 0x38, 0x0F, 0x0F, 0x00, 0xFF, 0xE0, 0x00, 0x60,
  0x00, 0x7F, 0xFF, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x60,
  0x40, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x04, 0x0C, 0x00,
  0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x0C,
  0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0x81, 0x80, 0x0C,
  0x08, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0x81, 0x80,
  0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x10, 0x30, 0x01, 0x81,
  0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x03, 0x00, 0x30, 0x18, 0x01,
  0x80, 0xC0, 0x18, 0x07, 0x01, 0x80, 0x1E, 0x38, 0x00, 0x7F, 0x80, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06,
  0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0C, 0x30,
  0x03, 0x0C, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x0C, 0x0C, 0x03,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x03, 0x03, 0x00,
  0xC1, 0x80, 0x30, 0x60, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x31,
  0x80, 0x0C, 0x60, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0D, 0x80,
  0x03, 0x60, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x03, 0x80, 0x0F, 0x80, 0x06, 0x00, 0x1B, 0x00, 0x0C, 0x00, 0x36,
  0x00, 0x38, 0x00, 0xCC, 0x00, 0x50, 0x01, 0x98, 0x01, 0xA0, 0x06, 0x30,
  0x03, 0x40, 0x0C, 0x60, 0x04, 0x80, 0x18, 0xC0, 0x19, 0x00, 0x61, 0x80,
  0x32, 0x00, 0xC3, 0x00, 0xC4, 0x03, 0x06, 0x01, 0x98, 0x06, 0x0C, 0x02,
  0x30, 0x0C, 0x18, 0x0C, 0x60, 0x30, 0x30, 0x18, 0xC0, 0x60, 0x60, 0x61,
  0x81, 0x80, 0xC0, 0xC3, 0x03, 0x01, 0x81, 0x06, 0x06, 0x03, 0x06, 0x0C,
  0x18, 0x06, 0x0C, 0x18, 0x30, 0x0C, 0x30, 0x30, 0xC0, 0x18, 0x60, 0x61,
  0x80, 0x30, 0xC0, 0xC3, 0x00, 0x63, 0x01, 0x8C, 0x00, 0xC6, 0x03, 0x18,
  0x01, 0x88, 0x06, 0x60, 0x03, 0x30, 0x0C, 0xC0, 0x06, 0x60, 0x19, 0x80,
  0x0D, 0x80, 0x36, 0x00, 0x1B, 0x00, 0x6C, 0x00, 0x34, 0x00, 0x90, 0x00,
  0x78, 0x01, 0x60, 0x00, 0xF0, 0x02, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x04,
  0x06, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x63,
  0x00, 0x00, 0xC6, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x02, 0xC0,
  0x00, 0x05, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x40, 0x00, 0x06, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x33, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x30, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0x80, 0x06, 0x01,
  0x80, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x06, 0x00, 0x30, 0x00, 0x60, 0x03, 0xB0, 0x01, 0x88, 0x01, 0x84, 0x00,
  0xC3, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18,
  0x18, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x0C, 0x00, 0x86, 0x00, 0x46, 0x00,
  0x23, 0x00, 0x1B, 0x00, 0x0D, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xC0,
  0x81, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x40, 0xC1, 0x83, 0x06, 0x0C,
  0x08, 0x10, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x04, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x81, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x00, 0x7F, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x4C, 0x00, 0x19, 0x80, 0x02, 0x18,
  0x00, 0xC3, 0x00, 0x30, 0x70, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C,
  0x0C, 0x01, 0x81, 0x80, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x63, 0x00, 0x06,
  0xE0, 0x00, 0xE0, 0xFF, 0xFC, 0xC1, 0x86, 0x0C, 0x30, 0x60, 0x83, 0x00,
  0xFC, 0x40, 0x73, 0xB0, 0x30, 0x2C, 0x18, 0x0F, 0x0C, 0x01, 0x83, 0x00,
  0x61, 0x80, 0x18, 0x60, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x30,
  0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x61, 0x80, 0x18, 0x60,
  0x06, 0x10, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x07,
  0x06, 0x03, 0xC1, 0x80, 0xA0, 0x60, 0x68, 0x0E, 0x76, 0x01, 0xF9, 0x80,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x3F, 0x00, 0x9C, 0xE0, 0x6C, 0x18,
  0x1E, 0x03, 0x07, 0x00, 0xC1, 0xC0, 0x30, 0x60, 0x0C, 0x38, 0x03, 0x0C,
  0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x20, 0x03, 0x18, 0x00, 0xC6, 0x00,
  0x21, 0x80, 0x18, 0x40, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x30,
  0xC0, 0x0C, 0x30, 0x06, 0x1C, 0x01, 0x87, 0x00, 0xC1, 0xC0, 0x30, 0x58,
  0x18, 0x13, 0x1C, 0x0C, 0x7E, 0x00, 0x04, 0x00, 0x00, 0xFE, 0x03, 0x88,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x71, 0x80, 0x7F, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x0F, 0xCC, 0x00,
  0xE7, 0x60, 0x0C, 0x0B, 0x00, 0xC0, 0x78, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x06, 0x00, 0x60, 0x30, 0x03, 0x03, 0x00, 0x38, 0x18, 0x01, 0x80, 0xC0,
  0x0C, 0x06, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18, 0x01, 0x80,
  0xC0, 0x0C, 0x06, 0x00, 0x60, 0x20, 0x03, 0x03, 0x00, 0x30, 0x18, 0x01,
  0x80, 0xC0, 0x1C, 0x06, 0x00, 0xE0, 0x18, 0x0F, 0x00, 0xC0, 0x50, 0x06,
  0x06, 0x80, 0x1C, 0xEC, 0x00, 0x7E, 0x60, 0x00, 0x80, 0x00, 0x00, 0xFC,
  0x07, 0x9C, 0x1C, 0x18, 0x30, 0x30, 0xC0, 0x61, 0x80, 0xC6, 0x01, 0x8C,
  0x03, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x63, 0x03, 0x86, 0x7E, 0x0F, 0xE0,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x10, 0x70, 0xC0, 0x7F,
  0x80, 0x10, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x10, 0x07, 0x3B, 0x00,
  0xC0, 0xB0, 0x18, 0x0F, 0x03, 0x00, 0x60, 0x30, 0x06, 0x06, 0x00, 0x60,
  0x60, 0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0C,
  0x18, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01,
  0x81, 0x00, 0x18, 0x30, 0x03, 0x03, 0x00, 0x30, 0x30, 0x07, 0x03, 0x00,
  0x70, 0x18, 0x0F, 0x01, 0x80, 0xA0, 0x18, 0x1E, 0x00, 0xE7, 0x60, 0x07,
  0xE6, 0x00, 0x10, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x80, 0x60, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x33, 0xF0,
  0x13, 0x1C, 0x1A, 0x06, 0x0F, 0x03, 0x07, 0x01, 0x83, 0x00, 0xC1, 0x80,
  0x61, 0xC0, 0x30, 0xC0, 0x18, 0x60, 0x08, 0x30, 0x0C, 0x10, 0x06, 0x18,
  0x03, 0x0C, 0x01, 0x86, 0x00, 0x83, 0x00, 0xC1, 0x00, 0x61, 0x80, 0x30,
  0xC0, 0x18, 0x60, 0x18, 0x30, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01,
  0x86, 0x01, 0x82, 0x00, 0xC3, 0x00, 0x60, 0x00, 0x80, 0x70, 0x1C, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x01, 0xC0, 0x80, 0x60, 0x60,
  0x30, 0x18, 0x18, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x41, 0x80, 0x30, 0xC0,
  0x0C, 0x60, 0x03, 0x38, 0x00, 0xCC, 0x00, 0x67, 0x00, 0x1B, 0xC0, 0x07,
  0xB0, 0x01, 0xC4, 0x00, 0x71, 0x80, 0x38, 0x60, 0x0C, 0x18, 0x03, 0x06,
  0x00, 0xC1, 0x80, 0x20, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x10, 0x0C, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x00, 0x03, 0x3F, 0x1F, 0x80,
  0x5C, 0xE7, 0x38, 0x1A, 0x07, 0x81, 0x83, 0x80, 0xE0, 0x30, 0x70, 0x1C,
  0x06, 0x0C, 0x03, 0x00, 0xC1, 0x80, 0x60, 0x18, 0x60, 0x0C, 0x03, 0x0C,
  0x03, 0x00, 0xC1, 0x80, 0x60, 0x18, 0x30, 0x0C, 0x03, 0x04, 0x01, 0x80,
  0x61, 0x80, 0x20, 0x08, 0x30, 0x0C, 0x03, 0x06, 0x01, 0x80, 0x60, 0xC0,
  0x30, 0x0C, 0x30, 0x06, 0x01, 0x86, 0x01, 0x80, 0x20, 0xC0, 0x30, 0x0C,
  0x18, 0x06, 0x01, 0x82, 0x00, 0xC0, 0x30, 0xC0, 0x18, 0x06, 0x18, 0x06,
  0x01, 0x83, 0x00, 0xC0, 0x30, 0x60, 0x18, 0x06, 0x08, 0x03, 0x00, 0xC3,
  0x00, 0xC0, 0x18, 0x00, 0x02, 0x3F, 0x01, 0x31, 0xC1, 0xA0, 0x60, 0xE0,
  0x30, 0x70, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x1C, 0x03, 0x0C, 0x01, 0x86,
  0x00, 0x83, 0x00, 0xC1, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x18,
  0x30, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x01, 0x82, 0x00,
  0xC3, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x10, 0x60, 0x18, 0x20, 0x0C, 0x30,
  0x06, 0x00, 0x00, 0xFC, 0x03, 0xCE, 0x07, 0x07, 0x06, 0x03, 0x0C, 0x03,
  0x0C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x06, 0x60, 0x06,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x60, 0x18,
  0x60, 0x30, 0x60, 0x70, 0x39, 0xE0, 0x1F, 0x80, 0x04, 0x00, 0x00, 0xCF,
  0xC0, 0x09, 0x8E, 0x01, 0xB0, 0x60, 0x1E, 0x03, 0x01, 0xC0, 0x30, 0x1C,
  0x03, 0x01, 0x80, 0x30, 0x38, 0x03, 0x03, 0x00, 0x30, 0x30, 0x03, 0x03,
  0x00, 0x30, 0x20, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x60,
  0x60, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0xC0, 0xC0, 0x0C,
  0x0C, 0x01, 0x81, 0xC0, 0x18, 0x1C, 0x03, 0x01, 0xC0, 0x30, 0x1E, 0x06,
  0x01, 0x31, 0xC0, 0x31, 0xF8, 0x03, 0x04, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x40, 0x73, 0xB0, 0x30, 0x2C, 0x18, 0x0F, 0x0C, 0x03, 0x83,
  0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xC3, 0x00,
  0x30, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x21, 0x80, 0x18,
  0x60, 0x06, 0x10, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x38,
  0x07, 0x06, 0x03, 0xC1, 0x80, 0xA0, 0x60, 0x78, 0x0E, 0x76, 0x03, 0xF9,
  0x80, 0x10, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x3E, 0x04, 0xE8, 0x1B, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x00, 0x01, 0xFE, 0x03, 0x8F, 0x06,
  0x02, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x80, 0x60, 0xE1, 0xC0, 0xFF,
  0x80, 0x04, 0x00, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x83, 0xFC,
  0xFF, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x10, 0x78, 0x0C, 0x00, 0x06, 0x01,
  0x82, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x10, 0x60, 0x18, 0x60,
  0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x03, 0x06, 0x01, 0x86, 0x00, 0xC3,
  0x00, 0x61, 0x80, 0x20, 0xC0, 0x30, 0x40, 0x18, 0x60, 0x0C, 0x30, 0x06,
  0x18, 0x06, 0x0C, 0x03, 0x04, 0x01, 0x86, 0x01, 0xC3, 0x00, 0xE1, 0x80,
  0xA0, 0xE0, 0xD0, 0x38, 0xD8, 0x0F, 0xCC, 0x01, 0x00, 0x00, 0xC0, 0x0F,
  0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x33, 0x00, 0xCC, 0x06, 0x30, 0x18,
  0xC0, 0xC3, 0x03, 0x0C, 0x08, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0x0C, 0x30,
  0x31, 0x80, 0xC6, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xD8, 0x03, 0x60,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x18,
  0x03, 0xC0, 0x18, 0x06, 0xC0, 0x38, 0x06, 0xC0, 0x28, 0x0C, 0xC0, 0x68,
  0x0C, 0xC0, 0x78, 0x0C, 0xC0, 0x58, 0x18, 0xC0, 0xD8, 0x18, 0xC0, 0xD8,
  0x10, 0xC1, 0x98, 0x30, 0xC1, 0x98, 0x30, 0xC1, 0x18, 0x60, 0xC3, 0x18,
  0x60, 0xC2, 0x18, 0x40, 0xC6, 0x18, 0xC0, 0xC6, 0x18, 0xC0, 0xCC, 0x19,
  0x80, 0xCC, 0x19, 0x80, 0xC8, 0x19, 0x00, 0xD8, 0x1B, 0x00, 0xD8, 0x1B,
  0x00, 0xD0, 0x1A, 0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x1C,
  0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x60, 0x18,
  0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x30, 0x03, 0x04, 0x00, 0x61, 0x80,
  0x0C, 0x60, 0x00, 0x8C, 0x00, 0x1B, 0x00, 0x03, 0x40, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0x20, 0x00,
  0x66, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x30, 0x60, 0x06,
  0x04, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x03, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x30, 0x06, 0x00, 0x30, 0x06,
  0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x20, 0x00, 0x30, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0x31, 0x80, 0x00, 0x33, 0x00, 0x00, 0x33, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x5E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x03,
  0xFF, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0F, 0xC0, 0x01, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0x00, 0xFB, 0xC0, 0x60, 0x3D, 0xF0, 0x07, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 36, 11, 1, -36 },
  { 46, 11, 13, 14, 5, -36 },
  { 64, 20, 36, 19, 0, -36 },
  { 154, 19, 42, 18, 0, -39 },
  { 254, 23, 38, 27, 2, -37 },
  { 364, 18, 38, 18, -1, -37 },
  { 450, 4, 13, 8, 5, -36 },
  { 457, 14, 44, 12, 1, -36 },
  { 534, 15, 44, 13, -4, -36 },
  { 617, 13, 15, 17, 6, -39 },
  { 642, 17, 24, 21, 2, -30 },
  { 693, 7, 12, 8, -2, -5 },
  { 704, 11, 2, 13, 1, -15 },
  { 707, 3, 4, 8, 1, -4 },
  { 709, 21, 36, 15, -2, -36 },
  { 804, 17, 38, 18, 1, -37 },
  { 885, 9, 36, 18, 6, -36 },
  { 926, 20, 37, 18, -2, -37 },
  { 1019, 19, 38, 18, -1, -37 },
  { 1110, 19, 37, 18, -1, -37 },
  { 1198, 19, 37, 18, -1, -36 },
  { 1286, 18, 38, 18, 1, -37 },
  { 1372, 18, 36, 18, 2, -36 },
  { 1453, 20, 38, 18, -1, -37 },
  { 1548, 18, 38, 18, 0, -37 },
  { 1634, 8, 27, 8, 0, -27 },
  { 1661, 10, 34, 8, -2, -27 },
  { 1704, 17, 22, 21, 2, -29 },
  { 1751, 17, 12, 21, 2, -24 },
  { 1777, 17, 22, 21, 2, -29 },
  { 1824, 14, 37, 13, 1, -37 },
  { 1889, 25, 42, 27, 1, -37 },
  { 2021, 17, 37, 17, -3, -37 },
  { 2100, 20, 36, 20, 0, -36 },
  { 2190, 20, 38, 18, 2, -37 },
  { 2285, 21, 36, 22, 0, -36 },
  { 2380, 20, 36, 18, 0, -36 },
  { 2470, 20, 36, 16, 0, -36 },
  { 2560, 23, 38, 23, 2, -37 },
  { 2670, 24, 36, 23, 0, -36 },
  { 2778, 16, 36, 9, -3, -36 },
  { 2850, 17, 45, 8, -7, -36 },
  { 2946, 22, 36, 18, 0, -36 },
  { 3045, 12, 36, 16, 0, -36 },
  { 3099, 31, 36, 31, 0, -36 },
  { 3239, 25, 36, 24, 0, -36 },
  { 3352, 20, 38, 23, 2, -37 },
  { 3447, 19, 36, 19, 0, -36 },
  { 3533, 20, 46, 23, 2, -37 },
  { 3648, 19, 36, 19, 0, -36 },
  { 3734, 20, 38, 18, -1, -37 },
  { 3829, 16, 36, 16, 3, -36 },
  { 3901, 21, 37, 22, 2, -36 },
  { 3999, 18, 36, 18, 4, -36 },
  { 4080, 31, 36, 31, 4, -36 },
  { 4220, 23, 36, 16, -3, -36 },
  { 4324, 17, 36, 15, 3, -36 },
  { 4401, 21, 36, 16, -2, -36 },
  { 4496, 18, 44, 14, -1, -36 },
  { 4595, 7, 36, 16, 5, -36 },
  { 4627, 18, 44, 14, -3, -36 },
  { 4726, 19, 17, 20, 1, -36 },
  { 4767, 14, 1, 14, -4, 5 },
  { 4769, 6, 8, 11, 7, -39 },
  { 4775, 18, 28, 20, 1, -27 },
  { 4838, 18, 40, 19, 0, -39 },
  { 4928, 15, 28, 14, 1, -27 },
  { 4981, 21, 40, 20, 1, -39 },
  { 5086, 15, 28, 17, 1, -27 },
  { 5139, 23, 51, 10, -7, -39 },
  { 5286, 20, 39, 20, -1, -27 },
  { 5384, 17, 39, 19, 0, -39 },
  { 5467, 10, 37, 8, 0, -37 },
  { 5514, 17, 49, 9, -7, -37 },
  { 5619, 18, 39, 16, 0, -39 },
  { 5707, 10, 39, 8, 0, -39 },
  { 5756, 27, 27, 29, 0, -27 },
  { 5848, 17, 27, 19, 0, -27 },
  { 5906, 16, 28, 19, 1, -27 },
  { 5962, 20, 39, 19, -2, -27 },
  { 6060, 18, 39, 20, 1, -27 },
  { 6148, 15, 27, 12, 0, -27 },
  { 6199, 16, 28, 14, -1, -27 },
  { 6255, 10, 34, 10, 1, -33 },
  { 6298, 17, 28, 19, 1, -27 },
  { 6358, 14, 27, 14, 3, -27 },
  { 6406, 24, 27, 24, 3, -27 },
  { 6487, 19, 27, 15, -2, -27 },
  { 6552, 24, 39, 15, -6, -27 },
  { 6669, 16, 27, 12, -2, -27 },
  { 6723, 17, 44, 16, 2, -36 },
  { 6817, 2, 51, 18, 8, -39 },
  { 6830, 17, 44, 16, -3, -36 },
  { 6924, 17, 4, 21, 2, -20 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC51PT7B_H_
