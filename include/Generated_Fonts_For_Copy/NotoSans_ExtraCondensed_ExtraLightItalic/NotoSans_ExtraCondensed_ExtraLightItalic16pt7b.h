#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC16PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x92, 0x02, 0x00, 0xB7, 0x60, 0x14, 0x52, 0x5E, 0x29,
  0x25, 0x3E, 0x52, 0x8A, 0x00, 0x08, 0xF5, 0x14, 0x50, 0x81, 0x0A, 0x28,
  0xAB, 0x10, 0x40, 0x20, 0xCA, 0x95, 0x4A, 0x96, 0xF6, 0xD5, 0x32, 0xA5,
  0x54, 0xE0, 0x11, 0x4A, 0x53, 0x11, 0x95, 0x9C, 0xA5, 0xD0, 0xF0, 0x18,
  0x88, 0x84, 0x22, 0x10, 0x84, 0x21, 0x04, 0x20, 0x11, 0x11, 0x11, 0x11,
  0x12, 0x24, 0x88, 0x2D, 0x6A, 0x10, 0x41, 0x3F, 0x10, 0x41, 0x00, 0x56,
  0xF0, 0x80, 0x02, 0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0x40, 0x82, 0x00,
  0x18, 0x92, 0x51, 0x45, 0x18, 0xA2, 0x8A, 0x29, 0x18, 0x75, 0x24, 0xA4,
  0x92, 0x00, 0x0C, 0x24, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x41, 0x07,
  0xC0, 0x39, 0x10, 0x41, 0x08, 0x43, 0x02, 0x08, 0x21, 0x38, 0x04, 0x31,
  0x46, 0x28, 0xA4, 0xA4, 0x91, 0xE1, 0x04, 0x3C, 0x84, 0x10, 0x70, 0x20,
  0x82, 0x08, 0x4E, 0x00, 0x0C, 0x42, 0x10, 0x41, 0xE4, 0xA2, 0x8A, 0x28,
  0x9C, 0xF8, 0x44, 0x22, 0x11, 0x08, 0x44, 0x20, 0x18, 0x94, 0x51, 0x48,
  0xC7, 0x22, 0x8A, 0x28, 0xBC, 0x10, 0xA4, 0x51, 0x45, 0x24, 0x8E, 0x08,
  0x41, 0x38, 0x28, 0x00, 0x00, 0x80, 0x11, 0x00, 0x00, 0x02, 0x44, 0x80,
  0x04, 0x66, 0x30, 0x30, 0x20, 0x40, 0xFC, 0x00, 0x3F, 0xC0, 0xC0, 0x81,
  0x19, 0x88, 0x00, 0x32, 0x42, 0x11, 0x10, 0x88, 0x40, 0x01, 0x00, 0x1F,
  0x21, 0x21, 0x4D, 0x55, 0x55, 0xA5, 0xAA, 0xBE, 0x80, 0x80, 0x70, 0x08,
  0x46, 0x32, 0x94, 0xE9, 0x4C, 0x62, 0x3C, 0x92, 0x51, 0x49, 0xE4, 0x91,
  0x8A, 0x2F, 0x00, 0x1C, 0x84, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x38,
  0x3C, 0x92, 0x51, 0x45, 0x14, 0x51, 0x8A, 0x2F, 0x00, 0x3C, 0x82, 0x10,
  0x41, 0xE4, 0x10, 0x82, 0x0F, 0x00, 0x3C, 0x82, 0x10, 0x41, 0xE4, 0x10,
  0x82, 0x08, 0x00, 0x1C, 0x45, 0x04, 0x08, 0x10, 0x27, 0x42, 0x89, 0x12,
  0x23, 0xC0, 0x22, 0x44, 0x8A, 0x14, 0x2F, 0x91, 0x22, 0x85, 0x0A, 0x20,
  0x38, 0x84, 0x42, 0x10, 0x84, 0x42, 0x38, 0x08, 0x42, 0x21, 0x08, 0x42,
  0x21, 0x08, 0x44, 0x60, 0x26, 0x48, 0xA2, 0x86, 0x0A, 0x14, 0x28, 0x91,
  0x22, 0x20, 0x22, 0x24, 0x44, 0x44, 0x88, 0xF0, 0x20, 0xC8, 0x22, 0x19,
  0x46, 0x52, 0x94, 0xA5, 0x49, 0x54, 0x99, 0x26, 0x49, 0x10, 0x21, 0x31,
  0x32, 0x52, 0x52, 0x52, 0x4A, 0x4C, 0x8C, 0x8C, 0x84, 0x10, 0x94, 0x61,
  0x86, 0x18, 0x61, 0x8A, 0x29, 0x38, 0x3C, 0x92, 0x51, 0x45, 0xE4, 0x10,
  0x82, 0x08, 0x00, 0x10, 0x94, 0x61, 0x86, 0x18, 0x61, 0x8A, 0x29, 0x38,
  0x20, 0x82, 0x00, 0x3C, 0x92, 0x51, 0x45, 0xE5, 0x14, 0x92, 0x48, 0x80,
  0x18, 0x94, 0x10, 0x40, 0x81, 0x04, 0x08, 0x21, 0x3C, 0xF9, 0x08, 0x84,
  0x21, 0x08, 0x84, 0x20, 0x22, 0x44, 0x8A, 0x14, 0x48, 0x91, 0x42, 0x89,
  0x11, 0xC0, 0x86, 0x28, 0xA4, 0x92, 0x4A, 0x28, 0xC3, 0x08, 0x00, 0x88,
  0x62, 0x29, 0x4A, 0x52, 0x95, 0x2A, 0x4A, 0xA2, 0xA8, 0xCA, 0x31, 0x08,
  0x40, 0x12, 0x28, 0x50, 0xC1, 0x02, 0x0A, 0x14, 0x48, 0x92, 0x20, 0x8C,
  0xA5, 0x46, 0x21, 0x08, 0x84, 0x20, 0x1E, 0x08, 0x10, 0x40, 0x82, 0x08,
  0x10, 0x40, 0x83, 0xE0, 0x39, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08,
  0x70, 0xAA, 0xA9, 0x54, 0x1C, 0x10, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41,
  0x08, 0x23, 0x80, 0x10, 0xA2, 0x91, 0xC4, 0xF0, 0x90, 0x18, 0x94, 0x51,
  0x4A, 0x28, 0xA2, 0x70, 0x20, 0x82, 0x0E, 0x25, 0x14, 0x51, 0x4A, 0x28,
  0xBC, 0x19, 0x10, 0x88, 0x42, 0x10, 0x70, 0x02, 0x04, 0x10, 0xE2, 0x48,
  0x91, 0x24, 0x89, 0x12, 0x23, 0x80, 0x11, 0x52, 0x97, 0x42, 0x10, 0x70,
  0x06, 0x10, 0x20, 0xE0, 0x82, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04,
  0x10, 0x60, 0x18, 0x94, 0x51, 0x4A, 0x28, 0xA2, 0x70, 0x41, 0x04, 0xE0,
  0x21, 0x08, 0x72, 0xA5, 0x29, 0x4C, 0x63, 0x20, 0x20, 0x24, 0x92, 0x92,
  0x00, 0x08, 0x00, 0x11, 0x08, 0x42, 0x21, 0x08, 0x42, 0x23, 0x00, 0x20,
  0x82, 0x09, 0x49, 0x46, 0x18, 0x52, 0x49, 0x24, 0x24, 0x94, 0x92, 0x52,
  0x40, 0x1B, 0x25, 0x49, 0x49, 0x49, 0x49, 0x89, 0x91, 0x92, 0x19, 0x52,
  0x94, 0xA6, 0x31, 0x90, 0x11, 0x52, 0x98, 0xC6, 0x31, 0x70, 0x0C, 0x24,
  0x89, 0x12, 0x24, 0x51, 0x22, 0x78, 0x81, 0x04, 0x08, 0x00, 0x18, 0x94,
  0x51, 0x4A, 0x28, 0xA2, 0x70, 0x41, 0x04, 0x10, 0x19, 0x10, 0x84, 0x22,
  0x10, 0x80, 0x3A, 0x10, 0x82, 0x10, 0x42, 0xE0, 0x24, 0xA4, 0x92, 0x93,
  0x80, 0x45, 0x14, 0x92, 0x4A, 0x29, 0x3C, 0x99, 0xAA, 0xCC, 0x88, 0x93,
  0x66, 0xD5, 0xAD, 0x5B, 0x26, 0x48, 0x24, 0xA1, 0x04, 0x30, 0xC5, 0x22,
  0x13, 0x12, 0x12, 0x14, 0x14, 0x18, 0x18, 0x10, 0x10, 0x20, 0x20, 0xC0,
  0x38, 0x44, 0x22, 0x21, 0x1E, 0x0C, 0x41, 0x04, 0x20, 0x8C, 0x08, 0x21,
  0x04, 0x10, 0x40, 0x80, 0xFF, 0xFF, 0x18, 0x42, 0x11, 0x08, 0x22, 0x11,
  0x08, 0x46, 0x40, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 11, 3, 0, -11 },
  { 6, 3, 4, 4, 2, -11 },
  { 8, 6, 11, 6, 0, -11 },
  { 17, 6, 13, 6, 0, -12 },
  { 27, 7, 12, 9, 1, -12 },
  { 38, 5, 12, 6, 0, -12 },
  { 46, 1, 4, 2, 2, -11 },
  { 47, 5, 14, 4, 0, -11 },
  { 56, 4, 14, 4, -1, -11 },
  { 63, 4, 4, 5, 2, -12 },
  { 65, 6, 7, 6, 0, -9 },
  { 71, 2, 4, 3, -1, -2 },
  { 72, 4, 1, 4, 0, -5 },
  { 73, 1, 1, 3, 0, -1 },
  { 74, 7, 11, 5, -1, -11 },
  { 84, 6, 12, 6, 0, -12 },
  { 93, 3, 11, 6, 2, -11 },
  { 98, 7, 12, 6, -1, -12 },
  { 109, 6, 12, 6, 0, -12 },
  { 118, 6, 12, 6, 0, -12 },
  { 127, 6, 11, 6, 0, -11 },
  { 136, 6, 12, 6, 0, -12 },
  { 145, 5, 11, 6, 1, -11 },
  { 152, 6, 12, 6, 0, -12 },
  { 161, 6, 12, 6, 0, -12 },
  { 170, 3, 9, 3, 0, -9 },
  { 174, 4, 11, 3, -1, -9 },
  { 180, 6, 7, 6, 0, -9 },
  { 186, 6, 4, 6, 0, -8 },
  { 189, 6, 7, 6, 0, -9 },
  { 195, 5, 12, 4, 0, -12 },
  { 203, 8, 12, 8, 0, -11 },
  { 215, 5, 11, 5, -1, -11 },
  { 222, 6, 11, 6, 0, -11 },
  { 231, 6, 12, 6, 1, -12 },
  { 240, 6, 11, 7, 0, -11 },
  { 249, 6, 11, 6, 0, -11 },
  { 258, 6, 11, 5, 0, -11 },
  { 267, 7, 12, 7, 1, -12 },
  { 278, 7, 11, 7, 0, -11 },
  { 288, 5, 11, 3, -1, -11 },
  { 295, 5, 14, 3, -2, -11 },
  { 304, 7, 11, 6, 0, -11 },
  { 314, 4, 11, 5, 0, -11 },
  { 320, 10, 11, 10, 0, -11 },
  { 334, 8, 11, 8, 0, -11 },
  { 345, 6, 12, 7, 1, -12 },
  { 354, 6, 11, 6, 0, -11 },
  { 363, 6, 15, 7, 1, -12 },
  { 375, 6, 11, 6, 0, -11 },
  { 384, 6, 12, 6, 0, -12 },
  { 393, 5, 11, 5, 1, -11 },
  { 400, 7, 11, 7, 0, -11 },
  { 410, 6, 11, 6, 1, -11 },
  { 419, 10, 11, 10, 1, -11 },
  { 433, 7, 11, 5, -1, -11 },
  { 443, 5, 11, 5, 1, -11 },
  { 450, 7, 11, 5, -1, -11 },
  { 460, 5, 14, 4, 0, -11 },
  { 469, 2, 11, 5, 2, -11 },
  { 472, 6, 14, 4, -1, -11 },
  { 483, 6, 5, 6, 0, -11 },
  { 487, 4, 1, 4, -1, 1 },
  { 488, 2, 2, 3, 2, -12 },
  { 489, 6, 9, 6, 0, -9 },
  { 496, 6, 12, 6, 0, -12 },
  { 505, 5, 9, 4, 0, -9 },
  { 511, 7, 12, 6, 0, -12 },
  { 522, 5, 9, 5, 0, -9 },
  { 528, 7, 16, 3, -2, -12 },
  { 542, 6, 13, 6, 0, -9 },
  { 552, 5, 12, 6, 0, -12 },
  { 560, 3, 11, 3, 0, -11 },
  { 565, 5, 15, 3, -2, -11 },
  { 575, 6, 12, 5, 0, -12 },
  { 584, 3, 12, 3, 0, -12 },
  { 589, 8, 9, 9, 0, -9 },
  { 598, 5, 9, 6, 0, -9 },
  { 604, 5, 9, 6, 0, -9 },
  { 610, 7, 13, 6, -1, -9 },
  { 622, 6, 13, 6, 0, -9 },
  { 632, 5, 9, 4, 0, -9 },
  { 638, 5, 9, 5, 0, -9 },
  { 644, 3, 11, 3, 0, -11 },
  { 649, 6, 8, 6, 0, -8 },
  { 655, 4, 8, 5, 1, -8 },
  { 659, 7, 8, 8, 1, -8 },
  { 666, 6, 8, 5, -1, -8 },
  { 672, 8, 12, 5, -2, -8 },
  { 684, 5, 8, 4, -1, -8 },
  { 689, 6, 14, 5, 0, -11 },
  { 700, 1, 16, 6, 2, -12 },
  { 702, 5, 14, 5, -1, -11 },
  { 711, 5, 1, 6, 1, -6 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC16PT7B_H_
