#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC21PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x21, 0x10, 0x84, 0x22, 0x10, 0x00, 0x22, 0x00, 0x55,
  0x99, 0x90, 0x09, 0x09, 0x09, 0x12, 0x3F, 0x12, 0x14, 0x24, 0x24, 0xFE,
  0x48, 0x48, 0x50, 0x90, 0x90, 0x04, 0x04, 0x1B, 0x28, 0x28, 0x28, 0x28,
  0x10, 0x10, 0x18, 0x14, 0x14, 0x14, 0x24, 0xF8, 0x20, 0x20, 0x30, 0xA4,
  0x92, 0x51, 0x49, 0x24, 0xA2, 0x57, 0x35, 0xEA, 0x8A, 0x45, 0x24, 0x92,
  0x4A, 0x29, 0x1C, 0x1C, 0x28, 0x91, 0x22, 0x45, 0x04, 0x18, 0x50, 0x96,
  0x34, 0x68, 0x91, 0x3D, 0x00, 0x5A, 0x80, 0x04, 0x20, 0x84, 0x20, 0x84,
  0x10, 0x41, 0x08, 0x20, 0x82, 0x04, 0x10, 0x41, 0x00, 0x10, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x11, 0x08, 0x84, 0x44, 0x00, 0x12, 0x45, 0xC8,
  0x50, 0x20, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10, 0x29, 0x28,
  0xF8, 0x60, 0x00, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10,
  0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x00, 0x0E, 0x24, 0x89, 0x12, 0x28,
  0x50, 0xA1, 0x43, 0x06, 0x14, 0x28, 0x91, 0x1C, 0x00, 0x13, 0xD1, 0x22,
  0x22, 0x24, 0x44, 0x48, 0x80, 0x1F, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02,
  0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0xFC, 0x3E, 0x02, 0x01, 0x01,
  0x02, 0x02, 0x04, 0x38, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0xF0, 0x03,
  0x06, 0x06, 0x0A, 0x12, 0x14, 0x24, 0x24, 0x44, 0x84, 0x88, 0xFE, 0x08,
  0x08, 0x08, 0x0F, 0x88, 0x04, 0x02, 0x01, 0x01, 0x00, 0xF0, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x23, 0xE0, 0x0F, 0x10, 0x10, 0x20, 0x20,
  0x40, 0x7C, 0x42, 0x42, 0x42, 0x82, 0x84, 0x84, 0x44, 0x78, 0x7E, 0x04,
  0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x00,
  0x1E, 0x21, 0x21, 0x21, 0x22, 0x22, 0x1C, 0x38, 0x48, 0x84, 0x84, 0x84,
  0x84, 0x84, 0x78, 0x1E, 0x44, 0x8A, 0x14, 0x28, 0x50, 0xA3, 0x3A, 0x08,
  0x10, 0x20, 0x81, 0x3C, 0x00, 0x24, 0x00, 0x00, 0x12, 0x00, 0x11, 0x00,
  0x00, 0x00, 0x02, 0x44, 0x88, 0x02, 0x18, 0xC2, 0x08, 0x0C, 0x04, 0x06,
  0x02, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x80, 0x80, 0xC0, 0x60, 0x21, 0x8C,
  0x20, 0x80, 0x3C, 0x10, 0x41, 0x04, 0x21, 0x08, 0x21, 0x04, 0x00, 0x03,
  0x08, 0x00, 0x0F, 0x04, 0x22, 0x05, 0x01, 0x46, 0x52, 0x99, 0x26, 0x4A,
  0xA4, 0xA9, 0x2A, 0x4A, 0xB4, 0x92, 0x20, 0x08, 0x02, 0x00, 0x78, 0x00,
  0x02, 0x0C, 0x18, 0x50, 0xA2, 0x44, 0x89, 0x3E, 0x45, 0x0A, 0x14, 0x30,
  0x60, 0x80, 0x1E, 0x11, 0x11, 0x21, 0x21, 0x21, 0x26, 0x3C, 0x42, 0x42,
  0x42, 0x42, 0x82, 0x84, 0xF8, 0x0F, 0x10, 0x20, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x78, 0x1E, 0x11, 0x11, 0x21,
  0x21, 0x21, 0x21, 0x21, 0x41, 0x41, 0x42, 0x42, 0x84, 0x88, 0xF0, 0x1F,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x3C, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x80, 0xF8, 0x1F, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x3C, 0x40, 0x40,
  0x40, 0x40, 0x80, 0x80, 0x80, 0x0F, 0x88, 0x08, 0x08, 0x04, 0x04, 0x02,
  0x01, 0x0E, 0x81, 0x41, 0x20, 0x90, 0x48, 0x24, 0x11, 0xF0, 0x10, 0x44,
  0x11, 0x08, 0x82, 0x20, 0x88, 0x22, 0x10, 0xFC, 0x41, 0x10, 0x44, 0x11,
  0x08, 0x82, 0x20, 0x88, 0x20, 0x1C, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20,
  0x82, 0x08, 0x21, 0x0E, 0x00, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02,
  0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x43, 0x00, 0x10, 0x88,
  0x84, 0x84, 0x42, 0x41, 0x40, 0xC0, 0x50, 0x68, 0x24, 0x12, 0x09, 0x08,
  0x44, 0x22, 0x10, 0x10, 0x84, 0x42, 0x10, 0x84, 0x42, 0x10, 0x88, 0x43,
  0xE0, 0x10, 0x18, 0x80, 0xC4, 0x0C, 0x50, 0x62, 0x85, 0x14, 0x28, 0xA1,
  0x45, 0x14, 0x48, 0xA2, 0x49, 0x12, 0x48, 0x94, 0x48, 0xA4, 0x46, 0x22,
  0x31, 0x00, 0x10, 0x44, 0x11, 0x84, 0xA1, 0x28, 0x8A, 0x22, 0x88, 0x92,
  0x44, 0x91, 0x44, 0x51, 0x14, 0x83, 0x20, 0x88, 0x20, 0x1E, 0x21, 0x21,
  0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x84, 0x84, 0x78,
  0x1E, 0x11, 0x11, 0x21, 0x21, 0x21, 0x22, 0x24, 0x78, 0x40, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x1E, 0x21, 0x21, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81,
  0x82, 0x82, 0x82, 0x84, 0x84, 0x78, 0x10, 0x10, 0x10, 0x08, 0x1E, 0x11,
  0x11, 0x21, 0x21, 0x21, 0x22, 0x24, 0x58, 0x48, 0x48, 0x48, 0x84, 0x84,
  0x84, 0x0F, 0x88, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x23, 0xE0, 0x7E, 0x20, 0x40, 0x82, 0x04, 0x08,
  0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x00, 0x20, 0x90, 0x90, 0x48,
  0x24, 0x12, 0x11, 0x09, 0x04, 0x82, 0x41, 0x21, 0x10, 0x88, 0x44, 0x43,
  0xC0, 0x83, 0x06, 0x14, 0x28, 0x91, 0x24, 0x48, 0x91, 0x42, 0x86, 0x0C,
  0x10, 0x20, 0x00, 0x84, 0x18, 0x41, 0x84, 0x28, 0xA2, 0x8C, 0x29, 0x44,
  0x94, 0x49, 0x48, 0xA4, 0x8A, 0x48, 0xC5, 0x0C, 0x50, 0xC6, 0x08, 0x60,
  0x86, 0x00, 0x10, 0x88, 0x82, 0x41, 0x40, 0xA0, 0x60, 0x30, 0x10, 0x18,
  0x0A, 0x09, 0x04, 0x84, 0x42, 0x22, 0x10, 0x42, 0x89, 0x12, 0x44, 0x8A,
  0x14, 0x30, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x00, 0x1F, 0x80, 0x80,
  0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02,
  0x03, 0xF0, 0x1E, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02,
  0x04, 0x10, 0x20, 0x40, 0x81, 0xC0, 0x92, 0x24, 0x92, 0x48, 0x92, 0x48,
  0x1E, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x11, 0xE0, 0x08, 0x14, 0x14, 0x22, 0x22, 0x42, 0xC1, 0xFC,
  0x94, 0x3E, 0x8D, 0x14, 0x28, 0x50, 0xA1, 0x44, 0x89, 0x33, 0xA0, 0x10,
  0x20, 0x40, 0x82, 0x05, 0xCC, 0x91, 0x22, 0x85, 0x0A, 0x14, 0x28, 0xB1,
  0x5C, 0x3A, 0x11, 0x08, 0x42, 0x10, 0x84, 0x3C, 0x01, 0x01, 0x01, 0x02,
  0x02, 0x3E, 0x46, 0x44, 0x84, 0x84, 0x84, 0x84, 0x88, 0x88, 0x98, 0xE8,
  0x39, 0x14, 0x62, 0x9B, 0x88, 0x20, 0x82, 0x0F, 0x00, 0x01, 0xC0, 0x80,
  0x20, 0x08, 0x02, 0x03, 0xC0, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0xE0, 0x00,
  0x1F, 0x23, 0x22, 0x42, 0x42, 0x42, 0x42, 0x84, 0x84, 0x4C, 0x74, 0x04,
  0x08, 0x08, 0x08, 0xF0, 0x10, 0x20, 0x40, 0x82, 0x07, 0xC8, 0x91, 0x22,
  0x85, 0x0A, 0x24, 0x48, 0xA1, 0x44, 0x11, 0x00, 0x22, 0x22, 0x44, 0x44,
  0x48, 0x80, 0x02, 0x04, 0x00, 0x00, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20,
  0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x86, 0x00, 0x10, 0x20, 0x40, 0x82,
  0x04, 0x49, 0x14, 0x28, 0xA1, 0xC2, 0x44, 0x91, 0x22, 0x44, 0x11, 0x11,
  0x22, 0x22, 0x24, 0x44, 0x48, 0x88, 0x3F, 0xE4, 0x44, 0x88, 0x91, 0x14,
  0x22, 0x88, 0x91, 0x12, 0x22, 0x44, 0x51, 0x0A, 0x22, 0x00, 0x3E, 0x44,
  0x89, 0x14, 0x28, 0x51, 0x22, 0x45, 0x0A, 0x20, 0x3D, 0x14, 0x61, 0x86,
  0x18, 0x62, 0x8A, 0x2F, 0x00, 0x17, 0x0C, 0x84, 0x22, 0x12, 0x11, 0x08,
  0x84, 0x42, 0x22, 0x31, 0x17, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x3E,
  0x8D, 0x14, 0x28, 0x50, 0xA1, 0x44, 0x89, 0x33, 0xA0, 0x41, 0x02, 0x04,
  0x08, 0x3C, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x00, 0x3D, 0x04,
  0x10, 0x20, 0x41, 0x02, 0x08, 0x4F, 0x00, 0x10, 0x8A, 0xE2, 0x11, 0x08,
  0x42, 0x11, 0x08, 0x70, 0x42, 0x89, 0x12, 0x28, 0x51, 0x22, 0x44, 0x89,
  0x33, 0xC0, 0x86, 0x28, 0xA2, 0x92, 0x4A, 0x28, 0xC3, 0x08, 0x00, 0x84,
  0x63, 0x28, 0xCA, 0x52, 0x95, 0x29, 0x4A, 0x52, 0x98, 0xC6, 0x31, 0x08,
  0x40, 0x11, 0x12, 0x14, 0x14, 0x08, 0x08, 0x18, 0x28, 0x28, 0x44, 0x84,
  0x08, 0x84, 0x42, 0x41, 0x20, 0x90, 0x50, 0x28, 0x18, 0x0C, 0x04, 0x02,
  0x02, 0x01, 0x01, 0x00, 0x81, 0x80, 0x1E, 0x08, 0x10, 0x40, 0x82, 0x08,
  0x10, 0x40, 0x83, 0xE0, 0x06, 0x10, 0x40, 0x81, 0x04, 0x08, 0x10, 0x41,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x80, 0xC0, 0xFF, 0xFF, 0xF8, 0x18,
  0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x0C, 0x20, 0x81, 0x02, 0x04,
  0x10, 0x21, 0x80, 0xF2, 0x18,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 15, 4, 0, -15 },
  { 11, 4, 5, 6, 2, -15 },
  { 14, 8, 15, 8, 0, -15 },
  { 29, 8, 17, 7, 0, -16 },
  { 46, 9, 15, 11, 1, -15 },
  { 63, 7, 15, 7, 0, -15 },
  { 77, 2, 5, 3, 2, -15 },
  { 79, 6, 18, 5, 0, -15 },
  { 93, 5, 18, 5, -1, -15 },
  { 105, 6, 6, 7, 2, -16 },
  { 110, 7, 9, 9, 1, -12 },
  { 118, 3, 5, 3, -1, -2 },
  { 120, 5, 1, 5, 0, -6 },
  { 121, 2, 2, 3, 0, -2 },
  { 122, 9, 15, 6, -1, -15 },
  { 139, 7, 15, 7, 0, -15 },
  { 153, 4, 15, 7, 2, -15 },
  { 161, 8, 15, 7, -1, -15 },
  { 176, 8, 15, 7, 0, -15 },
  { 191, 8, 15, 7, 0, -15 },
  { 206, 9, 15, 7, -1, -15 },
  { 223, 8, 15, 7, 0, -15 },
  { 238, 7, 15, 7, 1, -15 },
  { 252, 8, 15, 7, 0, -15 },
  { 267, 7, 15, 7, 0, -15 },
  { 281, 3, 11, 3, 0, -11 },
  { 286, 4, 14, 3, -1, -11 },
  { 293, 7, 9, 9, 1, -12 },
  { 301, 7, 5, 9, 1, -10 },
  { 306, 7, 9, 9, 1, -12 },
  { 314, 6, 15, 5, 0, -15 },
  { 326, 10, 17, 11, 1, -15 },
  { 348, 7, 15, 7, -1, -15 },
  { 362, 8, 15, 8, 0, -15 },
  { 377, 8, 15, 7, 1, -15 },
  { 392, 8, 15, 9, 0, -15 },
  { 407, 8, 15, 7, 0, -15 },
  { 422, 8, 15, 7, 0, -15 },
  { 437, 9, 15, 10, 1, -15 },
  { 454, 10, 15, 9, 0, -15 },
  { 473, 6, 15, 4, -1, -15 },
  { 485, 7, 19, 3, -3, -15 },
  { 502, 9, 15, 8, 0, -15 },
  { 519, 5, 15, 6, 0, -15 },
  { 529, 13, 15, 13, 0, -15 },
  { 554, 10, 15, 10, 0, -15 },
  { 573, 8, 15, 10, 1, -15 },
  { 588, 8, 15, 8, 0, -15 },
  { 603, 8, 19, 10, 1, -15 },
  { 622, 8, 15, 8, 0, -15 },
  { 637, 9, 15, 7, -1, -15 },
  { 654, 7, 15, 6, 1, -15 },
  { 668, 9, 15, 9, 1, -15 },
  { 685, 7, 15, 7, 2, -15 },
  { 699, 12, 15, 13, 2, -15 },
  { 722, 9, 15, 7, -1, -15 },
  { 739, 7, 15, 6, 1, -15 },
  { 753, 9, 15, 7, -1, -15 },
  { 770, 7, 18, 6, 0, -15 },
  { 786, 3, 15, 7, 2, -15 },
  { 792, 7, 18, 6, -1, -15 },
  { 808, 8, 7, 8, 0, -15 },
  { 815, 6, 1, 6, -2, 2 },
  { 816, 2, 3, 5, 3, -16 },
  { 817, 7, 11, 8, 1, -11 },
  { 827, 7, 16, 8, 0, -16 },
  { 841, 5, 11, 6, 1, -11 },
  { 848, 8, 16, 8, 1, -16 },
  { 864, 6, 11, 7, 1, -11 },
  { 873, 10, 21, 4, -3, -16 },
  { 900, 8, 16, 8, 0, -11 },
  { 916, 7, 16, 8, 0, -16 },
  { 930, 4, 15, 3, 0, -15 },
  { 938, 7, 20, 4, -3, -15 },
  { 956, 7, 16, 6, 0, -16 },
  { 970, 4, 16, 3, 0, -16 },
  { 978, 11, 11, 12, 0, -11 },
  { 994, 7, 11, 8, 0, -11 },
  { 1004, 6, 11, 8, 1, -11 },
  { 1013, 9, 16, 8, -1, -11 },
  { 1031, 7, 16, 8, 1, -11 },
  { 1045, 6, 11, 5, 0, -11 },
  { 1054, 6, 11, 6, 0, -11 },
  { 1063, 5, 14, 4, 0, -14 },
  { 1072, 7, 11, 8, 1, -11 },
  { 1082, 6, 11, 6, 1, -11 },
  { 1091, 10, 11, 10, 1, -11 },
  { 1105, 8, 11, 6, -1, -11 },
  { 1116, 9, 16, 6, -2, -11 },
  { 1134, 7, 11, 5, -1, -11 },
  { 1144, 7, 18, 7, 1, -15 },
  { 1160, 1, 21, 7, 3, -16 },
  { 1163, 7, 18, 7, -1, -15 },
  { 1179, 7, 2, 9, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC21PT7B_H_
