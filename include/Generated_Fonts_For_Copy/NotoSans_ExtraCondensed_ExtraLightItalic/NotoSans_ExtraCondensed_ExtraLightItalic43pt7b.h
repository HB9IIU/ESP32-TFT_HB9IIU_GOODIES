#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC43PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C,
  0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20,
  0x20, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0xC0, 0x31, 0x98, 0xC8, 0x64,
  0x26, 0x13, 0x19, 0x0C, 0x84, 0x42, 0x61, 0x21, 0x80, 0x00, 0x21, 0x80,
  0x30, 0xC0, 0x10, 0x40, 0x08, 0x60, 0x0C, 0x30, 0x04, 0x10, 0x02, 0x08,
  0x03, 0x0C, 0x01, 0x04, 0x0F, 0xFF, 0xC7, 0xFF, 0xE0, 0x61, 0x00, 0x20,
  0x80, 0x30, 0xC0, 0x18, 0x40, 0x08, 0x20, 0x04, 0x30, 0x06, 0x18, 0x02,
  0x08, 0x01, 0x0C, 0x0F, 0xFF, 0xC0, 0x82, 0x00, 0x41, 0x00, 0x61, 0x80,
  0x30, 0x80, 0x10, 0x40, 0x18, 0x60, 0x0C, 0x20, 0x04, 0x10, 0x02, 0x18,
  0x03, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x01,
  0xFC, 0x03, 0xAF, 0x06, 0x21, 0x0C, 0x20, 0x08, 0x60, 0x08, 0x40, 0x08,
  0x40, 0x08, 0x40, 0x08, 0xC0, 0x0C, 0x80, 0x04, 0x80, 0x06, 0x80, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x60, 0x01, 0x30, 0x01, 0x30, 0x03,
  0x10, 0x02, 0x18, 0x02, 0x18, 0x02, 0x10, 0x02, 0x10, 0x04, 0x30, 0x04,
  0x60, 0xC4, 0xC0, 0xFF, 0x80, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x07, 0x00, 0x41, 0xB0, 0x18, 0x62, 0x02, 0x18, 0x60,
  0xC3, 0x0C, 0x10, 0x41, 0x06, 0x18, 0x20, 0x82, 0x04, 0x30, 0x40, 0x84,
  0x18, 0x31, 0x83, 0x06, 0x20, 0x60, 0xCC, 0x0C, 0x11, 0x1D, 0x06, 0x67,
  0xE0, 0xC9, 0x8C, 0x13, 0x21, 0xC6, 0x4C, 0x39, 0x99, 0x05, 0xE2, 0x60,
  0x80, 0xCC, 0x10, 0x11, 0x02, 0x06, 0x20, 0xC0, 0x8C, 0x18, 0x31, 0x83,
  0x04, 0x30, 0x41, 0x84, 0x18, 0x20, 0x83, 0x0C, 0x18, 0x41, 0x02, 0x18,
  0x60, 0x66, 0x18, 0x07, 0x80, 0x00, 0x40, 0x00, 0xF0, 0x06, 0xE0, 0x31,
  0x80, 0x86, 0x06, 0x18, 0x18, 0x60, 0x61, 0x81, 0x84, 0x06, 0x30, 0x18,
  0xC0, 0x66, 0x01, 0x90, 0x06, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0D,
  0x00, 0x64, 0x03, 0x18, 0xD8, 0x63, 0x40, 0x8B, 0x02, 0x6C, 0x0D, 0xA0,
  0x34, 0x80, 0x72, 0x01, 0x88, 0x06, 0x20, 0x38, 0xC1, 0xA3, 0x8C, 0xC7,
  0xE3, 0x00, 0x33, 0x22, 0x66, 0x44, 0x44, 0xC0, 0x00, 0x30, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x20, 0x03, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x60,
  0x0C, 0x00, 0x04, 0x00, 0x40, 0x18, 0x42, 0x0E, 0x40, 0x69, 0xC3, 0xE0,
  0x60, 0x12, 0x0C, 0x63, 0x04, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x81,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x21, 0x86,
  0x10, 0xC2, 0x18, 0x42, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x06, 0xE0, 0x30, 0xC1,
  0x83, 0x0C, 0x0C, 0x30, 0x31, 0x80, 0xC6, 0x03, 0x10, 0x0C, 0xC0, 0x33,
  0x00, 0xC8, 0x03, 0x20, 0x0D, 0x80, 0x26, 0x00, 0x98, 0x06, 0x40, 0x1B,
  0x00, 0x6C, 0x01, 0x30, 0x04, 0xC0, 0x33, 0x00, 0xCC, 0x02, 0x20, 0x18,
  0x80, 0x62, 0x01, 0x0C, 0x0C, 0x30, 0x60, 0xC1, 0x01, 0x9C, 0x03, 0xE0,
  0x00, 0x03, 0x07, 0x1E, 0x36, 0x66, 0xC6, 0x84, 0x04, 0x0C, 0x0C, 0x0C,
  0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x60,
  0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x00, 0x7E, 0x00, 0xE3,
  0x80, 0x40, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x43,
  0xFF, 0xC0, 0x00, 0xFC, 0x07, 0x8E, 0x02, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0xC1, 0xC0, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0B,
  0x00, 0x1A, 0x00, 0x12, 0x00, 0x36, 0x00, 0x26, 0x00, 0x46, 0x00, 0xC4,
  0x00, 0x84, 0x01, 0x8C, 0x01, 0x0C, 0x02, 0x0C, 0x06, 0x08, 0x04, 0x18,
  0x0C, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x10, 0x20, 0x30, 0x60, 0x30,
  0xFF, 0xFE, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x1F, 0xE0, 0x08, 0x70,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x60, 0xC1, 0xC0, 0xFF, 0x00, 0x00, 0x7E, 0x01, 0xC4,
  0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x3C, 0x0D, 0xFC, 0x1E, 0x0C,
  0x28, 0x18, 0x60, 0x10, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x18,
  0x02, 0x30, 0x04, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x43, 0x01, 0x86, 0x02,
  0x04, 0x0C, 0x0C, 0x30, 0x0F, 0xC0, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xE7, 0x00, 0xC0,
  0xC0, 0x40, 0x20, 0x60, 0x18, 0x30, 0x0C, 0x10, 0x06, 0x08, 0x02, 0x04,
  0x01, 0x03, 0x01, 0x81, 0x80, 0x80, 0x40, 0x80, 0x30, 0xC0, 0x0D, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x06, 0x60, 0x06, 0x18, 0x06, 0x06, 0x06, 0x03,
  0x06, 0x00, 0x83, 0x00, 0x61, 0x00, 0x30, 0x80, 0x18, 0xC0, 0x0C, 0x60,
  0x06, 0x10, 0x02, 0x0C, 0x03, 0x06, 0x03, 0x01, 0xC3, 0x00, 0x7F, 0x00,
  0x00, 0xF0, 0x07, 0x38, 0x18, 0x30, 0x20, 0x30, 0xC0, 0x61, 0x00, 0xC6,
  0x01, 0x8C, 0x03, 0x10, 0x06, 0x20, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00,
  0x66, 0x01, 0x8C, 0x03, 0x08, 0x0E, 0x18, 0x3C, 0x39, 0xD8, 0x1F, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x10, 0xE0, 0x3F, 0x00, 0x00, 0x06,
  0x1C, 0x38, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x1C, 0x30, 0x00, 0x01, 0x80, 0xC0, 0xE0,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x81, 0x80, 0xC0, 0x40, 0x60, 0x20,
  0x30, 0x10, 0x08, 0x08, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x0F, 0xC1,
  0xCE, 0x10, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x03, 0xEE, 0x00, 0x30, 0x18, 0x03, 0x00, 0x60, 0x30, 0x01, 0x03, 0x00,
  0x08, 0x10, 0x00, 0x61, 0x80, 0x03, 0x08, 0x00, 0x18, 0xC0, 0xF8, 0xC4,
  0x08, 0xC6, 0x60, 0x84, 0x33, 0x0C, 0x21, 0x90, 0x43, 0x0D, 0x86, 0x18,
  0x4C, 0x20, 0x82, 0x43, 0x04, 0x12, 0x18, 0x61, 0x90, 0x83, 0x0D, 0x84,
  0x10, 0x4C, 0x21, 0x86, 0x61, 0x0C, 0x23, 0x08, 0x61, 0x18, 0x45, 0x10,
  0xC3, 0x6D, 0x86, 0x0E, 0x78, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x20, 0x00,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x02, 0xC0, 0x0D, 0x80, 0x13, 0x00, 0x66, 0x00, 0xCC,
  0x01, 0x18, 0x06, 0x30, 0x08, 0x60, 0x30, 0xC0, 0x61, 0x81, 0x83, 0x03,
  0x06, 0x04, 0x0C, 0x1F, 0xF8, 0x30, 0x30, 0xC0, 0x61, 0x80, 0xC2, 0x01,
  0x8C, 0x03, 0x18, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0x00, 0x36, 0x00, 0x68,
  0x00, 0xF0, 0x01, 0x80, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0xC0, 0xC0, 0x60,
  0x60, 0x20, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x04, 0x01, 0x02,
  0x00, 0x83, 0x00, 0xC1, 0x80, 0x40, 0xC0, 0x60, 0x40, 0xE0, 0x3F, 0xC0,
  0x3F, 0xE0, 0x18, 0x18, 0x0C, 0x06, 0x04, 0x03, 0x02, 0x00, 0x83, 0x00,
  0x41, 0x80, 0x20, 0xC0, 0x10, 0x40, 0x18, 0x60, 0x0C, 0x30, 0x04, 0x18,
  0x06, 0x08, 0x06, 0x04, 0x07, 0x06, 0x3E, 0x03, 0xFC, 0x00, 0x00, 0x7E,
  0x01, 0xE3, 0x03, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x40, 0x1F, 0xC0,
  0x01, 0xF0, 0x01, 0xFE, 0x00, 0xC1, 0xC0, 0x60, 0x60, 0x20, 0x18, 0x30,
  0x0C, 0x18, 0x06, 0x0C, 0x01, 0x04, 0x00, 0x82, 0x00, 0x43, 0x00, 0x21,
  0x80, 0x10, 0xC0, 0x18, 0x40, 0x0C, 0x20, 0x06, 0x30, 0x03, 0x18, 0x01,
  0x8C, 0x00, 0x84, 0x00, 0xC2, 0x00, 0x63, 0x00, 0x31, 0x80, 0x30, 0x80,
  0x18, 0x40, 0x18, 0x60, 0x0C, 0x30, 0x0C, 0x18, 0x0E, 0x08, 0x0E, 0x04,
  0x0E, 0x07, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x3F, 0xE0, 0x3F, 0xF0, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x1F, 0xF8,
  0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x1E, 0x7C, 0x0E,
  0x01, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x3F, 0x10, 0x00,
  0x62, 0x00, 0x08, 0x40, 0x03, 0x08, 0x00, 0x61, 0x00, 0x0C, 0x20, 0x01,
  0x04, 0x00, 0x20, 0x80, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x20, 0x04,
  0x06, 0x00, 0x80, 0x70, 0x30, 0x07, 0xFC, 0x00, 0x01, 0x00, 0x30, 0x30,
  0x03, 0x03, 0x00, 0x20, 0x30, 0x02, 0x02, 0x00, 0x60, 0x60, 0x06, 0x06,
  0x00, 0x60, 0x60, 0x04, 0x04, 0x00, 0x40, 0x40, 0x0C, 0x0C, 0x00, 0xC0,
  0xC0, 0x0C, 0x0C, 0x00, 0x80, 0x80, 0x08, 0x0F, 0xFF, 0x81, 0xFF, 0xF8,
  0x18, 0x01, 0x81, 0x80, 0x10, 0x10, 0x03, 0x01, 0x00, 0x30, 0x30, 0x03,
  0x03, 0x00, 0x20, 0x20, 0x02, 0x02, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00,
  0x60, 0x60, 0x04, 0x04, 0x00, 0x40, 0x40, 0x0C, 0x0C, 0x00, 0xC0, 0xC0,
  0x0C, 0x00, 0x03, 0xF8, 0x0F, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x03, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x03, 0xE0, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x60, 0x60, 0x18, 0x0C, 0x06, 0x01, 0x81, 0x80,
  0x20, 0x30, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x30, 0xC0, 0x04, 0x18, 0x00,
  0x86, 0x00, 0x31, 0x80, 0x06, 0x20, 0x00, 0xCC, 0x00, 0x13, 0x00, 0x02,
  0xE0, 0x00, 0xDC, 0x00, 0x1C, 0x80, 0x03, 0x10, 0x00, 0x63, 0x00, 0x08,
  0x60, 0x03, 0x0C, 0x00, 0x60, 0x80, 0x08, 0x18, 0x01, 0x03, 0x00, 0x60,
  0x60, 0x0C, 0x04, 0x01, 0x80, 0x80, 0x20, 0x18, 0x04, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x06, 0x00, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x00, 0x40, 0x3F, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0xC0, 0xE0,
  0x00, 0x70, 0x38, 0x00, 0x1C, 0x0A, 0x00, 0x0F, 0x02, 0x80, 0x03, 0xC1,
  0xA0, 0x01, 0xA0, 0x68, 0x00, 0x68, 0x1A, 0x00, 0x16, 0x04, 0x80, 0x0D,
  0x81, 0x20, 0x02, 0x40, 0xC8, 0x01, 0x90, 0x32, 0x00, 0x4C, 0x0C, 0x80,
  0x33, 0x02, 0x30, 0x08, 0xC0, 0x8C, 0x06, 0x20, 0x63, 0x01, 0x08, 0x18,
  0xC0, 0xC6, 0x06, 0x30, 0x21, 0x81, 0x0C, 0x18, 0x60, 0x43, 0x04, 0x10,
  0x30, 0xC3, 0x04, 0x0C, 0x30, 0xC3, 0x02, 0x0C, 0x60, 0xC0, 0x81, 0x18,
  0x30, 0x60, 0x4C, 0x08, 0x18, 0x13, 0x06, 0x06, 0x04, 0x81, 0x81, 0x01,
  0x60, 0x60, 0x40, 0x50, 0x10, 0x30, 0x1C, 0x04, 0x0C, 0x06, 0x03, 0x00,
  0x01, 0x80, 0x18, 0x1C, 0x00, 0xC0, 0xE0, 0x04, 0x05, 0x00, 0x20, 0x28,
  0x03, 0x03, 0x60, 0x18, 0x1B, 0x00, 0xC0, 0xD8, 0x04, 0x04, 0xC0, 0x20,
  0x22, 0x03, 0x03, 0x10, 0x18, 0x18, 0xC0, 0xC0, 0xC6, 0x04, 0x04, 0x30,
  0x20, 0x20, 0x83, 0x03, 0x04, 0x18, 0x18, 0x20, 0xC0, 0xC1, 0x84, 0x04,
  0x0C, 0x60, 0x20, 0x63, 0x03, 0x01, 0x18, 0x18, 0x08, 0x80, 0x80, 0x64,
  0x04, 0x03, 0x60, 0x60, 0x1B, 0x03, 0x00, 0x58, 0x18, 0x02, 0x80, 0x80,
  0x14, 0x04, 0x00, 0xE0, 0x60, 0x07, 0x03, 0x00, 0x38, 0x00, 0x00, 0x7E,
  0x00, 0x39, 0xC0, 0x18, 0x18, 0x0C, 0x06, 0x06, 0x00, 0x81, 0x00, 0x30,
  0xC0, 0x0C, 0x20, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x0C, 0xC0,
  0x03, 0x30, 0x00, 0x88, 0x00, 0x26, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01,
  0x98, 0x00, 0x64, 0x00, 0x11, 0x00, 0x0C, 0x40, 0x03, 0x30, 0x00, 0x8C,
  0x00, 0x63, 0x00, 0x18, 0x40, 0x04, 0x10, 0x03, 0x04, 0x01, 0x81, 0x80,
  0x60, 0x60, 0x30, 0x0C, 0x38, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x03, 0xFC,
  0x03, 0x06, 0x03, 0x03, 0x02, 0x03, 0x06, 0x03, 0x06, 0x01, 0x06, 0x03,
  0x04, 0x03, 0x04, 0x03, 0x0C, 0x03, 0x0C, 0x02, 0x0C, 0x06, 0x08, 0x06,
  0x08, 0x0C, 0x18, 0x18, 0x19, 0xF0, 0x1F, 0xC0, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x39, 0xC0, 0x18, 0x18, 0x0C, 0x06, 0x06, 0x00, 0x81, 0x00, 0x30,
  0xC0, 0x0C, 0x20, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x0C, 0xC0,
  0x03, 0x30, 0x00, 0x88, 0x00, 0x26, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01,
  0x98, 0x00, 0x64, 0x00, 0x11, 0x00, 0x0C, 0x40, 0x03, 0x30, 0x00, 0x8C,
  0x00, 0x63, 0x00, 0x18, 0x40, 0x04, 0x10, 0x03, 0x04, 0x01, 0x81, 0x80,
  0x60, 0x60, 0x30, 0x0C, 0x38, 0x01, 0xFC, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0xE0, 0x03, 0xFC, 0x03, 0x06, 0x03, 0x03, 0x02, 0x03, 0x06, 0x03,
  0x06, 0x03, 0x06, 0x03, 0x04, 0x03, 0x04, 0x03, 0x0C, 0x03, 0x0C, 0x02,
  0x0C, 0x06, 0x08, 0x04, 0x08, 0x0C, 0x18, 0x38, 0x1F, 0xE0, 0x18, 0xC0,
  0x10, 0xC0, 0x10, 0xC0, 0x30, 0xC0, 0x30, 0x40, 0x20, 0x60, 0x20, 0x60,
  0x60, 0x60, 0x60, 0x60, 0x60, 0x20, 0x40, 0x20, 0x40, 0x30, 0xC0, 0x30,
  0xC0, 0x30, 0x00, 0x7F, 0x00, 0xF3, 0xC0, 0xC0, 0x20, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x08, 0x07, 0x06, 0x07, 0x03, 0xFE, 0x00, 0x7F, 0xFB, 0xFF, 0xC0,
  0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x60, 0xC0, 0x08, 0x18, 0x03, 0x02, 0x00, 0x60, 0xC0, 0x0C, 0x18,
  0x01, 0x03, 0x00, 0x20, 0x40, 0x0C, 0x08, 0x01, 0x83, 0x00, 0x30, 0x60,
  0x04, 0x0C, 0x01, 0x81, 0x00, 0x30, 0x20, 0x06, 0x0C, 0x00, 0x81, 0x80,
  0x10, 0x30, 0x06, 0x04, 0x00, 0xC0, 0x80, 0x18, 0x30, 0x02, 0x06, 0x00,
  0x40, 0x80, 0x18, 0x10, 0x03, 0x02, 0x00, 0x40, 0xC0, 0x08, 0x18, 0x03,
  0x03, 0x00, 0x40, 0x20, 0x18, 0x06, 0x06, 0x00, 0xE1, 0xC0, 0x0F, 0xE0,
  0x00, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x34, 0x00, 0x48, 0x01, 0x90, 0x03,
  0x20, 0x0C, 0x40, 0x18, 0x80, 0x21, 0x00, 0xC2, 0x01, 0x04, 0x06, 0x08,
  0x0C, 0x10, 0x30, 0x20, 0x60, 0x40, 0x80, 0x83, 0x01, 0x04, 0x02, 0x18,
  0x04, 0x30, 0x08, 0xC0, 0x11, 0x80, 0x22, 0x00, 0x4C, 0x00, 0x90, 0x01,
  0x60, 0x02, 0xC0, 0x05, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x04, 0x00, 0x50, 0x03, 0x00, 0x34, 0x00, 0xC0, 0x0D, 0x00, 0x30,
  0x06, 0x40, 0x1C, 0x01, 0x90, 0x05, 0x00, 0x44, 0x03, 0x40, 0x31, 0x00,
  0x90, 0x08, 0x40, 0x24, 0x06, 0x30, 0x19, 0x01, 0x8C, 0x04, 0x40, 0x43,
  0x03, 0x10, 0x30, 0xC0, 0x84, 0x08, 0x30, 0x23, 0x06, 0x0C, 0x18, 0xC1,
  0x83, 0x04, 0x30, 0x40, 0xC3, 0x0C, 0x30, 0x30, 0xC3, 0x08, 0x0C, 0x20,
  0xC6, 0x03, 0x18, 0x31, 0x80, 0xC4, 0x0C, 0x40, 0x33, 0x03, 0x30, 0x0C,
  0xC0, 0xC8, 0x03, 0x20, 0x36, 0x00, 0xD8, 0x0D, 0x80, 0x34, 0x02, 0x40,
  0x0F, 0x00, 0xB0, 0x03, 0xC0, 0x28, 0x00, 0xE0, 0x0A, 0x00, 0x38, 0x03,
  0x80, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x00, 0xC0,
  0x40, 0x0C, 0x0C, 0x00, 0xC0, 0x80, 0x04, 0x18, 0x00, 0x41, 0x00, 0x04,
  0x30, 0x00, 0x42, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00,
  0x78, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xB0, 0x00, 0x19, 0x00, 0x03, 0x10, 0x00, 0x31, 0x00,
  0x06, 0x10, 0x00, 0x41, 0x00, 0x0C, 0x18, 0x00, 0x81, 0x80, 0x18, 0x18,
  0x03, 0x01, 0x80, 0x30, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x08, 0x00, 0x40,
  0x0D, 0x00, 0x64, 0x01, 0x90, 0x0C, 0x60, 0x21, 0x81, 0x86, 0x04, 0x18,
  0x30, 0x60, 0x81, 0x86, 0x02, 0x10, 0x08, 0xC0, 0x22, 0x00, 0x98, 0x02,
  0x40, 0x0B, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x1F,
  0xFC, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xC1, 0x04, 0x10, 0x61,
  0x86, 0x18, 0x20, 0x82, 0x0C, 0x30, 0xC3, 0x04, 0x10, 0x41, 0x86, 0x18,
  0x60, 0x82, 0x08, 0x30, 0xC3, 0x0C, 0x10, 0x40, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x00, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x60, 0x02, 0x60, 0x06, 0x20,
  0x04, 0x30, 0x0C, 0x10, 0x08, 0x18, 0x18, 0x18, 0x10, 0x0C, 0x30, 0x0C,
  0x60, 0x04, 0x60, 0x06, 0xC0, 0x03, 0xFF, 0xE0, 0xC2, 0x18, 0x43, 0x08,
  0x60, 0x01, 0xE2, 0x0E, 0x64, 0x38, 0x38, 0x60, 0x71, 0x80, 0xC2, 0x01,
  0x8C, 0x03, 0x18, 0x06, 0x20, 0x0C, 0xC0, 0x11, 0x80, 0x22, 0x00, 0xC4,
  0x01, 0x98, 0x03, 0x30, 0x04, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x01,
  0x86, 0x03, 0x06, 0x0A, 0x0C, 0x24, 0x0F, 0x98, 0x00, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x19, 0xE0, 0x2E, 0xE0, 0x50, 0x61, 0xC0, 0xC3,
  0x80, 0x86, 0x01, 0x0C, 0x02, 0x30, 0x04, 0x60, 0x08, 0xC0, 0x31, 0x00,
  0x62, 0x00, 0xCC, 0x01, 0x98, 0x02, 0x30, 0x0C, 0x40, 0x18, 0x80, 0x23,
  0x00, 0xC6, 0x01, 0x0E, 0x06, 0x14, 0x18, 0x2C, 0x60, 0xCF, 0x80, 0x01,
  0xF0, 0x79, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x10, 0x3F, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x78, 0x80, 0xE6, 0xC0,
  0xE0, 0xE0, 0x60, 0x70, 0x60, 0x30, 0x20, 0x18, 0x30, 0x0C, 0x18, 0x06,
  0x08, 0x03, 0x0C, 0x01, 0x06, 0x00, 0x82, 0x00, 0xC1, 0x00, 0x61, 0x80,
  0x30, 0xC0, 0x10, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x06, 0x06,
  0x07, 0x01, 0x02, 0x80, 0xC2, 0xC0, 0x3E, 0x60, 0x00, 0x01, 0xE0, 0x39,
  0x83, 0x06, 0x10, 0x31, 0x81, 0x98, 0x0C, 0xC0, 0x44, 0x06, 0x60, 0x63,
  0x06, 0x10, 0xE0, 0xFC, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x38, 0x40, 0xFE, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0x80, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x80, 0xE6, 0x40, 0xE0,
  0xE0, 0x60, 0x70, 0x60, 0x30, 0x20, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x08,
  0x03, 0x0C, 0x01, 0x06, 0x00, 0x82, 0x00, 0xC1, 0x00, 0x61, 0x80, 0x30,
  0xC0, 0x10, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x0E, 0x0C, 0x06, 0x06, 0x07,
  0x01, 0x02, 0x80, 0xC6, 0xC0, 0x3E, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x01,
  0x87, 0x00, 0x7F, 0x00, 0x00, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x1B, 0xE0, 0x2E, 0x60, 0x70, 0x41, 0xC0, 0xC3, 0x01, 0x86, 0x02, 0x0C,
  0x04, 0x10, 0x18, 0x60, 0x30, 0xC0, 0x61, 0x00, 0x82, 0x01, 0x0C, 0x06,
  0x18, 0x0C, 0x30, 0x18, 0x40, 0x20, 0x80, 0x43, 0x01, 0x86, 0x03, 0x0C,
  0x06, 0x10, 0x08, 0x20, 0x30, 0xC0, 0x60, 0x01, 0x03, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18,
  0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40,
  0x40, 0xC0, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x18, 0x20, 0x60, 0x40, 0x81, 0x83, 0x03, 0x0C, 0x04,
  0x30, 0x08, 0xC0, 0x31, 0x80, 0x66, 0x00, 0xD8, 0x01, 0x70, 0x02, 0xB0,
  0x0E, 0x60, 0x1C, 0xC0, 0x30, 0x80, 0x41, 0x00, 0x82, 0x03, 0x06, 0x06,
  0x0C, 0x08, 0x18, 0x10, 0x10, 0x60, 0x20, 0xC0, 0x60, 0x01, 0x80, 0x80,
  0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40,
  0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x00, 0x04,
  0xF8, 0xF8, 0x0B, 0x3B, 0x98, 0x1C, 0x3C, 0x18, 0x70, 0x30, 0x30, 0xC0,
  0x60, 0x61, 0x80, 0x80, 0xC2, 0x03, 0x01, 0x0C, 0x06, 0x02, 0x18, 0x0C,
  0x0C, 0x30, 0x10, 0x18, 0x40, 0x60, 0x30, 0x80, 0xC0, 0x43, 0x01, 0x80,
  0x86, 0x02, 0x03, 0x0C, 0x04, 0x06, 0x10, 0x18, 0x08, 0x20, 0x30, 0x10,
  0xC0, 0x60, 0x61, 0x80, 0x80, 0xC3, 0x01, 0x01, 0x84, 0x06, 0x02, 0x08,
  0x0C, 0x04, 0x30, 0x10, 0x18, 0x00, 0x04, 0xF8, 0x0B, 0x98, 0x1C, 0x10,
  0x70, 0x30, 0xC0, 0x41, 0x80, 0x83, 0x01, 0x0C, 0x06, 0x18, 0x0C, 0x30,
  0x18, 0x40, 0x20, 0x80, 0x43, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x10, 0x08,
  0x20, 0x10, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x04, 0x02, 0x08, 0x0C, 0x30,
  0x18, 0x00, 0x01, 0xF0, 0x1C, 0xE0, 0xC1, 0x82, 0x02, 0x18, 0x0C, 0xC0,
  0x33, 0x00, 0xC8, 0x03, 0x60, 0x0D, 0x80, 0x26, 0x00, 0x90, 0x02, 0x40,
  0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x04, 0xC0, 0x33, 0x00, 0x8C, 0x06, 0x30,
  0x10, 0x60, 0xC1, 0x86, 0x03, 0xF0, 0x00, 0x01, 0x1E, 0x00, 0x99, 0x80,
  0x50, 0x60, 0x70, 0x30, 0x38, 0x08, 0x18, 0x04, 0x0C, 0x02, 0x04, 0x01,
  0x06, 0x00, 0x83, 0x00, 0xC1, 0x00, 0x60, 0x80, 0x30, 0xC0, 0x18, 0x60,
  0x08, 0x30, 0x0C, 0x18, 0x06, 0x08, 0x02, 0x0C, 0x03, 0x06, 0x01, 0x83,
  0x81, 0x81, 0x41, 0x80, 0xB1, 0x80, 0xCF, 0x80, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE2, 0x0E, 0x64, 0x30, 0x78,
  0x60, 0x71, 0x80, 0xC2, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x20, 0x0C, 0xC0,
  0x11, 0x80, 0x22, 0x00, 0xC4, 0x01, 0x98, 0x03, 0x30, 0x04, 0x60, 0x18,
  0xC0, 0x31, 0x80, 0x63, 0x01, 0x86, 0x07, 0x04, 0x0A, 0x0C, 0x2C, 0x0F,
  0x98, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x04, 0xF0, 0x5D, 0x07,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x1C, 0xF0, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC3, 0x06, 0x0F, 0xF0, 0x00,
  0x04, 0x04, 0x04, 0x0C, 0x0C, 0x3F, 0x7F, 0x18, 0x18, 0x10, 0x10, 0x30,
  0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xC0,
  0x80, 0x80, 0xC0, 0xF0, 0x0C, 0x04, 0x20, 0x11, 0x80, 0xC6, 0x03, 0x18,
  0x0C, 0x40, 0x21, 0x00, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0x62, 0x01, 0x08,
  0x0C, 0x60, 0x31, 0x80, 0xC4, 0x02, 0x10, 0x08, 0x40, 0x63, 0x01, 0x8C,
  0x0E, 0x30, 0x30, 0xC1, 0x43, 0x8D, 0x07, 0xEC, 0x00, 0xC0, 0x1C, 0x03,
  0xC0, 0x2C, 0x06, 0xC0, 0x6C, 0x0C, 0x40, 0xC4, 0x08, 0x41, 0x84, 0x10,
  0x43, 0x04, 0x20, 0x46, 0x04, 0x60, 0x44, 0x04, 0xC0, 0x48, 0x05, 0x80,
  0x50, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x00, 0x40, 0x30, 0x14, 0x07,
  0x03, 0x40, 0x70, 0x34, 0x07, 0x02, 0x40, 0xF0, 0x64, 0x0B, 0x04, 0x41,
  0xB0, 0xC4, 0x13, 0x0C, 0x41, 0x30, 0x84, 0x32, 0x18, 0x42, 0x21, 0x04,
  0x62, 0x10, 0x44, 0x23, 0x04, 0x42, 0x20, 0x4C, 0x26, 0x04, 0x82, 0x40,
  0x58, 0x24, 0x05, 0x02, 0xC0, 0x50, 0x28, 0x07, 0x02, 0x80, 0x60, 0x38,
  0x0E, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x03, 0x02, 0x02, 0x02, 0x06,
  0x03, 0x04, 0x03, 0x0C, 0x03, 0x18, 0x01, 0x10, 0x01, 0x30, 0x01, 0x20,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x06, 0xC0,
  0x04, 0x40, 0x0C, 0x40, 0x08, 0x60, 0x18, 0x60, 0x30, 0x60, 0x20, 0x20,
  0x60, 0x20, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x0C, 0x06, 0x00, 0xC0, 0x40, 0x0C, 0x0C, 0x00, 0xC0, 0x80, 0x0C, 0x18,
  0x00, 0xC1, 0x80, 0x0C, 0x10, 0x00, 0xC3, 0x00, 0x04, 0x20, 0x00, 0x46,
  0x00, 0x04, 0x40, 0x00, 0x4C, 0x00, 0x04, 0x80, 0x00, 0x58, 0x00, 0x05,
  0x80, 0x00, 0x50, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x7C, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x01, 0xE0, 0x07, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0xE0, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xC0, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x78, 0x00,
  0xF0, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0x3E,
  0x02, 0xCF, 0x06, 0x03, 0xFC, 0x01, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 31, 9, 1, -31 },
  { 32, 9, 11, 12, 4, -31 },
  { 45, 17, 31, 16, 0, -31 },
  { 111, 16, 36, 15, 0, -33 },
  { 183, 19, 32, 23, 2, -31 },
  { 259, 14, 31, 15, 0, -31 },
  { 314, 4, 11, 7, 4, -31 },
  { 320, 12, 38, 10, 1, -31 },
  { 377, 12, 38, 11, -3, -31 },
  { 434, 11, 12, 14, 5, -33 },
  { 451, 15, 20, 17, 1, -25 },
  { 489, 6, 10, 7, -2, -4 },
  { 497, 9, 1, 11, 1, -12 },
  { 499, 2, 3, 7, 1, -3 },
  { 500, 18, 31, 13, -2, -31 },
  { 570, 14, 31, 15, 1, -31 },
  { 625, 8, 31, 15, 5, -31 },
  { 656, 17, 31, 15, -2, -31 },
  { 722, 16, 31, 15, -1, -31 },
  { 784, 16, 31, 15, -1, -31 },
  { 846, 16, 31, 15, -1, -31 },
  { 908, 15, 31, 15, 1, -31 },
  { 967, 15, 31, 15, 2, -31 },
  { 1026, 17, 31, 15, -1, -31 },
  { 1092, 15, 31, 15, 0, -31 },
  { 1151, 7, 23, 7, 0, -23 },
  { 1172, 9, 29, 7, -2, -23 },
  { 1205, 15, 18, 17, 1, -24 },
  { 1239, 15, 11, 17, 1, -21 },
  { 1260, 15, 18, 17, 1, -24 },
  { 1294, 12, 31, 11, 1, -31 },
  { 1341, 21, 35, 23, 1, -31 },
  { 1433, 15, 31, 15, -3, -31 },
  { 1492, 17, 31, 17, 0, -31 },
  { 1558, 16, 31, 15, 2, -31 },
  { 1620, 17, 31, 18, 0, -31 },
  { 1686, 17, 31, 15, 0, -31 },
  { 1752, 17, 31, 14, 0, -31 },
  { 1818, 19, 31, 20, 2, -31 },
  { 1892, 20, 31, 19, 0, -31 },
  { 1970, 13, 31, 8, -2, -31 },
  { 2021, 14, 39, 7, -6, -31 },
  { 2090, 19, 31, 15, 0, -31 },
  { 2164, 10, 31, 13, 0, -31 },
  { 2203, 26, 31, 26, 0, -31 },
  { 2304, 21, 31, 20, 0, -31 },
  { 2386, 18, 31, 20, 1, -31 },
  { 2456, 16, 31, 16, 0, -31 },
  { 2518, 18, 38, 20, 1, -31 },
  { 2604, 16, 31, 16, 0, -31 },
  { 2666, 17, 31, 15, -1, -31 },
  { 2732, 13, 31, 13, 3, -31 },
  { 2783, 19, 31, 19, 1, -31 },
  { 2857, 15, 31, 15, 4, -31 },
  { 2916, 26, 31, 26, 3, -31 },
  { 3017, 20, 31, 14, -3, -31 },
  { 3095, 14, 31, 13, 3, -31 },
  { 3150, 18, 31, 13, -2, -31 },
  { 3220, 16, 38, 12, -1, -31 },
  { 3296, 6, 31, 14, 4, -31 },
  { 3320, 16, 38, 12, -3, -31 },
  { 3396, 16, 15, 17, 1, -31 },
  { 3426, 11, 1, 12, -3, 4 },
  { 3428, 5, 7, 9, 6, -33 },
  { 3433, 15, 23, 17, 1, -23 },
  { 3477, 15, 33, 16, 0, -33 },
  { 3539, 12, 23, 12, 1, -23 },
  { 3574, 17, 33, 17, 1, -33 },
  { 3645, 13, 23, 14, 1, -23 },
  { 3683, 19, 43, 8, -6, -33 },
  { 3786, 17, 33, 17, -1, -23 },
  { 3857, 15, 33, 16, 0, -33 },
  { 3919, 8, 31, 7, 0, -31 },
  { 3950, 15, 41, 7, -6, -31 },
  { 4027, 15, 33, 13, 0, -33 },
  { 4089, 9, 33, 7, 0, -33 },
  { 4127, 23, 23, 24, 0, -23 },
  { 4194, 15, 23, 16, 0, -23 },
  { 4238, 14, 23, 16, 1, -23 },
  { 4279, 17, 33, 16, -2, -23 },
  { 4350, 15, 33, 17, 1, -23 },
  { 4412, 12, 23, 10, 0, -23 },
  { 4447, 14, 23, 12, -1, -23 },
  { 4488, 8, 28, 8, 1, -28 },
  { 4516, 14, 23, 16, 1, -23 },
  { 4557, 12, 23, 12, 2, -23 },
  { 4592, 20, 23, 21, 2, -23 },
  { 4650, 16, 23, 13, -2, -23 },
  { 4696, 20, 33, 13, -5, -23 },
  { 4779, 13, 23, 10, -1, -23 },
  { 4817, 15, 38, 14, 1, -31 },
  { 4889, 1, 43, 15, 7, -33 },
  { 4895, 15, 38, 13, -3, -31 },
  { 4967, 15, 4, 17, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC43PT7B_H_
