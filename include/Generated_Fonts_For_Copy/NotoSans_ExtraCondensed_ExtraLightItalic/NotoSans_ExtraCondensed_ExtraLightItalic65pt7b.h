#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC65PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x00, 0x1C, 0x1C, 0x70, 0x71, 0x81, 0x86, 0x06, 0x38,
  0x38, 0xE0, 0xE3, 0x03, 0x0C, 0x0C, 0x30, 0x31, 0xC1, 0xC6, 0x06, 0x18,
  0x18, 0x60, 0x61, 0x81, 0x84, 0x04, 0x30, 0x30, 0x00, 0x03, 0x81, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x30, 0x38, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C,
  0x06, 0x00, 0x07, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00,
  0x38, 0x18, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x00, 0xC0, 0xE0,
  0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x07, 0x00, 0x03, 0x81,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x06,
  0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x30, 0x18, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x03, 0x00, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x80, 0x18, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0,
  0xE0, 0x00, 0x70, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x81, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x0E, 0x00,
  0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x79, 0x9F, 0x00, 0x70, 0xC1, 0x00, 0x70, 0x40, 0x00, 0x70, 0x60,
  0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x04,
  0x00, 0x07, 0x06, 0x00, 0x03, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x07, 0x30, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xB8, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x08, 0x38,
  0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x01,
  0x80, 0x01, 0x81, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30,
  0x70, 0x20, 0x10, 0x70, 0x0C, 0x18, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0x01, 0xC7, 0x00, 0x30, 0x0C,
  0x18, 0x01, 0x80, 0xE0, 0xC0, 0x18, 0x06, 0x06, 0x00, 0xC0, 0x60, 0x30,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x03, 0x03, 0x80, 0xE0, 0x18, 0x18, 0x07, 0x00, 0xC1, 0xC0, 0x30,
  0x0E, 0x0C, 0x01, 0x80, 0x70, 0xE0, 0x0C, 0x03, 0x06, 0x00, 0xE0, 0x18,
  0x70, 0x07, 0x00, 0xC3, 0x00, 0x30, 0x0E, 0x38, 0x01, 0x80, 0x61, 0x87,
  0xEC, 0x03, 0x1C, 0x7F, 0xE0, 0x38, 0xC7, 0x0F, 0x01, 0x8E, 0x30, 0x78,
  0x1C, 0x63, 0x03, 0xC0, 0xC7, 0x18, 0x1F, 0x0E, 0x31, 0x80, 0xD8, 0xE3,
  0x8C, 0x06, 0xFE, 0x18, 0xE0, 0x33, 0xE1, 0xC6, 0x01, 0x80, 0x0C, 0x30,
  0x0C, 0x00, 0xE3, 0x80, 0x60, 0x06, 0x18, 0x03, 0x00, 0x70, 0xC0, 0x38,
  0x03, 0x06, 0x01, 0x80, 0x38, 0x30, 0x0C, 0x01, 0x83, 0x80, 0x60, 0x1C,
  0x1C, 0x03, 0x00, 0xC0, 0xC0, 0x38, 0x0E, 0x06, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x06, 0x03, 0x80, 0x60, 0x70,
  0x18, 0x03, 0x03, 0x01, 0xC0, 0x1C, 0x30, 0x0C, 0x00, 0x77, 0x80, 0xE0,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80,
  0x01, 0xC7, 0x00, 0x0E, 0x0C, 0x00, 0x38, 0x38, 0x00, 0xC0, 0xE0, 0x07,
  0x03, 0x80, 0x18, 0x0E, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x03,
  0x00, 0x18, 0x1C, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x0E, 0x00,
  0x18, 0x30, 0x00, 0x61, 0x80, 0x01, 0x8E, 0x00, 0x07, 0x30, 0x00, 0x1D,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xD8, 0x00, 0x0E, 0x60, 0x00, 0x71, 0xC0, 0x03, 0x83, 0x03, 0x0C,
  0x0C, 0x1C, 0x70, 0x30, 0x71, 0x80, 0xE1, 0x8E, 0x01, 0x86, 0x30, 0x06,
  0x39, 0xC0, 0x1C, 0xC6, 0x00, 0x77, 0x18, 0x00, 0xD8, 0xE0, 0x03, 0x63,
  0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0x60, 0xE0, 0x03, 0xC3, 0x80,
  0x1F, 0x06, 0x00, 0x6C, 0x1C, 0x03, 0x30, 0x78, 0x38, 0xE0, 0xFF, 0xC3,
  0x81, 0xFE, 0x06, 0x01, 0xC0, 0x00, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x0C,
  0x30, 0xC6, 0x18, 0x61, 0x84, 0x30, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x81, 0x80, 0xE1, 0x80, 0x71, 0x81, 0x1D, 0x8F, 0x07, 0xFF,
  0x03, 0xC0, 0x07, 0x80, 0x0C, 0xC0, 0x18, 0xC0, 0x30, 0x60, 0xE0, 0x70,
  0xC0, 0x30, 0x00, 0x38, 0x00, 0x10, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0xC0, 0xE0, 0x60, 0x70, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x07,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x6F, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0xC0, 0x03, 0xC7, 0x00, 0x1C, 0x0E, 0x00, 0x60, 0x18, 0x03, 0x80,
  0x60, 0x1C, 0x01, 0xC0, 0x60, 0x07, 0x03, 0x80, 0x1C, 0x0C, 0x00, 0x70,
  0x30, 0x01, 0xC1, 0xC0, 0x07, 0x06, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0,
  0x01, 0xC3, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x70, 0x00, 0x61, 0x80, 0x01,
  0x86, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x0C,
  0x00, 0x0C, 0x30, 0x00, 0x31, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00,
  0x18, 0x60, 0x00, 0x61, 0x80, 0x03, 0x86, 0x00, 0x0E, 0x18, 0x00, 0x30,
  0xE0, 0x00, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x18, 0x38, 0x00, 0x60, 0xE0,
  0x03, 0x83, 0x80, 0x0C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0x80, 0xE0, 0x0E,
  0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x38, 0x70, 0x00,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x0F, 0x03,
  0xF0, 0x77, 0x0E, 0x61, 0xC6, 0x78, 0xEF, 0x0E, 0x40, 0xC0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0x0F, 0x80, 0x06, 0x00, 0xE0, 0x02, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0xE0, 0x0E, 0x00, 0x40, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x80, 0x0F, 0x00, 0xC0, 0x1E, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x66, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xCC, 0x00,
  0x01, 0x8C, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x1C, 0x00, 0x07, 0x1C, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x38, 0x00,
  0x38, 0x38, 0x00, 0x30, 0x30, 0x00, 0x60, 0x30, 0x00, 0xE0, 0x30, 0x00,
  0xC0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0x80, 0x60, 0x03, 0x00, 0x60, 0x07,
  0x00, 0xE0, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18,
  0x00, 0xC0, 0x38, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0x70, 0x01, 0x80, 0x60,
  0x01, 0x80, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x10,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x20, 0x00, 0xE0, 0x18, 0x01, 0xE0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x3E, 0x18, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC3, 0xF8, 0x01, 0x9F, 0xF8, 0x07, 0x70, 0x38, 0x0F,
  0x80, 0x38, 0x1A, 0x00, 0x70, 0x3C, 0x00, 0x60, 0x70, 0x00, 0xC1, 0xE0,
  0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x03,
  0x87, 0x00, 0x07, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x70,
  0x30, 0x00, 0xC0, 0x60, 0x03, 0x80, 0xC0, 0x06, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x70, 0x03, 0x81, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x0F,
  0x80, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x18, 0x07, 0x00,
  0x0C, 0x03, 0x80, 0x07, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x60,
  0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x38, 0x06,
  0x00, 0x18, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x70, 0x0C, 0x00,
  0x38, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF7, 0x00, 0x01, 0xE1, 0xC0,
  0x01, 0xC0, 0x70, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xC0, 0x03,
  0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x30, 0x30, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x07, 0x00,
  0x01, 0x83, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x60, 0x30,
  0x00, 0x70, 0x1C, 0x00, 0x30, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x78, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xE0, 0x01, 0xE1, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0xE0, 0x03, 0x01, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x0E,
  0x00, 0x1C, 0x18, 0x00, 0x38, 0x30, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0,
  0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x38, 0x00,
  0x18, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x07,
  0x83, 0x00, 0x0E, 0x06, 0x00, 0x3C, 0x0E, 0x00, 0xD8, 0x0E, 0x03, 0x70,
  0x1E, 0x1E, 0xE0, 0x1F, 0xF1, 0x80, 0x0F, 0x83, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x80, 0x70, 0x1C, 0x0F, 0x01, 0xC0, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x00, 0x00,
  0x08, 0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xC0,
  0x70, 0x78, 0x10, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x78, 0x03, 0x80, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC3,
  0x80, 0x3F, 0x81, 0x86, 0x01, 0xFF, 0x03, 0x0C, 0x07, 0x06, 0x06, 0x30,
  0x0C, 0x1C, 0x0C, 0x60, 0x30, 0x30, 0x19, 0xC0, 0xE0, 0x60, 0x33, 0x01,
  0x80, 0xC0, 0xE6, 0x07, 0x03, 0x81, 0x8C, 0x0C, 0x06, 0x03, 0x38, 0x18,
  0x0C, 0x06, 0x60, 0x70, 0x18, 0x0C, 0xC0, 0xC0, 0x70, 0x19, 0x81, 0x80,
  0xC0, 0x63, 0x03, 0x01, 0x80, 0xCE, 0x0E, 0x03, 0x01, 0x98, 0x18, 0x0E,
  0x07, 0x30, 0x30, 0x1C, 0x0C, 0x60, 0x60, 0x30, 0x18, 0xC0, 0xC0, 0xE0,
  0x71, 0x81, 0x81, 0xC0, 0xC3, 0x03, 0x07, 0x83, 0x86, 0x06, 0x0F, 0x06,
  0x0C, 0x0E, 0x36, 0x18, 0x18, 0x0E, 0xC7, 0xE0, 0x30, 0x1F, 0x8F, 0x80,
  0x60, 0x08, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x02, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0,
  0x00, 0x0E, 0xC0, 0x00, 0x33, 0x00, 0x01, 0xCC, 0x00, 0x06, 0x30, 0x00,
  0x18, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x60,
  0xC0, 0x01, 0x83, 0x00, 0x0E, 0x1C, 0x00, 0x30, 0x70, 0x01, 0xC1, 0xC0,
  0x06, 0x07, 0x00, 0x18, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x01, 0xC0, 0x1C,
  0x07, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xFF,
  0x01, 0xFF, 0xFC, 0x06, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03,
  0x00, 0x1C, 0x1C, 0x00, 0x70, 0x60, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00,
  0x1C, 0x30, 0x00, 0x71, 0xC0, 0x01, 0xC6, 0x00, 0x07, 0x38, 0x00, 0x1C,
  0xE0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x60, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x1C, 0x03, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x38, 0x03, 0x00, 0x1C,
  0x03, 0x80, 0x06, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x01, 0x80, 0x60, 0x00,
  0xC0, 0x30, 0x00, 0x60, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x0C, 0x00,
  0x1C, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x01, 0xC0,
  0x07, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x0F, 0x00, 0x30, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0C, 0x01, 0xC0, 0x06, 0x00, 0x70, 0x07,
  0x00, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0xC0,
  0x60, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x18, 0x00, 0x1C,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03,
  0x81, 0x80, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x70, 0x00,
  0xE0, 0x38, 0x00, 0xE0, 0x18, 0x01, 0xE0, 0x0C, 0x07, 0xE0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0xF8, 0x38, 0x00, 0x78, 0x02, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0x01, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x18, 0x00,
  0xE0, 0x0E, 0x00, 0x18, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x30,
  0x00, 0x70, 0x0C, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x03, 0x80, 0x00,
  0xC0, 0xE0, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x03, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x30, 0x00, 0x0C,
  0x0C, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x60, 0x70, 0x00,
  0x38, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0xE0, 0x38, 0x00, 0x38, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x01,
  0xC0, 0x07, 0x80, 0x70, 0x03, 0xC0, 0x18, 0x01, 0xE0, 0x06, 0x01, 0xF0,
  0x01, 0x83, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x3C,
  0x00, 0x70, 0x03, 0xC0, 0x01, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0xFF, 0x83, 0x00, 0x07, 0xFC, 0x18, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x30, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0x38,
  0x00, 0x30, 0x00, 0xF0, 0x03, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x70, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18,
  0x01, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x01, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0x80, 0x00, 0x60, 0x06,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x30, 0x03, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x70, 0x07, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18,
  0x01, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x30, 0x03, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0x70, 0x03, 0x00, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x06,
  0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xC0, 0x1C,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x06, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x18, 0x38,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x1C, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x77, 0x80, 0x00, 0x07, 0x7C,
  0x00, 0x00, 0x6D, 0xC0, 0x00, 0x07, 0x8C, 0x00, 0x00, 0xF0, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x1C, 0x06, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x18, 0x07, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x18, 0x03, 0x00, 0x03, 0x80, 0x38, 0x00, 0x38,
  0x03, 0x80, 0x03, 0x00, 0x38, 0x00, 0x30, 0x01, 0x80, 0x07, 0x00, 0x18,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x06,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x00, 0x36, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x6E,
  0x00, 0xEC, 0x00, 0x00, 0xEC, 0x00, 0xCC, 0x00, 0x00, 0xCC, 0x00, 0xCC,
  0x00, 0x01, 0xDC, 0x00, 0xCC, 0x00, 0x01, 0x9C, 0x01, 0xCC, 0x00, 0x01,
  0x98, 0x01, 0xCC, 0x00, 0x03, 0x98, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x01,
  0x8C, 0x00, 0x07, 0x38, 0x01, 0x8C, 0x00, 0x06, 0x38, 0x03, 0x8C, 0x00,
  0x0E, 0x30, 0x03, 0x8C, 0x00, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0x1C, 0x30,
  0x03, 0x0C, 0x00, 0x18, 0x70, 0x03, 0x0C, 0x00, 0x38, 0x70, 0x07, 0x0E,
  0x00, 0x30, 0x60, 0x06, 0x0E, 0x00, 0x70, 0x60, 0x06, 0x0E, 0x00, 0x60,
  0xE0, 0x06, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xC0, 0xC0, 0x0E,
  0x0E, 0x01, 0xC0, 0xC0, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x03,
  0x81, 0xC0, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0x1C, 0x06, 0x03, 0x01, 0x80,
  0x1C, 0x06, 0x07, 0x01, 0x80, 0x18, 0x06, 0x06, 0x01, 0x80, 0x18, 0x06,
  0x0E, 0x03, 0x80, 0x18, 0x06, 0x0C, 0x03, 0x80, 0x38, 0x06, 0x1C, 0x03,
  0x00, 0x38, 0x06, 0x18, 0x03, 0x00, 0x30, 0x06, 0x38, 0x07, 0x00, 0x30,
  0x06, 0x30, 0x07, 0x00, 0x70, 0x06, 0x70, 0x06, 0x00, 0x70, 0x06, 0x60,
  0x06, 0x00, 0x60, 0x07, 0xE0, 0x06, 0x00, 0x60, 0x07, 0xC0, 0x0E, 0x00,
  0x60, 0x07, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x80, 0x0C, 0x00, 0xE0, 0x07,
  0x80, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x78, 0x00, 0x06, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x6C, 0x00, 0x0E, 0x00,
  0x6C, 0x00, 0x0C, 0x00, 0xEC, 0x00, 0x0C, 0x00, 0xEC, 0x00, 0x0C, 0x00,
  0xCE, 0x00, 0x1C, 0x00, 0xCE, 0x00, 0x1C, 0x00, 0xC6, 0x00, 0x18, 0x01,
  0xC6, 0x00, 0x18, 0x01, 0xC6, 0x00, 0x18, 0x01, 0x86, 0x00, 0x38, 0x01,
  0x87, 0x00, 0x38, 0x01, 0x87, 0x00, 0x30, 0x03, 0x83, 0x00, 0x30, 0x03,
  0x83, 0x00, 0x70, 0x03, 0x03, 0x00, 0x70, 0x03, 0x03, 0x80, 0x60, 0x03,
  0x03, 0x80, 0x60, 0x07, 0x01, 0x80, 0x60, 0x07, 0x01, 0x80, 0xE0, 0x06,
  0x01, 0x80, 0xE0, 0x06, 0x01, 0x80, 0xC0, 0x0E, 0x01, 0xC0, 0xC0, 0x0E,
  0x01, 0xC0, 0xC0, 0x0C, 0x00, 0xC1, 0xC0, 0x0C, 0x00, 0xC1, 0xC0, 0x0C,
  0x00, 0xC1, 0x80, 0x1C, 0x00, 0xC1, 0x80, 0x1C, 0x00, 0xE1, 0x80, 0x18,
  0x00, 0x63, 0x80, 0x18, 0x00, 0x63, 0x00, 0x18, 0x00, 0x63, 0x00, 0x38,
  0x00, 0x63, 0x00, 0x38, 0x00, 0x77, 0x00, 0x30, 0x00, 0x77, 0x00, 0x30,
  0x00, 0x36, 0x00, 0x70, 0x00, 0x36, 0x00, 0x70, 0x00, 0x36, 0x00, 0x60,
  0x00, 0x3E, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x60, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x00, 0x70, 0x0C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xC0, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x06, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07,
  0x38, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x06, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x0C, 0x60, 0x00, 0x03, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x18, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x1C, 0x00, 0x38, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x1C, 0x0F, 0x00, 0x0E, 0x01, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x0C, 0x01, 0xC0, 0x06, 0x00, 0xE0, 0x03, 0x00,
  0x60, 0x01, 0xC0, 0x30, 0x00, 0xC0, 0x38, 0x00, 0x60, 0x1C, 0x00, 0x30,
  0x0C, 0x00, 0x18, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x03, 0x80, 0x06,
  0x01, 0xC0, 0x07, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x03, 0x80, 0x30, 0x01,
  0xC0, 0x38, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x0C, 0x07, 0xC0, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x00, 0x70, 0x0C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xC0, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x06, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07,
  0x38, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x06, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x0C, 0x60, 0x00, 0x03, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x18, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x1C, 0x00, 0x38, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x70,
  0x3C, 0x00, 0x70, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x60, 0x07, 0x00, 0xE0,
  0x03, 0x00, 0xE0, 0x03, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x03, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x01, 0x80, 0x07, 0x01, 0x80,
  0x07, 0x01, 0x80, 0x07, 0x03, 0x80, 0x06, 0x03, 0x80, 0x0E, 0x03, 0x00,
  0x0C, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x38, 0x07, 0x00, 0x70, 0x07, 0x01,
  0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0C, 0x0E, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x1C, 0x06,
  0x00, 0x1C, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x03,
  0x00, 0x38, 0x03, 0x00, 0x38, 0x03, 0x80, 0x30, 0x03, 0x80, 0x30, 0x03,
  0x80, 0x70, 0x01, 0x80, 0x70, 0x01, 0x80, 0x70, 0x01, 0x80, 0x60, 0x01,
  0xC0, 0x60, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF0, 0x03, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x02, 0x00, 0x0F, 0x00, 0xE0, 0x07, 0x80,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF,
  0xFB, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x1C, 0x03, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x18, 0x07, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0x30,
  0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x70, 0x0C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x06,
  0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xC0, 0x38,
  0x00, 0x0C, 0x03, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x03, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x18, 0x07, 0x00, 0x01, 0x80, 0x70, 0x00, 0x38, 0x06,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x60, 0x0C, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x0C, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0x9C, 0x00,
  0x07, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00,
  0xC3, 0x80, 0x03, 0x87, 0x00, 0x06, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x30,
  0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x01, 0xC0, 0x0E, 0x03,
  0x80, 0x18, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x70, 0x0C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x60, 0x03, 0x81,
  0xC0, 0x03, 0x03, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x30,
  0x00, 0x30, 0xE0, 0x00, 0x61, 0x80, 0x00, 0xC7, 0x00, 0x01, 0x8C, 0x00,
  0x03, 0x18, 0x00, 0x06, 0x70, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x80, 0x00,
  0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x37,
  0x00, 0x03, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x80, 0x01, 0x9C, 0x00, 0x0F,
  0x00, 0x07, 0x38, 0x00, 0x36, 0x00, 0x0E, 0x70, 0x00, 0x6C, 0x00, 0x18,
  0xE0, 0x01, 0xD8, 0x00, 0x71, 0xC0, 0x03, 0x30, 0x00, 0xC3, 0x80, 0x06,
  0x60, 0x03, 0x87, 0x00, 0x18, 0xC0, 0x07, 0x0E, 0x00, 0x31, 0x80, 0x0C,
  0x1C, 0x00, 0xE3, 0x00, 0x38, 0x38, 0x01, 0x86, 0x00, 0x60, 0x70, 0x03,
  0x0C, 0x01, 0xC0, 0xE0, 0x0C, 0x18, 0x03, 0x81, 0xC0, 0x18, 0x70, 0x06,
  0x03, 0x80, 0x70, 0xE0, 0x1C, 0x07, 0x00, 0xC1, 0xC0, 0x30, 0x0C, 0x01,
  0x83, 0x80, 0xE0, 0x18, 0x07, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x0C, 0x03,
  0x00, 0x60, 0x38, 0x18, 0x0E, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x01, 0x80,
  0xC0, 0x60, 0x70, 0x03, 0x03, 0x80, 0xC0, 0xE0, 0x06, 0x06, 0x01, 0x81,
  0x80, 0x0C, 0x1C, 0x03, 0x07, 0x00, 0x18, 0x30, 0x06, 0x0C, 0x00, 0x30,
  0x60, 0x0C, 0x38, 0x00, 0x61, 0xC0, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x30,
  0xC0, 0x01, 0x86, 0x00, 0x63, 0x80, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x06,
  0x30, 0x01, 0x8C, 0x00, 0x0C, 0xE0, 0x03, 0x38, 0x00, 0x19, 0x80, 0x06,
  0x60, 0x00, 0x33, 0x00, 0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x1B, 0x00, 0x00,
  0xD8, 0x00, 0x36, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x0E,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x30, 0x38, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x1C, 0x60,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x38, 0x03, 0x80, 0x01, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x07, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x70, 0x00, 0x39, 0x80, 0x01, 0x8C, 0x00,
  0x1C, 0x60, 0x00, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x60, 0xC0, 0x07, 0x06,
  0x00, 0x30, 0x38, 0x03, 0x81, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x30, 0x1C,
  0x01, 0x80, 0xC0, 0x0C, 0x0E, 0x00, 0x60, 0x60, 0x03, 0x07, 0x00, 0x18,
  0x30, 0x00, 0xC3, 0x80, 0x06, 0x18, 0x00, 0x31, 0xC0, 0x01, 0xCC, 0x00,
  0x0E, 0xE0, 0x00, 0x36, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xC0,
  0x60, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E,
  0x07, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x1C, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x73, 0x80, 0x00, 0x61, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0xC0, 0xC0, 0x01,
  0xC0, 0xE0, 0x01, 0x80, 0x60, 0x03, 0x80, 0x70, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x30, 0x06, 0x00, 0x38, 0x0E, 0x00, 0x18, 0x0C, 0x00, 0x1C, 0x1C,
  0x00, 0x1C, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x06, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0xC1, 0xC1, 0x83, 0x83,
  0x06, 0x06, 0x0C, 0x0C, 0x08, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x1C, 0x03,
  0xC7, 0x30, 0x0E, 0x03, 0x60, 0x38, 0x06, 0xC0, 0xE0, 0x05, 0x81, 0x80,
  0x0E, 0x07, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x60, 0x00,
  0xE1, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x06, 0x00, 0x06, 0x1C, 0x00, 0x1C,
  0x38, 0x00, 0x38, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x87,
  0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x30, 0x00, 0x70, 0x60,
  0x00, 0xE0, 0xC0, 0x01, 0xC1, 0x80, 0x07, 0x03, 0x00, 0x0E, 0x06, 0x00,
  0x1C, 0x0C, 0x00, 0x78, 0x1C, 0x00, 0xF0, 0x38, 0x03, 0xC0, 0x30, 0x0D,
  0x80, 0x70, 0x33, 0x00, 0x7F, 0xC6, 0x00, 0x7F, 0x0C, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0xF8, 0x00, 0xE7, 0xFC, 0x01,
  0xDE, 0x7C, 0x03, 0x70, 0x38, 0x06, 0xC0, 0x30, 0x0F, 0x00, 0x70, 0x3C,
  0x00, 0xE0, 0x78, 0x00, 0xC0, 0xE0, 0x01, 0x81, 0xC0, 0x03, 0x07, 0x00,
  0x06, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x30, 0x00, 0x70, 0x60, 0x00,
  0xE1, 0xC0, 0x01, 0xC3, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x18, 0x00, 0x38, 0x70, 0x00, 0x70, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83,
  0x00, 0x07, 0x06, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x70, 0x70,
  0x00, 0xC0, 0xE0, 0x03, 0x83, 0xC0, 0x0E, 0x06, 0xC0, 0x1C, 0x0D, 0x80,
  0x70, 0x1B, 0x81, 0xC0, 0x33, 0xFF, 0x00, 0xC3, 0xFC, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x0F, 0x08, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x10, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x01, 0xF0, 0xE0, 0x01,
  0xFE, 0x30, 0x00, 0xF1, 0xCC, 0x00, 0x70, 0x1B, 0x00, 0x38, 0x06, 0xC0,
  0x1C, 0x00, 0xF0, 0x06, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0xC0, 0x03,
  0x80, 0x70, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x0E, 0x00, 0x0C, 0x03, 0x80,
  0x03, 0x00, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x06,
  0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x38, 0x00, 0x38,
  0x0E, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00,
  0x70, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0x30,
  0x00, 0xE0, 0x0C, 0x00, 0x78, 0x03, 0x80, 0x3E, 0x00, 0xE0, 0x0F, 0x00,
  0x18, 0x06, 0xC0, 0x07, 0x03, 0x30, 0x00, 0xFF, 0x8C, 0x00, 0x1F, 0xC7,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x03, 0xC7,
  0x00, 0xE0, 0x60, 0x38, 0x0E, 0x0E, 0x01, 0xC3, 0x80, 0x38, 0x60, 0x07,
  0x1C, 0x00, 0xE3, 0x00, 0x18, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x00, 0x38,
  0xE0, 0x0E, 0x1C, 0x03, 0x83, 0x01, 0xE0, 0x63, 0xF8, 0x1F, 0xFC, 0x03,
  0xF8, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x0C, 0x07,
  0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xFC, 0x70, 0x01, 0xE3, 0x98, 0x00, 0xE0, 0x36, 0x00,
  0x70, 0x0D, 0x80, 0x38, 0x01, 0x60, 0x0C, 0x00, 0x70, 0x07, 0x00, 0x1C,
  0x01, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x1C, 0x00,
  0x18, 0x07, 0x00, 0x06, 0x01, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38,
  0x00, 0x38, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x01, 0xC0,
  0x70, 0x00, 0x70, 0x1C, 0x00, 0x18, 0x07, 0x00, 0x06, 0x01, 0x80, 0x03,
  0x80, 0x60, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x01, 0x80,
  0x07, 0x00, 0x60, 0x03, 0xC0, 0x18, 0x00, 0xF0, 0x07, 0x00, 0x7C, 0x01,
  0xC0, 0x1E, 0x00, 0x30, 0x0D, 0x80, 0x0E, 0x06, 0x60, 0x01, 0xFF, 0x38,
  0x00, 0x3F, 0x8E, 0x00, 0x03, 0x83, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x08, 0x00, 0xE0, 0x03, 0x00, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x3E, 0x00, 0x73, 0xFE, 0x01, 0xDE, 0x38, 0x06, 0xC0, 0x70, 0x1E, 0x01,
  0xC0, 0x78, 0x03, 0x03, 0xC0, 0x0C, 0x0E, 0x00, 0x30, 0x38, 0x01, 0xC0,
  0xE0, 0x07, 0x03, 0x00, 0x18, 0x1C, 0x00, 0x60, 0x70, 0x01, 0x81, 0x80,
  0x0E, 0x06, 0x00, 0x38, 0x18, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x00, 0x0C,
  0x0C, 0x00, 0x70, 0x30, 0x01, 0xC1, 0xC0, 0x06, 0x07, 0x00, 0x18, 0x18,
  0x00, 0x60, 0x60, 0x03, 0x81, 0x80, 0x0C, 0x0E, 0x00, 0x30, 0x38, 0x00,
  0xC0, 0xC0, 0x07, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x60, 0x70, 0x01, 0x81,
  0x80, 0x06, 0x06, 0x00, 0x38, 0x18, 0x00, 0xE0, 0xE0, 0x03, 0x00, 0x00,
  0x10, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x06, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x38, 0x0C, 0x00, 0x70,
  0x30, 0x00, 0xC0, 0xE0, 0x01, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x18,
  0x00, 0x18, 0x70, 0x00, 0x31, 0xC0, 0x00, 0x67, 0x80, 0x01, 0xCF, 0x00,
  0x03, 0xB6, 0x00, 0x06, 0xCC, 0x00, 0x0F, 0x98, 0x00, 0x1E, 0x30, 0x00,
  0x78, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0x81, 0xC0, 0x03, 0x01, 0x80, 0x0E,
  0x03, 0x00, 0x1C, 0x06, 0x00, 0x30, 0x0E, 0x00, 0x60, 0x1C, 0x00, 0xC0,
  0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0xC0, 0x30, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x00, 0x00, 0x43, 0xE0, 0x3E, 0x00, 0x63, 0xFC, 0x3F, 0xE0,
  0x19, 0xC7, 0x9C, 0x3C, 0x06, 0xC0, 0x6E, 0x07, 0x01, 0xE0, 0x1B, 0x00,
  0xC0, 0x70, 0x07, 0x80, 0x30, 0x3C, 0x01, 0xC0, 0x0C, 0x0E, 0x00, 0x70,
  0x03, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x70, 0x01,
  0x80, 0x1C, 0x1C, 0x00, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x01, 0x81, 0x80,
  0x0C, 0x00, 0x60, 0x60, 0x03, 0x00, 0x38, 0x38, 0x01, 0xC0, 0x0E, 0x0E,
  0x00, 0x70, 0x03, 0x03, 0x00, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x00, 0x30,
  0x30, 0x01, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x01,
  0x81, 0x80, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0,
  0x0E, 0x0E, 0x00, 0x70, 0x03, 0x83, 0x00, 0x1C, 0x00, 0xC0, 0xC0, 0x06,
  0x00, 0x30, 0x30, 0x01, 0x80, 0x0C, 0x1C, 0x00, 0xE0, 0x07, 0x07, 0x00,
  0x38, 0x01, 0xC1, 0x80, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x00, 0x18, 0x18,
  0x00, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x06,
  0x3F, 0xE0, 0x19, 0xE3, 0x80, 0x6C, 0x07, 0x01, 0xE0, 0x1C, 0x07, 0x00,
  0x30, 0x3C, 0x00, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70,
  0x70, 0x01, 0x81, 0xC0, 0x06, 0x07, 0x00, 0x18, 0x18, 0x00, 0xE0, 0x60,
  0x03, 0x83, 0x80, 0x0C, 0x0E, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x07,
  0x03, 0x00, 0x1C, 0x1C, 0x00, 0x60, 0x70, 0x01, 0x81, 0x80, 0x0E, 0x06,
  0x00, 0x38, 0x18, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00,
  0x70, 0x30, 0x01, 0xC1, 0xC0, 0x06, 0x07, 0x00, 0x18, 0x18, 0x00, 0x60,
  0x60, 0x03, 0x81, 0x80, 0x0E, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x00,
  0x07, 0xFC, 0x01, 0xF1, 0xC0, 0x3C, 0x0E, 0x03, 0x80, 0x60, 0x70, 0x07,
  0x0E, 0x00, 0x70, 0xC0, 0x03, 0x1C, 0x00, 0x31, 0xC0, 0x03, 0x18, 0x00,
  0x33, 0x80, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x70, 0x00, 0x77, 0x00,
  0x07, 0x60, 0x00, 0x76, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0,
  0x00, 0xEE, 0x00, 0x0E, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0xCC,
  0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00, 0x38, 0xC0, 0x07, 0x0E, 0x00, 0x70,
  0xE0, 0x0E, 0x06, 0x01, 0xC0, 0x70, 0x38, 0x03, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x08, 0x7C, 0x00, 0x0C, 0x3F, 0xC0, 0x03, 0x3C,
  0x78, 0x00, 0xCC, 0x0E, 0x00, 0x36, 0x01, 0x80, 0x0F, 0x00, 0x70, 0x07,
  0x80, 0x1C, 0x01, 0xE0, 0x03, 0x00, 0x70, 0x00, 0xC0, 0x1C, 0x00, 0x30,
  0x06, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x00, 0xE0, 0x00, 0xC0, 0x30, 0x00,
  0x30, 0x0C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x60,
  0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x80, 0x03, 0x80,
  0xE0, 0x00, 0xE0, 0x38, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x07,
  0x01, 0xC0, 0x01, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x30, 0x07, 0x00,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xF8, 0x03, 0x80, 0x36, 0x01, 0xC0, 0x0C,
  0xC0, 0xE0, 0x03, 0x3F, 0xF0, 0x01, 0xC7, 0xF8, 0x00, 0x70, 0x60, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0xFF, 0x1C, 0x03, 0xC7, 0x30, 0x0E, 0x07, 0x60, 0x38, 0x06,
  0xC0, 0xE0, 0x0D, 0x81, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0C, 0x00, 0x38,
  0x38, 0x00, 0x70, 0x60, 0x00, 0xE1, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x06,
  0x00, 0x06, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x60, 0x00, 0x60, 0xC0,
  0x00, 0xC1, 0x80, 0x01, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0C, 0x1C, 0x00,
  0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0xC1, 0x80, 0x07,
  0x03, 0x00, 0x0E, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x78, 0x1C, 0x01, 0xF0,
  0x38, 0x03, 0xC0, 0x30, 0x0D, 0x80, 0x70, 0x33, 0x00, 0x7F, 0xCE, 0x00,
  0x7F, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0xE0, 0x31, 0xF8, 0x06, 0x79, 0x00, 0xDC, 0x00, 0x1B, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x0F, 0xFE, 0x01, 0xE0, 0xF0, 0x38, 0x02, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x38, 0x0F, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0xFF, 0xC7, 0xFE, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0xF0,
  0x1F, 0x80, 0x38, 0x00, 0x07, 0x00, 0x18, 0x38, 0x00, 0xC1, 0x80, 0x0E,
  0x0C, 0x00, 0x70, 0xE0, 0x03, 0x07, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80,
  0x0E, 0x0C, 0x00, 0x60, 0xE0, 0x03, 0x07, 0x00, 0x18, 0x30, 0x01, 0xC1,
  0x80, 0x0E, 0x0C, 0x00, 0x60, 0xE0, 0x03, 0x07, 0x00, 0x18, 0x30, 0x01,
  0xC1, 0x80, 0x0E, 0x1C, 0x00, 0x60, 0xE0, 0x03, 0x06, 0x00, 0x18, 0x30,
  0x01, 0xC1, 0x80, 0x0E, 0x1C, 0x00, 0x60, 0xE0, 0x07, 0x06, 0x00, 0x38,
  0x30, 0x01, 0xC1, 0x80, 0x1E, 0x0C, 0x00, 0xE0, 0x60, 0x0F, 0x03, 0x00,
  0xD8, 0x1C, 0x0C, 0xC0, 0x7F, 0xEC, 0x03, 0xFC, 0x60, 0x03, 0x80, 0x00,
  0xC0, 0x01, 0xF0, 0x00, 0xEC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x07, 0x30,
  0x01, 0x8C, 0x00, 0xE3, 0x00, 0x30, 0xC0, 0x1C, 0x30, 0x06, 0x0C, 0x03,
  0x83, 0x00, 0xE0, 0xC0, 0x30, 0x30, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x80,
  0xC0, 0xC0, 0x30, 0x70, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC3, 0x80, 0x30,
  0xC0, 0x0C, 0x70, 0x03, 0x18, 0x00, 0xCE, 0x00, 0x33, 0x00, 0x0C, 0xC0,
  0x03, 0x60, 0x00, 0xD8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x1F, 0x00, 0x1E, 0x00,
  0x6C, 0x00, 0x78, 0x03, 0xB0, 0x01, 0xE0, 0x0C, 0xC0, 0x0D, 0x80, 0x33,
  0x00, 0x3E, 0x01, 0xCC, 0x01, 0xB8, 0x06, 0x30, 0x06, 0xC0, 0x18, 0xC0,
  0x1B, 0x00, 0xC3, 0x00, 0xCC, 0x03, 0x0C, 0x03, 0x30, 0x1C, 0x30, 0x18,
  0xC0, 0x60, 0xC0, 0x63, 0x01, 0x83, 0x03, 0x8C, 0x0E, 0x0C, 0x0C, 0x30,
  0x30, 0x30, 0x30, 0xC1, 0xC0, 0xC1, 0x83, 0x06, 0x03, 0x06, 0x0C, 0x18,
  0x0C, 0x38, 0x30, 0xE0, 0x30, 0xC0, 0xC3, 0x00, 0xC3, 0x03, 0x0C, 0x03,
  0x18, 0x0C, 0x60, 0x0C, 0x60, 0x31, 0x80, 0x33, 0x80, 0xCE, 0x00, 0xCC,
  0x03, 0x30, 0x03, 0x30, 0x0C, 0xC0, 0x0D, 0x80, 0x36, 0x00, 0x36, 0x00,
  0xD8, 0x00, 0xF8, 0x03, 0x60, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x60,
  0x0C, 0x00, 0x60, 0x18, 0x00, 0x70, 0x38, 0x00, 0x70, 0x30, 0x00, 0x30,
  0x70, 0x00, 0x30, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x31, 0xC0, 0x00, 0x39,
  0x80, 0x00, 0x1B, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x66, 0x00, 0x00, 0xC6, 0x00, 0x01, 0xC6, 0x00, 0x01, 0x86,
  0x00, 0x03, 0x87, 0x00, 0x07, 0x03, 0x00, 0x06, 0x03, 0x00, 0x0E, 0x03,
  0x00, 0x0C, 0x03, 0x00, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x01,
  0x80, 0x70, 0x01, 0x80, 0xE0, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x98,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x02, 0x7F, 0xC0, 0x05, 0xE3,
  0xE0, 0x3E, 0x01, 0xF1, 0xE8, 0x00, 0xFF, 0x90, 0x00, 0x7C, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 46, 14, 1, -46 },
  { 76, 14, 16, 18, 6, -46 },
  { 104, 26, 46, 25, 0, -46 },
  { 254, 25, 53, 23, -1, -49 },
  { 420, 29, 48, 35, 3, -47 },
  { 594, 22, 48, 22, -1, -47 },
  { 726, 6, 16, 10, 6, -46 },
  { 738, 18, 56, 16, 2, -46 },
  { 864, 18, 56, 16, -5, -46 },
  { 990, 16, 18, 21, 8, -49 },
  { 1026, 23, 30, 26, 2, -38 },
  { 1113, 9, 14, 11, -3, -6 },
  { 1129, 14, 2, 17, 1, -19 },
  { 1133, 4, 5, 11, 1, -5 },
  { 1136, 27, 46, 20, -3, -46 },
  { 1292, 22, 48, 23, 1, -47 },
  { 1424, 12, 46, 23, 7, -46 },
  { 1493, 25, 47, 23, -2, -47 },
  { 1640, 24, 48, 23, -1, -47 },
  { 1784, 24, 47, 23, -1, -47 },
  { 1925, 25, 47, 23, -2, -46 },
  { 2072, 23, 48, 23, 1, -47 },
  { 2210, 23, 46, 23, 2, -46 },
  { 2343, 25, 48, 23, -1, -47 },
  { 2493, 23, 48, 23, 0, -47 },
  { 2631, 10, 35, 11, 0, -35 },
  { 2675, 14, 43, 11, -3, -35 },
  { 2751, 23, 28, 26, 2, -37 },
  { 2832, 23, 16, 26, 2, -31 },
  { 2878, 23, 28, 26, 2, -37 },
  { 2959, 18, 47, 16, 1, -47 },
  { 3065, 31, 53, 34, 2, -47 },
  { 3271, 22, 47, 22, -4, -47 },
  { 3401, 25, 46, 25, 0, -46 },
  { 3545, 26, 48, 23, 2, -47 },
  { 3701, 26, 46, 27, 0, -46 },
  { 3851, 25, 46, 22, 0, -46 },
  { 3995, 25, 46, 21, 0, -46 },
  { 4139, 29, 48, 30, 2, -47 },
  { 4313, 30, 46, 29, 0, -46 },
  { 4486, 21, 46, 12, -4, -46 },
  { 4607, 21, 57, 11, -9, -46 },
  { 4757, 28, 46, 23, 0, -46 },
  { 4918, 15, 46, 20, 0, -46 },
  { 5005, 40, 46, 39, 0, -46 },
  { 5235, 32, 46, 31, 0, -46 },
  { 5419, 26, 48, 30, 2, -47 },
  { 5575, 25, 46, 24, 0, -46 },
  { 5719, 26, 58, 30, 2, -47 },
  { 5908, 24, 46, 24, 0, -46 },
  { 6046, 26, 48, 23, -2, -47 },
  { 6202, 21, 46, 20, 4, -46 },
  { 6323, 28, 47, 28, 2, -46 },
  { 6488, 23, 46, 23, 5, -46 },
  { 6621, 39, 46, 40, 5, -46 },
  { 6846, 29, 46, 21, -4, -46 },
  { 7013, 21, 46, 20, 4, -46 },
  { 7134, 27, 46, 20, -3, -46 },
  { 7290, 23, 56, 18, -1, -46 },
  { 7451, 9, 46, 21, 7, -46 },
  { 7503, 23, 56, 18, -4, -46 },
  { 7664, 24, 22, 25, 1, -46 },
  { 7730, 17, 2, 18, -5, 6 },
  { 7735, 7, 11, 14, 9, -50 },
  { 7745, 23, 36, 25, 2, -35 },
  { 7849, 23, 50, 25, 0, -49 },
  { 7993, 18, 36, 18, 2, -35 },
  { 8074, 26, 50, 25, 2, -49 },
  { 8237, 19, 36, 22, 2, -35 },
  { 8323, 28, 66, 13, -8, -50 },
  { 8554, 26, 51, 25, -1, -35 },
  { 8720, 22, 49, 24, 0, -49 },
  { 8855, 13, 47, 11, 0, -47 },
  { 8932, 22, 63, 11, -9, -47 },
  { 9106, 23, 49, 20, 0, -49 },
  { 9247, 13, 49, 10, 0, -49 },
  { 9327, 34, 35, 36, 0, -35 },
  { 9476, 22, 35, 24, 0, -35 },
  { 9573, 20, 36, 24, 2, -35 },
  { 9663, 26, 50, 25, -3, -35 },
  { 9826, 23, 50, 25, 2, -35 },
  { 9970, 19, 35, 16, 0, -35 },
  { 10054, 20, 36, 18, -1, -35 },
  { 10144, 13, 44, 13, 1, -43 },
  { 10216, 21, 35, 24, 2, -34 },
  { 10308, 18, 34, 18, 4, -34 },
  { 10385, 30, 34, 31, 4, -34 },
  { 10513, 24, 34, 19, -3, -34 },
  { 10615, 30, 50, 20, -7, -34 },
  { 10803, 20, 34, 16, -2, -34 },
  { 10888, 22, 56, 20, 2, -46 },
  { 11042, 2, 66, 23, 10, -50 },
  { 11059, 22, 56, 20, -4, -46 },
  { 11213, 23, 6, 26, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic65pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC65PT7B_H_
