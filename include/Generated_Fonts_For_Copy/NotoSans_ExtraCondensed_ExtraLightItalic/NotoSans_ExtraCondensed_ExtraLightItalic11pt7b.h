#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC11PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x62, 0xFC, 0x33, 0x75, 0x6B, 0xAC, 0x36, 0x64, 0x25, 0x6C,
  0x40, 0xDD, 0xED, 0xF7, 0xBB, 0x65, 0x64, 0xDA, 0xAE, 0xE0, 0x25, 0x29,
  0x24, 0x90, 0x24, 0x92, 0x4A, 0x50, 0xCE, 0x80, 0x22, 0xF2, 0x20, 0xC0,
  0xE0, 0x80, 0x08, 0x44, 0x22, 0x11, 0x10, 0x35, 0x59, 0x99, 0xAE, 0x75,
  0x6A, 0x71, 0x11, 0x24, 0x8E, 0x71, 0x16, 0x22, 0x2E, 0x13, 0x26, 0xAE,
  0x22, 0x74, 0x46, 0x11, 0x2E, 0x34, 0x46, 0x99, 0xAE, 0x71, 0x12, 0x24,
  0x48, 0x75, 0x56, 0x6A, 0x9E, 0x75, 0x99, 0x62, 0x2C, 0x40, 0x20, 0x20,
  0x00, 0xB0, 0x34, 0xC3, 0xFF, 0xC3, 0x3C, 0x64, 0xA5, 0x04, 0x39, 0x15,
  0x6D, 0xB7, 0x6B, 0x20, 0x60, 0x11, 0x33, 0x75, 0x59, 0x35, 0x57, 0x99,
  0x9E, 0x3A, 0x11, 0x08, 0x42, 0x0C, 0x35, 0x55, 0x99, 0x9E, 0x34, 0x46,
  0x88, 0x8E, 0x34, 0x44, 0xA8, 0x88, 0x3A, 0x11, 0x09, 0xC6, 0x4E, 0x4A,
  0x52, 0xD9, 0x4A, 0x52, 0x32, 0x22, 0x24, 0x4C, 0x11, 0x11, 0x22, 0x22,
  0x2C, 0x4A, 0x98, 0x84, 0x52, 0x94, 0x49, 0x29, 0x27, 0x42, 0x89, 0x12,
  0x6A, 0xD6, 0xAD, 0x54, 0x4A, 0x5A, 0xDA, 0xD6, 0x52, 0x3A, 0x53, 0x18,
  0xC6, 0x5C, 0x35, 0x55, 0x68, 0x88, 0x3A, 0x53, 0x18, 0xC6, 0x5C, 0x21,
  0x00, 0x35, 0x55, 0x6A, 0xAA, 0x74, 0x44, 0x22, 0x2E, 0xE9, 0x49, 0x24,
  0x4A, 0x52, 0x99, 0x4A, 0x5C, 0x9A, 0xAA, 0xCC, 0x88, 0x93, 0x4A, 0x96,
  0xCD, 0x92, 0x24, 0x48, 0x29, 0x4C, 0x22, 0x29, 0x52, 0xB7, 0x69, 0x24,
  0x71, 0x22, 0x44, 0x8E, 0x74, 0x44, 0x48, 0x88, 0x8C, 0xAA, 0x95, 0x31,
  0x11, 0x12, 0x22, 0x2C, 0x26, 0x59, 0xE0, 0x80, 0x75, 0x99, 0x9E, 0x44,
  0x75, 0x99, 0x9E, 0x6A, 0x49, 0x80, 0x08, 0x5C, 0xA9, 0x4A, 0x9C, 0x75,
  0xAC, 0x8E, 0x32, 0x32, 0x24, 0x44, 0x48, 0x80, 0x75, 0x99, 0xAE, 0x22,
  0xC0, 0x44, 0x75, 0x59, 0xAA, 0x45, 0xAA, 0x20, 0x92, 0x92, 0x52, 0x00,
  0x44, 0x56, 0xCA, 0xAA, 0x55, 0xAA, 0x7D, 0x59, 0x69, 0xAA, 0xA0, 0x75,
  0x99, 0xAA, 0x75, 0x99, 0x9E, 0x75, 0x99, 0x9E, 0x88, 0x80, 0x75, 0x99,
  0xAE, 0x22, 0x20, 0x6A, 0x49, 0x00, 0x71, 0x23, 0x80, 0x56, 0xA8, 0x55,
  0x99, 0xAE, 0xBB, 0x49, 0x00, 0xAE, 0x6D, 0x4A, 0x50, 0x56, 0x44, 0xCA,
  0x29, 0x4C, 0x42, 0x11, 0x08, 0x80, 0x65, 0x29, 0x80, 0x12, 0x24, 0xC4,
  0x44, 0x84, 0xFF, 0xE0, 0x21, 0x11, 0x12, 0x22, 0x4C, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 8, 2, 0, -8 },
  { 3, 2, 3, 3, 1, -8 },
  { 4, 4, 8, 4, 0, -8 },
  { 8, 4, 9, 4, 0, -8 },
  { 13, 4, 8, 6, 1, -8 },
  { 17, 4, 8, 4, 0, -8 },
  { 21, 1, 3, 2, 1, -8 },
  { 22, 3, 10, 3, 0, -8 },
  { 26, 3, 10, 3, -1, -8 },
  { 30, 3, 3, 4, 1, -8 },
  { 32, 4, 5, 4, 0, -6 },
  { 35, 1, 2, 2, 0, -1 },
  { 36, 3, 1, 3, 0, -3 },
  { 37, 1, 1, 2, 0, -1 },
  { 38, 5, 8, 3, -1, -8 },
  { 43, 4, 8, 4, 0, -8 },
  { 47, 2, 8, 4, 1, -8 },
  { 49, 4, 8, 4, 0, -8 },
  { 53, 4, 8, 4, 0, -8 },
  { 57, 4, 8, 4, 0, -8 },
  { 61, 4, 8, 4, 0, -8 },
  { 65, 4, 8, 4, 0, -8 },
  { 69, 4, 8, 4, 0, -8 },
  { 73, 4, 8, 4, 0, -8 },
  { 77, 4, 8, 4, 0, -8 },
  { 81, 2, 6, 2, 0, -6 },
  { 83, 3, 7, 2, -1, -6 },
  { 86, 4, 4, 4, 0, -6 },
  { 88, 4, 2, 4, 0, -5 },
  { 89, 4, 4, 4, 0, -6 },
  { 91, 3, 8, 3, 0, -8 },
  { 94, 6, 9, 6, 0, -8 },
  { 101, 4, 8, 4, -1, -8 },
  { 105, 4, 8, 4, 0, -8 },
  { 109, 5, 8, 4, 0, -8 },
  { 114, 4, 8, 5, 0, -8 },
  { 118, 4, 8, 4, 0, -8 },
  { 122, 4, 8, 4, 0, -8 },
  { 126, 5, 8, 5, 0, -8 },
  { 131, 5, 8, 5, 0, -8 },
  { 136, 4, 8, 2, -1, -8 },
  { 140, 4, 10, 2, -2, -8 },
  { 145, 5, 8, 4, 0, -8 },
  { 150, 3, 8, 3, 0, -8 },
  { 153, 7, 8, 7, 0, -8 },
  { 160, 5, 8, 5, 0, -8 },
  { 165, 5, 8, 5, 0, -8 },
  { 170, 4, 8, 4, 0, -8 },
  { 174, 5, 10, 5, 0, -8 },
  { 181, 4, 8, 4, 0, -8 },
  { 185, 4, 8, 4, 0, -8 },
  { 189, 3, 8, 3, 1, -8 },
  { 192, 5, 8, 5, 0, -8 },
  { 197, 4, 8, 4, 1, -8 },
  { 201, 7, 8, 7, 1, -8 },
  { 208, 5, 8, 3, -1, -8 },
  { 213, 3, 8, 3, 1, -8 },
  { 216, 4, 8, 3, 0, -8 },
  { 220, 4, 10, 3, 0, -8 },
  { 225, 2, 8, 4, 1, -8 },
  { 227, 4, 10, 3, -1, -8 },
  { 232, 4, 4, 4, 0, -8 },
  { 234, 3, 1, 3, -1, 1 },
  { 235, 1, 1, 2, 2, -8 },
  { 236, 4, 6, 4, 0, -6 },
  { 239, 4, 8, 4, 0, -8 },
  { 243, 3, 6, 3, 0, -6 },
  { 246, 5, 8, 4, 0, -8 },
  { 251, 4, 6, 4, 0, -6 },
  { 254, 4, 11, 2, -1, -8 },
  { 260, 4, 9, 4, 0, -6 },
  { 265, 4, 8, 4, 0, -8 },
  { 269, 2, 8, 2, 0, -8 },
  { 271, 3, 11, 2, -1, -8 },
  { 276, 4, 8, 3, 0, -8 },
  { 280, 2, 8, 2, 0, -8 },
  { 282, 6, 6, 6, 0, -6 },
  { 287, 4, 6, 4, 0, -6 },
  { 290, 4, 6, 4, 0, -6 },
  { 293, 4, 9, 4, 0, -6 },
  { 298, 4, 9, 4, 0, -6 },
  { 303, 3, 6, 3, 0, -6 },
  { 306, 3, 6, 3, 0, -6 },
  { 309, 2, 7, 2, 0, -7 },
  { 311, 4, 6, 4, 0, -6 },
  { 314, 3, 6, 3, 1, -6 },
  { 317, 5, 6, 5, 1, -6 },
  { 321, 4, 6, 3, 0, -6 },
  { 324, 5, 9, 3, -1, -6 },
  { 330, 3, 6, 3, 0, -6 },
  { 333, 4, 10, 3, 0, -8 },
  { 338, 1, 11, 4, 1, -8 },
  { 340, 4, 10, 3, -1, -8 },
  { 345, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC11PT7B_H_
