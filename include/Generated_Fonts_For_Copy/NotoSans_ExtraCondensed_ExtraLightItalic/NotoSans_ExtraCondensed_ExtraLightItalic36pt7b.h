#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC36PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x08,
  0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x20, 0x00, 0x00, 0x00,
  0x40, 0x60, 0xC0, 0x31, 0x23, 0x23, 0x22, 0x62, 0x42, 0x46, 0x44, 0x44,
  0x84, 0x00, 0x84, 0x02, 0x10, 0x18, 0x80, 0x42, 0x01, 0x08, 0x0C, 0x60,
  0x21, 0x00, 0x84, 0x1F, 0xFC, 0x10, 0x80, 0x42, 0x01, 0x18, 0x08, 0x40,
  0x21, 0x00, 0x84, 0x06, 0x20, 0xFF, 0xF3, 0xFF, 0xC3, 0x10, 0x08, 0x40,
  0x21, 0x01, 0x8C, 0x04, 0x20, 0x10, 0x80, 0x46, 0x02, 0x10, 0x00, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x0F, 0xF0, 0xC8, 0x84, 0x40, 0x62, 0x02, 0x10,
  0x11, 0x00, 0x88, 0x06, 0x40, 0x12, 0x00, 0x50, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x02, 0xC0, 0x22, 0x01, 0x10, 0x08, 0xC0, 0x44, 0x02, 0x20, 0x21,
  0x11, 0x10, 0xFF, 0x00, 0xE0, 0x02, 0x00, 0x20, 0x01, 0x00, 0x00, 0x0E,
  0x02, 0x12, 0x04, 0x23, 0x04, 0x63, 0x08, 0x43, 0x08, 0x43, 0x10, 0xC2,
  0x10, 0x82, 0x20, 0x82, 0x20, 0x82, 0x40, 0x86, 0x46, 0x84, 0x9B, 0x84,
  0xB1, 0x89, 0x21, 0x99, 0x21, 0x72, 0x41, 0x02, 0x41, 0x04, 0x43, 0x04,
  0xC2, 0x08, 0x82, 0x08, 0x82, 0x10, 0x86, 0x10, 0x84, 0x20, 0x84, 0x20,
  0x88, 0x40, 0x70, 0x03, 0xC0, 0x66, 0x04, 0x60, 0x42, 0x0C, 0x60, 0xC6,
  0x0C, 0x40, 0xC4, 0x0C, 0x80, 0xD8, 0x05, 0x00, 0x60, 0x0C, 0x01, 0xE0,
  0x32, 0x02, 0x23, 0x63, 0x24, 0x32, 0xC1, 0x68, 0x14, 0x81, 0xC8, 0x08,
  0x81, 0x88, 0x38, 0xC6, 0xC7, 0xC4, 0x32, 0x22, 0x64, 0x44, 0x48, 0x00,
  0x40, 0x20, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02,
  0x00, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x80, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x30, 0x08, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00,
  0xC0, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x00, 0x04, 0x02, 0x21, 0x0D, 0x11,
  0xF8, 0xC0, 0xD0, 0xCC, 0xC2, 0x01, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0xFF, 0xF8, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x13,
  0x26, 0x44, 0x88, 0xFF, 0xB8, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x66, 0x0C, 0x20, 0x82,
  0x18, 0x31, 0x03, 0x30, 0x32, 0x03, 0x20, 0x26, 0x02, 0x40, 0x24, 0x02,
  0x40, 0x6C, 0x06, 0xC0, 0x68, 0x04, 0x80, 0x48, 0x0C, 0x80, 0x88, 0x08,
  0x81, 0x88, 0x10, 0x83, 0x08, 0x20, 0xC6, 0x07, 0x80, 0x06, 0x18, 0x53,
  0x2C, 0xD1, 0x82, 0x04, 0x08, 0x30, 0x60, 0x81, 0x02, 0x0C, 0x10, 0x20,
  0x41, 0x83, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x00, 0x01, 0xF0, 0x18, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0xFF, 0x00, 0x01, 0xF0, 0x18, 0x60, 0x40, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x07, 0x80, 0x07, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x81, 0x83, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0A, 0x00,
  0x68, 0x01, 0x60, 0x09, 0x80, 0x64, 0x01, 0x10, 0x0C, 0x40, 0x23, 0x01,
  0x08, 0x0C, 0x20, 0x20, 0x81, 0x86, 0x04, 0x18, 0x20, 0x41, 0x81, 0x04,
  0x04, 0x3F, 0xFC, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x07, 0xF0, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x81, 0x83, 0xF8, 0x00,
  0x00, 0xF8, 0x18, 0x81, 0x80, 0x18, 0x00, 0x80, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x19, 0xC0, 0xBB, 0x07, 0x0C, 0x70, 0x23, 0x01,
  0x18, 0x08, 0x80, 0x44, 0x02, 0x20, 0x11, 0x00, 0x88, 0x0C, 0x40, 0x42,
  0x06, 0x18, 0x20, 0x43, 0x03, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x00, 0x03, 0xE0, 0x31, 0x83, 0x06, 0x10, 0x11, 0x80, 0x8C, 0x04,
  0x60, 0x23, 0x03, 0x18, 0x10, 0x41, 0x03, 0x18, 0x0F, 0x00, 0x70, 0x06,
  0x80, 0xC6, 0x0C, 0x18, 0x40, 0x46, 0x02, 0x20, 0x19, 0x00, 0xC8, 0x06,
  0x40, 0x22, 0x01, 0x18, 0x18, 0x61, 0x81, 0xF8, 0x00, 0x03, 0xC0, 0x62,
  0x0C, 0x10, 0x81, 0x18, 0x11, 0x01, 0x30, 0x13, 0x01, 0x20, 0x12, 0x01,
  0x20, 0x12, 0x03, 0x20, 0x33, 0x07, 0x18, 0xA0, 0xF2, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x06, 0x0F, 0x80,
  0x0C, 0x30, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x43, 0x0C, 0x00, 0x03, 0x03, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x10, 0x10, 0x30, 0x20,
  0x60, 0x40, 0x80, 0x00, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x20, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x0C, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x60, 0x02, 0x00, 0x00, 0x0F, 0x83, 0x18, 0x01,
  0x00, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x03,
  0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x60, 0x18, 0x00, 0x00, 0x7C, 0x00, 0xE3,
  0x00, 0xC0, 0x40, 0xC0, 0x30, 0xC0, 0x08, 0x40, 0x04, 0x40, 0x02, 0x20,
  0x61, 0x30, 0xF8, 0x90, 0xCC, 0x48, 0x44, 0x28, 0x42, 0x14, 0x21, 0x0A,
  0x31, 0x8D, 0x10, 0x85, 0x88, 0x42, 0x84, 0x21, 0x46, 0x31, 0xA3, 0x18,
  0x90, 0x94, 0xC8, 0x4A, 0xC4, 0x39, 0xC2, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x10, 0x01, 0xF8, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x50, 0x05, 0x00, 0xD0, 0x09, 0x00, 0x90, 0x11, 0x01, 0x10,
  0x31, 0x02, 0x10, 0x21, 0x04, 0x10, 0x41, 0x0C, 0x10, 0xFF, 0x18, 0x11,
  0x81, 0x10, 0x13, 0x01, 0x20, 0x16, 0x03, 0x40, 0x34, 0x03, 0xC0, 0x38,
  0x03, 0x07, 0xE0, 0x1F, 0xE0, 0x40, 0x81, 0x03, 0x04, 0x04, 0x30, 0x10,
  0xC0, 0x42, 0x03, 0x08, 0x08, 0x20, 0x61, 0x81, 0x06, 0x18, 0x1F, 0x80,
  0x43, 0x81, 0x02, 0x0C, 0x0C, 0x20, 0x30, 0x80, 0x42, 0x01, 0x18, 0x0C,
  0x60, 0x31, 0x00, 0x84, 0x06, 0x10, 0x30, 0xC3, 0x83, 0xF8, 0x00, 0x00,
  0xFC, 0x06, 0x10, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x80, 0x7E, 0x00, 0x07, 0xC0, 0x0F,
  0xE0, 0x10, 0x60, 0x20, 0x60, 0x40, 0x41, 0x80, 0x83, 0x01, 0x04, 0x03,
  0x08, 0x06, 0x10, 0x08, 0x60, 0x10, 0xC0, 0x21, 0x00, 0x42, 0x00, 0x8C,
  0x03, 0x18, 0x04, 0x20, 0x08, 0x40, 0x30, 0x80, 0x63, 0x00, 0x86, 0x03,
  0x08, 0x0C, 0x10, 0x30, 0x20, 0xC0, 0xC7, 0x01, 0xF8, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x1F, 0xE0, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x7F, 0x83, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xC3, 0x03, 0x01,
  0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x7C, 0x40, 0x0C,
  0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x08, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x10,
  0x40, 0x10, 0x40, 0x10, 0x60, 0x30, 0x30, 0x30, 0x1F, 0xE0, 0x06, 0x01,
  0x83, 0x00, 0x81, 0x00, 0x40, 0x80, 0x20, 0x40, 0x30, 0x60, 0x18, 0x30,
  0x08, 0x10, 0x04, 0x08, 0x02, 0x04, 0x03, 0x06, 0x01, 0x82, 0x00, 0x81,
  0xFF, 0xC0, 0x80, 0x20, 0xC0, 0x30, 0x60, 0x10, 0x20, 0x08, 0x10, 0x04,
  0x08, 0x06, 0x0C, 0x03, 0x06, 0x01, 0x02, 0x00, 0x81, 0x00, 0x40, 0x80,
  0x60, 0xC0, 0x30, 0x60, 0x10, 0x00, 0x07, 0xE0, 0x30, 0x06, 0x00, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x10, 0x1F, 0x80, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x18, 0x0F, 0x00, 0x06, 0x03, 0x06, 0x06, 0x04, 0x0C,
  0x04, 0x08, 0x04, 0x18, 0x0C, 0x30, 0x0C, 0x60, 0x08, 0x40, 0x08, 0xC0,
  0x09, 0x80, 0x19, 0x00, 0x12, 0x00, 0x16, 0x00, 0x1F, 0x00, 0x3B, 0x00,
  0x31, 0x00, 0x21, 0x00, 0x21, 0x80, 0x21, 0x80, 0x60, 0x80, 0x60, 0x80,
  0x40, 0x80, 0x40, 0xC0, 0x40, 0xC0, 0xC0, 0x40, 0xC0, 0x40, 0x06, 0x06,
  0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10,
  0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xFF,
  0x06, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x06, 0x07,
  0x00, 0x28, 0x3C, 0x00, 0xA0, 0xF0, 0x05, 0x82, 0x40, 0x16, 0x09, 0x00,
  0xD0, 0x24, 0x02, 0x41, 0x90, 0x19, 0x04, 0x40, 0x4C, 0x11, 0x03, 0x30,
  0x44, 0x08, 0x83, 0x10, 0x62, 0x0C, 0x41, 0x08, 0x21, 0x0C, 0x60, 0x84,
  0x21, 0x02, 0x11, 0x84, 0x18, 0x44, 0x10, 0x61, 0x30, 0xC1, 0x06, 0x83,
  0x04, 0x1A, 0x08, 0x10, 0x70, 0x20, 0xC1, 0xC0, 0x82, 0x06, 0x06, 0x00,
  0x06, 0x00, 0xC1, 0x80, 0x20, 0x70, 0x08, 0x1C, 0x02, 0x05, 0x01, 0x83,
  0x40, 0x40, 0xD0, 0x10, 0x24, 0x04, 0x09, 0x83, 0x02, 0x20, 0xC1, 0x88,
  0x20, 0x42, 0x08, 0x10, 0x82, 0x04, 0x31, 0x83, 0x0C, 0x60, 0xC1, 0x10,
  0x20, 0x44, 0x08, 0x11, 0x02, 0x04, 0xC1, 0x81, 0xA0, 0x60, 0x68, 0x10,
  0x0A, 0x04, 0x02, 0x81, 0x00, 0xE0, 0xC0, 0x30, 0x30, 0x0C, 0x00, 0x00,
  0xF0, 0x06, 0x30, 0x18, 0x30, 0x60, 0x20, 0x80, 0x63, 0x00, 0xC4, 0x01,
  0x98, 0x03, 0x20, 0x06, 0x40, 0x0D, 0x80, 0x13, 0x00, 0x24, 0x00, 0x48,
  0x00, 0x90, 0x03, 0x60, 0x06, 0xC0, 0x09, 0x80, 0x13, 0x00, 0x66, 0x00,
  0x8C, 0x03, 0x18, 0x04, 0x10, 0x18, 0x20, 0x60, 0x61, 0x80, 0x7E, 0x00,
  0x07, 0xC0, 0x1F, 0xC0, 0x41, 0x81, 0x02, 0x04, 0x08, 0x30, 0x30, 0xC0,
  0xC2, 0x02, 0x08, 0x08, 0x20, 0x21, 0x81, 0x84, 0x04, 0x10, 0x20, 0x43,
  0x03, 0xF8, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xF0,
  0x06, 0x30, 0x18, 0x30, 0x60, 0x20, 0x80, 0x63, 0x00, 0xC4, 0x01, 0x98,
  0x03, 0x20, 0x06, 0x40, 0x0D, 0x80, 0x13, 0x00, 0x24, 0x00, 0x48, 0x00,
  0x90, 0x03, 0x60, 0x06, 0xC0, 0x09, 0x80, 0x13, 0x00, 0x66, 0x00, 0x8C,
  0x03, 0x18, 0x04, 0x10, 0x18, 0x20, 0x60, 0x61, 0x80, 0x7E, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x07, 0xC0,
  0x1F, 0xC0, 0x41, 0x81, 0x02, 0x04, 0x08, 0x30, 0x30, 0xC0, 0xC2, 0x02,
  0x08, 0x08, 0x20, 0x61, 0x81, 0x86, 0x0C, 0x10, 0x60, 0x7F, 0x03, 0xF0,
  0x0C, 0x40, 0x21, 0x00, 0x86, 0x02, 0x18, 0x18, 0x20, 0x60, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x30, 0xC0, 0xC3, 0x01, 0x00, 0x01, 0xF8, 0x06, 0x1C,
  0x18, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x81, 0x81, 0xFE, 0x00, 0x7F, 0xF7, 0xFE,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0x0C, 0x02, 0x10, 0x04, 0x20, 0x08, 0x40, 0x31, 0x80, 0x43, 0x00, 0x84,
  0x01, 0x08, 0x06, 0x10, 0x0C, 0x60, 0x10, 0xC0, 0x21, 0x00, 0x42, 0x01,
  0x84, 0x02, 0x18, 0x04, 0x20, 0x08, 0x40, 0x30, 0x80, 0x63, 0x00, 0x86,
  0x01, 0x0C, 0x06, 0x10, 0x08, 0x30, 0x10, 0x60, 0x60, 0x61, 0x80, 0x7E,
  0x00, 0x80, 0x1C, 0x00, 0xA0, 0x0D, 0x00, 0x48, 0x06, 0x40, 0x22, 0x01,
  0x10, 0x18, 0x80, 0x84, 0x0C, 0x20, 0x41, 0x06, 0x08, 0x30, 0x41, 0x02,
  0x18, 0x10, 0x80, 0x8C, 0x04, 0x40, 0x22, 0x01, 0x30, 0x09, 0x00, 0x58,
  0x02, 0x80, 0x14, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x80, 0x30, 0x0E, 0x00,
  0x80, 0x28, 0x06, 0x01, 0xA0, 0x18, 0x04, 0x80, 0x60, 0x32, 0x02, 0x80,
  0xC8, 0x0A, 0x02, 0x20, 0x68, 0x18, 0x81, 0x20, 0x42, 0x04, 0x83, 0x08,
  0x22, 0x0C, 0x20, 0x88, 0x20, 0x86, 0x21, 0x82, 0x10, 0x84, 0x08, 0x42,
  0x30, 0x23, 0x08, 0x80, 0x88, 0x22, 0x02, 0x60, 0x98, 0x09, 0x02, 0x40,
  0x24, 0x0B, 0x00, 0xB0, 0x28, 0x02, 0x80, 0xA0, 0x0E, 0x03, 0x80, 0x30,
  0x0C, 0x00, 0xC0, 0x70, 0x03, 0x01, 0x80, 0x00, 0x03, 0x03, 0x03, 0x02,
  0x03, 0x06, 0x01, 0x04, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x18, 0x01, 0x10,
  0x01, 0x20, 0x01, 0xA0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x02, 0x80, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x08, 0x40,
  0x10, 0x40, 0x30, 0x40, 0x20, 0x40, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x60,
  0x40, 0x34, 0x02, 0x40, 0x66, 0x04, 0x60, 0xC6, 0x08, 0x21, 0x82, 0x10,
  0x23, 0x02, 0x20, 0x26, 0x02, 0x40, 0x2C, 0x02, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x40, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x1F, 0xC0, 0x84, 0x21, 0x0C, 0x61,
  0x08, 0x42, 0x10, 0xC6, 0x10, 0x84, 0x21, 0x0C, 0x61, 0x08, 0x42, 0x10,
  0xC0, 0x03, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x1F, 0x80, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x09, 0x00,
  0xC8, 0x04, 0x60, 0x61, 0x02, 0x0C, 0x30, 0x21, 0x01, 0x18, 0x0C, 0x80,
  0x28, 0x01, 0x80, 0xFF, 0xC0, 0xC4, 0x22, 0x10, 0x07, 0xD8, 0x62, 0x86,
  0x0C, 0x60, 0x62, 0x03, 0x10, 0x19, 0x80, 0x88, 0x04, 0x40, 0x26, 0x03,
  0x30, 0x11, 0x80, 0x88, 0x04, 0x40, 0x62, 0x03, 0x10, 0x30, 0xC1, 0x82,
  0x14, 0x1F, 0x20, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x09, 0xF0, 0x50, 0x83, 0x06, 0x38, 0x31, 0x81,
  0x8C, 0x0C, 0x40, 0x62, 0x03, 0x30, 0x11, 0x00, 0x88, 0x04, 0x40, 0x62,
  0x03, 0x30, 0x11, 0x81, 0x8C, 0x08, 0x60, 0xC7, 0x8C, 0x27, 0xC0, 0x07,
  0xC3, 0x01, 0x80, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x10, 0x07, 0xE0, 0x00,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x07, 0xD8, 0x31, 0x41, 0x83, 0x0C, 0x0C, 0x20, 0x30, 0x80, 0x86,
  0x02, 0x10, 0x08, 0x40, 0x23, 0x01, 0x8C, 0x04, 0x30, 0x10, 0x80, 0x42,
  0x03, 0x08, 0x0C, 0x20, 0x60, 0xC1, 0x81, 0x0A, 0x07, 0xC8, 0x00, 0x07,
  0xC1, 0x88, 0x61, 0x18, 0x32, 0x04, 0xC0, 0x90, 0x32, 0x0C, 0xC7, 0x1F,
  0x83, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x20,
  0xFC, 0x00, 0x00, 0x02, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x01, 0xF8, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0xF0, 0x00, 0x60, 0x00, 0x01, 0xF6, 0x06, 0x28, 0x18, 0x30, 0x60, 0x60,
  0x80, 0xC1, 0x01, 0x06, 0x02, 0x08, 0x04, 0x10, 0x18, 0x60, 0x30, 0xC0,
  0x41, 0x80, 0x82, 0x03, 0x04, 0x06, 0x08, 0x0C, 0x10, 0x30, 0x30, 0x60,
  0x21, 0x40, 0x7D, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x81, 0x02, 0x03, 0xF8, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x09, 0xE0, 0xA3,
  0x0C, 0x11, 0x81, 0x18, 0x11, 0x81, 0x10, 0x31, 0x02, 0x30, 0x23, 0x02,
  0x20, 0x62, 0x06, 0x20, 0x46, 0x04, 0x40, 0x44, 0x0C, 0x40, 0xC4, 0x08,
  0xC0, 0x80, 0x02, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x06, 0x08, 0x10, 0x60,
  0xC1, 0x02, 0x04, 0x18, 0x30, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0xC1,
  0x80, 0x00, 0x10, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x18, 0x0F, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x10, 0x82, 0x08, 0x61, 0x8C,
  0x18, 0x81, 0x10, 0x13, 0x01, 0x60, 0x36, 0x02, 0xA0, 0x32, 0x02, 0x30,
  0x23, 0x06, 0x10, 0x41, 0x04, 0x10, 0x41, 0x0C, 0x18, 0xC1, 0x80, 0x02,
  0x04, 0x18, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x82, 0x04,
  0x08, 0x30, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x00, 0x0B,
  0xE7, 0xC1, 0x47, 0x8C, 0x30, 0x60, 0x8C, 0x08, 0x11, 0x83, 0x02, 0x20,
  0x60, 0xC4, 0x08, 0x10, 0x81, 0x02, 0x30, 0x20, 0x46, 0x0C, 0x18, 0x81,
  0x83, 0x10, 0x20, 0x42, 0x04, 0x08, 0xC0, 0x81, 0x10, 0x30, 0x62, 0x04,
  0x0C, 0x40, 0x81, 0x18, 0x10, 0x23, 0x06, 0x04, 0x00, 0x09, 0xE0, 0xA3,
  0x0C, 0x11, 0x81, 0x18, 0x11, 0x83, 0x10, 0x31, 0x02, 0x30, 0x23, 0x02,
  0x20, 0x62, 0x06, 0x20, 0x46, 0x04, 0x40, 0x44, 0x0C, 0x40, 0xCC, 0x08,
  0xC0, 0x80, 0x07, 0xC1, 0x0C, 0x40, 0x98, 0x12, 0x02, 0xC0, 0x58, 0x0A,
  0x01, 0x40, 0x38, 0x0F, 0x01, 0xC0, 0x28, 0x05, 0x01, 0xA0, 0x24, 0x0C,
  0xC1, 0x08, 0x61, 0xF8, 0x00, 0x02, 0x7C, 0x05, 0x08, 0x0C, 0x18, 0x38,
  0x30, 0x60, 0x60, 0xC0, 0xC1, 0x01, 0x82, 0x03, 0x0C, 0x06, 0x18, 0x08,
  0x20, 0x10, 0x40, 0x20, 0x80, 0xC3, 0x01, 0x06, 0x06, 0x0C, 0x08, 0x18,
  0x30, 0x38, 0xC0, 0xDF, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x00, 0x07, 0xD8, 0x62, 0x86,
  0x0C, 0x60, 0x62, 0x03, 0x10, 0x19, 0x80, 0x88, 0x04, 0x40, 0x26, 0x03,
  0x30, 0x11, 0x80, 0x88, 0x04, 0x40, 0x62, 0x03, 0x10, 0x30, 0xC1, 0x82,
  0x14, 0x1F, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x09, 0xC2, 0x80, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00,
  0x40, 0x30, 0x0C, 0x00, 0x07, 0xF0, 0xC2, 0x18, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x08, 0x30, 0xFE, 0x00, 0x08, 0x10, 0x20,
  0xC1, 0x0F, 0xC4, 0x18, 0x30, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x41,
  0x82, 0x04, 0x08, 0x10, 0x20, 0x78, 0x10, 0x31, 0x03, 0x10, 0x23, 0x02,
  0x30, 0x22, 0x06, 0x20, 0x62, 0x04, 0x60, 0x44, 0x04, 0x40, 0xC4, 0x0C,
  0xC0, 0x8C, 0x08, 0x81, 0x88, 0x18, 0x83, 0x0C, 0x70, 0x7D, 0x00, 0x80,
  0xE0, 0x28, 0x0A, 0x04, 0x81, 0x20, 0xC8, 0x22, 0x18, 0x84, 0x23, 0x08,
  0x82, 0x20, 0x98, 0x24, 0x0B, 0x02, 0x80, 0xA0, 0x30, 0x0C, 0x00, 0x80,
  0x81, 0xC0, 0xC0, 0xA0, 0x60, 0x50, 0x30, 0x48, 0x28, 0x24, 0x14, 0x32,
  0x1A, 0x11, 0x09, 0x08, 0x84, 0x88, 0x44, 0x44, 0x22, 0x26, 0x13, 0x12,
  0x09, 0x09, 0x04, 0x85, 0x02, 0x82, 0x81, 0x41, 0x40, 0xE0, 0xC0, 0x60,
  0x60, 0x30, 0x30, 0x00, 0x04, 0x0C, 0x10, 0x20, 0x61, 0x00, 0x8C, 0x02,
  0x20, 0x09, 0x00, 0x24, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x60, 0x0D, 0x80, 0x22, 0x01, 0x88, 0x04, 0x20, 0x20, 0xC1, 0x83, 0x0C,
  0x04, 0x00, 0x01, 0x01, 0x80, 0x80, 0x80, 0x40, 0xC0, 0x20, 0x40, 0x10,
  0x60, 0x08, 0x20, 0x04, 0x10, 0x02, 0x10, 0x01, 0x08, 0x00, 0x8C, 0x00,
  0x44, 0x00, 0x26, 0x00, 0x12, 0x00, 0x0B, 0x00, 0x05, 0x00, 0x02, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x3E, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0xE0, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x40, 0x18, 0x03, 0xF8, 0x00, 0x00, 0x18, 0x07, 0x80, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x1E, 0x00, 0xE0, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xF0, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x07, 0x00, 0xF0, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0xF0,
  0x08, 0x00, 0x7C, 0x0E, 0x19, 0xA0, 0x38,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 26, 8, 0, -26 },
  { 27, 8, 10, 10, 3, -26 },
  { 37, 14, 26, 14, 0, -26 },
  { 83, 13, 29, 13, 0, -27 },
  { 131, 16, 26, 19, 2, -26 },
  { 183, 12, 26, 12, 0, -26 },
  { 222, 4, 10, 5, 3, -26 },
  { 227, 10, 32, 9, 1, -26 },
  { 267, 10, 32, 9, -3, -26 },
  { 307, 9, 10, 12, 4, -27 },
  { 319, 13, 17, 15, 1, -21 },
  { 347, 4, 8, 6, -1, -3 },
  { 351, 8, 1, 9, 1, -10 },
  { 352, 2, 3, 6, 1, -3 },
  { 353, 15, 26, 11, -2, -26 },
  { 402, 12, 26, 13, 1, -26 },
  { 441, 7, 26, 13, 4, -26 },
  { 464, 14, 26, 13, -1, -26 },
  { 510, 14, 26, 13, -1, -26 },
  { 556, 14, 26, 13, -1, -26 },
  { 602, 14, 26, 13, -1, -26 },
  { 648, 13, 26, 13, 1, -26 },
  { 691, 13, 26, 13, 1, -26 },
  { 734, 13, 26, 13, 0, -26 },
  { 777, 12, 26, 13, 0, -26 },
  { 816, 6, 19, 6, 0, -19 },
  { 831, 8, 24, 6, -2, -19 },
  { 855, 13, 15, 15, 1, -20 },
  { 880, 13, 9, 15, 1, -17 },
  { 895, 13, 15, 15, 1, -20 },
  { 920, 11, 26, 9, 0, -26 },
  { 956, 17, 29, 19, 1, -26 },
  { 1018, 12, 26, 12, -2, -26 },
  { 1057, 14, 26, 14, 0, -26 },
  { 1103, 14, 26, 12, 1, -26 },
  { 1149, 15, 26, 15, 0, -26 },
  { 1198, 14, 26, 12, 0, -26 },
  { 1244, 14, 26, 11, 0, -26 },
  { 1290, 16, 26, 17, 1, -26 },
  { 1342, 17, 26, 16, 0, -26 },
  { 1398, 11, 26, 7, -2, -26 },
  { 1434, 12, 32, 6, -5, -26 },
  { 1482, 16, 26, 13, 0, -26 },
  { 1534, 8, 26, 11, 0, -26 },
  { 1560, 22, 26, 22, 0, -26 },
  { 1632, 18, 26, 17, 0, -26 },
  { 1691, 15, 26, 16, 1, -26 },
  { 1740, 14, 26, 13, 0, -26 },
  { 1786, 15, 32, 16, 1, -26 },
  { 1846, 14, 26, 13, 0, -26 },
  { 1892, 15, 26, 13, -1, -26 },
  { 1941, 12, 26, 11, 2, -26 },
  { 1980, 15, 26, 16, 1, -26 },
  { 2029, 13, 26, 13, 3, -26 },
  { 2072, 22, 26, 22, 3, -26 },
  { 2144, 16, 26, 11, -2, -26 },
  { 2196, 12, 26, 11, 2, -26 },
  { 2235, 15, 26, 11, -2, -26 },
  { 2284, 13, 32, 10, -1, -26 },
  { 2336, 5, 26, 12, 4, -26 },
  { 2353, 13, 32, 10, -2, -26 },
  { 2405, 13, 13, 14, 1, -26 },
  { 2427, 10, 1, 10, -3, 3 },
  { 2429, 4, 5, 8, 5, -27 },
  { 2432, 13, 19, 14, 1, -19 },
  { 2463, 13, 27, 14, 0, -27 },
  { 2507, 10, 19, 10, 1, -19 },
  { 2531, 14, 27, 14, 1, -27 },
  { 2579, 11, 19, 12, 1, -19 },
  { 2606, 16, 37, 7, -5, -28 },
  { 2680, 15, 28, 14, -1, -19 },
  { 2733, 12, 27, 13, 0, -27 },
  { 2774, 7, 26, 6, 0, -26 },
  { 2797, 12, 35, 6, -5, -26 },
  { 2850, 12, 27, 11, 0, -27 },
  { 2891, 7, 27, 6, 0, -27 },
  { 2915, 19, 19, 20, 0, -19 },
  { 2961, 12, 19, 13, 0, -19 },
  { 2990, 11, 19, 13, 1, -19 },
  { 3017, 15, 27, 14, -2, -19 },
  { 3068, 13, 27, 14, 1, -19 },
  { 3112, 10, 19, 9, 0, -19 },
  { 3136, 12, 19, 10, -1, -19 },
  { 3165, 7, 24, 7, 1, -24 },
  { 3186, 12, 19, 13, 1, -19 },
  { 3215, 10, 19, 10, 2, -19 },
  { 3239, 17, 19, 17, 2, -19 },
  { 3280, 14, 19, 11, -2, -19 },
  { 3314, 17, 28, 11, -4, -19 },
  { 3374, 11, 19, 9, -1, -19 },
  { 3401, 13, 32, 11, 1, -26 },
  { 3453, 1, 36, 13, 6, -27 },
  { 3458, 12, 32, 11, -2, -26 },
  { 3506, 13, 3, 15, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC36PT7B_H_
