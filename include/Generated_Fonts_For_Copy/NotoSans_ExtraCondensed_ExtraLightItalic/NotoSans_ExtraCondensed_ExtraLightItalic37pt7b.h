#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC37PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x30, 0x40, 0x81,
  0x06, 0x0C, 0x10, 0x20, 0x41, 0x82, 0x00, 0x00, 0x00, 0x60, 0xC1, 0x00,
  0x62, 0x85, 0x1A, 0x2C, 0x50, 0xA1, 0x44, 0x88, 0x00, 0x86, 0x01, 0x08,
  0x06, 0x30, 0x08, 0x40, 0x10, 0x80, 0x63, 0x00, 0x84, 0x0F, 0xFF, 0x06,
  0x10, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x86, 0x01, 0x08, 0x02, 0x10,
  0x0C, 0x60, 0xFF, 0xF0, 0x21, 0x00, 0xC6, 0x01, 0x08, 0x02, 0x10, 0x0C,
  0x60, 0x10, 0x80, 0x21, 0x00, 0x42, 0x01, 0x08, 0x00, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0xFE, 0x06, 0x5C, 0x22, 0x01, 0x88, 0x06, 0x20, 0x10,
  0x80, 0x46, 0x01, 0x90, 0x02, 0x40, 0x0D, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x02, 0x80, 0x0B, 0x00, 0x26, 0x01, 0x18, 0x04, 0x60, 0x11, 0x80,
  0x44, 0x01, 0x10, 0x88, 0x83, 0xFC, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x0E, 0x00, 0x1B, 0x02, 0x31, 0x04, 0x21, 0x04, 0x61, 0x08,
  0x41, 0x08, 0x43, 0x10, 0xC3, 0x10, 0x82, 0x20, 0x82, 0x20, 0x82, 0x40,
  0x86, 0x4F, 0x84, 0x99, 0x84, 0x91, 0x89, 0x21, 0xD9, 0x21, 0x62, 0x61,
  0x02, 0x41, 0x04, 0x41, 0x04, 0x41, 0x08, 0xC3, 0x08, 0xC2, 0x10, 0xC2,
  0x10, 0xC6, 0x20, 0xC4, 0x20, 0xCC, 0x40, 0x78, 0x01, 0xC0, 0x36, 0x06,
  0x20, 0x42, 0x04, 0x20, 0xC2, 0x0C, 0x60, 0xC4, 0x0C, 0x40, 0xCC, 0x05,
  0x80, 0x70, 0x06, 0x00, 0xE0, 0x1A, 0x03, 0x20, 0x23, 0x34, 0x33, 0xC1,
  0x28, 0x16, 0x81, 0xC8, 0x0C, 0x80, 0x88, 0x18, 0x81, 0xCC, 0x64, 0x7C,
  0x40, 0x69, 0x2D, 0x24, 0x80, 0x00, 0xC0, 0x60, 0x10, 0x08, 0x06, 0x03,
  0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x30, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01,
  0x00, 0x60, 0x08, 0x06, 0x00, 0x04, 0x01, 0x08, 0x43, 0x90, 0x37, 0xC3,
  0x01, 0x40, 0x98, 0x42, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x11, 0x32,
  0x64, 0x48, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x3E, 0x04, 0x30, 0xC3, 0x08, 0x11, 0x01, 0x10, 0x13, 0x03, 0x20, 0x32,
  0x03, 0x60, 0x34, 0x02, 0x40, 0x24, 0x02, 0xC0, 0x6C, 0x06, 0xC0, 0x68,
  0x04, 0x80, 0x48, 0x0C, 0x80, 0x88, 0x08, 0x81, 0x08, 0x10, 0x82, 0x0C,
  0x60, 0x7C, 0x00, 0x0E, 0x3C, 0xD3, 0x2C, 0x41, 0x83, 0x04, 0x08, 0x30,
  0x60, 0x81, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20,
  0xC1, 0x80, 0x01, 0xE0, 0x1F, 0xE0, 0x40, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xE0, 0x1E, 0xE0, 0x40, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x1E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC2, 0x06, 0x0F,
  0xF0, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x0F, 0x00, 0x28, 0x01,
  0x20, 0x04, 0x80, 0x26, 0x01, 0x98, 0x04, 0x40, 0x21, 0x00, 0x8C, 0x04,
  0x30, 0x30, 0x80, 0x82, 0x04, 0x08, 0x30, 0x60, 0x81, 0x86, 0x04, 0x10,
  0x12, 0xFF, 0xF0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x03, 0xFC, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0xF8, 0x07, 0xF0, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x30, 0x81, 0x83, 0xFC, 0x00,
  0x00, 0x78, 0x0E, 0xC1, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xDF, 0x05, 0x8C, 0x30, 0x23, 0x81,
  0x98, 0x0C, 0xC0, 0x64, 0x03, 0x20, 0x19, 0x00, 0x88, 0x04, 0x40, 0x62,
  0x03, 0x10, 0x10, 0xC1, 0x82, 0x18, 0x0F, 0x80, 0x3F, 0xF8, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x83, 0x06, 0x10, 0x11, 0x80, 0x8C,
  0x04, 0x60, 0x23, 0x01, 0x18, 0x18, 0x40, 0x83, 0x08, 0x08, 0x80, 0x78,
  0x03, 0x80, 0x76, 0x06, 0x18, 0x60, 0x42, 0x03, 0x30, 0x19, 0x00, 0x48,
  0x02, 0x40, 0x12, 0x01, 0x90, 0x08, 0xC0, 0xC3, 0x0C, 0x0F, 0xC0, 0x01,
  0xC0, 0x3F, 0x81, 0x04, 0x10, 0x31, 0x81, 0x88, 0x0C, 0x40, 0x66, 0x03,
  0x30, 0x19, 0x00, 0xC8, 0x06, 0x40, 0x22, 0x03, 0x18, 0x18, 0xC1, 0x43,
  0xF6, 0x06, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x3F, 0x00, 0x08, 0x30, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x0C, 0x30, 0x01, 0x03,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x18, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0x80, 0x00,
  0x08, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x30, 0x07, 0x00, 0xE0,
  0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x10, 0x00, 0x07, 0x83, 0xF8, 0x41,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x01,
  0x80, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x3F, 0x80, 0x18, 0x10, 0x08, 0x02, 0x04, 0x00, 0x83, 0x00, 0x30,
  0x80, 0x0C, 0x40, 0x01, 0x10, 0x7C, 0x48, 0x32, 0x12, 0x18, 0x8D, 0x84,
  0x63, 0x42, 0x10, 0x90, 0x84, 0x24, 0x61, 0x09, 0x10, 0xC2, 0xC4, 0x21,
  0xA1, 0x08, 0x48, 0x46, 0x12, 0x11, 0x88, 0x84, 0x62, 0x21, 0xEF, 0x08,
  0x31, 0x82, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x40, 0x07, 0xE0, 0x00, 0x00, 0x30, 0x03, 0x00, 0x30, 0x05,
  0x00, 0x50, 0x0D, 0x00, 0x90, 0x09, 0x01, 0x10, 0x11, 0x03, 0x10, 0x21,
  0x06, 0x10, 0x41, 0x04, 0x10, 0xC1, 0x0F, 0xF1, 0x81, 0x18, 0x11, 0x01,
  0x30, 0x12, 0x01, 0x60, 0x14, 0x01, 0x40, 0x1C, 0x01, 0x80, 0x10, 0x07,
  0xF8, 0x18, 0x30, 0x40, 0x41, 0x01, 0x04, 0x04, 0x30, 0x10, 0xC0, 0x42,
  0x03, 0x08, 0x0C, 0x20, 0x61, 0x83, 0x07, 0xF8, 0x1F, 0xC0, 0x41, 0x81,
  0x03, 0x0C, 0x04, 0x30, 0x10, 0x80, 0x42, 0x01, 0x18, 0x04, 0x60, 0x31,
  0x00, 0x84, 0x06, 0x10, 0x30, 0xC3, 0x83, 0xFC, 0x00, 0x00, 0x78, 0x03,
  0xDC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x61, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x0C, 0x30, 0x10, 0x30, 0x20, 0x20, 0x40, 0x61, 0x80, 0xC3,
  0x01, 0x84, 0x03, 0x08, 0x06, 0x10, 0x0C, 0x60, 0x18, 0xC0, 0x31, 0x00,
  0x42, 0x00, 0x8C, 0x01, 0x18, 0x06, 0x20, 0x0C, 0x40, 0x10, 0x80, 0x63,
  0x00, 0x86, 0x03, 0x08, 0x0C, 0x10, 0x10, 0x20, 0xE0, 0xC7, 0x01, 0xF8,
  0x00, 0x07, 0xFC, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x07, 0xF8, 0x1F, 0xE0,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x7F, 0x83,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0xFF, 0xC0, 0xC0, 0x40, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x01, 0xF0, 0x80, 0x08, 0xC0, 0x0C, 0x60, 0x06, 0x30,
  0x02, 0x18, 0x01, 0x0C, 0x00, 0x86, 0x00, 0xC1, 0x00, 0x60, 0xC0, 0x20,
  0x60, 0x10, 0x18, 0x08, 0x07, 0xFC, 0x00, 0x06, 0x00, 0x83, 0x00, 0xC1,
  0x00, 0x60, 0x80, 0x20, 0x40, 0x10, 0x60, 0x08, 0x30, 0x0C, 0x10, 0x04,
  0x08, 0x02, 0x04, 0x01, 0x06, 0x01, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0x80,
  0x20, 0xC0, 0x10, 0x60, 0x18, 0x20, 0x0C, 0x10, 0x04, 0x08, 0x02, 0x0C,
  0x01, 0x06, 0x01, 0x82, 0x00, 0xC1, 0x00, 0x40, 0x80, 0x20, 0xC0, 0x30,
  0x60, 0x18, 0x00, 0x07, 0xE0, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x1F, 0x80, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x18, 0x0F, 0x00, 0x40, 0x00, 0x06, 0x03, 0x06, 0x06, 0x04, 0x0C, 0x04,
  0x08, 0x04, 0x10, 0x0C, 0x30, 0x0C, 0x60, 0x08, 0x40, 0x08, 0xC0, 0x09,
  0x80, 0x1B, 0x00, 0x1A, 0x00, 0x17, 0x00, 0x19, 0x00, 0x39, 0x00, 0x31,
  0x00, 0x21, 0x80, 0x21, 0x80, 0x20, 0x80, 0x60, 0x80, 0x60, 0xC0, 0x40,
  0xC0, 0x40, 0xC0, 0x40, 0x40, 0xC0, 0x40, 0xC0, 0x60, 0x06, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00,
  0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80,
  0xC0, 0xFF, 0x80, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x18, 0x1C, 0x00, 0x70,
  0x28, 0x00, 0xA0, 0x50, 0x03, 0xC1, 0xA0, 0x05, 0x03, 0x40, 0x1A, 0x04,
  0x80, 0x24, 0x09, 0x00, 0xD8, 0x12, 0x01, 0x30, 0x64, 0x06, 0x40, 0xC8,
  0x08, 0x81, 0x10, 0x31, 0x02, 0x20, 0x46, 0x0C, 0x40, 0x8C, 0x18, 0x82,
  0x10, 0x21, 0x04, 0x20, 0x43, 0x18, 0x40, 0x86, 0x21, 0x83, 0x0C, 0xC3,
  0x06, 0x19, 0x04, 0x08, 0x36, 0x08, 0x10, 0x68, 0x30, 0x20, 0x70, 0x60,
  0xC0, 0xC0, 0x81, 0x81, 0x81, 0x00, 0x07, 0x00, 0xC1, 0xC0, 0x30, 0x50,
  0x08, 0x14, 0x02, 0x05, 0x00, 0x83, 0x40, 0x60, 0xD8, 0x18, 0x26, 0x04,
  0x08, 0x81, 0x02, 0x20, 0x41, 0x88, 0x30, 0x63, 0x08, 0x10, 0xC2, 0x04,
  0x10, 0x83, 0x04, 0x60, 0xC1, 0x18, 0x20, 0x44, 0x08, 0x19, 0x02, 0x06,
  0x41, 0x80, 0xB0, 0x60, 0x2C, 0x10, 0x0A, 0x04, 0x03, 0x81, 0x00, 0xE0,
  0xC0, 0x38, 0x30, 0x06, 0x00, 0x00, 0x70, 0x03, 0xF8, 0x08, 0x10, 0x20,
  0x30, 0xC0, 0x61, 0x00, 0x46, 0x00, 0x88, 0x01, 0x30, 0x02, 0x40, 0x04,
  0x80, 0x1B, 0x00, 0x36, 0x00, 0x68, 0x00, 0x90, 0x01, 0x20, 0x02, 0xC0,
  0x0D, 0x80, 0x1B, 0x00, 0x26, 0x00, 0xCC, 0x01, 0x98, 0x02, 0x30, 0x0C,
  0x20, 0x30, 0x60, 0x40, 0xC3, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x18, 0x60,
  0x40, 0xC1, 0x03, 0x04, 0x0C, 0x30, 0x30, 0xC0, 0xC2, 0x03, 0x08, 0x0C,
  0x20, 0x21, 0x81, 0x86, 0x04, 0x10, 0x60, 0x4F, 0x03, 0xF0, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x70, 0x03, 0xF8, 0x08, 0x10,
  0x20, 0x30, 0xC0, 0x61, 0x00, 0x46, 0x00, 0x88, 0x01, 0x30, 0x02, 0x40,
  0x04, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x68, 0x00, 0xD0, 0x01, 0x20, 0x02,
  0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x26, 0x00, 0xCC, 0x01, 0x98, 0x02, 0x30,
  0x0C, 0x20, 0x30, 0x60, 0x40, 0xC3, 0x00, 0xFC, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x07, 0xF0, 0x18, 0x60,
  0x40, 0x81, 0x03, 0x04, 0x0C, 0x30, 0x30, 0xC0, 0xC2, 0x03, 0x08, 0x08,
  0x20, 0x21, 0x81, 0x86, 0x0C, 0x10, 0x60, 0x7F, 0x03, 0x10, 0x0C, 0x40,
  0x21, 0x80, 0x86, 0x02, 0x08, 0x18, 0x20, 0x60, 0x81, 0x03, 0x04, 0x0C,
  0x10, 0x30, 0xC0, 0x43, 0x01, 0x00, 0x00, 0x70, 0x07, 0xFC, 0x18, 0x08,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x41, 0x03, 0x83, 0xFC, 0x00, 0x7F, 0xF0, 0x20,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0x0C, 0x03, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x18, 0x06, 0x18, 0x06,
  0x10, 0x04, 0x10, 0x04, 0x10, 0x0C, 0x30, 0x0C, 0x30, 0x08, 0x20, 0x08,
  0x20, 0x08, 0x20, 0x18, 0x60, 0x18, 0x60, 0x10, 0x40, 0x10, 0x40, 0x10,
  0xC0, 0x30, 0xC0, 0x20, 0xC0, 0x20, 0xC0, 0x60, 0xC0, 0x40, 0xC0, 0xC0,
  0x61, 0x80, 0x3F, 0x00, 0xC0, 0x1E, 0x00, 0xB0, 0x0D, 0x80, 0x4C, 0x02,
  0x60, 0x32, 0x01, 0x10, 0x18, 0x80, 0x84, 0x0C, 0x20, 0x41, 0x02, 0x08,
  0x30, 0x41, 0x02, 0x18, 0x10, 0x80, 0x8C, 0x04, 0x60, 0x22, 0x01, 0x30,
  0x09, 0x00, 0x58, 0x02, 0x80, 0x14, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x80,
  0x30, 0x0E, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xA0, 0x14, 0x06, 0x80, 0x50,
  0x12, 0x03, 0x40, 0xC8, 0x0B, 0x02, 0x20, 0x6C, 0x08, 0x81, 0x30, 0x62,
  0x04, 0xC1, 0x08, 0x33, 0x0C, 0x20, 0x8C, 0x20, 0x86, 0x30, 0x82, 0x10,
  0x86, 0x08, 0x42, 0x10, 0x23, 0x08, 0xC0, 0x88, 0x22, 0x02, 0x20, 0x88,
  0x09, 0x02, 0x60, 0x24, 0x09, 0x00, 0xB0, 0x2C, 0x02, 0x80, 0xA0, 0x0A,
  0x02, 0x80, 0x38, 0x0E, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x00, 0x03,
  0x03, 0x01, 0x02, 0x01, 0x06, 0x01, 0x04, 0x01, 0x0C, 0x01, 0x08, 0x01,
  0x18, 0x01, 0x90, 0x01, 0xA0, 0x01, 0xA0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0x40, 0x04, 0x40, 0x0C,
  0x40, 0x08, 0x40, 0x10, 0x40, 0x30, 0x40, 0x20, 0x40, 0x60, 0x60, 0x40,
  0x60, 0xC0, 0x60, 0x60, 0x36, 0x02, 0x60, 0x66, 0x04, 0x20, 0xC2, 0x08,
  0x21, 0x82, 0x10, 0x23, 0x02, 0x20, 0x26, 0x02, 0x40, 0x3C, 0x03, 0x80,
  0x38, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x03, 0xFF, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xFF, 0xE0, 0x01, 0xFC,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x3F, 0x80, 0x84, 0x21, 0x84, 0x21, 0x08, 0x42,
  0x18, 0xC2, 0x10, 0x84, 0x31, 0x8C, 0x21, 0x08, 0x43, 0x18, 0xC0, 0x03,
  0xF8, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x1F, 0x80, 0x03, 0x00, 0x1C, 0x01, 0xA0, 0x09, 0x00, 0x8C, 0x04,
  0x20, 0x41, 0x86, 0x04, 0x20, 0x33, 0x00, 0x90, 0x05, 0x80, 0x38, 0x00,
  0x80, 0xFF, 0xFF, 0xF0, 0xC4, 0x22, 0x11, 0x03, 0x88, 0x32, 0x42, 0x0E,
  0x30, 0x63, 0x03, 0x10, 0x18, 0x80, 0xCC, 0x06, 0x40, 0x22, 0x01, 0x30,
  0x09, 0x80, 0xCC, 0x06, 0x40, 0x22, 0x03, 0x18, 0x18, 0xC1, 0xC6, 0x0C,
  0x10, 0xA0, 0xF9, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0xE0, 0x59, 0x82, 0x86, 0x18, 0x11,
  0x80, 0x8C, 0x04, 0x60, 0x22, 0x01, 0x10, 0x09, 0x80, 0xC8, 0x06, 0x40,
  0x22, 0x01, 0x10, 0x19, 0x80, 0x8C, 0x04, 0x60, 0x63, 0x06, 0x34, 0x61,
  0x3E, 0x00, 0x03, 0xC3, 0x90, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x80,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x30,
  0x06, 0x20, 0xF8, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x03, 0x88, 0x0C, 0xB0, 0x20, 0xE0,
  0xC1, 0x83, 0x03, 0x04, 0x06, 0x08, 0x0C, 0x30, 0x18, 0x40, 0x20, 0x80,
  0x43, 0x00, 0x86, 0x03, 0x0C, 0x06, 0x10, 0x08, 0x20, 0x30, 0x60, 0x60,
  0xC1, 0xC1, 0x83, 0x01, 0x0A, 0x03, 0xE4, 0x00, 0x03, 0x81, 0xD8, 0x61,
  0x88, 0x13, 0x06, 0x40, 0xD8, 0x12, 0x06, 0x41, 0x9B, 0xC3, 0xE0, 0x60,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x84, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x17, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE2, 0x03, 0x24, 0x08,
  0x38, 0x30, 0x60, 0xC0, 0xC1, 0x01, 0x82, 0x03, 0x0C, 0x06, 0x10, 0x08,
  0x20, 0x10, 0xC0, 0x21, 0x80, 0xC3, 0x01, 0x84, 0x02, 0x08, 0x0C, 0x10,
  0x18, 0x30, 0x70, 0x60, 0xC0, 0x42, 0x80, 0xF9, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x07, 0x38, 0x03,
  0xC0, 0x00, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0xE0, 0x59, 0x83, 0x84, 0x18, 0x31, 0x81, 0x0C,
  0x08, 0x60, 0x42, 0x02, 0x10, 0x31, 0x81, 0x0C, 0x08, 0x40, 0x42, 0x06,
  0x10, 0x31, 0x81, 0x0C, 0x08, 0x40, 0x42, 0x06, 0x10, 0x31, 0x81, 0x00,
  0x02, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x82,
  0x04, 0x08, 0x30, 0x60, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x00,
  0x00, 0x10, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0xB0, 0x0E, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x18, 0x40, 0x82, 0x08,
  0x10, 0xC1, 0x8C, 0x0C, 0x40, 0x44, 0x02, 0x60, 0x16, 0x01, 0xF0, 0x0A,
  0x80, 0x66, 0x02, 0x30, 0x10, 0x81, 0x84, 0x08, 0x20, 0x41, 0x02, 0x0C,
  0x30, 0x61, 0x81, 0x00, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x0C,
  0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x18,
  0x20, 0x40, 0x83, 0x06, 0x00, 0x09, 0xE3, 0xC0, 0xB3, 0x66, 0x0C, 0x1C,
  0x30, 0xC1, 0x83, 0x18, 0x10, 0x31, 0x81, 0x02, 0x18, 0x30, 0x21, 0x03,
  0x02, 0x10, 0x20, 0x63, 0x02, 0x04, 0x30, 0x20, 0x42, 0x06, 0x04, 0x20,
  0x60, 0xC2, 0x04, 0x0C, 0x60, 0x40, 0x84, 0x04, 0x08, 0x40, 0xC0, 0x84,
  0x08, 0x18, 0xC0, 0x81, 0x8C, 0x08, 0x10, 0x08, 0xE0, 0x59, 0x83, 0x84,
  0x18, 0x31, 0x81, 0x0C, 0x08, 0x60, 0x42, 0x02, 0x10, 0x31, 0x81, 0x0C,
  0x08, 0x40, 0x42, 0x06, 0x10, 0x31, 0x81, 0x08, 0x08, 0x40, 0x42, 0x06,
  0x30, 0x31, 0x81, 0x00, 0x03, 0xC0, 0xEE, 0x18, 0x21, 0x02, 0x30, 0x32,
  0x03, 0x60, 0x36, 0x03, 0x40, 0x24, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x68,
  0x04, 0x80, 0x48, 0x0C, 0xC0, 0x8C, 0x18, 0x43, 0x07, 0xE0, 0x02, 0x38,
  0x05, 0x98, 0x0A, 0x18, 0x18, 0x10, 0x70, 0x20, 0xC0, 0x41, 0x80, 0x82,
  0x01, 0x04, 0x02, 0x18, 0x0C, 0x30, 0x18, 0x40, 0x20, 0x80, 0x41, 0x01,
  0x86, 0x03, 0x0C, 0x04, 0x18, 0x18, 0x30, 0x60, 0x51, 0x81, 0xBE, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x88, 0x76, 0x42, 0x0E, 0x20, 0x63, 0x03, 0x10,
  0x18, 0x80, 0xCC, 0x06, 0x40, 0x22, 0x01, 0x30, 0x09, 0x80, 0xCC, 0x06,
  0x40, 0x22, 0x03, 0x10, 0x18, 0xC1, 0xC6, 0x0C, 0x10, 0xA0, 0xF9, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x00, 0x08, 0xE1, 0x74, 0x38, 0x06, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x00, 0x03, 0xC0, 0xE7, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x83, 0x0F,
  0xE0, 0x08, 0x10, 0x20, 0xC1, 0xEF, 0xC4, 0x18, 0x30, 0x40, 0x81, 0x06,
  0x0C, 0x10, 0x20, 0x41, 0x82, 0x04, 0x08, 0x10, 0x20, 0x78, 0x18, 0x11,
  0x01, 0x10, 0x11, 0x03, 0x30, 0x23, 0x02, 0x20, 0x22, 0x06, 0x20, 0x66,
  0x04, 0x40, 0x44, 0x04, 0x40, 0xCC, 0x0C, 0xC0, 0x88, 0x18, 0x81, 0x88,
  0x38, 0xC7, 0x87, 0xD0, 0x80, 0x60, 0x38, 0x0A, 0x02, 0x81, 0xA0, 0x48,
  0x32, 0x08, 0x86, 0x21, 0x08, 0x42, 0x30, 0x88, 0x26, 0x09, 0x02, 0xC0,
  0xA0, 0x28, 0x0C, 0x03, 0x00, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x70, 0x78,
  0x28, 0x2C, 0x1C, 0x36, 0x16, 0x13, 0x0B, 0x09, 0x8D, 0x8C, 0xC4, 0xC4,
  0x62, 0x66, 0x22, 0x32, 0x11, 0x19, 0x09, 0x8D, 0x84, 0x86, 0x82, 0x42,
  0x41, 0x41, 0x40, 0xA0, 0xA0, 0x70, 0x70, 0x30, 0x30, 0x18, 0x18, 0x00,
  0x04, 0x04, 0x10, 0x30, 0x61, 0x80, 0x84, 0x02, 0x30, 0x08, 0x80, 0x26,
  0x00, 0xF0, 0x03, 0x80, 0x06, 0x00, 0x30, 0x00, 0xE0, 0x05, 0x80, 0x32,
  0x00, 0x88, 0x06, 0x20, 0x10, 0xC0, 0x83, 0x06, 0x04, 0x30, 0x10, 0x01,
  0x00, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x20, 0x60, 0x10, 0x20, 0x08, 0x30,
  0x04, 0x10, 0x02, 0x08, 0x01, 0x0C, 0x00, 0x84, 0x00, 0x46, 0x00, 0x22,
  0x00, 0x13, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x80, 0x01, 0x40, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x13, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xE1, 0xFC, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x7F, 0x00, 0x00, 0x78, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x60, 0x1C, 0x00, 0x70, 0x00, 0x80, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xE0, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xC0, 0x06, 0x00, 0x60, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x07, 0x00, 0xE0, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x70,
  0x0C, 0x00, 0x18, 0x0B, 0xF0, 0x60, 0xFD, 0x00, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 26, 8, 1, -26 },
  { 24, 7, 9, 10, 4, -26 },
  { 32, 15, 26, 14, 0, -26 },
  { 81, 14, 30, 13, 0, -28 },
  { 134, 16, 27, 20, 2, -27 },
  { 188, 12, 27, 13, 0, -27 },
  { 229, 3, 9, 6, 4, -26 },
  { 233, 10, 32, 9, 1, -26 },
  { 273, 11, 32, 9, -3, -26 },
  { 317, 10, 10, 12, 4, -28 },
  { 330, 13, 17, 15, 1, -22 },
  { 358, 4, 9, 6, -1, -4 },
  { 363, 8, 2, 10, 1, -11 },
  { 365, 2, 3, 6, 1, -3 },
  { 366, 16, 26, 11, -2, -26 },
  { 418, 12, 27, 13, 1, -27 },
  { 459, 7, 26, 13, 4, -26 },
  { 482, 14, 27, 13, -1, -27 },
  { 530, 14, 27, 13, -1, -27 },
  { 578, 14, 27, 13, -1, -27 },
  { 626, 14, 26, 13, -1, -26 },
  { 672, 13, 27, 13, 1, -27 },
  { 716, 13, 26, 13, 1, -26 },
  { 759, 13, 27, 13, 0, -27 },
  { 803, 13, 27, 13, 0, -27 },
  { 847, 6, 20, 6, 0, -20 },
  { 862, 8, 25, 6, -2, -20 },
  { 887, 13, 16, 15, 1, -21 },
  { 913, 13, 10, 15, 1, -18 },
  { 930, 13, 16, 15, 1, -21 },
  { 956, 11, 27, 9, 0, -27 },
  { 994, 18, 30, 19, 1, -27 },
  { 1062, 12, 27, 13, -2, -27 },
  { 1103, 14, 26, 14, 0, -26 },
  { 1149, 15, 27, 13, 1, -27 },
  { 1200, 15, 26, 16, 0, -26 },
  { 1249, 14, 26, 13, 0, -26 },
  { 1295, 14, 26, 12, 0, -26 },
  { 1341, 17, 27, 17, 1, -27 },
  { 1399, 17, 26, 17, 0, -26 },
  { 1455, 11, 26, 7, -2, -26 },
  { 1491, 12, 33, 6, -5, -26 },
  { 1541, 16, 26, 13, 0, -26 },
  { 1593, 9, 26, 11, 0, -26 },
  { 1623, 23, 26, 22, 0, -26 },
  { 1698, 18, 26, 17, 0, -26 },
  { 1757, 15, 27, 17, 1, -27 },
  { 1808, 14, 26, 13, 0, -26 },
  { 1854, 15, 33, 17, 1, -27 },
  { 1916, 14, 26, 14, 0, -26 },
  { 1962, 15, 27, 13, -1, -27 },
  { 2013, 12, 26, 11, 2, -26 },
  { 2052, 16, 26, 16, 1, -26 },
  { 2104, 13, 26, 13, 3, -26 },
  { 2147, 22, 26, 23, 3, -26 },
  { 2219, 16, 26, 12, -2, -26 },
  { 2271, 12, 26, 11, 2, -26 },
  { 2310, 16, 26, 12, -2, -26 },
  { 2362, 14, 32, 10, -1, -26 },
  { 2418, 5, 26, 12, 4, -26 },
  { 2435, 13, 32, 10, -2, -26 },
  { 2487, 13, 13, 15, 1, -26 },
  { 2509, 10, 2, 10, -3, 3 },
  { 2512, 4, 6, 8, 5, -28 },
  { 2515, 13, 20, 14, 1, -20 },
  { 2548, 13, 28, 14, 0, -28 },
  { 2594, 10, 20, 10, 1, -20 },
  { 2619, 15, 28, 14, 1, -28 },
  { 2672, 11, 20, 12, 1, -20 },
  { 2700, 17, 37, 7, -5, -28 },
  { 2779, 15, 29, 14, -1, -20 },
  { 2834, 13, 28, 14, 0, -28 },
  { 2880, 7, 27, 6, 0, -27 },
  { 2904, 12, 36, 6, -5, -27 },
  { 2958, 13, 28, 11, 0, -28 },
  { 3004, 7, 28, 6, 0, -28 },
  { 3029, 20, 20, 21, 0, -20 },
  { 3079, 13, 20, 14, 0, -20 },
  { 3112, 12, 20, 14, 1, -20 },
  { 3142, 15, 28, 14, -2, -20 },
  { 3195, 13, 29, 14, 1, -20 },
  { 3243, 11, 20, 9, 0, -20 },
  { 3271, 12, 20, 10, -1, -20 },
  { 3301, 7, 24, 7, 1, -24 },
  { 3322, 12, 20, 14, 1, -20 },
  { 3352, 10, 20, 11, 2, -20 },
  { 3377, 17, 20, 18, 2, -20 },
  { 3420, 14, 20, 11, -2, -20 },
  { 3455, 17, 29, 11, -4, -20 },
  { 3517, 11, 20, 9, -1, -20 },
  { 3545, 13, 32, 12, 1, -26 },
  { 3597, 1, 37, 13, 6, -28 },
  { 3602, 12, 32, 12, -2, -26 },
  { 3650, 13, 4, 15, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC37PT7B_H_
