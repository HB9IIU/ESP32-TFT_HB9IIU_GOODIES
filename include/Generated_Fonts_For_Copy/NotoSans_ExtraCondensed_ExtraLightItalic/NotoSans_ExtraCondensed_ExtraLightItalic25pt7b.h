#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC25PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x11, 0x08, 0x42, 0x11, 0x08, 0x42, 0x20, 0x00, 0x46,
  0x00, 0x25, 0x24, 0x92, 0x4A, 0x29, 0x00, 0x04, 0x41, 0x20, 0x48, 0x22,
  0x08, 0x8F, 0xF0, 0x90, 0x44, 0x12, 0x04, 0x82, 0x23, 0xFC, 0x24, 0x11,
  0x04, 0x81, 0x20, 0x88, 0x26, 0x00, 0x02, 0x01, 0x03, 0xE2, 0x52, 0x41,
  0x20, 0x90, 0x48, 0x18, 0x04, 0x03, 0x01, 0xC0, 0xA0, 0x90, 0x48, 0x24,
  0x94, 0x7C, 0x08, 0x04, 0x00, 0x18, 0x24, 0x89, 0x11, 0x22, 0x44, 0x49,
  0x12, 0x22, 0x44, 0x53, 0x8A, 0xB2, 0xA5, 0x94, 0x85, 0x10, 0xA2, 0x24,
  0x44, 0x89, 0x12, 0x22, 0x48, 0x70, 0x0E, 0x09, 0x11, 0x12, 0x12, 0x12,
  0x14, 0x18, 0x18, 0x28, 0x49, 0x49, 0x85, 0x86, 0x86, 0x84, 0x8A, 0xF2,
  0x29, 0x25, 0x20, 0x06, 0x08, 0x20, 0x82, 0x04, 0x10, 0x20, 0x41, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x08, 0x00, 0x04,
  0x08, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81,
  0x04, 0x08, 0x20, 0x41, 0x04, 0x18, 0x00, 0x10, 0x4D, 0x0F, 0x33, 0x40,
  0x80, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x25, 0x28, 0xF8, 0x70, 0x00, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x20, 0x00, 0x07, 0x04, 0x84, 0x22, 0x12, 0x09, 0x04, 0x82,
  0x82, 0x41, 0x20, 0x90, 0x48, 0x24, 0x24, 0x12, 0x08, 0x88, 0x4C, 0x3C,
  0x00, 0x13, 0x59, 0x12, 0x22, 0x24, 0x44, 0x44, 0x88, 0x88, 0x0F, 0x82,
  0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x3F, 0x80, 0x0F, 0x82, 0x30,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x04, 0x0E, 0x00, 0x80, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x3F, 0x00, 0x00, 0xC0, 0x30, 0x18,
  0x0A, 0x02, 0x81, 0x20, 0x48, 0x24, 0x11, 0x04, 0x42, 0x10, 0x84, 0x42,
  0x3F, 0xE0, 0x20, 0x08, 0x04, 0x01, 0x00, 0x07, 0xC2, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x01, 0x00, 0x70, 0x23, 0x00, 0x40, 0x10, 0x02, 0x01, 0x00,
  0x40, 0x10, 0x0C, 0x02, 0x3F, 0x00, 0x07, 0x18, 0x10, 0x20, 0x40, 0x40,
  0x40, 0xBC, 0xC6, 0xC2, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x88, 0x70,
  0x7F, 0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04,
  0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x00, 0x0F, 0x08, 0x48,
  0x24, 0x12, 0x09, 0x04, 0x44, 0x24, 0x0C, 0x1A, 0x10, 0x90, 0x48, 0x24,
  0x12, 0x09, 0x04, 0x86, 0x3E, 0x00, 0x0F, 0x08, 0x88, 0x24, 0x12, 0x0A,
  0x05, 0x02, 0x82, 0x41, 0x11, 0x8F, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08,
  0x08, 0x78, 0x00, 0x12, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x80, 0x08, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x42, 0x21, 0x10, 0x01, 0x06, 0x08, 0x30,
  0xC0, 0xC0, 0x30, 0x08, 0x06, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x03, 0x04, 0x18, 0x60, 0x80, 0x3C, 0x04,
  0x08, 0x10, 0x20, 0x41, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x00, 0x00,
  0x41, 0x80, 0x03, 0xC0, 0xC2, 0x10, 0x22, 0x01, 0x20, 0x14, 0x39, 0x44,
  0x94, 0x91, 0x89, 0x19, 0x12, 0x91, 0x29, 0x22, 0x92, 0x49, 0x64, 0x9D,
  0x88, 0x00, 0x80, 0x08, 0x00, 0x80, 0x07, 0xC0, 0x00, 0x80, 0xC0, 0x60,
  0x50, 0x28, 0x24, 0x12, 0x09, 0x08, 0x84, 0x47, 0xE2, 0x11, 0x09, 0x04,
  0x82, 0x81, 0x40, 0xE0, 0x40, 0x0F, 0x02, 0x21, 0x04, 0x41, 0x10, 0x44,
  0x22, 0x08, 0x84, 0x3E, 0x08, 0xC2, 0x11, 0x04, 0x41, 0x10, 0x44, 0x11,
  0x08, 0x86, 0x3E, 0x00, 0x07, 0xC2, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x40, 0x1F, 0x00, 0x0F, 0x02, 0x21, 0x04, 0x41, 0x10, 0x44, 0x12, 0x04,
  0x81, 0x20, 0x48, 0x12, 0x09, 0x02, 0x40, 0x90, 0x44, 0x11, 0x08, 0x84,
  0x3E, 0x00, 0x0F, 0xC2, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x3F, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x3F,
  0x00, 0x0F, 0xC2, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x0F, 0x82, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x00,
  0x07, 0xC1, 0x04, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x72, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x44, 0x08, 0x41, 0x07,
  0xE0, 0x08, 0x11, 0x02, 0x10, 0x21, 0x02, 0x10, 0x21, 0x04, 0x20, 0x42,
  0x04, 0x3F, 0xC2, 0x04, 0x20, 0x84, 0x08, 0x40, 0x84, 0x08, 0x40, 0x84,
  0x10, 0x81, 0x08, 0x10, 0x1E, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10,
  0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x41, 0xE0, 0x00, 0x80, 0x40, 0x40,
  0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x01, 0x07, 0x80, 0x08, 0x62, 0x08,
  0x42, 0x08, 0x81, 0x10, 0x24, 0x09, 0x01, 0x40, 0x28, 0x07, 0x00, 0x90,
  0x22, 0x04, 0x40, 0x88, 0x11, 0x02, 0x10, 0x82, 0x10, 0x40, 0x08, 0x41,
  0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x83, 0xF0,
  0x08, 0x02, 0x10, 0x0C, 0x60, 0x18, 0xC0, 0x51, 0x80, 0xC3, 0x02, 0x89,
  0x05, 0x12, 0x12, 0x24, 0x24, 0x48, 0x90, 0x91, 0x22, 0x22, 0x44, 0x48,
  0x88, 0x91, 0x11, 0x44, 0x22, 0x88, 0x86, 0x11, 0x0C, 0x20, 0x08, 0x10,
  0x81, 0x18, 0x11, 0x42, 0x14, 0x21, 0x42, 0x24, 0x22, 0x42, 0x22, 0x42,
  0x24, 0x22, 0x44, 0x24, 0x42, 0x44, 0x28, 0x41, 0x84, 0x18, 0x81, 0x88,
  0x10, 0x07, 0x86, 0x21, 0x04, 0x81, 0x20, 0x50, 0x14, 0x05, 0x01, 0x80,
  0x60, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x48, 0x12, 0x08, 0xC6, 0x1E, 0x00,
  0x0E, 0x04, 0xC4, 0x22, 0x11, 0x08, 0x84, 0x82, 0x41, 0x21, 0x13, 0x0E,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x00, 0x07, 0x86, 0x21,
  0x04, 0x81, 0x20, 0x50, 0x14, 0x05, 0x01, 0x80, 0x60, 0x28, 0x0A, 0x02,
  0x80, 0xA0, 0x48, 0x12, 0x08, 0xC6, 0x1E, 0x00, 0x80, 0x20, 0x08, 0x01,
  0x00, 0x0F, 0x04, 0xC4, 0x22, 0x11, 0x08, 0x84, 0x82, 0x41, 0x21, 0x1F,
  0x09, 0x08, 0x84, 0x42, 0x21, 0x10, 0x84, 0x82, 0x41, 0x00, 0x07, 0xC2,
  0x11, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x3F, 0x00, 0xFF, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x80, 0x80, 0x80, 0x10, 0x48, 0x12, 0x04, 0x81, 0x20, 0x88, 0x24, 0x09,
  0x02, 0x40, 0x90, 0x48, 0x12, 0x04, 0x81, 0x20, 0x88, 0x22, 0x08, 0x84,
  0x1E, 0x00, 0x80, 0xC0, 0xA0, 0x50, 0x68, 0x24, 0x12, 0x11, 0x08, 0x88,
  0x44, 0x22, 0x12, 0x09, 0x05, 0x02, 0x81, 0x80, 0xC0, 0x60, 0x00, 0x81,
  0x03, 0x02, 0x06, 0x0C, 0x14, 0x18, 0x28, 0x50, 0x90, 0xA1, 0x21, 0x42,
  0x44, 0x88, 0x89, 0x11, 0x22, 0x42, 0x44, 0x84, 0x89, 0x0A, 0x14, 0x14,
  0x28, 0x30, 0x60, 0x60, 0xC0, 0xC1, 0x81, 0x02, 0x00, 0x08, 0x21, 0x08,
  0x22, 0x04, 0x40, 0x90, 0x12, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30,
  0x0A, 0x01, 0x40, 0x44, 0x08, 0x82, 0x10, 0x82, 0x10, 0x40, 0x83, 0x82,
  0x84, 0x84, 0x88, 0x48, 0x50, 0x50, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x80, 0x0F, 0xC0, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x18, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x3F, 0x80, 0x0F, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80,
  0xF0, 0x92, 0x49, 0x22, 0x49, 0x24, 0x89, 0x24, 0x07, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x87, 0xC0, 0x08, 0x0A, 0x05,
  0x04, 0x82, 0x22, 0x11, 0x05, 0x02, 0x81, 0x00, 0xFE, 0xA5, 0x1F, 0x91,
  0x90, 0x48, 0x28, 0x14, 0x12, 0x09, 0x04, 0x82, 0x42, 0x21, 0x11, 0x8F,
  0x40, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x90, 0x74, 0x61, 0x30, 0x90,
  0x48, 0x24, 0x14, 0x0A, 0x09, 0x04, 0x82, 0x42, 0x63, 0x2F, 0x00, 0x1E,
  0x41, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x07, 0x00, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x21, 0xF0, 0x8C, 0x41, 0x10, 0x48,
  0x32, 0x08, 0x82, 0x20, 0x88, 0x22, 0x10, 0x84, 0x23, 0x0F, 0x40, 0x1E,
  0x45, 0x0A, 0x18, 0x51, 0x3C, 0x40, 0x81, 0x02, 0x04, 0x07, 0x80, 0x00,
  0xE0, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x03, 0xE0, 0x10, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0xC0, 0x00, 0x0F, 0x88,
  0xC8, 0x24, 0x14, 0x1A, 0x09, 0x04, 0x82, 0x41, 0x21, 0x10, 0x88, 0xC7,
  0xA0, 0x10, 0x10, 0x08, 0x04, 0x44, 0x3C, 0x00, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x1F, 0x11, 0x31, 0x21, 0x21, 0x21, 0x41, 0x42, 0x42, 0x42,
  0x42, 0x82, 0x84, 0x08, 0xC0, 0x00, 0x08, 0x44, 0x21, 0x08, 0x84, 0x21,
  0x08, 0x84, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0x02, 0x02, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x20, 0x20, 0xC0, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x84, 0x44, 0x44,
  0x22, 0x12, 0x0A, 0x07, 0x05, 0x83, 0x41, 0x20, 0x88, 0x44, 0x42, 0x21,
  0x00, 0x08, 0x42, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44,
  0x20, 0x1F, 0x78, 0x8C, 0x4C, 0x42, 0x42, 0x12, 0x10, 0x90, 0x85, 0x08,
  0x48, 0x42, 0x42, 0x12, 0x10, 0x90, 0x85, 0x08, 0x48, 0x42, 0x00, 0x1F,
  0x11, 0x31, 0x21, 0x21, 0x21, 0x41, 0x42, 0x42, 0x42, 0x42, 0x82, 0x84,
  0x1E, 0x22, 0x41, 0x41, 0x81, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x88,
  0x70, 0x0F, 0x85, 0x11, 0x84, 0x41, 0x10, 0x44, 0x12, 0x04, 0x82, 0x20,
  0x88, 0x22, 0x11, 0x8C, 0x5E, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x00, 0x1F, 0x23, 0x41, 0x41, 0x81, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84,
  0x8C, 0xF4, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x1E, 0x60, 0xC1, 0x02,
  0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x00, 0x3E, 0x41, 0x02, 0x02,
  0x04, 0x04, 0x04, 0x08, 0x10, 0x20, 0x4F, 0x00, 0x10, 0x84, 0xF2, 0x10,
  0x84, 0x22, 0x10, 0x84, 0x42, 0x0C, 0x21, 0x41, 0x42, 0x42, 0x42, 0x42,
  0x82, 0x84, 0x84, 0x84, 0x8C, 0x8C, 0xF8, 0x83, 0x06, 0x14, 0x28, 0x91,
  0x24, 0x48, 0x91, 0x42, 0x82, 0x04, 0x00, 0x82, 0x18, 0x62, 0x86, 0x28,
  0xA2, 0x8A, 0x48, 0xA4, 0x92, 0x89, 0x28, 0xA2, 0x8A, 0x30, 0xA3, 0x0C,
  0x20, 0xC2, 0x00, 0x10, 0x88, 0x84, 0x41, 0x40, 0xC0, 0x60, 0x20, 0x28,
  0x14, 0x12, 0x11, 0x08, 0x88, 0x20, 0x04, 0x10, 0x42, 0x04, 0x20, 0x44,
  0x04, 0x40, 0x48, 0x04, 0x80, 0x50, 0x05, 0x00, 0x50, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0xE0, 0x00, 0x1F,
  0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0xF8,
  0x03, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x60, 0xC0,
  0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x30, 0xFF, 0xFF,
  0xFF, 0x80, 0x06, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02,
  0x01, 0x00, 0xC0, 0x70, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x07, 0x00, 0x71, 0x8F,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 18, 5, 0, -18 },
  { 13, 6, 7, 7, 2, -18 },
  { 19, 10, 18, 9, 0, -18 },
  { 42, 9, 20, 9, 0, -19 },
  { 65, 11, 18, 13, 1, -18 },
  { 90, 8, 18, 9, 0, -18 },
  { 108, 3, 7, 4, 2, -18 },
  { 111, 7, 22, 6, 1, -18 },
  { 131, 7, 22, 6, -2, -18 },
  { 151, 6, 7, 8, 3, -19 },
  { 157, 8, 12, 10, 1, -15 },
  { 169, 3, 5, 4, -1, -2 },
  { 171, 5, 1, 7, 1, -7 },
  { 172, 2, 2, 4, 0, -2 },
  { 173, 10, 18, 8, -1, -18 },
  { 196, 9, 18, 9, 0, -18 },
  { 217, 4, 18, 9, 3, -18 },
  { 226, 10, 18, 9, -1, -18 },
  { 249, 10, 18, 9, -1, -18 },
  { 272, 10, 18, 9, -1, -18 },
  { 295, 10, 18, 9, -1, -18 },
  { 318, 8, 18, 9, 1, -18 },
  { 336, 9, 18, 9, 1, -18 },
  { 357, 9, 18, 9, 0, -18 },
  { 378, 9, 18, 9, 0, -18 },
  { 399, 4, 13, 4, 0, -13 },
  { 406, 5, 16, 4, -1, -13 },
  { 416, 8, 10, 10, 1, -14 },
  { 426, 8, 6, 10, 1, -12 },
  { 432, 8, 10, 10, 1, -14 },
  { 442, 7, 18, 6, 0, -18 },
  { 458, 12, 20, 13, 1, -18 },
  { 488, 9, 18, 9, -2, -18 },
  { 509, 10, 18, 10, 0, -18 },
  { 532, 10, 18, 9, 1, -18 },
  { 555, 10, 18, 11, 0, -18 },
  { 578, 10, 18, 9, 0, -18 },
  { 601, 10, 18, 8, 0, -18 },
  { 624, 11, 18, 12, 1, -18 },
  { 649, 12, 18, 11, 0, -18 },
  { 676, 7, 18, 5, -1, -18 },
  { 692, 9, 22, 4, -4, -18 },
  { 717, 11, 18, 9, 0, -18 },
  { 742, 6, 18, 8, 0, -18 },
  { 756, 15, 18, 15, 0, -18 },
  { 790, 12, 18, 12, 0, -18 },
  { 817, 10, 18, 11, 1, -18 },
  { 840, 9, 18, 9, 0, -18 },
  { 861, 10, 22, 11, 1, -18 },
  { 889, 9, 18, 9, 0, -18 },
  { 910, 10, 18, 9, -1, -18 },
  { 933, 8, 18, 8, 2, -18 },
  { 951, 10, 18, 11, 1, -18 },
  { 974, 9, 18, 9, 2, -18 },
  { 995, 15, 18, 15, 2, -18 },
  { 1029, 11, 18, 8, -1, -18 },
  { 1054, 8, 18, 8, 2, -18 },
  { 1072, 10, 18, 8, -1, -18 },
  { 1095, 8, 22, 7, 0, -18 },
  { 1117, 3, 18, 8, 3, -18 },
  { 1124, 9, 22, 7, -2, -18 },
  { 1149, 9, 9, 10, 1, -18 },
  { 1160, 7, 1, 7, -2, 2 },
  { 1161, 2, 4, 5, 4, -19 },
  { 1162, 9, 13, 10, 1, -13 },
  { 1177, 9, 19, 10, 0, -19 },
  { 1199, 7, 13, 7, 1, -13 },
  { 1211, 10, 19, 10, 1, -19 },
  { 1235, 7, 13, 8, 1, -13 },
  { 1247, 11, 25, 5, -3, -19 },
  { 1282, 9, 19, 10, 0, -13 },
  { 1304, 8, 19, 9, 0, -19 },
  { 1323, 5, 18, 4, 0, -18 },
  { 1335, 8, 24, 4, -3, -18 },
  { 1359, 9, 19, 8, 0, -19 },
  { 1381, 5, 19, 4, 0, -19 },
  { 1393, 13, 13, 14, 0, -13 },
  { 1415, 8, 13, 9, 0, -13 },
  { 1428, 8, 13, 9, 1, -13 },
  { 1441, 10, 19, 10, -1, -13 },
  { 1465, 8, 19, 10, 1, -13 },
  { 1484, 7, 13, 6, 0, -13 },
  { 1496, 7, 13, 7, 0, -13 },
  { 1508, 5, 16, 5, 0, -16 },
  { 1518, 8, 13, 9, 1, -13 },
  { 1531, 7, 13, 7, 1, -13 },
  { 1543, 12, 13, 12, 1, -13 },
  { 1563, 9, 13, 7, -1, -13 },
  { 1578, 12, 19, 8, -3, -13 },
  { 1607, 8, 13, 6, -1, -13 },
  { 1620, 8, 22, 8, 1, -18 },
  { 1642, 1, 25, 9, 4, -19 },
  { 1646, 9, 22, 8, -2, -18 },
  { 1671, 8, 2, 10, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC25PT7B_H_
