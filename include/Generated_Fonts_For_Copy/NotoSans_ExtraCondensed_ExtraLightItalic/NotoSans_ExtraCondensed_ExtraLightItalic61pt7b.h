#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC61PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x18, 0x38, 0xC1, 0x8E, 0x0C,
  0x70, 0x63, 0x07, 0x18, 0x38, 0xC1, 0x8E, 0x0C, 0x60, 0x63, 0x03, 0x18,
  0x30, 0xC1, 0x84, 0x0C, 0x60, 0x63, 0x02, 0x18, 0x30, 0x00, 0x03, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x38, 0x18, 0x00, 0x30, 0x38, 0x00, 0x30, 0x30,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60,
  0x00, 0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0,
  0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x03, 0x81, 0x80, 0x03, 0x03, 0x00,
  0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x06, 0x07, 0x00, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x0C, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x38, 0x18, 0x00,
  0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x60, 0x70, 0x00,
  0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x71, 0x86, 0x01, 0x82, 0x04, 0x07,
  0x04, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0,
  0x80, 0x01, 0x81, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0E, 0x18,
  0x00, 0x0C, 0x20, 0x00, 0x1C, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0x38, 0x00, 0x02, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x40, 0xC0, 0x00, 0x81, 0x80, 0x03,
  0x03, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x30, 0x00, 0x60,
  0xE0, 0x00, 0xC3, 0x80, 0x81, 0x8E, 0x01, 0xFB, 0xF8, 0x01, 0xFF, 0xE0,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF0, 0x01,
  0xC0, 0x7E, 0x00, 0x30, 0x18, 0x60, 0x0E, 0x06, 0x0C, 0x01, 0x81, 0xC1,
  0x80, 0x70, 0x30, 0x30, 0x0C, 0x06, 0x06, 0x03, 0x81, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x1C, 0x06, 0x03, 0x03, 0x01, 0x80, 0x60, 0xE0, 0x30, 0x0C,
  0x18, 0x06, 0x01, 0x87, 0x00, 0xC0, 0x70, 0xC0, 0x38, 0x0C, 0x38, 0x06,
  0x01, 0x86, 0x00, 0xC0, 0x31, 0xC0, 0x18, 0x0E, 0x30, 0x23, 0x01, 0x8E,
  0x3F, 0x60, 0x31, 0x8E, 0x7C, 0x0E, 0x71, 0x87, 0x81, 0x8C, 0x60, 0xF0,
  0x73, 0x9C, 0x1E, 0x0C, 0x63, 0x03, 0xE3, 0x1C, 0x60, 0x6F, 0xE3, 0x18,
  0x0C, 0xF0, 0xE3, 0x01, 0x80, 0x18, 0x60, 0x30, 0x07, 0x18, 0x06, 0x00,
  0xC3, 0x00, 0xC0, 0x38, 0x60, 0x18, 0x06, 0x0C, 0x07, 0x01, 0xC3, 0x80,
  0xC0, 0x30, 0x60, 0x18, 0x0E, 0x0C, 0x03, 0x01, 0x81, 0x80, 0xE0, 0x70,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x80, 0xC0, 0xC0, 0x60, 0x18, 0x18,
  0x1C, 0x03, 0x06, 0x03, 0x00, 0x60, 0xC0, 0xE0, 0x06, 0x70, 0x18, 0x00,
  0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0E,
  0x38, 0x00, 0x60, 0xC0, 0x07, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80,
  0x1C, 0x0C, 0x00, 0xE0, 0x60, 0x06, 0x03, 0x00, 0x30, 0x38, 0x01, 0x81,
  0x80, 0x0C, 0x0C, 0x00, 0x60, 0xE0, 0x03, 0x06, 0x00, 0x1C, 0x60, 0x00,
  0x67, 0x00, 0x03, 0x30, 0x00, 0x1B, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x77, 0x00, 0x07, 0x18, 0x00, 0x70,
  0xC0, 0xC3, 0x06, 0x0E, 0x38, 0x38, 0x63, 0x80, 0xC3, 0x18, 0x06, 0x39,
  0xC0, 0x31, 0x8E, 0x01, 0xCC, 0x60, 0x06, 0xE3, 0x00, 0x36, 0x38, 0x01,
  0xF1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0x83, 0x80, 0x1E, 0x0C,
  0x01, 0xB0, 0x60, 0x1D, 0x83, 0x81, 0xCC, 0x0F, 0xFC, 0x70, 0x3F, 0xC1,
  0x80, 0x20, 0x00, 0x00, 0x18, 0xCE, 0x73, 0x18, 0xC6, 0x63, 0x18, 0xC4,
  0x63, 0x18, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x41, 0x80, 0xF1, 0x80,
  0x39, 0x83, 0x0F, 0xBF, 0x03, 0xF0, 0x03, 0x80, 0x06, 0x80, 0x1C, 0xC0,
  0x38, 0x60, 0x70, 0x60, 0xE0, 0x30, 0x00, 0x38, 0x00, 0x10, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x0C, 0x38, 0x70, 0xC3, 0x86, 0x0C, 0x30, 0x61,
  0x83, 0x0C, 0x10, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x6E, 0xFE, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFE, 0x00,
  0x78, 0xE0, 0x06, 0x07, 0x00, 0xC0, 0x30, 0x1C, 0x03, 0x01, 0x80, 0x30,
  0x38, 0x03, 0x03, 0x00, 0x30, 0x70, 0x03, 0x06, 0x00, 0x30, 0xE0, 0x03,
  0x0C, 0x00, 0x30, 0xC0, 0x03, 0x1C, 0x00, 0x31, 0xC0, 0x03, 0x18, 0x00,
  0x71, 0x80, 0x07, 0x38, 0x00, 0x73, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00,
  0x06, 0x30, 0x00, 0x67, 0x00, 0x0E, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60,
  0x00, 0xC6, 0x00, 0x1C, 0x60, 0x01, 0xCE, 0x00, 0x18, 0xE0, 0x01, 0x8E,
  0x00, 0x38, 0xE0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x07, 0x0E, 0x00, 0x60,
  0xE0, 0x0E, 0x0E, 0x00, 0xC0, 0xE0, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x30,
  0x07, 0x07, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x1C, 0x0F, 0x83, 0xE0, 0xEC, 0x39, 0x9E, 0x37, 0x0E, 0xC1, 0x80,
  0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x60, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xC0, 0xE0, 0x06, 0x00, 0xE0,
  0x08, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x01, 0x00, 0x38,
  0x03, 0xE7, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x06,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x36, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98,
  0x00, 0x06, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x31, 0x80, 0x00, 0xC3, 0x00,
  0x03, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x38, 0x00, 0x30, 0x60, 0x00,
  0xC0, 0xC0, 0x03, 0x81, 0x80, 0x06, 0x07, 0x00, 0x18, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0x30, 0x03, 0x80, 0x60, 0x06, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x03, 0x80, 0x18, 0x06, 0x00, 0x70,
  0x18, 0x00, 0xC0, 0x70, 0x01, 0x80, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1B, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x60, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x01, 0x00, 0x38, 0x03, 0xEF, 0xE0, 0x07, 0xFF, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xE0, 0x40,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0xE0, 0x01, 0x9F, 0xF0, 0x0E, 0xF3, 0xE0, 0x37, 0x03,
  0x80, 0xD0, 0x07, 0x03, 0xC0, 0x1C, 0x1E, 0x00, 0x30, 0x70, 0x00, 0xC1,
  0xC0, 0x03, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80,
  0x03, 0x06, 0x00, 0x0C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x06,
  0x0E, 0x00, 0x18, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x01, 0x80, 0x0C, 0x06,
  0x00, 0x70, 0x18, 0x03, 0x80, 0x70, 0x0C, 0x00, 0xE0, 0xF0, 0x01, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xF0, 0x01, 0xE0, 0xF0, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x38,
  0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x80, 0x06, 0x07, 0x00,
  0x0C, 0x0E, 0x00, 0x18, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xC0, 0x30, 0x01,
  0x80, 0x60, 0x06, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x70, 0x01, 0xC1, 0xC0,
  0x01, 0x87, 0x00, 0x03, 0xBC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0xE3, 0x80, 0x07, 0x03, 0x00, 0x1C, 0x07, 0x00, 0x70,
  0x07, 0x01, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x0E, 0x00, 0x1C, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x30, 0xE0, 0x00, 0x61, 0xC0, 0x00, 0xC3, 0x80, 0x01,
  0x87, 0x00, 0x03, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x38, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00,
  0x3C, 0x38, 0x01, 0x80, 0xE0, 0x1C, 0x03, 0x01, 0xC0, 0x1C, 0x0C, 0x00,
  0x60, 0xE0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x80, 0x06, 0x18,
  0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x70, 0x00, 0x63, 0x80, 0x07,
  0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0xE1, 0xC0,
  0x07, 0x06, 0x00, 0x78, 0x30, 0x06, 0xC1, 0xC0, 0x7E, 0x07, 0x07, 0x60,
  0x1F, 0xF3, 0x00, 0x7E, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x3B, 0xF0, 0x01, 0xFF,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0xF0, 0x38, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0x83,
  0xC0, 0x80, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x30,
  0x00, 0x38, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x01, 0x86, 0x00, 0xFE, 0x0C, 0x30, 0x1E, 0x70, 0x63, 0x01,
  0xC3, 0x03, 0x18, 0x0C, 0x18, 0x19, 0xC0, 0xC0, 0xC0, 0xCC, 0x0E, 0x06,
  0x06, 0x60, 0x60, 0x60, 0x33, 0x07, 0x03, 0x03, 0x30, 0x30, 0x18, 0x19,
  0x81, 0x80, 0xC0, 0xCC, 0x1C, 0x0C, 0x06, 0x60, 0xC0, 0x60, 0x36, 0x06,
  0x03, 0x03, 0x30, 0x30, 0x38, 0x19, 0x81, 0x81, 0x80, 0xCC, 0x1C, 0x0C,
  0x0C, 0x60, 0xC0, 0xE0, 0x63, 0x06, 0x07, 0x03, 0x18, 0x30, 0x38, 0x30,
  0xC1, 0x83, 0xC1, 0x86, 0x0E, 0x16, 0x18, 0x30, 0x31, 0xB1, 0x81, 0x81,
  0xF8, 0xF8, 0x0C, 0x07, 0x87, 0x80, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00,
  0x03, 0x98, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0x61,
  0x80, 0x07, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x18, 0x18, 0x00,
  0xC0, 0xC0, 0x0E, 0x06, 0x00, 0x60, 0x30, 0x03, 0x03, 0x80, 0x30, 0x1C,
  0x01, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x07, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0x00, 0x70, 0x38, 0x03, 0x81, 0x80, 0x1C, 0x1C, 0x00, 0xE0,
  0xE0, 0x07, 0x06, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x00, 0x0E, 0x38, 0x00,
  0x71, 0x80, 0x03, 0x8C, 0x00, 0x1C, 0xE0, 0x00, 0xE6, 0x00, 0x07, 0x70,
  0x00, 0x3B, 0x00, 0x01, 0xD8, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x60, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x06, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x07, 0x00, 0xC0,
  0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0x80, 0x07, 0x01, 0x80,
  0x06, 0x01, 0x80, 0x06, 0x03, 0x80, 0x0E, 0x03, 0x00, 0x0C, 0x03, 0x00,
  0x1C, 0x03, 0x00, 0x38, 0x03, 0x00, 0x70, 0x07, 0x01, 0xE0, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x06, 0x07, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x60, 0x0C, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x1C, 0x00,
  0x30, 0x1C, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00,
  0x30, 0x38, 0x00, 0x70, 0x30, 0x00, 0x70, 0x30, 0x00, 0x60, 0x30, 0x00,
  0xE0, 0x30, 0x00, 0xC0, 0x70, 0x01, 0xC0, 0x60, 0x03, 0x80, 0x60, 0x07,
  0x00, 0x60, 0x1E, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x1E, 0x06, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x02, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0C,
  0x07, 0x80, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x00, 0x1C, 0x01,
  0x80, 0x0E, 0x00, 0xC0, 0x03, 0x00, 0xE0, 0x01, 0x80, 0x70, 0x00, 0xE0,
  0x30, 0x00, 0x70, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x1C, 0x0E, 0x00, 0x0E,
  0x06, 0x00, 0x07, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x00,
  0xC0, 0xE0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x38, 0x18, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x03, 0x81, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0x60,
  0x00, 0x70, 0x30, 0x00, 0x30, 0x18, 0x00, 0x38, 0x1C, 0x00, 0x18, 0x0C,
  0x00, 0x1C, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x0C, 0x03, 0x80, 0x0E, 0x01,
  0xC0, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x1E, 0x00, 0x30, 0x7E, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7C, 0x07,
  0x80, 0x1E, 0x00, 0x30, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x7F, 0x83, 0x00, 0x0F, 0xF0, 0x60,
  0x00, 0x06, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x00, 0x60,
  0x30, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x60, 0x1C, 0x00,
  0x0C, 0x01, 0xC0, 0x03, 0x80, 0x3C, 0x00, 0x70, 0x03, 0xC0, 0x0C, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x40, 0x00, 0x00, 0x70,
  0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x60, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x1C, 0x03,
  0x80, 0x01, 0x80, 0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x38, 0x03, 0x00, 0x03, 0x00, 0x70, 0x00, 0x30, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x60, 0x0C, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xE0,
  0x1C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80,
  0x01, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x80, 0x01, 0x80, 0x30, 0x00, 0x18,
  0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x38, 0x07, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x06, 0x70, 0x00,
  0x7F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x18, 0x00,
  0x70, 0x06, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x38,
  0x03, 0x80, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x38, 0x00,
  0x70, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x03, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x60, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0x31, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x06,
  0x70, 0x00, 0x01, 0xBE, 0x00, 0x00, 0x6D, 0x80, 0x00, 0x3E, 0x60, 0x00,
  0x0F, 0x18, 0x00, 0x03, 0x87, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x1C, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x60,
  0x18, 0x00, 0x18, 0x06, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x00, 0x70, 0x00,
  0xC0, 0x1C, 0x00, 0x30, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x0E, 0x00, 0x60, 0x03, 0x80, 0x18, 0x00, 0x60, 0x0E, 0x00,
  0x18, 0x03, 0x00, 0x07, 0x00, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0x60,
  0x00, 0x03, 0xC0, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x36, 0x00, 0x00, 0x6C,
  0x00, 0xD8, 0x00, 0x03, 0x30, 0x07, 0x60, 0x00, 0x0D, 0xC0, 0x19, 0x80,
  0x00, 0x76, 0x00, 0x66, 0x00, 0x01, 0x98, 0x01, 0x98, 0x00, 0x0E, 0x60,
  0x06, 0x60, 0x00, 0x33, 0x80, 0x39, 0x80, 0x01, 0xCE, 0x00, 0xC6, 0x00,
  0x06, 0x30, 0x03, 0x18, 0x00, 0x38, 0xC0, 0x0C, 0x60, 0x00, 0xC3, 0x00,
  0x31, 0x80, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x18, 0x60, 0x06, 0x1C, 0x00,
  0xE1, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03,
  0x83, 0x00, 0x60, 0xE0, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x30, 0x30, 0x0C,
  0x0C, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x03, 0x03, 0x01, 0x81, 0xC0, 0x1C,
  0x0C, 0x06, 0x07, 0x00, 0x60, 0x30, 0x30, 0x18, 0x01, 0x80, 0xC0, 0xC0,
  0x60, 0x06, 0x03, 0x07, 0x01, 0x80, 0x18, 0x0C, 0x18, 0x0E, 0x00, 0xE0,
  0x30, 0xE0, 0x30, 0x03, 0x00, 0xC3, 0x00, 0xC0, 0x0C, 0x03, 0x1C, 0x03,
  0x00, 0x30, 0x0C, 0x60, 0x0C, 0x01, 0xC0, 0x33, 0x80, 0x70, 0x06, 0x00,
  0xEC, 0x01, 0x80, 0x18, 0x03, 0xF0, 0x06, 0x00, 0x60, 0x0F, 0x80, 0x18,
  0x01, 0x80, 0x3E, 0x00, 0x60, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x30, 0x01,
  0xC0, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x60, 0x07,
  0x80, 0x01, 0x80, 0x1E, 0x00, 0x06, 0x00, 0xF8, 0x00, 0x18, 0x03, 0x60,
  0x00, 0xE0, 0x0D, 0x80, 0x03, 0x00, 0x36, 0x00, 0x0C, 0x00, 0xDC, 0x00,
  0x30, 0x07, 0x30, 0x00, 0xC0, 0x18, 0xC0, 0x07, 0x00, 0x63, 0x00, 0x18,
  0x01, 0x8C, 0x00, 0x60, 0x06, 0x38, 0x01, 0x80, 0x38, 0xE0, 0x0E, 0x00,
  0xC1, 0x80, 0x38, 0x03, 0x06, 0x00, 0xC0, 0x0C, 0x18, 0x03, 0x00, 0x30,
  0x60, 0x0C, 0x01, 0xC1, 0xC0, 0x70, 0x06, 0x03, 0x01, 0x80, 0x18, 0x0C,
  0x06, 0x00, 0x60, 0x30, 0x18, 0x03, 0x80, 0xC0, 0x60, 0x0E, 0x03, 0x03,
  0x80, 0x30, 0x0E, 0x0C, 0x00, 0xC0, 0x18, 0x30, 0x03, 0x00, 0x60, 0xC0,
  0x1C, 0x01, 0x83, 0x00, 0x60, 0x06, 0x1C, 0x01, 0x80, 0x1C, 0x60, 0x06,
  0x00, 0x31, 0x80, 0x18, 0x00, 0xC6, 0x00, 0xE0, 0x03, 0x38, 0x03, 0x00,
  0x0C, 0xC0, 0x0C, 0x00, 0x33, 0x00, 0x30, 0x00, 0xEC, 0x01, 0xC0, 0x01,
  0xB0, 0x07, 0x00, 0x07, 0xC0, 0x18, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x78,
  0x01, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x38, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x07, 0x80, 0x0E, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x06, 0x00, 0x0C, 0x07, 0x00,
  0x06, 0x03, 0x00, 0x03, 0x03, 0x80, 0x01, 0xC1, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x38, 0x00, 0x03, 0x1C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x07, 0x38, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x06, 0x01, 0x80,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0x01, 0xC0, 0x0E, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x30, 0x03, 0x80, 0x60, 0x07, 0x00, 0xC0, 0x06, 0x03,
  0x80, 0x0C, 0x07, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0xE0, 0x30,
  0x01, 0xC0, 0xE0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x1C, 0x06, 0x00,
  0x38, 0x0C, 0x00, 0x60, 0x38, 0x01, 0xC0, 0x60, 0x07, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0xF0, 0x07, 0x1F, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0x07, 0x80, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x06,
  0x00, 0x0C, 0x07, 0x00, 0x06, 0x03, 0x00, 0x03, 0x03, 0x80, 0x01, 0xC1,
  0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C,
  0x70, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x38, 0x00, 0x03, 0x1C, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x67, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x39, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00,
  0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x60,
  0x00, 0x18, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x07,
  0x00, 0x06, 0x01, 0x80, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x1C, 0x07, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x03, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x30,
  0x03, 0x80, 0x60, 0x07, 0x00, 0xC0, 0x06, 0x03, 0x80, 0x0C, 0x07, 0x00,
  0x18, 0x0C, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0xE0, 0x03,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xE0,
  0x38, 0x01, 0x80, 0x60, 0x07, 0x00, 0xC0, 0x3C, 0x01, 0x83, 0xF0, 0x07,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x18, 0x38, 0x00, 0x30, 0x30, 0x00, 0x60,
  0x60, 0x01, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x80, 0x0C, 0x07,
  0x00, 0x18, 0x06, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x70, 0x0E, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0x60, 0x03, 0x00, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0x01, 0xE0, 0x0E, 0x00,
  0x20, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x80, 0x03, 0x80, 0x70, 0x07, 0x80, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x58, 0x00, 0x00, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00,
  0x60, 0x18, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0xE0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x01,
  0x80, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06,
  0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x0C, 0x00,
  0x0C, 0x07, 0x00, 0x03, 0x01, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x18,
  0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xE0,
  0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0xC0, 0x60, 0x00, 0x70, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x80,
  0x01, 0x80, 0xE0, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03,
  0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x38,
  0x03, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x6C, 0x00, 0x03, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x73, 0x00,
  0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x38, 0xC0, 0x00, 0xC3, 0x00, 0x07,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C,
  0x00, 0x70, 0x30, 0x01, 0x80, 0xC0, 0x0E, 0x03, 0x00, 0x30, 0x0C, 0x01,
  0xC0, 0x30, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x0C, 0x03, 0x00,
  0x30, 0x1C, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x0E, 0x00, 0x30,
  0x30, 0x00, 0xC1, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xC0,
  0x00, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x80, 0x00,
  0xCC, 0x00, 0x03, 0x30, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x1D, 0x80, 0x00, 0xE0, 0x00, 0x66, 0x00, 0x03, 0x80, 0x03,
  0x98, 0x00, 0x1C, 0x00, 0x0C, 0x60, 0x00, 0x70, 0x00, 0x31, 0x80, 0x03,
  0xC0, 0x01, 0xC6, 0x00, 0x0F, 0x00, 0x06, 0x18, 0x00, 0x3C, 0x00, 0x38,
  0x60, 0x01, 0xB0, 0x00, 0xC1, 0x80, 0x06, 0xC0, 0x03, 0x06, 0x00, 0x3B,
  0x00, 0x1C, 0x18, 0x00, 0xCC, 0x00, 0x60, 0x60, 0x03, 0x30, 0x03, 0x81,
  0x80, 0x18, 0xC0, 0x0C, 0x06, 0x00, 0x63, 0x00, 0x30, 0x18, 0x03, 0x8C,
  0x01, 0xC0, 0x60, 0x0C, 0x30, 0x06, 0x01, 0x80, 0x30, 0xC0, 0x38, 0x06,
  0x01, 0x83, 0x00, 0xC0, 0x18, 0x06, 0x0C, 0x03, 0x00, 0x60, 0x38, 0x30,
  0x1C, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x06, 0x03, 0x03, 0x03, 0x80, 0x18,
  0x18, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x30, 0x30, 0x01, 0x81, 0x80, 0xC1,
  0xC0, 0x06, 0x0C, 0x03, 0x06, 0x00, 0x18, 0x30, 0x0C, 0x38, 0x00, 0x61,
  0xC0, 0x30, 0xC0, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x03, 0x1C,
  0x00, 0x18, 0xC0, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x73, 0x80, 0x01, 0x9C,
  0x01, 0x8C, 0x00, 0x06, 0x60, 0x06, 0x30, 0x00, 0x19, 0x80, 0x19, 0xC0,
  0x00, 0x6C, 0x00, 0x66, 0x00, 0x01, 0xB0, 0x01, 0x98, 0x00, 0x07, 0xC0,
  0x06, 0xC0, 0x00, 0x1E, 0x00, 0x1B, 0x00, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0xE0, 0x01, 0xC0, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x71, 0x80, 0x00, 0x06, 0x18, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x38,
  0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0xE0, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x00, 0xC0, 0x0E, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x76, 0x00, 0x06, 0x60, 0x00, 0xE7, 0x00, 0x0C, 0x70,
  0x01, 0xC3, 0x00, 0x18, 0x30, 0x03, 0x03, 0x00, 0x30, 0x30, 0x06, 0x03,
  0x00, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x03, 0x03, 0x80,
  0x30, 0x30, 0x03, 0x87, 0x00, 0x18, 0x60, 0x01, 0x8E, 0x00, 0x18, 0xC0,
  0x01, 0x9C, 0x00, 0x19, 0x80, 0x01, 0xB8, 0x00, 0x1B, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x70, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x18, 0xC0, 0x00, 0x61,
  0xC0, 0x01, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x18, 0x06,
  0x00, 0x70, 0x0E, 0x00, 0xC0, 0x0C, 0x03, 0x80, 0x18, 0x06, 0x00, 0x18,
  0x1C, 0x00, 0x30, 0x30, 0x00, 0x70, 0xE0, 0x00, 0x61, 0x80, 0x00, 0xE7,
  0x00, 0x00, 0xDC, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC3,
  0x86, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x00, 0x3C, 0x00, 0x07, 0xF8,
  0xC0, 0x78, 0xE6, 0x07, 0x03, 0x30, 0x70, 0x0F, 0x03, 0x00, 0x78, 0x38,
  0x01, 0xC1, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xC0, 0x03, 0x0E, 0x00, 0x18,
  0x60, 0x01, 0xC3, 0x00, 0x0E, 0x38, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00,
  0x18, 0x60, 0x00, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x61, 0x80, 0x03, 0x0C,
  0x00, 0x18, 0x60, 0x01, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x60, 0xC0, 0x07,
  0x06, 0x00, 0x38, 0x30, 0x03, 0xC1, 0x80, 0x1E, 0x0E, 0x01, 0xE0, 0x70,
  0x1B, 0x01, 0xC1, 0x98, 0x0F, 0xFC, 0xC0, 0x3F, 0x84, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x0F, 0x00, 0x18, 0xFE, 0x00, 0x67, 0x3C, 0x01, 0xB0, 0x38,
  0x0D, 0x80, 0x60, 0x3C, 0x01, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x1C,
  0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x06, 0x00, 0x1C, 0x18, 0x00,
  0x70, 0xE0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60,
  0xC0, 0x03, 0x86, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80,
  0x07, 0x06, 0x00, 0x18, 0x38, 0x00, 0x60, 0xE0, 0x03, 0x83, 0x80, 0x0C,
  0x0E, 0x00, 0x70, 0x78, 0x01, 0x81, 0xA0, 0x0E, 0x06, 0xC0, 0x70, 0x1B,
  0x03, 0x80, 0x47, 0xFC, 0x03, 0x0F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x7F, 0xC0, 0x78, 0x40, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x40, 0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x1C, 0x18, 0x00, 0xFF, 0x18, 0x01, 0xE3, 0x98,
  0x03, 0x81, 0xB8, 0x07, 0x00, 0xF0, 0x06, 0x00, 0xF0, 0x0E, 0x00, 0x70,
  0x0C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x18, 0x00, 0x60, 0x38, 0x00, 0x60,
  0x30, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x70, 0x00, 0xC0, 0x60, 0x00, 0xC0,
  0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0x80,
  0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x80,
  0xC0, 0x03, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x0F, 0x00,
  0xC0, 0x0F, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x36, 0x00, 0x70, 0x66, 0x00,
  0x7F, 0xE6, 0x00, 0x3F, 0x84, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x3F, 0xC0, 0x1E, 0x38, 0x0E, 0x06, 0x07, 0x01, 0x83, 0x80, 0x70, 0xC0,
  0x1C, 0x70, 0x06, 0x18, 0x01, 0x8E, 0x00, 0x63, 0x00, 0x38, 0xC0, 0x0C,
  0x70, 0x06, 0x18, 0x03, 0x86, 0x03, 0xC3, 0x87, 0xC0, 0xFF, 0xC0, 0x3F,
  0x80, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x80, 0xFB, 0xE0, 0x1F, 0xF0, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7B,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x4F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xE3, 0x00, 0x3C, 0x73, 0x00, 0x70, 0x33, 0x00, 0xE0, 0x1E, 0x00,
  0xC0, 0x1E, 0x01, 0xC0, 0x0E, 0x01, 0x80, 0x0E, 0x03, 0x80, 0x0E, 0x03,
  0x00, 0x0C, 0x07, 0x00, 0x0C, 0x06, 0x00, 0x1C, 0x06, 0x00, 0x1C, 0x0E,
  0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x1C,
  0x00, 0x38, 0x1C, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x70, 0x18, 0x00, 0x70, 0x18, 0x00, 0x60, 0x18, 0x00, 0xE0, 0x18,
  0x00, 0xE0, 0x18, 0x01, 0xE0, 0x18, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x1C,
  0x06, 0xC0, 0x0E, 0x0C, 0xC0, 0x0F, 0xFD, 0xC0, 0x07, 0xF1, 0x80, 0x01,
  0xC1, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x80, 0x38, 0x00, 0xF9,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC1, 0xE0, 0x06, 0x7F, 0x80,
  0x37, 0x9E, 0x01, 0xF0, 0x30, 0x1A, 0x01, 0xC0, 0xF0, 0x0E, 0x07, 0x00,
  0x70, 0x38, 0x03, 0x81, 0x80, 0x18, 0x1C, 0x00, 0xC0, 0xE0, 0x06, 0x06,
  0x00, 0x30, 0x30, 0x03, 0x83, 0x80, 0x18, 0x1C, 0x00, 0xC0, 0xC0, 0x06,
  0x06, 0x00, 0x30, 0x30, 0x03, 0x83, 0x80, 0x18, 0x18, 0x00, 0xC0, 0xC0,
  0x06, 0x06, 0x00, 0x70, 0x30, 0x03, 0x03, 0x80, 0x18, 0x18, 0x00, 0xC0,
  0xC0, 0x06, 0x06, 0x00, 0x70, 0x30, 0x03, 0x03, 0x80, 0x18, 0x18, 0x00,
  0xC0, 0xC0, 0x06, 0x06, 0x00, 0x70, 0x70, 0x03, 0x00, 0x00, 0x20, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x9E,
  0x00, 0x0F, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xE0, 0x30,
  0x0E, 0x01, 0x80, 0x60, 0x1C, 0x06, 0x00, 0xC0, 0x70, 0x06, 0x07, 0x00,
  0x30, 0x30, 0x03, 0x83, 0x00, 0x18, 0x38, 0x00, 0xC3, 0x80, 0x06, 0x18,
  0x00, 0x31, 0x80, 0x03, 0x9C, 0x00, 0x19, 0xE0, 0x00, 0xCF, 0x00, 0x06,
  0xD8, 0x00, 0x3C, 0xC0, 0x03, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xE0, 0xC0,
  0x06, 0x06, 0x00, 0x70, 0x30, 0x03, 0x01, 0x80, 0x18, 0x0E, 0x00, 0xC0,
  0x70, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0xC0, 0x1C, 0x06, 0x00, 0xE0, 0x70, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x78, 0x01, 0x9F, 0xE1,
  0xFE, 0x01, 0xB8, 0xF3, 0x8F, 0x03, 0x60, 0x76, 0x07, 0x03, 0x40, 0x3C,
  0x03, 0x03, 0x80, 0x38, 0x03, 0x03, 0x80, 0x38, 0x03, 0x03, 0x80, 0x30,
  0x03, 0x07, 0x00, 0x30, 0x03, 0x07, 0x00, 0x30, 0x03, 0x06, 0x00, 0x70,
  0x07, 0x06, 0x00, 0x60, 0x06, 0x06, 0x00, 0x60, 0x06, 0x0E, 0x00, 0x60,
  0x06, 0x0C, 0x00, 0xE0, 0x0E, 0x0C, 0x00, 0xE0, 0x0C, 0x0C, 0x00, 0xC0,
  0x0C, 0x0C, 0x00, 0xC0, 0x0C, 0x1C, 0x00, 0xC0, 0x0C, 0x18, 0x01, 0xC0,
  0x1C, 0x18, 0x01, 0x80, 0x18, 0x18, 0x01, 0x80, 0x18, 0x18, 0x01, 0x80,
  0x18, 0x38, 0x03, 0x80, 0x18, 0x30, 0x03, 0x80, 0x38, 0x30, 0x03, 0x00,
  0x30, 0x30, 0x03, 0x00, 0x30, 0x70, 0x03, 0x00, 0x30, 0x60, 0x07, 0x00,
  0x30, 0x60, 0x06, 0x00, 0x70, 0x60, 0x06, 0x00, 0x60, 0x60, 0x06, 0x00,
  0x60, 0xE0, 0x0E, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x0C, 0xFF, 0x00, 0x6F,
  0x3C, 0x06, 0xC0, 0x60, 0x34, 0x03, 0x81, 0xE0, 0x1C, 0x0E, 0x00, 0xE0,
  0x70, 0x06, 0x07, 0x00, 0x30, 0x38, 0x01, 0x81, 0xC0, 0x0C, 0x0C, 0x00,
  0xE0, 0x60, 0x07, 0x07, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C,
  0x00, 0xE0, 0x60, 0x07, 0x07, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C,
  0x0C, 0x00, 0xE0, 0x60, 0x06, 0x07, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80,
  0x0C, 0x0C, 0x00, 0xE0, 0xE0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81,
  0x80, 0x0C, 0x0C, 0x00, 0xE0, 0xE0, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x1F,
  0xE0, 0x07, 0x8E, 0x01, 0xC0, 0xE0, 0x70, 0x0C, 0x1C, 0x01, 0x83, 0x00,
  0x38, 0xE0, 0x07, 0x18, 0x00, 0x67, 0x00, 0x0C, 0xE0, 0x01, 0x98, 0x00,
  0x77, 0x00, 0x0E, 0xE0, 0x01, 0xD8, 0x00, 0x33, 0x00, 0x06, 0xE0, 0x00,
  0xDC, 0x00, 0x1B, 0x00, 0x07, 0x60, 0x00, 0xEC, 0x00, 0x19, 0x80, 0x03,
  0x30, 0x00, 0xE6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xE3, 0x00, 0x18,
  0x60, 0x07, 0x0E, 0x01, 0xC1, 0xC0, 0x30, 0x1C, 0x1E, 0x03, 0xEF, 0x80,
  0x3F, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x18, 0xFE, 0x00,
  0x0C, 0xE3, 0x80, 0x06, 0xC0, 0xE0, 0x06, 0xC0, 0x30, 0x03, 0x40, 0x18,
  0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x70, 0x01,
  0xC0, 0x38, 0x00, 0xE0, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x0E, 0x00,
  0x1C, 0x07, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0,
  0x01, 0x80, 0xE0, 0x01, 0xC0, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18,
  0x00, 0x70, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x18, 0x07, 0x00, 0x1C, 0x03,
  0x80, 0x0C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0xF0, 0x07, 0x00,
  0x6C, 0x07, 0x00, 0x36, 0x07, 0x00, 0x19, 0xFF, 0x00, 0x1C, 0x7F, 0x00,
  0x0E, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07,
  0xF8, 0xC0, 0x78, 0xE6, 0x07, 0x03, 0x30, 0x70, 0x0F, 0x03, 0x00, 0x78,
  0x38, 0x01, 0xC1, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xC0, 0x03, 0x0E, 0x00,
  0x18, 0x60, 0x00, 0xC3, 0x00, 0x0E, 0x38, 0x00, 0x61, 0x80, 0x03, 0x0C,
  0x00, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x61, 0x80, 0x03,
  0x0C, 0x00, 0x18, 0x60, 0x01, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x60, 0xC0,
  0x07, 0x06, 0x00, 0x38, 0x30, 0x03, 0xC1, 0x80, 0x1E, 0x0C, 0x01, 0xE0,
  0x70, 0x1B, 0x01, 0xC1, 0xD8, 0x0F, 0xFD, 0xC0, 0x3F, 0x8C, 0x00, 0x30,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0xCF, 0xC0, 0x6F, 0x20, 0x6E, 0x00, 0x36, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0xF8, 0x07, 0x87, 0x81, 0xC0, 0x20, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x20, 0x0E,
  0x07, 0xDF, 0x80, 0x7F, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x1F, 0xF3, 0xFF, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xF6, 0x07, 0xE0, 0x18, 0x00, 0x06, 0x00,
  0x30, 0x60, 0x07, 0x0E, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0,
  0x0E, 0x0C, 0x00, 0xE1, 0xC0, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x18,
  0x01, 0xC1, 0x80, 0x18, 0x38, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x83,
  0x00, 0x38, 0x70, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x70,
  0x60, 0x07, 0x0E, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x0E,
  0x0C, 0x01, 0xE0, 0xC0, 0x1C, 0x0C, 0x03, 0xC0, 0xC0, 0x2C, 0x0E, 0x0E,
  0xC0, 0xFF, 0xC8, 0x07, 0xF9, 0x80, 0x0C, 0x00, 0x00, 0xE0, 0x01, 0xB0,
  0x01, 0xD8, 0x00, 0xCC, 0x00, 0xE6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x30,
  0xC0, 0x18, 0x60, 0x1C, 0x30, 0x0C, 0x18, 0x0E, 0x0C, 0x06, 0x06, 0x07,
  0x03, 0x03, 0x01, 0x81, 0x80, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0xE0, 0x18,
  0x60, 0x0C, 0x70, 0x06, 0x30, 0x03, 0x18, 0x01, 0x98, 0x00, 0xCC, 0x00,
  0x6E, 0x00, 0x36, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x7C, 0x00, 0xE0, 0x06,
  0xC0, 0x0E, 0x00, 0x6C, 0x01, 0xE0, 0x0C, 0xC0, 0x1E, 0x00, 0xCC, 0x01,
  0xE0, 0x1C, 0xC0, 0x36, 0x01, 0x8C, 0x03, 0x60, 0x18, 0xC0, 0x76, 0x03,
  0x0C, 0x06, 0x60, 0x30, 0xC0, 0x66, 0x03, 0x0C, 0x0C, 0x60, 0x60, 0xC0,
  0xC6, 0x06, 0x0C, 0x18, 0x60, 0xC0, 0xC1, 0x86, 0x0C, 0x0C, 0x18, 0x60,
  0xC0, 0xC3, 0x06, 0x18, 0x0C, 0x30, 0x61, 0x80, 0xC6, 0x06, 0x38, 0x0C,
  0x60, 0x63, 0x00, 0xC6, 0x06, 0x30, 0x0C, 0xC0, 0x66, 0x00, 0xCC, 0x06,
  0x60, 0x0D, 0x80, 0x6E, 0x00, 0xD8, 0x06, 0xC0, 0x0D, 0x80, 0x6C, 0x00,
  0xF0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x0E, 0x00,
  0x70, 0x00, 0xE0, 0x07, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0E,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x60, 0x03, 0x01, 0xC0, 0x06, 0x03, 0x00,
  0x0C, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x30, 0x60, 0x00, 0x31, 0xC0, 0x00,
  0x63, 0x00, 0x00, 0xCE, 0x00, 0x01, 0x98, 0x00, 0x03, 0x60, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x31, 0xC0,
  0x00, 0xE1, 0x80, 0x01, 0x83, 0x00, 0x06, 0x06, 0x00, 0x1C, 0x0C, 0x00,
  0x30, 0x1C, 0x00, 0xE0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0x60, 0x1C,
  0x00, 0xC0, 0x70, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x0E, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x30, 0x07, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x07, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0D, 0xC0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x04, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x10, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x80, 0x0B, 0xFF, 0x00,
  0x78, 0x1E, 0x0F, 0x00, 0x7F, 0xE8, 0x00, 0xFC, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 12, 44, 13, 1, -44 },
  { 67, 13, 16, 17, 6, -44 },
  { 93, 24, 44, 23, 0, -44 },
  { 225, 23, 50, 21, 0, -46 },
  { 369, 27, 45, 33, 3, -44 },
  { 521, 21, 45, 21, -1, -44 },
  { 640, 5, 16, 9, 6, -44 },
  { 650, 17, 53, 15, 1, -43 },
  { 763, 17, 53, 15, -4, -43 },
  { 876, 16, 17, 20, 7, -46 },
  { 910, 21, 29, 25, 2, -36 },
  { 987, 7, 14, 10, -2, -6 },
  { 1000, 13, 3, 16, 1, -18 },
  { 1005, 4, 5, 10, 1, -5 },
  { 1008, 25, 44, 18, -3, -44 },
  { 1146, 20, 45, 22, 1, -44 },
  { 1259, 11, 44, 22, 7, -44 },
  { 1320, 24, 44, 22, -2, -44 },
  { 1452, 23, 45, 22, -1, -44 },
  { 1582, 23, 44, 22, -1, -44 },
  { 1709, 23, 45, 22, -1, -44 },
  { 1839, 22, 45, 22, 1, -44 },
  { 1963, 22, 44, 22, 2, -44 },
  { 2084, 23, 45, 22, -1, -44 },
  { 2214, 21, 45, 22, 0, -44 },
  { 2333, 10, 32, 10, 0, -32 },
  { 2373, 13, 40, 10, -3, -32 },
  { 2438, 21, 25, 25, 2, -34 },
  { 2504, 21, 15, 25, 2, -29 },
  { 2544, 21, 25, 25, 2, -34 },
  { 2610, 17, 44, 15, 1, -44 },
  { 2704, 29, 49, 32, 2, -44 },
  { 2882, 21, 44, 21, -4, -44 },
  { 2998, 24, 44, 23, 0, -44 },
  { 3130, 24, 45, 21, 2, -44 },
  { 3265, 25, 44, 26, 0, -44 },
  { 3403, 23, 44, 21, 0, -44 },
  { 3530, 24, 44, 19, 0, -44 },
  { 3662, 27, 45, 28, 2, -44 },
  { 3814, 28, 44, 27, 0, -44 },
  { 3968, 19, 44, 11, -3, -44 },
  { 4073, 21, 55, 10, -9, -44 },
  { 4218, 26, 44, 22, 0, -44 },
  { 4361, 14, 44, 19, 0, -44 },
  { 4438, 38, 44, 37, 0, -44 },
  { 4647, 30, 44, 29, 0, -44 },
  { 4812, 25, 45, 28, 2, -44 },
  { 4953, 23, 44, 22, 0, -44 },
  { 5080, 25, 54, 28, 2, -44 },
  { 5249, 23, 44, 23, 0, -44 },
  { 5376, 25, 45, 21, -2, -44 },
  { 5517, 19, 44, 19, 4, -44 },
  { 5622, 26, 45, 26, 2, -44 },
  { 5769, 22, 44, 22, 5, -44 },
  { 5890, 38, 44, 37, 4, -44 },
  { 6099, 28, 44, 19, -4, -44 },
  { 6253, 20, 44, 18, 4, -44 },
  { 6363, 26, 44, 19, -3, -44 },
  { 6506, 22, 54, 17, -1, -44 },
  { 6655, 9, 44, 20, 6, -44 },
  { 6705, 22, 54, 17, -4, -44 },
  { 6854, 23, 22, 24, 1, -44 },
  { 6918, 17, 2, 16, -5, 5 },
  { 6923, 6, 10, 13, 9, -47 },
  { 6931, 21, 34, 24, 2, -33 },
  { 7021, 22, 47, 23, 0, -46 },
  { 7151, 17, 34, 17, 2, -33 },
  { 7224, 24, 47, 24, 2, -46 },
  { 7365, 18, 34, 21, 2, -33 },
  { 7442, 27, 62, 12, -8, -47 },
  { 7652, 24, 48, 24, -1, -33 },
  { 7796, 21, 46, 23, 0, -46 },
  { 7917, 12, 44, 10, 0, -44 },
  { 7983, 20, 59, 10, -8, -44 },
  { 8131, 21, 46, 19, 0, -46 },
  { 8252, 12, 46, 10, 0, -46 },
  { 8321, 32, 33, 34, 0, -33 },
  { 8453, 21, 33, 22, 0, -33 },
  { 8540, 19, 34, 23, 2, -33 },
  { 8621, 25, 47, 23, -3, -33 },
  { 8768, 21, 47, 24, 2, -33 },
  { 8892, 17, 33, 15, 0, -33 },
  { 8963, 19, 34, 17, -1, -33 },
  { 9044, 12, 41, 12, 1, -40 },
  { 9106, 20, 33, 23, 2, -32 },
  { 9189, 17, 32, 17, 3, -32 },
  { 9257, 28, 32, 29, 4, -32 },
  { 9369, 23, 32, 18, -3, -32 },
  { 9461, 29, 47, 18, -7, -32 },
  { 9632, 19, 32, 15, -2, -32 },
  { 9708, 21, 54, 19, 2, -44 },
  { 9850, 3, 61, 21, 9, -46 },
  { 9873, 21, 54, 19, -4, -44 },
  { 10015, 21, 5, 25, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC61PT7B_H_
