#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC38PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x60, 0xC1,
  0x02, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x82,
  0x00, 0x63, 0x62, 0x42, 0x46, 0x46, 0xC4, 0x84, 0x84, 0x8C, 0x88, 0x00,
  0xC6, 0x01, 0x08, 0x02, 0x10, 0x0C, 0x20, 0x10, 0x80, 0x21, 0x00, 0xC2,
  0x01, 0x0C, 0x1F, 0xFE, 0x0C, 0x20, 0x10, 0xC0, 0x21, 0x00, 0x42, 0x01,
  0x8C, 0x02, 0x10, 0x04, 0x20, 0x18, 0xC1, 0xFF, 0xE0, 0x42, 0x01, 0x84,
  0x02, 0x18, 0x04, 0x20, 0x18, 0x40, 0x21, 0x80, 0x42, 0x00, 0x84, 0x03,
  0x18, 0x00, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x78, 0x07, 0xFC, 0x31,
  0x10, 0x88, 0x06, 0x20, 0x18, 0x80, 0x42, 0x01, 0x88, 0x06, 0x40, 0x09,
  0x00, 0x14, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0B, 0x00, 0x24, 0x00,
  0x98, 0x04, 0x20, 0x10, 0x80, 0x42, 0x01, 0x18, 0x04, 0x42, 0x23, 0x0F,
  0xF0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x00, 0x04, 0x00, 0x0F,
  0x81, 0x84, 0x40, 0x84, 0x20, 0x82, 0x10, 0x43, 0x08, 0x41, 0x04, 0x20,
  0x82, 0x30, 0xC3, 0x10, 0x41, 0x98, 0x20, 0x88, 0x10, 0x4C, 0x48, 0x64,
  0xF4, 0x26, 0xCE, 0x12, 0x43, 0x13, 0x61, 0xF9, 0x20, 0x91, 0x90, 0x40,
  0x98, 0x60, 0xC8, 0x30, 0x44, 0x10, 0x62, 0x08, 0x21, 0x0C, 0x30, 0x86,
  0x10, 0x42, 0x18, 0x23, 0x08, 0x11, 0x0C, 0x0F, 0x00, 0x00, 0x80, 0x3E,
  0x02, 0x20, 0x62, 0x04, 0x30, 0x42, 0x0C, 0x20, 0xC6, 0x0C, 0x60, 0x44,
  0x04, 0x80, 0x58, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xA0, 0x33, 0x16, 0x31,
  0x41, 0x3C, 0x12, 0x81, 0xA8, 0x1E, 0x80, 0xC8, 0x0C, 0x81, 0xC8, 0x14,
  0xC2, 0x47, 0xC6, 0x6D, 0x25, 0xA4, 0x90, 0x00, 0x40, 0x20, 0x10, 0x0C,
  0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x18,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20,
  0x00, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x40, 0x18, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0xC0, 0x00, 0x06,
  0x01, 0x00, 0x43, 0x10, 0x34, 0xC3, 0xE0, 0xC0, 0xC8, 0x62, 0x10, 0x40,
  0x10, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x46, 0x23, 0x10, 0x88, 0xC0, 0xFF,
  0xF8, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x3E, 0x06, 0x30,
  0xC1, 0x08, 0x11, 0x81, 0x10, 0x13, 0x01, 0x30, 0x12, 0x01, 0x20, 0x16,
  0x03, 0x40, 0x34, 0x03, 0x40, 0x2C, 0x02, 0xC0, 0x2C, 0x06, 0x80, 0x68,
  0x04, 0x80, 0xC8, 0x0C, 0x80, 0x88, 0x18, 0x81, 0x0C, 0x30, 0x46, 0x07,
  0xC0, 0x06, 0x1C, 0x7B, 0x3C, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0xC1,
  0x82, 0x04, 0x08, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x18, 0x20, 0x41, 0x83,
  0x00, 0x00, 0x40, 0x0F, 0xE0, 0x60, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00,
  0x3F, 0xF0, 0x00, 0x40, 0x07, 0xF0, 0x18, 0x30, 0x00, 0x20, 0x00, 0x40,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x03, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x01, 0x82, 0x06, 0x07, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x50, 0x01, 0xE0, 0x02, 0xC0, 0x09, 0x00, 0x32, 0x00, 0x44, 0x01, 0x98,
  0x02, 0x30, 0x08, 0x40, 0x30, 0x80, 0x43, 0x01, 0x86, 0x02, 0x08, 0x08,
  0x10, 0x30, 0x20, 0x40, 0xC1, 0x81, 0x83, 0xFF, 0xCF, 0xFF, 0x80, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x03, 0xFE,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xFE, 0x00, 0x86, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC1, 0x03, 0x03, 0xFC,
  0x00, 0x00, 0x30, 0x0F, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC6, 0x06, 0xFC, 0x28, 0x21,
  0x81, 0x9C, 0x0C, 0xC0, 0x26, 0x01, 0x30, 0x09, 0x00, 0xC8, 0x06, 0x40,
  0x22, 0x01, 0x10, 0x18, 0xC0, 0x86, 0x0C, 0x18, 0xC0, 0x7C, 0x00, 0x1F,
  0xFC, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x0F, 0xC0, 0x61, 0x83, 0x02, 0x08, 0x0C, 0x60, 0x31, 0x80, 0xC6,
  0x03, 0x18, 0x08, 0x20, 0x60, 0x81, 0x03, 0x08, 0x06, 0xC0, 0x0E, 0x00,
  0xF8, 0x06, 0x20, 0x30, 0xC1, 0x81, 0x8C, 0x06, 0x30, 0x08, 0x80, 0x22,
  0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x63, 0x03, 0x06, 0x18, 0x0F, 0xC0,
  0x00, 0x80, 0x1F, 0x81, 0x84, 0x18, 0x30, 0x80, 0x8C, 0x04, 0x40, 0x22,
  0x01, 0x30, 0x09, 0x80, 0x4C, 0x06, 0x40, 0x32, 0x01, 0x98, 0x1C, 0xC0,
  0xC3, 0x0A, 0x1F, 0xB0, 0x31, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x81, 0xF8, 0x00, 0x0C, 0x30,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x0C,
  0x30, 0x03, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x18, 0x18, 0x10, 0x30, 0x20, 0x60,
  0x40, 0xC0, 0x00, 0x08, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x20, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x00, 0x30, 0x06, 0x00, 0xE0,
  0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x00, 0x01, 0x01, 0xF8, 0x41, 0x80,
  0x30, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80,
  0x20, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x60, 0x00, 0x00, 0x7E,
  0x00, 0x70, 0x60, 0x30, 0x08, 0x18, 0x03, 0x04, 0x00, 0x42, 0x00, 0x11,
  0x80, 0x04, 0x40, 0x41, 0x30, 0x7C, 0x48, 0x23, 0x12, 0x10, 0x85, 0x84,
  0x21, 0x42, 0x18, 0x50, 0x86, 0x34, 0x61, 0x09, 0x18, 0x42, 0xC4, 0x30,
  0xA1, 0x0C, 0x68, 0x42, 0x12, 0x11, 0x84, 0x84, 0x62, 0x21, 0xE7, 0x08,
  0x30, 0x82, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x40, 0x07, 0xF0, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x50, 0x02, 0x80, 0x34, 0x01, 0x20, 0x19, 0x00, 0x88, 0x04, 0x40, 0x62,
  0x02, 0x10, 0x30, 0x81, 0x04, 0x08, 0x20, 0xFF, 0x07, 0xF8, 0x60, 0x42,
  0x02, 0x10, 0x11, 0x80, 0x88, 0x04, 0xC0, 0x24, 0x01, 0x60, 0x0B, 0x00,
  0x70, 0x02, 0x03, 0xF8, 0x0C, 0x38, 0x18, 0x10, 0x20, 0x30, 0x40, 0x60,
  0x80, 0xC3, 0x01, 0x86, 0x02, 0x08, 0x04, 0x10, 0x18, 0x20, 0x60, 0xC1,
  0x81, 0xFC, 0x02, 0x1C, 0x04, 0x0C, 0x08, 0x08, 0x30, 0x18, 0x60, 0x30,
  0x80, 0x61, 0x00, 0xC6, 0x01, 0x0C, 0x02, 0x10, 0x0C, 0x20, 0x10, 0x40,
  0x61, 0x87, 0x03, 0xFC, 0x00, 0x00, 0x18, 0x01, 0xFC, 0x06, 0x08, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC1, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x0C, 0x30, 0x18, 0x30, 0x30, 0x30, 0x40, 0x60, 0x80, 0x43, 0x00, 0x86,
  0x01, 0x08, 0x02, 0x10, 0x04, 0x20, 0x08, 0xC0, 0x11, 0x80, 0x62, 0x00,
  0xC4, 0x01, 0x98, 0x02, 0x30, 0x04, 0x60, 0x18, 0x80, 0x21, 0x00, 0xC6,
  0x01, 0x8C, 0x06, 0x10, 0x08, 0x20, 0x30, 0x40, 0xC1, 0x8E, 0x03, 0xF0,
  0x00, 0x03, 0xFE, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0xFF, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x7F, 0x80,
  0x60, 0x60, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0xF8, 0x80, 0xFC, 0x40, 0x04, 0x60, 0x02, 0x30, 0x01, 0x18,
  0x01, 0x8C, 0x00, 0xC6, 0x00, 0x41, 0x00, 0x20, 0x80, 0x30, 0x60, 0x18,
  0x10, 0x0C, 0x0E, 0x04, 0x01, 0xFE, 0x00, 0x02, 0x00, 0xC1, 0x80, 0x20,
  0x60, 0x08, 0x10, 0x06, 0x04, 0x01, 0x81, 0x00, 0x40, 0xC0, 0x10, 0x30,
  0x04, 0x08, 0x03, 0x02, 0x00, 0xC0, 0x80, 0x20, 0x60, 0x08, 0x1F, 0xFE,
  0x04, 0x01, 0x81, 0x00, 0x60, 0xC0, 0x10, 0x30, 0x04, 0x08, 0x03, 0x02,
  0x00, 0xC0, 0x80, 0x20, 0x60, 0x08, 0x18, 0x02, 0x04, 0x01, 0x81, 0x00,
  0x60, 0x40, 0x10, 0x30, 0x04, 0x0C, 0x03, 0x00, 0x07, 0xF0, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0xFC,
  0x00, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0xF0, 0x0E, 0x00, 0x02, 0x03, 0x06, 0x02, 0x06, 0x06, 0x04, 0x0C,
  0x04, 0x18, 0x04, 0x10, 0x0C, 0x30, 0x0C, 0x60, 0x08, 0xC0, 0x08, 0x80,
  0x09, 0x80, 0x1B, 0x00, 0x1B, 0x00, 0x15, 0x00, 0x19, 0x00, 0x31, 0x00,
  0x31, 0x80, 0x21, 0x80, 0x20, 0x80, 0x20, 0x80, 0x60, 0xC0, 0x60, 0xC0,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0x02, 0x03,
  0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00,
  0x80, 0x40, 0x60, 0x3F, 0xE0, 0x03, 0x00, 0x06, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x28, 0x00, 0xF0, 0x50, 0x01, 0x40, 0xA0, 0x06, 0x83, 0x40,
  0x09, 0x06, 0x80, 0x16, 0x09, 0x00, 0x6C, 0x12, 0x00, 0x90, 0x24, 0x03,
  0x20, 0xC8, 0x04, 0xC1, 0x90, 0x19, 0x82, 0x30, 0x22, 0x04, 0x60, 0xC4,
  0x18, 0xC1, 0x08, 0x31, 0x86, 0x30, 0x43, 0x08, 0x60, 0x86, 0x30, 0x81,
  0x0C, 0x41, 0x06, 0x09, 0x82, 0x0C, 0x12, 0x0C, 0x10, 0x2C, 0x18, 0x20,
  0x50, 0x20, 0x40, 0xE0, 0x41, 0x81, 0x81, 0x83, 0x03, 0x03, 0x00, 0x03,
  0x00, 0x60, 0xE0, 0x08, 0x1C, 0x01, 0x02, 0x80, 0x60, 0x50, 0x0C, 0x0B,
  0x01, 0x03, 0x60, 0x20, 0x64, 0x0C, 0x08, 0x81, 0x81, 0x10, 0x20, 0x22,
  0x04, 0x0C, 0x60, 0x81, 0x8C, 0x30, 0x20, 0x86, 0x04, 0x10, 0x81, 0x82,
  0x10, 0x30, 0x62, 0x06, 0x0C, 0xC0, 0x80, 0x98, 0x10, 0x12, 0x06, 0x02,
  0x40, 0xC0, 0x48, 0x10, 0x0F, 0x02, 0x01, 0xC0, 0x40, 0x18, 0x18, 0x03,
  0x03, 0x00, 0x60, 0x00, 0x00, 0x20, 0x01, 0xFC, 0x03, 0x06, 0x06, 0x06,
  0x04, 0x02, 0x0C, 0x02, 0x18, 0x03, 0x10, 0x03, 0x10, 0x03, 0x30, 0x02,
  0x20, 0x02, 0x20, 0x02, 0x60, 0x02, 0x60, 0x02, 0x40, 0x06, 0x40, 0x06,
  0x40, 0x04, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18,
  0xC0, 0x10, 0xC0, 0x30, 0x40, 0x20, 0x60, 0x60, 0x30, 0xC0, 0x3F, 0x00,
  0x03, 0xF0, 0x18, 0xE0, 0x60, 0xC1, 0x83, 0x04, 0x04, 0x10, 0x10, 0xC0,
  0x43, 0x01, 0x08, 0x04, 0x20, 0x30, 0x80, 0x86, 0x06, 0x18, 0x30, 0x41,
  0x81, 0xFC, 0x0F, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x20, 0x01, 0xFC, 0x03, 0x06, 0x06, 0x06, 0x04, 0x02, 0x0C, 0x02,
  0x18, 0x03, 0x10, 0x03, 0x10, 0x03, 0x30, 0x02, 0x20, 0x02, 0x20, 0x02,
  0x60, 0x02, 0x60, 0x02, 0x40, 0x06, 0x40, 0x06, 0x40, 0x04, 0xC0, 0x04,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x10, 0xC0, 0x30,
  0x40, 0x20, 0x60, 0x60, 0x30, 0xC0, 0x3F, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0xF0,
  0x18, 0x60, 0x60, 0xC1, 0x03, 0x04, 0x04, 0x10, 0x10, 0xC0, 0x43, 0x01,
  0x08, 0x0C, 0x20, 0x30, 0x80, 0x86, 0x06, 0x18, 0x30, 0x43, 0x81, 0xF8,
  0x0C, 0x60, 0x31, 0x80, 0xC6, 0x02, 0x08, 0x08, 0x20, 0x60, 0x81, 0x83,
  0x04, 0x0C, 0x10, 0x10, 0x40, 0x43, 0x01, 0x0C, 0x06, 0x00, 0x00, 0x20,
  0x03, 0xFC, 0x0C, 0x08, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC3, 0x07,
  0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x00, 0x04, 0x01, 0x0C, 0x03,
  0x0C, 0x03, 0x08, 0x02, 0x08, 0x02, 0x18, 0x02, 0x18, 0x06, 0x10, 0x06,
  0x10, 0x04, 0x10, 0x04, 0x30, 0x04, 0x30, 0x0C, 0x20, 0x0C, 0x20, 0x08,
  0x20, 0x08, 0x60, 0x18, 0x60, 0x18, 0x40, 0x10, 0x40, 0x10, 0xC0, 0x10,
  0xC0, 0x30, 0xC0, 0x20, 0xC0, 0x20, 0xC0, 0x60, 0x40, 0x40, 0x61, 0x80,
  0x3F, 0x00, 0xC0, 0x0F, 0x00, 0x6C, 0x01, 0x30, 0x0C, 0xC0, 0x33, 0x00,
  0x8C, 0x06, 0x30, 0x10, 0xC0, 0xC3, 0x02, 0x0C, 0x08, 0x30, 0x60, 0xC1,
  0x03, 0x0C, 0x0C, 0x20, 0x31, 0x80, 0xC6, 0x03, 0x10, 0x0C, 0xC0, 0x32,
  0x00, 0xD8, 0x03, 0x40, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x00, 0xC0, 0x10, 0x07, 0x80, 0x60, 0x0B, 0x00, 0xC0, 0x36, 0x01,
  0x80, 0x6C, 0x05, 0x00, 0x98, 0x0A, 0x03, 0x20, 0x34, 0x04, 0x40, 0x48,
  0x18, 0x80, 0x90, 0x31, 0x02, 0x20, 0x42, 0x04, 0x41, 0x84, 0x18, 0x82,
  0x08, 0x21, 0x0C, 0x10, 0x42, 0x10, 0x21, 0x84, 0x20, 0x42, 0x08, 0xC0,
  0x8C, 0x31, 0x01, 0x10, 0x66, 0x02, 0x20, 0xC8, 0x04, 0xC1, 0x90, 0x09,
  0x03, 0x60, 0x16, 0x06, 0x80, 0x28, 0x0F, 0x00, 0x50, 0x1C, 0x00, 0xE0,
  0x28, 0x01, 0x80, 0x70, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x81,
  0x80, 0x40, 0x80, 0x20, 0xC0, 0x10, 0x40, 0x08, 0x60, 0x06, 0x20, 0x03,
  0x30, 0x01, 0x90, 0x00, 0x50, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x06, 0x80, 0x02, 0x40, 0x03, 0x20, 0x01, 0x10,
  0x01, 0x88, 0x01, 0x84, 0x00, 0x82, 0x00, 0xC1, 0x80, 0x40, 0xC0, 0x60,
  0x60, 0x20, 0x30, 0x30, 0x08, 0x00, 0x60, 0x1B, 0x01, 0x98, 0x08, 0xC0,
  0xC2, 0x04, 0x10, 0x60, 0x82, 0x04, 0x30, 0x21, 0x01, 0x18, 0x08, 0x80,
  0x6C, 0x03, 0x40, 0x1E, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x00, 0x03, 0xFF, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0xFE, 0x00, 0x84, 0x31, 0x84, 0x21, 0x08, 0x43,
  0x18, 0x42, 0x10, 0x84, 0x31, 0x84, 0x21, 0x08, 0x43, 0x18, 0x42, 0x03,
  0xF8, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0x80, 0xFC, 0x00, 0x01, 0x00, 0x0E, 0x00, 0x28, 0x01, 0x30,
  0x0C, 0x40, 0x21, 0x01, 0x86, 0x04, 0x08, 0x30, 0x30, 0x80, 0x46, 0x01,
  0x90, 0x06, 0xC0, 0x0C, 0xFF, 0xFF, 0xF0, 0x99, 0x22, 0x40, 0x07, 0xC8,
  0x61, 0x46, 0x0A, 0x20, 0x33, 0x01, 0x10, 0x09, 0x80, 0x4C, 0x06, 0x40,
  0x32, 0x01, 0x30, 0x09, 0x80, 0x4C, 0x06, 0x60, 0x33, 0x01, 0x18, 0x18,
  0xC0, 0xC6, 0x0E, 0x18, 0xB0, 0xF9, 0x00, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x37,
  0xC0, 0xB1, 0x83, 0x82, 0x0C, 0x08, 0x60, 0x31, 0x80, 0xC6, 0x02, 0x10,
  0x08, 0x40, 0x23, 0x00, 0x88, 0x06, 0x20, 0x18, 0x80, 0x42, 0x01, 0x18,
  0x0C, 0x60, 0x21, 0x81, 0x86, 0x04, 0x34, 0x60, 0x9F, 0x00, 0x07, 0xE1,
  0x80, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x84,
  0x1F, 0x00, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x0F, 0x90, 0x30, 0xA0, 0xC1,
  0x41, 0x01, 0x86, 0x02, 0x08, 0x04, 0x30, 0x18, 0x60, 0x30, 0x80, 0x61,
  0x00, 0x86, 0x01, 0x0C, 0x02, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x20, 0xC0,
  0xC1, 0x81, 0x83, 0x07, 0x03, 0x16, 0x07, 0xC8, 0x00, 0x07, 0xC1, 0x8C,
  0x60, 0x88, 0x13, 0x02, 0x40, 0xD8, 0x12, 0x06, 0x43, 0x9F, 0xC3, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x84, 0x1F,
  0x80, 0x00, 0x07, 0x80, 0x06, 0x40, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0xFE, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x07, 0x80, 0x00, 0x01, 0xF2,
  0x06, 0x14, 0x18, 0x28, 0x20, 0x30, 0xC0, 0x41, 0x00, 0x86, 0x03, 0x0C,
  0x06, 0x10, 0x0C, 0x20, 0x10, 0xC0, 0x21, 0x80, 0xC3, 0x01, 0x86, 0x03,
  0x0C, 0x04, 0x18, 0x18, 0x30, 0x30, 0x60, 0xE0, 0x62, 0x80, 0xF9, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x06,
  0x06, 0x18, 0x07, 0xE0, 0x00, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x6F, 0x82, 0x86, 0x18,
  0x30, 0xC1, 0x84, 0x0C, 0x60, 0x63, 0x02, 0x10, 0x10, 0x80, 0x8C, 0x0C,
  0x60, 0x62, 0x02, 0x10, 0x10, 0x81, 0x8C, 0x0C, 0x60, 0x42, 0x02, 0x10,
  0x10, 0x81, 0x8C, 0x0C, 0x00, 0x02, 0x0C, 0x08, 0x00, 0x00, 0x00, 0x06,
  0x08, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x30, 0x60, 0x81, 0x02, 0x0C,
  0x18, 0x20, 0x41, 0x83, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x06, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0xC2, 0x0C, 0x10, 0x40,
  0x86, 0x0C, 0x60, 0x66, 0x02, 0x20, 0x13, 0x00, 0xB0, 0x0F, 0xC0, 0x76,
  0x03, 0x10, 0x10, 0x80, 0x84, 0x0C, 0x20, 0x41, 0x82, 0x0C, 0x10, 0x61,
  0x81, 0x0C, 0x08, 0x00, 0x03, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04,
  0x04, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30,
  0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x0D, 0xF3, 0xE0,
  0xA1, 0x43, 0x0C, 0x1C, 0x10, 0xC1, 0x81, 0x18, 0x18, 0x11, 0x81, 0x03,
  0x18, 0x10, 0x31, 0x03, 0x02, 0x10, 0x30, 0x23, 0x02, 0x02, 0x30, 0x20,
  0x62, 0x02, 0x04, 0x20, 0x60, 0x42, 0x06, 0x04, 0x60, 0x40, 0xC6, 0x04,
  0x0C, 0x40, 0xC0, 0x84, 0x0C, 0x08, 0xC0, 0xC0, 0x8C, 0x08, 0x18, 0x0D,
  0xF0, 0x50, 0xC3, 0x06, 0x18, 0x31, 0x81, 0x8C, 0x0C, 0x60, 0x42, 0x02,
  0x10, 0x11, 0x81, 0x8C, 0x0C, 0x40, 0x42, 0x02, 0x10, 0x31, 0x81, 0x8C,
  0x08, 0x40, 0x42, 0x02, 0x30, 0x31, 0x81, 0x80, 0x07, 0xE0, 0xC2, 0x18,
  0x31, 0x03, 0x30, 0x12, 0x01, 0x60, 0x36, 0x03, 0x40, 0x34, 0x03, 0xC0,
  0x2C, 0x02, 0xC0, 0x6C, 0x06, 0x80, 0x48, 0x0C, 0xC0, 0x8C, 0x18, 0x63,
  0x03, 0xE0, 0x03, 0x7C, 0x02, 0xC6, 0x02, 0x82, 0x03, 0x02, 0x06, 0x03,
  0x06, 0x03, 0x06, 0x03, 0x04, 0x02, 0x04, 0x02, 0x0C, 0x02, 0x0C, 0x02,
  0x08, 0x06, 0x08, 0x04, 0x08, 0x04, 0x18, 0x0C, 0x18, 0x08, 0x18, 0x18,
  0x18, 0x30, 0x14, 0x60, 0x37, 0xC0, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x07, 0xC8, 0x61, 0x46, 0x0A, 0x20, 0x33, 0x01, 0x10, 0x09, 0x80, 0x4C,
  0x06, 0x40, 0x32, 0x01, 0x30, 0x09, 0x80, 0x4C, 0x06, 0x60, 0x33, 0x01,
  0x18, 0x18, 0xC0, 0xC6, 0x0E, 0x18, 0xB0, 0xF9, 0x00, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x00,
  0x0D, 0xE1, 0x60, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10,
  0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x60, 0x00, 0x07, 0xF0, 0xC1, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x83, 0x0F, 0xE0, 0x0C, 0x10,
  0x20, 0x41, 0x8F, 0xC4, 0x08, 0x30, 0x60, 0x81, 0x02, 0x0C, 0x18, 0x20,
  0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0x40, 0xF0, 0x18, 0x18, 0x80, 0x84,
  0x04, 0x20, 0x23, 0x03, 0x18, 0x10, 0x80, 0x84, 0x04, 0x20, 0x63, 0x03,
  0x18, 0x10, 0x80, 0x84, 0x04, 0x60, 0x63, 0x03, 0x18, 0x10, 0x81, 0x84,
  0x1C, 0x31, 0xA0, 0xFB, 0x00, 0xC0, 0x78, 0x0B, 0x03, 0x60, 0x4C, 0x19,
  0x82, 0x30, 0xC6, 0x10, 0xC6, 0x18, 0x83, 0x10, 0x66, 0x0C, 0x81, 0xB0,
  0x34, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x00, 0xC0, 0xC0, 0xF0,
  0x30, 0x2C, 0x0C, 0x1B, 0x05, 0x04, 0xC1, 0x41, 0x30, 0xD0, 0xCC, 0x24,
  0x23, 0x19, 0x08, 0xC4, 0x44, 0x31, 0x11, 0x0C, 0xC4, 0xC3, 0x21, 0x20,
  0xD8, 0x48, 0x34, 0x16, 0x0D, 0x05, 0x02, 0xC1, 0xC0, 0xA0, 0x60, 0x28,
  0x38, 0x0C, 0x0E, 0x03, 0x03, 0x00, 0x06, 0x06, 0x0C, 0x18, 0x08, 0x60,
  0x10, 0x80, 0x23, 0x00, 0x44, 0x00, 0xD8, 0x01, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x48, 0x01, 0x90, 0x02, 0x20, 0x0C, 0x60,
  0x30, 0xC0, 0x40, 0x81, 0x81, 0x06, 0x02, 0x00, 0x01, 0x00, 0x80, 0x80,
  0xC0, 0x40, 0x40, 0x20, 0x60, 0x10, 0x20, 0x08, 0x10, 0x04, 0x18, 0x02,
  0x08, 0x01, 0x0C, 0x00, 0x84, 0x00, 0x46, 0x00, 0x22, 0x00, 0x13, 0x00,
  0x09, 0x00, 0x04, 0x80, 0x02, 0xC0, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xE0,
  0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0,
  0x10, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x04,
  0x7F, 0x00, 0x00, 0x78, 0x06, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x03, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xC0, 0x07, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x03, 0x00, 0x0D, 0x00, 0x30, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x0F, 0x00, 0xE0, 0x00, 0x7C, 0x0E, 0x38, 0x60, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 27, 8, 1, -27 },
  { 25, 8, 10, 10, 4, -27 },
  { 35, 15, 27, 14, 0, -27 },
  { 86, 14, 31, 13, 0, -29 },
  { 141, 17, 28, 20, 2, -28 },
  { 201, 12, 28, 13, 0, -28 },
  { 243, 3, 10, 6, 4, -27 },
  { 247, 10, 33, 9, 1, -27 },
  { 289, 11, 33, 9, -3, -27 },
  { 335, 10, 11, 12, 4, -29 },
  { 349, 13, 17, 15, 1, -22 },
  { 377, 5, 9, 6, -2, -4 },
  { 383, 8, 1, 10, 1, -11 },
  { 384, 2, 3, 6, 1, -3 },
  { 385, 16, 27, 11, -2, -27 },
  { 439, 12, 28, 13, 1, -28 },
  { 481, 7, 27, 13, 4, -27 },
  { 505, 14, 28, 13, -1, -28 },
  { 554, 15, 28, 13, -1, -28 },
  { 607, 15, 27, 13, -1, -27 },
  { 658, 15, 27, 13, -1, -27 },
  { 709, 13, 28, 13, 1, -28 },
  { 755, 14, 27, 13, 1, -27 },
  { 803, 14, 28, 13, 0, -28 },
  { 852, 13, 28, 13, 0, -28 },
  { 898, 6, 20, 6, 0, -20 },
  { 913, 8, 25, 6, -2, -20 },
  { 938, 13, 15, 15, 1, -21 },
  { 963, 13, 9, 15, 1, -18 },
  { 978, 13, 15, 15, 1, -21 },
  { 1003, 11, 28, 10, 0, -28 },
  { 1042, 18, 30, 20, 1, -27 },
  { 1110, 13, 27, 13, -3, -27 },
  { 1154, 15, 27, 15, 0, -27 },
  { 1205, 15, 28, 13, 1, -28 },
  { 1258, 15, 27, 16, 0, -27 },
  { 1309, 15, 27, 13, 0, -27 },
  { 1360, 15, 27, 12, 0, -27 },
  { 1411, 17, 28, 17, 1, -28 },
  { 1471, 18, 27, 17, 0, -27 },
  { 1532, 12, 27, 7, -2, -27 },
  { 1573, 12, 34, 6, -5, -27 },
  { 1624, 16, 27, 14, 0, -27 },
  { 1678, 9, 27, 12, 0, -27 },
  { 1709, 23, 27, 23, 0, -27 },
  { 1787, 19, 27, 18, 0, -27 },
  { 1852, 16, 28, 17, 1, -28 },
  { 1908, 14, 27, 14, 0, -27 },
  { 1956, 16, 35, 17, 1, -28 },
  { 2026, 14, 27, 14, 0, -27 },
  { 2074, 15, 28, 13, -1, -28 },
  { 2127, 12, 27, 12, 2, -27 },
  { 2168, 16, 27, 16, 1, -27 },
  { 2222, 14, 27, 14, 3, -27 },
  { 2270, 23, 27, 23, 3, -27 },
  { 2348, 17, 27, 12, -2, -27 },
  { 2406, 13, 27, 12, 2, -27 },
  { 2450, 16, 27, 12, -2, -27 },
  { 2504, 14, 33, 10, -1, -27 },
  { 2562, 5, 27, 12, 4, -27 },
  { 2579, 13, 33, 10, -2, -27 },
  { 2633, 14, 13, 15, 1, -27 },
  { 2656, 10, 2, 10, -3, 3 },
  { 2659, 3, 6, 8, 6, -29 },
  { 2662, 13, 20, 15, 1, -20 },
  { 2695, 14, 29, 14, 0, -29 },
  { 2746, 11, 20, 11, 1, -20 },
  { 2774, 15, 29, 15, 1, -29 },
  { 2829, 11, 20, 13, 1, -20 },
  { 2857, 17, 38, 7, -5, -29 },
  { 2938, 15, 29, 15, -1, -20 },
  { 2993, 13, 29, 14, 0, -29 },
  { 3041, 7, 27, 6, 0, -27 },
  { 3065, 13, 36, 6, -5, -27 },
  { 3124, 13, 29, 12, 0, -29 },
  { 3172, 8, 29, 6, 0, -29 },
  { 3201, 20, 20, 21, 0, -20 },
  { 3251, 13, 20, 14, 0, -20 },
  { 3284, 12, 20, 14, 1, -20 },
  { 3314, 16, 29, 15, -2, -20 },
  { 3372, 13, 29, 15, 1, -20 },
  { 3420, 11, 20, 9, 0, -20 },
  { 3448, 12, 20, 11, -1, -20 },
  { 3478, 7, 25, 7, 1, -25 },
  { 3500, 13, 20, 14, 1, -20 },
  { 3533, 11, 20, 11, 2, -20 },
  { 3561, 18, 20, 18, 2, -20 },
  { 3606, 15, 20, 11, -2, -20 },
  { 3644, 17, 29, 12, -4, -20 },
  { 3706, 11, 20, 9, -1, -20 },
  { 3734, 13, 33, 12, 1, -27 },
  { 3788, 1, 38, 13, 6, -29 },
  { 3793, 13, 33, 12, -2, -27 },
  { 3847, 13, 3, 15, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC38PT7B_H_
