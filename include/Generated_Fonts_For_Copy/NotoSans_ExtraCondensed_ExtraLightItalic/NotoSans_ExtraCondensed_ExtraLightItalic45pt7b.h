#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC45PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x02,
  0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x04, 0x06, 0x03, 0x01,
  0x80, 0x30, 0xCC, 0x23, 0x08, 0x86, 0x21, 0x98, 0x46, 0x11, 0x04, 0x43,
  0x10, 0x8C, 0x20, 0x00, 0x30, 0xC0, 0x08, 0x20, 0x06, 0x18, 0x01, 0x06,
  0x00, 0x41, 0x00, 0x30, 0xC0, 0x08, 0x30, 0x02, 0x08, 0x01, 0x86, 0x07,
  0xFF, 0xF1, 0xFF, 0xFC, 0x0C, 0x10, 0x03, 0x0C, 0x00, 0x82, 0x00, 0x60,
  0x80, 0x18, 0x60, 0x04, 0x10, 0x01, 0x04, 0x00, 0xC3, 0x00, 0x20, 0xC0,
  0xFF, 0xFE, 0x3F, 0xFF, 0x81, 0x86, 0x00, 0x41, 0x00, 0x30, 0xC0, 0x0C,
  0x30, 0x02, 0x08, 0x01, 0x82, 0x00, 0x61, 0x80, 0x10, 0x40, 0x04, 0x10,
  0x03, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x1F, 0xF0, 0x19, 0x9C, 0x18, 0x80, 0x18, 0x40, 0x0C, 0x20, 0x04, 0x10,
  0x02, 0x18, 0x01, 0x08, 0x00, 0xC4, 0x00, 0x62, 0x00, 0x13, 0x00, 0x0D,
  0x80, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x13, 0x00,
  0x08, 0x80, 0x04, 0x60, 0x02, 0x30, 0x03, 0x08, 0x01, 0x0C, 0x00, 0x86,
  0x00, 0x43, 0x00, 0x61, 0x04, 0x31, 0x83, 0x97, 0x80, 0xFF, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x78, 0x06, 0x0C, 0xC0, 0x41, 0x8C, 0x0C, 0x30, 0x40, 0x83, 0x04,
  0x18, 0x20, 0xC1, 0x06, 0x0C, 0x30, 0x60, 0xC2, 0x04, 0x0C, 0x60, 0x40,
  0x84, 0x0C, 0x08, 0xC0, 0xC1, 0x88, 0x0C, 0x19, 0x84, 0xC1, 0x11, 0xFC,
  0x33, 0x31, 0xC3, 0x26, 0x1C, 0x66, 0x41, 0xC4, 0x4C, 0x17, 0xCC, 0xC1,
  0x10, 0x88, 0x10, 0x19, 0x81, 0x01, 0x18, 0x30, 0x31, 0x83, 0x02, 0x10,
  0x30, 0x61, 0x02, 0x04, 0x10, 0x20, 0xC1, 0x06, 0x08, 0x10, 0x41, 0x81,
  0x0C, 0x10, 0x10, 0x83, 0x01, 0x98, 0x20, 0x1F, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x7C, 0x00, 0xCC, 0x01, 0x86, 0x01, 0x86, 0x01, 0x06, 0x03,
  0x04, 0x03, 0x04, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x18, 0x03, 0x18, 0x01,
  0x30, 0x01, 0x60, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x80, 0x0C,
  0xC0, 0x18, 0xC3, 0x18, 0x42, 0x30, 0x66, 0x20, 0x66, 0x60, 0x64, 0x60,
  0x2C, 0x40, 0x38, 0x40, 0x38, 0xC0, 0x38, 0x40, 0x30, 0x40, 0x78, 0x60,
  0xD8, 0x71, 0x88, 0x3F, 0x0C, 0x33, 0x32, 0x26, 0x66, 0x44, 0xC0, 0x00,
  0x18, 0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x20, 0x02, 0x0C, 0x20, 0x62, 0x01, 0xEF, 0x07,
  0x00, 0xE0, 0x13, 0x02, 0x10, 0xC1, 0x80, 0x08, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x0C, 0x31, 0x86, 0x10, 0xC2, 0x18, 0x43, 0x00, 0xFF, 0xFF,
  0xF0, 0x7F, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x01, 0xF0, 0x06, 0x30,
  0x18, 0x20, 0x60, 0x60, 0x80, 0xC3, 0x01, 0x84, 0x03, 0x18, 0x06, 0x30,
  0x0C, 0x40, 0x19, 0x80, 0x33, 0x00, 0x44, 0x00, 0x98, 0x03, 0x30, 0x06,
  0x60, 0x0C, 0xC0, 0x19, 0x00, 0x26, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30,
  0x04, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x43, 0x01, 0x86, 0x03, 0x0C, 0x0C,
  0x18, 0x10, 0x10, 0x60, 0x31, 0x80, 0x3E, 0x00, 0x03, 0x07, 0x1F, 0x3B,
  0x62, 0xC6, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18,
  0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60,
  0x40, 0xC0, 0xC0, 0xC0, 0x00, 0x18, 0x00, 0x3F, 0xC0, 0x1C, 0x38, 0x04,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0xFF, 0x00,
  0xE1, 0xC0, 0x40, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x81, 0x83, 0x80, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0x40, 0x01, 0xA0, 0x00, 0xB0, 0x00, 0xD8, 0x00, 0x4C, 0x00,
  0x64, 0x00, 0x62, 0x00, 0x23, 0x00, 0x31, 0x80, 0x30, 0xC0, 0x18, 0x40,
  0x18, 0x60, 0x08, 0x30, 0x0C, 0x18, 0x0C, 0x0C, 0x04, 0x04, 0x06, 0x06,
  0x02, 0x03, 0x03, 0x01, 0x83, 0x00, 0x81, 0x00, 0x41, 0xFF, 0xFC, 0xFF,
  0xFE, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x01, 0xFF, 0x80, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x7F, 0x00, 0x31, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x03, 0x07, 0x01, 0xFF, 0x00,
  0x00, 0x0C, 0x00, 0x7F, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x21, 0x80, 0x27, 0xF0, 0x6C, 0x30, 0x70, 0x18, 0x70, 0x18,
  0x60, 0x18, 0x60, 0x08, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18,
  0xC0, 0x18, 0xC0, 0x10, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x20, 0xC0, 0x60,
  0x60, 0xC0, 0x71, 0x80, 0x3F, 0x00, 0x3F, 0xFF, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x7F, 0x00, 0x70, 0xC0, 0x60, 0x30, 0x20, 0x18, 0x30, 0x04, 0x18,
  0x02, 0x0C, 0x01, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x40, 0xC0, 0x60,
  0x30, 0x60, 0x18, 0x60, 0x06, 0x60, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xB8,
  0x03, 0x8C, 0x03, 0x03, 0x03, 0x00, 0x81, 0x80, 0x61, 0x80, 0x30, 0xC0,
  0x08, 0x40, 0x04, 0x60, 0x02, 0x30, 0x01, 0x18, 0x01, 0x84, 0x00, 0xC3,
  0x00, 0xC1, 0xC0, 0x60, 0x70, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x30, 0x01,
  0xFC, 0x03, 0x8C, 0x06, 0x06, 0x06, 0x02, 0x0C, 0x02, 0x0C, 0x03, 0x18,
  0x03, 0x18, 0x03, 0x18, 0x03, 0x10, 0x03, 0x10, 0x02, 0x30, 0x02, 0x30,
  0x06, 0x30, 0x06, 0x30, 0x0E, 0x10, 0x0E, 0x18, 0x1E, 0x1C, 0x34, 0x0F,
  0xEC, 0x01, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x87,
  0x00, 0xFE, 0x00, 0x06, 0x0C, 0x38, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x1C, 0x38, 0x60,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x40, 0x60, 0x20, 0x30, 0x18, 0x08, 0x0C, 0x04, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x03, 0x01, 0xFE, 0x18,
  0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x01, 0xC1, 0xC0, 0x0C, 0x01, 0x00, 0x60, 0x06, 0x03, 0x00, 0x08,
  0x08, 0x00, 0x30, 0x60, 0x00, 0xC3, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x60,
  0x7E, 0x31, 0x83, 0x10, 0xC4, 0x18, 0x43, 0x30, 0x43, 0x0C, 0x83, 0x0C,
  0x32, 0x08, 0x20, 0x98, 0x60, 0x82, 0x61, 0x06, 0x09, 0x04, 0x18, 0x64,
  0x30, 0x41, 0x90, 0xC3, 0x04, 0xC3, 0x0C, 0x33, 0x08, 0x30, 0xCC, 0x21,
  0xC2, 0x30, 0x86, 0x18, 0xC3, 0x3C, 0xC3, 0x0F, 0x9E, 0x0C, 0x1C, 0x70,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x50, 0x01, 0xA0, 0x02,
  0x40, 0x0C, 0x80, 0x19, 0x00, 0x22, 0x00, 0xC4, 0x01, 0x08, 0x06, 0x10,
  0x0C, 0x20, 0x10, 0x40, 0x60, 0x80, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0F,
  0xF8, 0x3F, 0xF0, 0x60, 0x21, 0x80, 0x43, 0x00, 0x8C, 0x01, 0x18, 0x02,
  0x20, 0x04, 0xC0, 0x09, 0x80, 0x16, 0x00, 0x2C, 0x00, 0x50, 0x00, 0xE0,
  0x01, 0x01, 0xFE, 0x00, 0x43, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00,
  0x80, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x02, 0x06, 0x01, 0x81, 0x80, 0x60,
  0x40, 0x18, 0x30, 0x0C, 0x0C, 0x06, 0x03, 0x03, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x18, 0x18, 0x06, 0x03, 0x01, 0x80, 0x60, 0x40, 0x18, 0x10, 0x06,
  0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x20, 0x06, 0x18, 0x01, 0x06,
  0x00, 0xC1, 0x80, 0x20, 0x60, 0x18, 0x10, 0x1C, 0x0F, 0xFE, 0x03, 0xFE,
  0x00, 0x00, 0x0C, 0x00, 0x3F, 0xC0, 0x70, 0x20, 0x70, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x70, 0x80, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x47, 0xC0, 0x30, 0x38, 0x0C, 0x06, 0x03, 0x00, 0xC0,
  0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x40,
  0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x80, 0x0C, 0x20, 0x03,
  0x18, 0x00, 0x86, 0x00, 0x61, 0x80, 0x18, 0x40, 0x06, 0x10, 0x01, 0x0C,
  0x00, 0xC3, 0x00, 0x30, 0xC0, 0x18, 0x20, 0x06, 0x18, 0x03, 0x06, 0x00,
  0xC1, 0x80, 0x60, 0x40, 0x30, 0x10, 0x38, 0x0F, 0xFC, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x1F, 0xF8, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x07, 0xFC, 0x00, 0xE0, 0x70,
  0x38, 0x02, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x01,
  0xF8, 0xC0, 0x21, 0x0C, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00, 0x30, 0x80,
  0x03, 0x08, 0x00, 0x20, 0x80, 0x06, 0x08, 0x00, 0x60, 0xC0, 0x06, 0x0C,
  0x00, 0x60, 0xC0, 0x04, 0x06, 0x00, 0xC0, 0x70, 0x0C, 0x03, 0xC1, 0xC0,
  0x0F, 0xF8, 0x00, 0x01, 0x80, 0x18, 0x08, 0x00, 0xC0, 0xC0, 0x04, 0x06,
  0x00, 0x60, 0x30, 0x03, 0x01, 0x00, 0x18, 0x18, 0x00, 0x80, 0xC0, 0x04,
  0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x00, 0x18, 0x18, 0x00, 0x80, 0xC0,
  0x04, 0x06, 0x00, 0x60, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x18, 0x00, 0x80,
  0xC0, 0x0C, 0x06, 0x00, 0x60, 0x20, 0x03, 0x01, 0x00, 0x10, 0x18, 0x00,
  0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x20, 0x03, 0x03, 0x00, 0x10, 0x18,
  0x00, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x20, 0x03, 0x03, 0x00, 0x10,
  0x18, 0x01, 0x80, 0x01, 0xFC, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x3F, 0xC0, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x3E, 0x00,
  0x78, 0x00, 0x01, 0x80, 0x60, 0x20, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0,
  0x30, 0x30, 0x04, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x60, 0x06, 0x18, 0x00,
  0xC6, 0x00, 0x10, 0xC0, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x02,
  0x60, 0x00, 0x5C, 0x00, 0x1E, 0xC0, 0x03, 0x98, 0x00, 0x63, 0x00, 0x08,
  0x20, 0x01, 0x04, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x20,
  0x20, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0x80,
  0x30, 0x30, 0x06, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03,
  0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0,
  0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0F, 0xFF, 0xFF, 0x01, 0x80,
  0x00, 0x70, 0x18, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x1E,
  0x03, 0xC0, 0x01, 0xE0, 0x2C, 0x00, 0x34, 0x06, 0xC0, 0x03, 0x40, 0x6C,
  0x00, 0x6C, 0x06, 0xC0, 0x06, 0xC0, 0x6C, 0x00, 0xCC, 0x04, 0xC0, 0x0C,
  0x80, 0xCC, 0x00, 0x88, 0x0C, 0xC0, 0x19, 0x80, 0xCC, 0x01, 0x18, 0x08,
  0xC0, 0x31, 0x80, 0x8C, 0x02, 0x10, 0x18, 0x40, 0x63, 0x01, 0x84, 0x04,
  0x30, 0x18, 0x40, 0xC3, 0x01, 0x04, 0x08, 0x20, 0x10, 0x41, 0x82, 0x03,
  0x04, 0x18, 0x60, 0x30, 0x43, 0x06, 0x03, 0x04, 0x30, 0x60, 0x20, 0x66,
  0x04, 0x06, 0x06, 0x60, 0x40, 0x60, 0x6C, 0x0C, 0x06, 0x06, 0xC0, 0xC0,
  0x40, 0x78, 0x0C, 0x04, 0x07, 0x80, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x07,
  0x01, 0x80, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x38, 0x00, 0x80, 0xF0,
  0x06, 0x03, 0xC0, 0x18, 0x0B, 0x00, 0x60, 0x64, 0x01, 0x81, 0x90, 0x04,
  0x06, 0x60, 0x30, 0x19, 0x80, 0xC0, 0x46, 0x03, 0x03, 0x18, 0x08, 0x0C,
  0x20, 0x20, 0x30, 0x81, 0x80, 0x83, 0x06, 0x02, 0x0C, 0x18, 0x18, 0x30,
  0x40, 0x60, 0x41, 0x01, 0x81, 0x0C, 0x04, 0x04, 0x30, 0x10, 0x18, 0xC0,
  0xC0, 0x62, 0x03, 0x01, 0x98, 0x0C, 0x02, 0x60, 0x20, 0x09, 0x81, 0x80,
  0x34, 0x06, 0x00, 0xD0, 0x18, 0x03, 0xC0, 0x60, 0x0F, 0x01, 0x00, 0x1C,
  0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0x00, 0x10, 0x00, 0x3F, 0x80, 0x18,
  0x30, 0x0C, 0x06, 0x06, 0x01, 0x83, 0x00, 0x20, 0xC0, 0x08, 0x60, 0x03,
  0x18, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0x80, 0x02, 0x60, 0x00, 0x98,
  0x00, 0x26, 0x00, 0x19, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00,
  0x13, 0x00, 0x0C, 0xC0, 0x03, 0x20, 0x00, 0xC8, 0x00, 0x22, 0x00, 0x18,
  0x80, 0x06, 0x20, 0x03, 0x08, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0x18, 0x30,
  0x0C, 0x06, 0x06, 0x01, 0xC3, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x9F, 0x00, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x10, 0x0C, 0x18, 0x06,
  0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x00, 0x61, 0x80, 0x60, 0xC0,
  0x30, 0x60, 0x30, 0x20, 0x18, 0x10, 0x18, 0x18, 0x38, 0x0F, 0xF0, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x3F, 0x80, 0x18, 0x30,
  0x0C, 0x06, 0x06, 0x01, 0x83, 0x00, 0x20, 0xC0, 0x08, 0x60, 0x03, 0x18,
  0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0x80, 0x03, 0x60, 0x00, 0x98, 0x00,
  0x26, 0x00, 0x19, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x13,
  0x00, 0x0C, 0xC0, 0x03, 0x20, 0x00, 0xC8, 0x00, 0x22, 0x00, 0x18, 0x80,
  0x06, 0x20, 0x03, 0x08, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x0C,
  0x06, 0x06, 0x01, 0xC3, 0x00, 0x3F, 0x80, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x8F, 0x00, 0xC0, 0xC0, 0x60, 0x20, 0x30,
  0x18, 0x10, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC1,
  0x00, 0x41, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x30, 0x30, 0x38, 0x10, 0x38,
  0x1F, 0xF0, 0x0F, 0xE0, 0x06, 0x30, 0x02, 0x08, 0x01, 0x06, 0x01, 0x83,
  0x00, 0xC1, 0x80, 0x60, 0xC0, 0x20, 0x20, 0x30, 0x10, 0x18, 0x0C, 0x0C,
  0x06, 0x06, 0x03, 0x02, 0x01, 0x83, 0x00, 0x41, 0x80, 0x20, 0x00, 0x18,
  0x00, 0x3F, 0xE0, 0x1C, 0x1C, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x08, 0x03, 0x03, 0x87, 0x80, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x02, 0x00, 0x20,
  0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x40, 0x04, 0x18, 0x00, 0x83,
  0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x00, 0x10, 0x60, 0x06, 0x0C,
  0x00, 0xC1, 0x80, 0x18, 0x20, 0x02, 0x04, 0x00, 0x41, 0x80, 0x18, 0x30,
  0x03, 0x06, 0x00, 0x60, 0x80, 0x08, 0x10, 0x03, 0x06, 0x00, 0x60, 0xC0,
  0x0C, 0x18, 0x01, 0x02, 0x00, 0x20, 0x40, 0x0C, 0x18, 0x01, 0x83, 0x00,
  0x20, 0x60, 0x0C, 0x04, 0x01, 0x00, 0xC0, 0x60, 0x0C, 0x38, 0x00, 0xFE,
  0x00, 0x80, 0x03, 0x80, 0x06, 0x80, 0x06, 0x80, 0x0C, 0x80, 0x0C, 0x80,
  0x18, 0x80, 0x18, 0x80, 0x10, 0x80, 0x30, 0x80, 0x30, 0x80, 0x60, 0x80,
  0x60, 0x80, 0xC0, 0x80, 0xC0, 0x80, 0x80, 0x81, 0x80, 0x81, 0x80, 0x83,
  0x00, 0x83, 0x00, 0x82, 0x00, 0x86, 0x00, 0x84, 0x00, 0x8C, 0x00, 0x8C,
  0x00, 0x98, 0x00, 0x98, 0x00, 0x90, 0x00, 0xB0, 0x00, 0xA0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0x40, 0x06, 0x00, 0x34, 0x00, 0x60, 0x06,
  0x40, 0x0E, 0x00, 0x64, 0x00, 0xE0, 0x0C, 0x40, 0x0A, 0x00, 0xC4, 0x01,
  0xE0, 0x08, 0x40, 0x16, 0x01, 0x84, 0x01, 0x60, 0x18, 0x40, 0x36, 0x03,
  0x04, 0x02, 0x60, 0x30, 0x40, 0x66, 0x02, 0x04, 0x06, 0x60, 0x60, 0x40,
  0x46, 0x06, 0x04, 0x0C, 0x60, 0xC0, 0x40, 0x86, 0x0C, 0x04, 0x18, 0x60,
  0x80, 0x41, 0x86, 0x18, 0x04, 0x10, 0x61, 0x80, 0x43, 0x06, 0x10, 0x0C,
  0x20, 0x63, 0x00, 0xC6, 0x04, 0x20, 0x0C, 0x60, 0x46, 0x00, 0xC4, 0x04,
  0x60, 0x0C, 0xC0, 0x44, 0x00, 0xC8, 0x04, 0xC0, 0x0D, 0x80, 0x48, 0x00,
  0xD8, 0x05, 0x80, 0x0D, 0x00, 0x58, 0x00, 0xF0, 0x05, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0xE0, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x40, 0x60, 0x04, 0x04, 0x00, 0x40, 0xC0, 0x06, 0x08,
  0x00, 0x61, 0x80, 0x06, 0x10, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0x66,
  0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x05, 0x00, 0x00, 0xD0, 0x00, 0x19, 0x00, 0x01,
  0x90, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x61, 0x80, 0x04, 0x18, 0x00,
  0xC1, 0x80, 0x18, 0x18, 0x01, 0x80, 0x80, 0x30, 0x08, 0x03, 0x00, 0x80,
  0x60, 0x0C, 0x0C, 0x00, 0xC0, 0x40, 0x0D, 0x80, 0x36, 0x01, 0x98, 0x06,
  0x60, 0x31, 0x80, 0xC6, 0x06, 0x18, 0x10, 0x20, 0xC0, 0x82, 0x02, 0x18,
  0x08, 0x40, 0x23, 0x00, 0xC8, 0x03, 0x60, 0x0D, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0x82,
  0x0C, 0x30, 0xC3, 0x04, 0x10, 0x41, 0x86, 0x18, 0x60, 0x82, 0x08, 0x30,
  0xC3, 0x0C, 0x10, 0x41, 0x06, 0x18, 0x61, 0x82, 0x08, 0x20, 0xC3, 0x00,
  0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x01, 0x00, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xE0, 0x03,
  0x60, 0x03, 0x30, 0x06, 0x30, 0x06, 0x18, 0x0C, 0x18, 0x0C, 0x08, 0x18,
  0x0C, 0x10, 0x0C, 0x30, 0x06, 0x20, 0x06, 0x60, 0x03, 0x40, 0x03, 0xC0,
  0x01, 0xFF, 0xF0, 0xCC, 0x46, 0x23, 0x10, 0x01, 0xF1, 0x03, 0x9B, 0x06,
  0x0B, 0x0C, 0x06, 0x18, 0x06, 0x18, 0x06, 0x30, 0x06, 0x30, 0x06, 0x20,
  0x04, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x0C, 0x40, 0x08, 0xC0,
  0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x70, 0x40,
  0x70, 0x60, 0xB0, 0x71, 0xA0, 0x3F, 0x20, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x7C, 0x06, 0xCE, 0x05, 0x06, 0x07, 0x03, 0x0E,
  0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18,
  0x03, 0x10, 0x03, 0x10, 0x02, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30,
  0x0C, 0x20, 0x0C, 0x60, 0x08, 0x70, 0x18, 0x50, 0x10, 0x50, 0x30, 0x58,
  0xE0, 0xCF, 0xC0, 0x01, 0xF8, 0x1C, 0x81, 0x80, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x01, 0xC2, 0x07, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x1F, 0x30, 0x0E, 0x6C, 0x06, 0x0B, 0x03,
  0x01, 0x81, 0x80, 0x60, 0x60, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00,
  0x41, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x04, 0x00, 0xC1, 0x00, 0x20,
  0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0xC0, 0xC0, 0x30, 0x30,
  0x1C, 0x04, 0x07, 0x01, 0x82, 0xC0, 0x71, 0xA0, 0x0F, 0xC8, 0x00, 0x01,
  0xF0, 0x18, 0xC1, 0x86, 0x18, 0x11, 0x80, 0x8C, 0x04, 0xC0, 0x66, 0x03,
  0x20, 0x33, 0x03, 0x18, 0x70, 0xFF, 0x07, 0xC0, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC3,
  0x07, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x31, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x40, 0x39, 0xB0,
  0x18, 0x2C, 0x0C, 0x06, 0x06, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x18, 0x30,
  0x06, 0x0C, 0x01, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x10, 0x02,
  0x04, 0x00, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x03,
  0x00, 0xC0, 0xC0, 0x70, 0x10, 0x1C, 0x06, 0x0B, 0x01, 0xC6, 0x80, 0x3F,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x80, 0xC0, 0x3F, 0xE0, 0x01,
  0xE0, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x19, 0xF0, 0x36,
  0x70, 0x50, 0x60, 0xC0, 0x43, 0x80, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x0C,
  0x20, 0x18, 0xC0, 0x21, 0x80, 0xC3, 0x01, 0x84, 0x03, 0x18, 0x04, 0x30,
  0x08, 0x60, 0x30, 0x80, 0x61, 0x00, 0xC6, 0x01, 0x0C, 0x02, 0x18, 0x0C,
  0x20, 0x18, 0x40, 0x31, 0x80, 0x40, 0x01, 0x81, 0xC0, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18,
  0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x01, 0xF0,
  0x03, 0xC0, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x03, 0x06, 0x06, 0x04, 0x0C, 0x04, 0x18, 0x0C, 0x10, 0x0C, 0x30, 0x0C,
  0x60, 0x08, 0xC0, 0x18, 0x80, 0x19, 0x80, 0x1B, 0x80, 0x17, 0x80, 0x1D,
  0x80, 0x38, 0x80, 0x30, 0x80, 0x30, 0xC0, 0x20, 0xC0, 0x20, 0xC0, 0x60,
  0xC0, 0x60, 0x40, 0x60, 0x40, 0x40, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0x01,
  0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80,
  0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0,
  0x60, 0x00, 0x06, 0x7C, 0x7C, 0x05, 0xCC, 0xE6, 0x05, 0x07, 0x83, 0x06,
  0x07, 0x03, 0x0E, 0x06, 0x03, 0x0C, 0x06, 0x03, 0x0C, 0x06, 0x02, 0x0C,
  0x04, 0x02, 0x18, 0x04, 0x06, 0x18, 0x0C, 0x06, 0x18, 0x0C, 0x06, 0x18,
  0x0C, 0x04, 0x10, 0x08, 0x04, 0x30, 0x18, 0x0C, 0x30, 0x18, 0x0C, 0x30,
  0x18, 0x0C, 0x20, 0x10, 0x08, 0x20, 0x10, 0x18, 0x60, 0x30, 0x18, 0x60,
  0x30, 0x18, 0x60, 0x30, 0x18, 0x40, 0x20, 0x10, 0x40, 0x60, 0x30, 0xC0,
  0x60, 0x30, 0x06, 0x7C, 0x09, 0x9C, 0x14, 0x18, 0x30, 0x10, 0xE0, 0x21,
  0x80, 0xC3, 0x01, 0x86, 0x03, 0x18, 0x06, 0x30, 0x08, 0x60, 0x30, 0xC0,
  0x61, 0x00, 0xC6, 0x01, 0x0C, 0x02, 0x18, 0x0C, 0x20, 0x18, 0x40, 0x31,
  0x80, 0x43, 0x00, 0x86, 0x03, 0x08, 0x06, 0x10, 0x0C, 0x60, 0x10, 0x01,
  0xF0, 0x1C, 0x60, 0x60, 0xC3, 0x03, 0x18, 0x04, 0x60, 0x13, 0x00, 0x4C,
  0x01, 0x20, 0x05, 0x80, 0x36, 0x00, 0xD8, 0x03, 0x40, 0x0D, 0x00, 0x3C,
  0x00, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x4C, 0x03, 0x30, 0x08, 0xC0, 0x61,
  0x83, 0x07, 0x18, 0x0F, 0xC0, 0x01, 0x9F, 0x00, 0x4C, 0xE0, 0x16, 0x18,
  0x07, 0x03, 0x03, 0x80, 0xC0, 0xE0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x02,
  0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x04, 0x00, 0x83, 0x00,
  0x60, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x03, 0x00, 0xC1, 0xC0, 0x20,
  0x70, 0x18, 0x1C, 0x0C, 0x05, 0x03, 0x01, 0x63, 0x80, 0xCF, 0xC0, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF1,
  0x03, 0xBB, 0x06, 0x0B, 0x0C, 0x0E, 0x18, 0x06, 0x18, 0x06, 0x30, 0x06,
  0x30, 0x06, 0x30, 0x04, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x08,
  0x40, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x30,
  0xC0, 0x70, 0xC0, 0x70, 0x60, 0xB0, 0x71, 0xA0, 0x3F, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x06, 0x78, 0x26, 0x41,
  0x40, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x01,
  0xF8, 0x1C, 0x70, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x0C, 0x18, 0x3F, 0xC0, 0x02, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60,
  0xFE, 0x7E, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20,
  0x10, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x18,
  0x0C, 0x07, 0xC0, 0x0C, 0x06, 0x18, 0x0C, 0x20, 0x18, 0xC0, 0x21, 0x80,
  0x43, 0x01, 0x86, 0x03, 0x08, 0x06, 0x30, 0x08, 0x60, 0x10, 0xC0, 0x61,
  0x00, 0xC2, 0x01, 0x8C, 0x02, 0x18, 0x0C, 0x30, 0x18, 0x40, 0x30, 0x80,
  0x63, 0x01, 0x86, 0x03, 0x0C, 0x0E, 0x18, 0x3C, 0x18, 0xD0, 0x3F, 0x20,
  0x80, 0x38, 0x02, 0x80, 0x68, 0x06, 0x80, 0xC8, 0x0C, 0x80, 0x88, 0x18,
  0x81, 0x08, 0x30, 0x83, 0x08, 0x60, 0x86, 0x08, 0x40, 0x8C, 0x08, 0x80,
  0x98, 0x09, 0x00, 0xB0, 0x0B, 0x00, 0xA0, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0x60, 0x38, 0x0E, 0x02, 0x80, 0xA0,
  0x68, 0x1A, 0x04, 0x81, 0xA0, 0xC8, 0x12, 0x0C, 0x83, 0x20, 0x88, 0x22,
  0x18, 0x86, 0x21, 0x08, 0x42, 0x10, 0x84, 0x23, 0x08, 0xC2, 0x20, 0x88,
  0x26, 0x09, 0x82, 0x40, 0x90, 0x24, 0x09, 0x02, 0xC0, 0xB0, 0x68, 0x0A,
  0x07, 0x80, 0xE0, 0x78, 0x0C, 0x07, 0x00, 0xC0, 0x70, 0x0C, 0x06, 0x00,
  0x02, 0x01, 0x81, 0x01, 0x80, 0xC0, 0x80, 0x60, 0xC0, 0x30, 0xC0, 0x08,
  0x60, 0x04, 0x60, 0x03, 0x20, 0x01, 0xB0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0D, 0x00, 0x0C, 0x80, 0x04, 0x60,
  0x06, 0x30, 0x06, 0x18, 0x03, 0x04, 0x03, 0x02, 0x01, 0x01, 0x81, 0x80,
  0xC1, 0x80, 0x60, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x10, 0x0C, 0x00,
  0x80, 0x40, 0x04, 0x06, 0x00, 0x20, 0x30, 0x01, 0x03, 0x00, 0x08, 0x18,
  0x00, 0x40, 0x80, 0x02, 0x0C, 0x00, 0x10, 0x40, 0x00, 0x86, 0x00, 0x04,
  0x20, 0x00, 0x23, 0x00, 0x01, 0x18, 0x00, 0x08, 0x80, 0x00, 0x4C, 0x00,
  0x02, 0x40, 0x00, 0x16, 0x00, 0x00, 0xA0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xB8, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x19, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0x7F, 0x81, 0xC0, 0xE7, 0x80,
  0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 32, 9, 1, -32 },
  { 37, 10, 11, 12, 4, -32 },
  { 51, 18, 32, 17, 0, -32 },
  { 123, 17, 37, 16, 0, -34 },
  { 202, 20, 34, 24, 2, -33 },
  { 287, 16, 33, 15, -1, -33 },
  { 353, 4, 11, 7, 4, -32 },
  { 359, 13, 39, 11, 1, -32 },
  { 423, 12, 39, 11, -3, -32 },
  { 482, 12, 12, 15, 5, -34 },
  { 500, 16, 21, 18, 1, -26 },
  { 542, 6, 10, 7, -2, -4 },
  { 550, 10, 2, 12, 1, -13 },
  { 553, 2, 4, 7, 1, -4 },
  { 554, 19, 32, 14, -2, -32 },
  { 630, 15, 33, 16, 1, -33 },
  { 692, 8, 32, 16, 5, -32 },
  { 724, 18, 33, 16, -2, -33 },
  { 799, 17, 34, 16, -1, -33 },
  { 872, 17, 32, 16, -1, -32 },
  { 940, 17, 32, 16, -1, -32 },
  { 1008, 16, 33, 16, 1, -33 },
  { 1074, 16, 32, 16, 2, -32 },
  { 1138, 17, 33, 16, -1, -33 },
  { 1209, 16, 33, 16, 0, -33 },
  { 1275, 7, 24, 7, 0, -24 },
  { 1296, 9, 30, 7, -2, -24 },
  { 1330, 16, 18, 18, 1, -25 },
  { 1366, 16, 11, 18, 1, -21 },
  { 1388, 16, 18, 18, 1, -25 },
  { 1424, 12, 33, 11, 1, -33 },
  { 1474, 22, 36, 24, 1, -32 },
  { 1573, 15, 32, 15, -3, -32 },
  { 1633, 18, 32, 17, 0, -32 },
  { 1705, 17, 33, 16, 2, -33 },
  { 1776, 18, 32, 19, 0, -32 },
  { 1848, 17, 32, 15, 0, -32 },
  { 1916, 17, 32, 14, 0, -32 },
  { 1984, 20, 33, 21, 2, -33 },
  { 2067, 21, 32, 20, 0, -32 },
  { 2151, 14, 32, 8, -3, -32 },
  { 2207, 15, 40, 7, -6, -32 },
  { 2282, 19, 32, 16, 0, -32 },
  { 2358, 10, 32, 14, 0, -32 },
  { 2398, 28, 32, 27, 0, -32 },
  { 2510, 22, 32, 21, 0, -32 },
  { 2598, 18, 33, 20, 2, -33 },
  { 2673, 17, 32, 16, 0, -32 },
  { 2741, 18, 41, 20, 2, -33 },
  { 2834, 17, 32, 17, 0, -32 },
  { 2902, 18, 33, 16, -1, -33 },
  { 2977, 14, 32, 14, 3, -32 },
  { 3033, 19, 32, 19, 1, -32 },
  { 3109, 16, 32, 16, 4, -32 },
  { 3173, 28, 32, 27, 3, -32 },
  { 3285, 20, 32, 14, -3, -32 },
  { 3365, 14, 32, 14, 3, -32 },
  { 3421, 19, 32, 14, -2, -32 },
  { 3497, 16, 39, 12, -1, -32 },
  { 3575, 6, 32, 15, 5, -32 },
  { 3599, 16, 39, 12, -3, -32 },
  { 3677, 16, 16, 18, 1, -32 },
  { 3709, 12, 1, 12, -3, 4 },
  { 3711, 4, 7, 10, 7, -34 },
  { 3715, 16, 24, 17, 1, -24 },
  { 3763, 16, 34, 17, 0, -34 },
  { 3831, 13, 24, 13, 1, -24 },
  { 3870, 18, 34, 17, 1, -34 },
  { 3947, 13, 24, 15, 1, -24 },
  { 3986, 20, 45, 9, -6, -34 },
  { 4099, 18, 35, 17, -1, -24 },
  { 4178, 15, 34, 17, 0, -34 },
  { 4242, 9, 32, 7, 0, -32 },
  { 4278, 15, 43, 8, -6, -32 },
  { 4359, 16, 34, 14, 0, -34 },
  { 4427, 9, 34, 7, 0, -34 },
  { 4466, 24, 24, 25, 0, -24 },
  { 4538, 15, 24, 17, 0, -24 },
  { 4583, 14, 24, 17, 1, -24 },
  { 4625, 18, 34, 17, -2, -24 },
  { 4702, 16, 35, 18, 1, -24 },
  { 4772, 13, 24, 11, 0, -24 },
  { 4811, 14, 24, 13, -1, -24 },
  { 4853, 9, 30, 9, 1, -30 },
  { 4887, 15, 24, 17, 1, -24 },
  { 4932, 12, 24, 13, 3, -24 },
  { 4968, 20, 24, 21, 3, -24 },
  { 5028, 17, 24, 13, -2, -24 },
  { 5079, 21, 35, 14, -5, -24 },
  { 5171, 14, 24, 11, -2, -24 },
  { 5213, 16, 39, 14, 1, -32 },
  { 5291, 2, 45, 16, 7, -34 },
  { 5303, 16, 39, 14, -3, -32 },
  { 5381, 16, 4, 18, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC45PT7B_H_
