#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC62PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x18, 0x38, 0xC1, 0xCE, 0x0C,
  0x70, 0x63, 0x03, 0x18, 0x38, 0xC1, 0x8E, 0x0C, 0x60, 0x63, 0x03, 0x18,
  0x30, 0xC1, 0x84, 0x0C, 0x60, 0x63, 0x02, 0x18, 0x10, 0x00, 0x03, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x06,
  0x00, 0x0C, 0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C,
  0x00, 0x18, 0x18, 0x00, 0x38, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x30,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60,
  0x00, 0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0,
  0x01, 0x81, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x81, 0x80, 0x03, 0x01, 0x80,
  0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x06, 0x03, 0x00, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x0C, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x0C, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x38, 0x18, 0x00,
  0x30, 0x18, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x60, 0x30, 0x00,
  0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x79, 0x8F, 0x00, 0xE1, 0x82,
  0x01, 0xC1, 0x80, 0x01, 0x81, 0x00, 0x01, 0x83, 0x00, 0x03, 0x83, 0x00,
  0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x02, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x86, 0x00, 0x01, 0x86, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x19, 0x80,
  0x00, 0x11, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x20, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60,
  0x00, 0x60, 0xE0, 0x00, 0x40, 0xC0, 0x00, 0x41, 0xC0, 0x00, 0xC1, 0x80,
  0x40, 0xC7, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x0C, 0x07, 0x38, 0x01, 0x80, 0xE1, 0x80, 0x18, 0x0C, 0x18, 0x03, 0x01,
  0xC0, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x30, 0x1C,
  0x0C, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x18, 0x06, 0x01, 0x81, 0x80,
  0x60, 0x18, 0x30, 0x06, 0x01, 0x83, 0x00, 0x60, 0x38, 0x60, 0x0E, 0x03,
  0x06, 0x00, 0xC0, 0x30, 0xC0, 0x0C, 0x03, 0x0C, 0x00, 0xC0, 0x71, 0x83,
  0xCC, 0x06, 0x18, 0xFE, 0xC0, 0x63, 0x1C, 0x6C, 0x0E, 0x31, 0x83, 0xC0,
  0xC6, 0x30, 0x3C, 0x1C, 0x63, 0x03, 0xC1, 0x8C, 0x60, 0x36, 0x30, 0xC6,
  0x03, 0x7E, 0x18, 0xE0, 0x33, 0xC1, 0x8C, 0x03, 0x00, 0x30, 0xC0, 0x70,
  0x03, 0x1C, 0x06, 0x00, 0x61, 0x80, 0x60, 0x06, 0x18, 0x06, 0x00, 0xC1,
  0x80, 0x60, 0x0C, 0x18, 0x06, 0x01, 0x81, 0x80, 0xE0, 0x18, 0x38, 0x0C,
  0x03, 0x03, 0x00, 0xC0, 0x30, 0x30, 0x1C, 0x06, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x18, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0x30, 0x30, 0x18, 0x01, 0x86,
  0x01, 0x80, 0x1D, 0xC0, 0x30, 0x00, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x7F, 0x00, 0x07, 0x38, 0x00, 0x70, 0xE0, 0x03, 0x07,
  0x00, 0x30, 0x38, 0x01, 0x81, 0xC0, 0x0C, 0x0E, 0x00, 0xE0, 0x70, 0x07,
  0x03, 0x00, 0x38, 0x18, 0x01, 0x81, 0xC0, 0x0C, 0x0C, 0x00, 0x70, 0x60,
  0x03, 0x87, 0x00, 0x1C, 0x30, 0x00, 0x63, 0x00, 0x03, 0x38, 0x00, 0x1B,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x3F, 0x00, 0x03, 0x98, 0x00, 0x38, 0xC0, 0x03, 0x86, 0x06, 0x38, 0x38,
  0x31, 0x80, 0xC3, 0x9C, 0x06, 0x18, 0xC0, 0x30, 0xCE, 0x01, 0xCE, 0x60,
  0x06, 0x63, 0x00, 0x37, 0x18, 0x01, 0xB1, 0xC0, 0x0F, 0x8E, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xF0, 0x60, 0x0D, 0x83, 0x80,
  0xEC, 0x1C, 0x0E, 0x70, 0x7F, 0xE1, 0x81, 0xFE, 0x0C, 0x01, 0x00, 0x00,
  0x18, 0xCE, 0x73, 0x18, 0xC6, 0x63, 0x18, 0xC4, 0x63, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x40, 0xC0, 0xE0, 0x80, 0x38, 0x81, 0x0F, 0x9F, 0x07,
  0xFE, 0x03, 0x80, 0x06, 0x80, 0x0C, 0xC0, 0x18, 0x60, 0x30, 0x60, 0x60,
  0x30, 0x40, 0x30, 0x00, 0x18, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x06, 0x0E, 0x0E, 0x0C,
  0x1C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x6F, 0xFE, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0x38, 0x00,
  0xE0, 0xE0, 0x0E, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0xE0, 0x70, 0x07,
  0x03, 0x00, 0x38, 0x18, 0x01, 0xC1, 0xC0, 0x0E, 0x0C, 0x00, 0x70, 0xE0,
  0x03, 0x86, 0x00, 0x1C, 0x30, 0x00, 0xC3, 0x80, 0x06, 0x1C, 0x00, 0x30,
  0xC0, 0x01, 0x86, 0x00, 0x0C, 0x70, 0x00, 0xE3, 0x00, 0x07, 0x18, 0x00,
  0x38, 0xC0, 0x01, 0x8E, 0x00, 0x0C, 0x70, 0x00, 0x63, 0x80, 0x07, 0x18,
  0x00, 0x38, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0xE3, 0x80, 0x06,
  0x1C, 0x00, 0x30, 0xE0, 0x03, 0x87, 0x00, 0x18, 0x38, 0x00, 0xC1, 0xC0,
  0x0E, 0x0E, 0x00, 0x60, 0x70, 0x07, 0x03, 0x80, 0x30, 0x0C, 0x03, 0x80,
  0x60, 0x18, 0x03, 0x01, 0xC0, 0x1C, 0x1C, 0x00, 0x7F, 0xC0, 0x01, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x3C, 0x0F, 0x83, 0xF1, 0xCC, 0x71,
  0x9C, 0x37, 0x0E, 0x41, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0x60, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x70, 0x0E, 0x00, 0x20, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xE0, 0x03, 0xE1, 0xE0, 0x0F, 0x00, 0xE0, 0x08, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x02, 0x00, 0x70, 0x07,
  0xCF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x06, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x33, 0x00, 0x00, 0x6E, 0x00, 0x01, 0x98, 0x00,
  0x07, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x63, 0x80, 0x01,
  0x86, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x70, 0x00, 0xE0,
  0xE0, 0x01, 0x81, 0x80, 0x07, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x1C,
  0x00, 0xE0, 0x30, 0x01, 0x80, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x30, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x18, 0x06, 0x00, 0x30, 0x0C,
  0x00, 0xE0, 0x30, 0x01, 0xC0, 0xE0, 0x03, 0x09, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x40, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x01, 0x00, 0x38, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x01,
  0xF0, 0xC0, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x87, 0xE0, 0x0E, 0x7F, 0xC0,
  0x3B, 0x83, 0x80, 0xD8, 0x07, 0x03, 0xC0, 0x1C, 0x0E, 0x00, 0x30, 0x78,
  0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x60, 0x00,
  0xE1, 0x80, 0x03, 0x86, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xE0, 0x00, 0xC3,
  0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x60, 0xE0, 0x01, 0x83, 0x80,
  0x0E, 0x06, 0x00, 0x30, 0x18, 0x01, 0xC0, 0x60, 0x06, 0x01, 0xC0, 0x38,
  0x03, 0x81, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x70,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x06, 0x01, 0xC0, 0x06, 0x01, 0x80,
  0x06, 0x01, 0x80, 0x07, 0x01, 0x80, 0x06, 0x03, 0x80, 0x06, 0x03, 0x80,
  0x06, 0x01, 0x80, 0x06, 0x01, 0x80, 0x0E, 0x01, 0x80, 0x0C, 0x01, 0xC0,
  0x18, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x70, 0x00, 0x60, 0xE0, 0x00, 0x71,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xEE,
  0x00, 0x03, 0x87, 0x00, 0x07, 0x03, 0x80, 0x0E, 0x01, 0x80, 0x1C, 0x01,
  0xC0, 0x38, 0x00, 0xC0, 0x30, 0x00, 0xE0, 0x70, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x60, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xE0, 0x00,
  0x60, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0x60, 0x00,
  0xC0, 0x70, 0x01, 0xC0, 0x30, 0x03, 0x80, 0x3C, 0x07, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0x80, 0x07, 0x8F, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x38, 0x06, 0x00, 0x60,
  0x38, 0x01, 0x80, 0xC0, 0x06, 0x07, 0x00, 0x18, 0x18, 0x00, 0x70, 0x60,
  0x01, 0xC3, 0x80, 0x07, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01,
  0x87, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87,
  0x00, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xC0, 0xC0, 0x0F, 0x03, 0x80,
  0x6C, 0x0E, 0x03, 0xB0, 0x1E, 0x3D, 0xC0, 0x3F, 0xC6, 0x00, 0x3E, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x18, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x03, 0xC3, 0xC0, 0x80, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x18, 0x0E, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x1C, 0x30, 0x03, 0xE0, 0x70, 0xC0, 0x3F, 0xC1, 0xC7,
  0x01, 0xC3, 0x07, 0x18, 0x0E, 0x0C, 0x18, 0x60, 0x30, 0x60, 0x63, 0x01,
  0x81, 0x81, 0x8C, 0x0E, 0x06, 0x06, 0x30, 0x30, 0x18, 0x19, 0xC0, 0xC0,
  0xC0, 0x66, 0x06, 0x03, 0x01, 0x98, 0x18, 0x0C, 0x0C, 0x60, 0x60, 0x70,
  0x31, 0x83, 0x01, 0x80, 0xCC, 0x0C, 0x06, 0x03, 0x30, 0x30, 0x18, 0x18,
  0xC0, 0xC0, 0xE0, 0x63, 0x03, 0x03, 0x01, 0x8C, 0x1C, 0x0C, 0x0C, 0x30,
  0x70, 0x70, 0x30, 0xC1, 0xC1, 0xC1, 0xC3, 0x07, 0x0F, 0x06, 0x0C, 0x0C,
  0x2C, 0x30, 0x30, 0x31, 0x99, 0xC0, 0xC0, 0xFC, 0x7E, 0x03, 0x01, 0xE0,
  0xE0, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x06, 0x60, 0x00, 0x33,
  0x00, 0x03, 0x98, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00,
  0x61, 0x80, 0x07, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x18, 0x18,
  0x00, 0xC0, 0xC0, 0x0E, 0x06, 0x00, 0x60, 0x30, 0x07, 0x01, 0x80, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x18, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0x00, 0x30, 0x38, 0x01, 0x81, 0x80, 0x0C, 0x1C, 0x00,
  0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x06, 0x38,
  0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0xE0, 0x00, 0x66, 0x00, 0x03,
  0x70, 0x00, 0x1B, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x60, 0x1C, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00,
  0xC0, 0x03, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x01, 0x80, 0x07, 0x01,
  0x80, 0x07, 0x01, 0x80, 0x06, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x0C, 0x03,
  0x00, 0x1C, 0x03, 0x00, 0x38, 0x03, 0x00, 0x70, 0x07, 0x07, 0xE0, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x06, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x38, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x30, 0x38, 0x00, 0x30, 0x30, 0x00, 0x70, 0x30, 0x00, 0x70, 0x30,
  0x00, 0x60, 0x30, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x60, 0x03, 0x80, 0x60,
  0x07, 0x80, 0x60, 0x3F, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0x87, 0x00, 0x3C, 0x01, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x02, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x18, 0x0F, 0x00, 0x0C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x03, 0x00, 0x0C, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x03, 0x80, 0xE0, 0x01,
  0xC0, 0x70, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00,
  0x0C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x00, 0x03, 0x81, 0x80,
  0x01, 0xC0, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x30, 0x30,
  0x00, 0x18, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x06,
  0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xC0,
  0xE0, 0x00, 0x60, 0x60, 0x00, 0x70, 0x30, 0x00, 0x30, 0x18, 0x00, 0x38,
  0x1C, 0x00, 0x18, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x0E,
  0x03, 0x80, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x1E,
  0x00, 0x30, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x20, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x01, 0xC0,
  0x06, 0x00, 0x78, 0x00, 0x20, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x1F, 0xF0, 0x60,
  0x01, 0xFF, 0x06, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x18, 0x0E, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 0x00, 0x38, 0x00, 0x30, 0x01, 0xC0,
  0x03, 0x00, 0x1E, 0x00, 0x70, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x38, 0x03, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x0E, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x38, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x60, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x0E, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x60, 0x0E, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x18, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0xE0, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0xE0, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80,
  0x38, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0xF8, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x04, 0x70, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x03,
  0x80, 0x0E, 0x00, 0x60, 0x01, 0xC0, 0x1C, 0x00, 0x30, 0x07, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0x80,
  0x00, 0xC0, 0xE0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x07, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x0C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x67, 0x80, 0x00, 0x0D, 0xB0,
  0x00, 0x01, 0xB6, 0x00, 0x00, 0x7C, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x30, 0x1C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18,
  0x06, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x18, 0x01, 0x80,
  0x03, 0x00, 0x30, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x03, 0x80, 0x07, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x0D, 0x80, 0x00, 0x1F, 0x80, 0x36, 0x00, 0x00, 0x6C, 0x00,
  0xD8, 0x00, 0x03, 0xB0, 0x07, 0x60, 0x00, 0x0C, 0xC0, 0x19, 0x80, 0x00,
  0x73, 0x00, 0x66, 0x00, 0x01, 0x9C, 0x01, 0x98, 0x00, 0x0E, 0x60, 0x06,
  0x60, 0x00, 0x31, 0x80, 0x39, 0xC0, 0x00, 0xC6, 0x00, 0xC7, 0x00, 0x06,
  0x38, 0x03, 0x1C, 0x00, 0x18, 0xE0, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x01, 0xC3, 0x00, 0x1C, 0x30, 0x06, 0x0C, 0x00, 0x61,
  0xC0, 0x18, 0x30, 0x03, 0x87, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x83,
  0x00, 0x70, 0x60, 0x0E, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x0E, 0x0E,
  0x00, 0xC0, 0xC0, 0x30, 0x30, 0x03, 0x03, 0x01, 0xC0, 0xC0, 0x1C, 0x0C,
  0x06, 0x03, 0x00, 0x60, 0x30, 0x38, 0x1C, 0x01, 0x80, 0xC0, 0xC0, 0x70,
  0x06, 0x03, 0x07, 0x01, 0x80, 0x18, 0x0C, 0x18, 0x06, 0x00, 0xE0, 0x38,
  0x60, 0x18, 0x03, 0x00, 0xE3, 0x00, 0xE0, 0x0C, 0x03, 0x8C, 0x03, 0x80,
  0x30, 0x0E, 0x60, 0x0C, 0x01, 0xC0, 0x19, 0x80, 0x30, 0x07, 0x00, 0x6E,
  0x00, 0xC0, 0x18, 0x01, 0xB0, 0x07, 0x00, 0x60, 0x07, 0xC0, 0x18, 0x01,
  0x80, 0x1E, 0x00, 0x60, 0x0E, 0x00, 0x78, 0x01, 0x80, 0x30, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x01, 0xE0, 0x00, 0x30, 0x07, 0x80,
  0x01, 0xC0, 0x1E, 0x00, 0x06, 0x00, 0xF8, 0x00, 0x18, 0x03, 0xE0, 0x00,
  0x60, 0x0D, 0xC0, 0x03, 0x80, 0x33, 0x00, 0x0E, 0x00, 0xCC, 0x00, 0x30,
  0x07, 0x30, 0x00, 0xC0, 0x1C, 0xC0, 0x03, 0x00, 0x63, 0x00, 0x1C, 0x01,
  0x8E, 0x00, 0x60, 0x06, 0x18, 0x01, 0x80, 0x38, 0x60, 0x06, 0x00, 0xC1,
  0x80, 0x18, 0x03, 0x06, 0x00, 0xE0, 0x0C, 0x1C, 0x03, 0x00, 0x30, 0x70,
  0x0C, 0x01, 0xC0, 0xC0, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x07,
  0x00, 0x60, 0x30, 0x18, 0x03, 0x80, 0xE0, 0x60, 0x0E, 0x01, 0x81, 0x80,
  0x30, 0x06, 0x0E, 0x00, 0xC0, 0x18, 0x38, 0x03, 0x00, 0x60, 0xC0, 0x1C,
  0x01, 0xC3, 0x00, 0x60, 0x07, 0x0C, 0x01, 0x80, 0x0C, 0x70, 0x06, 0x00,
  0x31, 0x80, 0x18, 0x00, 0xC6, 0x00, 0xE0, 0x03, 0x18, 0x03, 0x00, 0x0E,
  0x60, 0x0C, 0x00, 0x1B, 0x80, 0x30, 0x00, 0x6C, 0x01, 0xC0, 0x01, 0xB0,
  0x07, 0x00, 0x06, 0xC0, 0x18, 0x00, 0x1F, 0x00, 0x60, 0x00, 0x7C, 0x01,
  0x80, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0x8F, 0x80, 0x07, 0x01, 0xC0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x18, 0x07, 0x00, 0x0E, 0x03, 0x00, 0x07,
  0x03, 0x00, 0x03, 0x83, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x61, 0xC0, 0x00,
  0x30, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x70, 0x00, 0x06, 0x30, 0x00,
  0x07, 0x18, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x33, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x0C, 0xE0,
  0x00, 0x0E, 0x60, 0x00, 0x07, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x9C,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x63, 0x80, 0x00, 0x31,
  0xC0, 0x00, 0x38, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E,
  0x1C, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x01, 0x80, 0x03,
  0x80, 0xC0, 0x03, 0x80, 0x70, 0x03, 0x80, 0x18, 0x03, 0x80, 0x0E, 0x03,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0x81, 0xE0, 0x03, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0,
  0x06, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00,
  0x60, 0x30, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0x80, 0x06, 0x03, 0x00, 0x0C,
  0x06, 0x00, 0x38, 0x0C, 0x00, 0x60, 0x38, 0x01, 0xC0, 0x60, 0x07, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0x8F, 0x80, 0x07, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x18, 0x07, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x03, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xC1, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x60,
  0x00, 0x0C, 0x70, 0x00, 0x06, 0x30, 0x00, 0x07, 0x18, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x19, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x07,
  0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x63, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x38, 0xE0, 0x00,
  0x18, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x0E, 0x00,
  0x07, 0x07, 0x00, 0x03, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x03, 0x80, 0x70,
  0x03, 0x80, 0x18, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0x80, 0xE0, 0x03, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03,
  0x00, 0xC0, 0x06, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x18, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0x60, 0x30, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x06, 0x03,
  0x00, 0x1C, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x60,
  0x0F, 0x00, 0xC0, 0x3C, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0E, 0x1C,
  0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x01, 0xC0, 0xE0,
  0x03, 0x81, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x70, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x0E,
  0x00, 0x60, 0x1C, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0x60, 0x03, 0x80, 0xC0,
  0x07, 0x03, 0x80, 0x06, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xC3, 0xE0, 0x07, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x40, 0x01, 0xC0, 0x38, 0x03, 0xC0, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFE, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0x70, 0x18, 0x00, 0x1C, 0x0E, 0x00, 0x06, 0x03,
  0x80, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x0C,
  0x07, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x70, 0x18, 0x00,
  0x1C, 0x06, 0x00, 0x06, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30,
  0x00, 0x38, 0x0C, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x06, 0x03, 0x80, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x0E, 0x03, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x1C, 0x06,
  0x00, 0x06, 0x03, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x38,
  0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00,
  0x60, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x1E,
  0x03, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x6E, 0x00, 0x03, 0xB8, 0x00, 0x0C,
  0xE0, 0x00, 0x33, 0x80, 0x01, 0xCE, 0x00, 0x06, 0x38, 0x00, 0x38, 0xE0,
  0x00, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x18, 0x38, 0x00, 0x60, 0xE0, 0x03,
  0x83, 0x80, 0x0C, 0x0E, 0x00, 0x70, 0x30, 0x01, 0x80, 0xC0, 0x0E, 0x03,
  0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xE0, 0x0C, 0x03, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0x70, 0x03, 0x01, 0x80,
  0x0C, 0x0E, 0x00, 0x30, 0x30, 0x00, 0xC1, 0xC0, 0x03, 0x06, 0x00, 0x0C,
  0x18, 0x00, 0x30, 0xE0, 0x00, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x0C, 0x60,
  0x00, 0x33, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0D, 0xC0, 0x00,
  0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x01, 0xF0,
  0x00, 0x1C, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0xEC, 0x00, 0x0F, 0x00,
  0x06, 0x60, 0x00, 0xF8, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x03, 0x98, 0x00,
  0x36, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x01, 0xC6, 0x00, 0x19, 0x80, 0x0C,
  0x30, 0x00, 0xCC, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x07, 0x0C, 0x00, 0x63,
  0x00, 0x30, 0x60, 0x06, 0x18, 0x03, 0x83, 0x00, 0x31, 0xC0, 0x18, 0x18,
  0x01, 0x8C, 0x00, 0xC0, 0xC0, 0x18, 0x60, 0x0E, 0x06, 0x00, 0xC3, 0x00,
  0x60, 0x30, 0x0E, 0x18, 0x07, 0x01, 0x80, 0x60, 0xC0, 0x30, 0x0C, 0x03,
  0x06, 0x01, 0x80, 0x60, 0x30, 0x30, 0x1C, 0x03, 0x01, 0x81, 0x80, 0xC0,
  0x18, 0x1C, 0x0C, 0x0E, 0x00, 0xC0, 0xC0, 0x60, 0x60, 0x06, 0x06, 0x03,
  0x03, 0x00, 0x30, 0x60, 0x18, 0x38, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x0C,
  0x38, 0x06, 0x1C, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x03, 0x0C, 0x01, 0x86,
  0x00, 0x18, 0xC0, 0x0C, 0x70, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x06, 0x70,
  0x03, 0x38, 0x00, 0x33, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0xCC, 0x00,
  0x0D, 0xC0, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x03, 0x60, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x38, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x71, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x38, 0x1C,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0xE0, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x77, 0x00, 0x06, 0x70, 0x00, 0xE7, 0x00, 0x0C, 0x30, 0x01,
  0xC3, 0x00, 0x18, 0x30, 0x03, 0x83, 0x00, 0x30, 0x30, 0x06, 0x03, 0x00,
  0x60, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x38, 0x18, 0x03, 0x83, 0x80, 0x18,
  0x30, 0x01, 0x87, 0x00, 0x18, 0x60, 0x01, 0x8E, 0x00, 0x18, 0xC0, 0x01,
  0x9C, 0x00, 0x19, 0x80, 0x01, 0xB8, 0x00, 0x1B, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0xC0, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xB0,
  0x00, 0x07, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x60, 0xC0,
  0x01, 0xC1, 0x80, 0x03, 0x03, 0x80, 0x0E, 0x03, 0x00, 0x18, 0x07, 0x00,
  0x70, 0x06, 0x00, 0xC0, 0x0E, 0x03, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x18,
  0x00, 0x38, 0x70, 0x00, 0x30, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x6E, 0x00,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0x86, 0x0C, 0x30, 0x61,
  0x83, 0x0C, 0x00, 0x7F, 0x0C, 0x03, 0xFE, 0x60, 0x1C, 0x19, 0x80, 0xE0,
  0x36, 0x07, 0x00, 0x58, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0x1C,
  0x18, 0x00, 0x70, 0x60, 0x01, 0xC3, 0x80, 0x06, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0x61, 0xC0, 0x03, 0x86, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x60, 0x00,
  0xC3, 0x80, 0x03, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83,
  0x00, 0x06, 0x0C, 0x00, 0x38, 0x30, 0x00, 0xE0, 0xC0, 0x07, 0x03, 0x00,
  0x1C, 0x0C, 0x00, 0x70, 0x30, 0x03, 0xC0, 0xE0, 0x1B, 0x03, 0x80, 0x58,
  0x07, 0x07, 0x60, 0x1F, 0xF9, 0x80, 0x3F, 0xC6, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x7E, 0x00, 0x67, 0xFC, 0x01, 0xB8, 0x38, 0x06,
  0xC0, 0x60, 0x3E, 0x01, 0xC0, 0xF0, 0x07, 0x03, 0x80, 0x0C, 0x0E, 0x00,
  0x30, 0x70, 0x00, 0xC1, 0xC0, 0x03, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x60, 0x01, 0xC3, 0x80, 0x07, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x60, 0xC0,
  0x01, 0x83, 0x00, 0x06, 0x18, 0x00, 0x38, 0x60, 0x00, 0xE1, 0x80, 0x03,
  0x06, 0x00, 0x0C, 0x18, 0x00, 0x70, 0xE0, 0x01, 0x83, 0x80, 0x0E, 0x0E,
  0x00, 0x30, 0x38, 0x00, 0xC1, 0xE0, 0x07, 0x06, 0x80, 0x38, 0x1B, 0x01,
  0xC0, 0x6C, 0x0E, 0x01, 0x9F, 0xF0, 0x0C, 0x3F, 0x80, 0x00, 0x30, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x70, 0x20, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x40, 0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x01, 0xFC, 0x60,
  0x01, 0xFF, 0x30, 0x01, 0xC1, 0x98, 0x01, 0xC0, 0x6C, 0x01, 0xC0, 0x1E,
  0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x60, 0x01,
  0xC0, 0x30, 0x00, 0xE0, 0x38, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00,
  0x18, 0x0E, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x01, 0x80,
  0x03, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x01, 0xC0, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x03,
  0x00, 0x1C, 0x01, 0x80, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x07, 0x80,
  0x38, 0x07, 0xC0, 0x1C, 0x06, 0xC0, 0x07, 0x07, 0x60, 0x03, 0xFF, 0x30,
  0x00, 0xFF, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xE0,
  0x1C, 0x18, 0x0E, 0x07, 0x07, 0x00, 0xC3, 0x80, 0x30, 0xC0, 0x0C, 0x70,
  0x07, 0x18, 0x01, 0x8E, 0x00, 0x63, 0x00, 0x38, 0xC0, 0x0C, 0x70, 0x06,
  0x18, 0x07, 0x86, 0x03, 0xC3, 0xBF, 0xC0, 0xFF, 0xC0, 0x3C, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x80, 0xFB, 0xE0, 0x1F, 0xF0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x47, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE1, 0x80, 0x0F, 0xF9,
  0x80, 0x0E, 0x0C, 0xC0, 0x0E, 0x03, 0x60, 0x0E, 0x00, 0xB0, 0x06, 0x00,
  0x70, 0x06, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x01, 0x80,
  0x07, 0x01, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x70,
  0x00, 0xE0, 0x30, 0x00, 0x70, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x0E,
  0x00, 0x0C, 0x07, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00,
  0xC0, 0x03, 0x80, 0x60, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x18, 0x00, 0xE0,
  0x0C, 0x00, 0x70, 0x06, 0x00, 0x78, 0x03, 0x00, 0x3C, 0x01, 0xC0, 0x3E,
  0x00, 0xE0, 0x36, 0x00, 0x38, 0x3B, 0x00, 0x1F, 0xF9, 0x80, 0x07, 0xF9,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x08,
  0x03, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x3F, 0x80, 0x33, 0xFE, 0x01, 0xB0, 0x38, 0x0F, 0x01, 0xC0,
  0xD0, 0x06, 0x07, 0x80, 0x30, 0x38, 0x01, 0x81, 0xC0, 0x0C, 0x0C, 0x00,
  0xE0, 0xE0, 0x06, 0x07, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x1C,
  0x00, 0xE0, 0xE0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C,
  0x1C, 0x00, 0xE0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80,
  0x1C, 0x1C, 0x00, 0xE0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81,
  0x80, 0x1C, 0x1C, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01,
  0x83, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x8E, 0x00, 0x0F, 0xC0, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x60, 0x0E, 0x01, 0x80,
  0x70, 0x06, 0x01, 0x80, 0x38, 0x0C, 0x00, 0xC0, 0x70, 0x03, 0x03, 0x80,
  0x0C, 0x0C, 0x00, 0x70, 0x60, 0x01, 0xC3, 0x80, 0x06, 0x1C, 0x00, 0x18,
  0xE0, 0x00, 0x63, 0x00, 0x03, 0x9C, 0x00, 0x0C, 0xF0, 0x00, 0x37, 0xC0,
  0x00, 0xDB, 0x00, 0x03, 0xCE, 0x00, 0x1E, 0x18, 0x00, 0x70, 0x60, 0x01,
  0xC1, 0x80, 0x06, 0x06, 0x00, 0x38, 0x18, 0x00, 0xE0, 0x70, 0x03, 0x00,
  0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x80, 0x60, 0x0E, 0x01, 0x80, 0x18, 0x0E, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x00, 0x01, 0x8F, 0xE0, 0xFE, 0x00, 0xCF, 0xF9,
  0xFF, 0x80, 0x6C, 0x1C, 0xC1, 0xC0, 0x7C, 0x06, 0xC0, 0x70, 0x34, 0x03,
  0xC0, 0x38, 0x1C, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x0E, 0x06, 0x00,
  0x70, 0x07, 0x07, 0x00, 0x30, 0x03, 0x03, 0x80, 0x18, 0x01, 0x81, 0xC0,
  0x0C, 0x00, 0xC0, 0xC0, 0x0E, 0x00, 0xE0, 0x60, 0x06, 0x00, 0x70, 0x70,
  0x03, 0x00, 0x30, 0x38, 0x01, 0x80, 0x18, 0x18, 0x01, 0xC0, 0x0C, 0x0C,
  0x00, 0xE0, 0x0E, 0x06, 0x00, 0x60, 0x07, 0x07, 0x00, 0x30, 0x03, 0x03,
  0x00, 0x18, 0x01, 0x81, 0x80, 0x1C, 0x00, 0xC0, 0xC0, 0x0C, 0x00, 0xE0,
  0x60, 0x06, 0x00, 0x60, 0x70, 0x03, 0x00, 0x30, 0x30, 0x03, 0x80, 0x18,
  0x18, 0x01, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0x0E, 0x0E, 0x00, 0x60, 0x06,
  0x07, 0x00, 0x30, 0x03, 0x03, 0x00, 0x38, 0x01, 0x81, 0x80, 0x18, 0x01,
  0xC0, 0xC0, 0x0C, 0x00, 0xE0, 0xE0, 0x06, 0x00, 0x60, 0x00, 0x01, 0x8F,
  0xE0, 0x0C, 0xFF, 0x80, 0x6C, 0x0E, 0x07, 0xC0, 0x70, 0x34, 0x01, 0x81,
  0xE0, 0x0C, 0x0E, 0x00, 0x60, 0x70, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01,
  0x81, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x07, 0x00, 0x38, 0x38,
  0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x07, 0x07, 0x00, 0x38,
  0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x07, 0x07, 0x00,
  0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0xE0, 0x07, 0x07,
  0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0xE0, 0x07,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0x07, 0x01, 0x80, 0x60, 0x70,
  0x0E, 0x1C, 0x01, 0xC3, 0x00, 0x18, 0xE0, 0x03, 0x18, 0x00, 0x67, 0x00,
  0x0C, 0xC0, 0x01, 0x98, 0x00, 0x37, 0x00, 0x06, 0xE0, 0x00, 0xD8, 0x00,
  0x3B, 0x00, 0x07, 0xE0, 0x00, 0xDC, 0x00, 0x1B, 0x80, 0x03, 0x60, 0x00,
  0xEC, 0x00, 0x1D, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x1C, 0xC0, 0x03,
  0x18, 0x00, 0xE3, 0x00, 0x18, 0x60, 0x07, 0x0E, 0x00, 0xC1, 0xC0, 0x38,
  0x1C, 0x0E, 0x01, 0xEF, 0x80, 0x1F, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0xFC, 0x00, 0x19, 0xFF, 0x00, 0x0D, 0xC1, 0xC0, 0x06, 0xC0, 0x60, 0x06,
  0xC0, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x06, 0x00, 0xE0, 0x03, 0x00,
  0xF0, 0x01, 0x80, 0x70, 0x00, 0xC0, 0x38, 0x00, 0x60, 0x18, 0x00, 0x30,
  0x0C, 0x00, 0x18, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x00, 0x07,
  0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0x60, 0x00,
  0xE0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x38, 0x0E, 0x00,
  0x18, 0x07, 0x00, 0x0C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x06, 0x00, 0xE0,
  0x07, 0x00, 0xD0, 0x07, 0x00, 0x6C, 0x07, 0x00, 0x36, 0x07, 0x00, 0x19,
  0xFF, 0x00, 0x1C, 0x7F, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x0C, 0x03, 0xFE, 0x60, 0x1C, 0x1D, 0x80, 0xE0, 0x36,
  0x07, 0x00, 0xD8, 0x38, 0x01, 0xC0, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x18,
  0x00, 0x70, 0x60, 0x01, 0xC3, 0x80, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00,
  0x61, 0xC0, 0x03, 0x86, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC3,
  0x80, 0x03, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00,
  0x06, 0x0C, 0x00, 0x38, 0x30, 0x00, 0xE0, 0xC0, 0x07, 0x03, 0x00, 0x1C,
  0x0C, 0x00, 0x70, 0x30, 0x03, 0xC0, 0xE0, 0x1F, 0x03, 0x80, 0xD8, 0x07,
  0x07, 0x60, 0x1F, 0xF9, 0x80, 0x3F, 0xCE, 0x00, 0x18, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x01, 0x8F, 0xC0, 0x67, 0xE0, 0x1B, 0x80, 0x0D, 0x80, 0x03, 0x40,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0E, 0x03, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x30, 0x0E, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x30, 0x0F, 0xF1, 0xFF, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0F,
  0x60, 0x7E, 0x01, 0x80, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30,
  0xE0, 0x07, 0x0E, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x0E,
  0x1C, 0x00, 0xE1, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x01,
  0xC3, 0x80, 0x18, 0x30, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x87, 0x00,
  0x38, 0x70, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x70, 0xE0,
  0x07, 0x0C, 0x00, 0x60, 0xC0, 0x0E, 0x0C, 0x00, 0xE0, 0xC0, 0x0E, 0x0C,
  0x01, 0xE0, 0xC0, 0x1C, 0x0C, 0x03, 0xC0, 0xE0, 0x6C, 0x0F, 0xFC, 0xC0,
  0x7F, 0x88, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0xE0, 0x01, 0xB0, 0x01, 0xD8,
  0x00, 0xCC, 0x00, 0xE6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x38, 0xC0, 0x18,
  0x60, 0x1C, 0x30, 0x0C, 0x18, 0x0E, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x03,
  0x01, 0x81, 0x80, 0xC1, 0xC0, 0x60, 0xC0, 0x30, 0xE0, 0x18, 0x60, 0x0C,
  0x70, 0x06, 0x30, 0x03, 0x18, 0x01, 0x9C, 0x00, 0xCC, 0x00, 0x6E, 0x00,
  0x36, 0x00, 0x1B, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x6C, 0x00, 0xF0, 0x06, 0xC0, 0x0B, 0x00, 0xEC, 0x01, 0xB0,
  0x0C, 0xC0, 0x1B, 0x00, 0xCC, 0x03, 0x30, 0x1C, 0xC0, 0x33, 0x01, 0x8C,
  0x03, 0x30, 0x18, 0xC0, 0x63, 0x03, 0x0C, 0x06, 0x60, 0x30, 0xC0, 0xC6,
  0x07, 0x0C, 0x0C, 0x60, 0x60, 0xC1, 0xC6, 0x06, 0x0C, 0x18, 0x60, 0xC0,
  0xC1, 0x86, 0x0C, 0x0C, 0x30, 0x61, 0xC0, 0xC3, 0x06, 0x18, 0x0C, 0x70,
  0x61, 0x80, 0xC6, 0x06, 0x30, 0x0C, 0x60, 0x63, 0x00, 0xCC, 0x06, 0x30,
  0x0C, 0xC0, 0x66, 0x00, 0xDC, 0x06, 0x60, 0x0D, 0x80, 0x6C, 0x00, 0xD8,
  0x06, 0xC0, 0x0F, 0x00, 0x6C, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x78,
  0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x06, 0x01, 0x80, 0x1C, 0x03, 0x80, 0x30, 0x03, 0x00, 0xC0,
  0x06, 0x03, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x30, 0x00,
  0x70, 0xC0, 0x00, 0x63, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x9C, 0x00, 0x03,
  0x30, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x39, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x06, 0x00,
  0x0C, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x18, 0x01, 0xC0, 0x30, 0x07,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0xE0, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x70, 0x00, 0x30, 0x03,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x30, 0x38, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x1C,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01,
  0x9C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x43, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x01, 0xFE, 0x00, 0x5E, 0x7C, 0x03, 0x80, 0xF8, 0x78, 0x01,
  0xFF, 0x40, 0x01, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 12, 44, 13, 1, -44 },
  { 67, 13, 16, 17, 6, -44 },
  { 93, 24, 44, 23, 0, -44 },
  { 225, 24, 51, 22, -1, -47 },
  { 378, 28, 46, 33, 3, -45 },
  { 539, 21, 46, 21, -1, -45 },
  { 660, 5, 16, 9, 6, -44 },
  { 670, 18, 54, 15, 1, -44 },
  { 792, 17, 54, 15, -4, -44 },
  { 907, 16, 17, 20, 7, -47 },
  { 941, 21, 28, 25, 2, -36 },
  { 1015, 8, 14, 10, -2, -6 },
  { 1029, 14, 2, 16, 1, -18 },
  { 1033, 4, 5, 10, 1, -5 },
  { 1036, 26, 44, 19, -3, -44 },
  { 1179, 21, 46, 22, 1, -45 },
  { 1300, 11, 44, 22, 7, -44 },
  { 1361, 24, 45, 22, -2, -45 },
  { 1496, 23, 46, 22, -1, -45 },
  { 1629, 23, 45, 22, -1, -45 },
  { 1759, 23, 45, 22, -1, -44 },
  { 1889, 22, 46, 22, 1, -45 },
  { 2016, 22, 44, 22, 2, -44 },
  { 2137, 24, 46, 22, -1, -45 },
  { 2275, 22, 46, 22, 0, -45 },
  { 2402, 10, 33, 10, 0, -33 },
  { 2444, 13, 41, 10, -3, -33 },
  { 2511, 21, 26, 25, 2, -35 },
  { 2580, 21, 16, 25, 2, -30 },
  { 2622, 21, 26, 25, 2, -35 },
  { 2691, 17, 45, 16, 1, -45 },
  { 2787, 30, 51, 33, 2, -45 },
  { 2979, 21, 44, 21, -4, -44 },
  { 3095, 24, 44, 24, 0, -44 },
  { 3227, 24, 46, 22, 2, -45 },
  { 3365, 25, 44, 26, 0, -44 },
  { 3503, 24, 44, 21, 0, -44 },
  { 3635, 24, 44, 20, 0, -44 },
  { 3767, 28, 46, 29, 2, -45 },
  { 3928, 29, 44, 28, 0, -44 },
  { 4088, 20, 44, 11, -4, -44 },
  { 4198, 21, 55, 10, -9, -44 },
  { 4343, 27, 44, 22, 0, -44 },
  { 4492, 14, 44, 19, 0, -44 },
  { 4569, 38, 44, 37, 0, -44 },
  { 4778, 30, 44, 29, 0, -44 },
  { 4943, 25, 46, 28, 2, -45 },
  { 5087, 23, 44, 23, 0, -44 },
  { 5214, 25, 56, 28, 2, -45 },
  { 5389, 23, 44, 23, 0, -44 },
  { 5516, 25, 46, 22, -2, -45 },
  { 5660, 20, 44, 19, 4, -44 },
  { 5770, 26, 45, 27, 2, -44 },
  { 5917, 22, 44, 22, 5, -44 },
  { 6038, 37, 44, 38, 5, -44 },
  { 6242, 28, 44, 20, -4, -44 },
  { 6396, 20, 44, 19, 4, -44 },
  { 6506, 26, 44, 19, -3, -44 },
  { 6649, 22, 54, 17, -1, -44 },
  { 6798, 9, 44, 20, 6, -44 },
  { 6848, 22, 54, 17, -4, -44 },
  { 6997, 23, 21, 24, 1, -44 },
  { 7058, 17, 2, 17, -5, 6 },
  { 7063, 6, 9, 13, 9, -47 },
  { 7070, 22, 34, 24, 2, -33 },
  { 7164, 22, 48, 24, 0, -47 },
  { 7296, 17, 34, 17, 2, -33 },
  { 7369, 25, 48, 24, 2, -47 },
  { 7519, 18, 34, 21, 2, -33 },
  { 7596, 27, 62, 12, -8, -47 },
  { 7806, 25, 48, 24, -1, -33 },
  { 7956, 21, 47, 23, 0, -47 },
  { 8080, 12, 44, 10, 0, -44 },
  { 8146, 20, 59, 10, -8, -44 },
  { 8294, 22, 47, 19, 0, -47 },
  { 8424, 13, 47, 10, 0, -47 },
  { 8501, 33, 33, 35, 0, -33 },
  { 8638, 21, 33, 23, 0, -33 },
  { 8725, 19, 34, 23, 2, -33 },
  { 8806, 25, 47, 24, -3, -33 },
  { 8953, 22, 48, 24, 2, -33 },
  { 9085, 18, 33, 15, 0, -33 },
  { 9160, 19, 34, 18, -1, -33 },
  { 9241, 12, 42, 12, 1, -41 },
  { 9304, 20, 34, 23, 2, -33 },
  { 9389, 17, 33, 18, 4, -33 },
  { 9460, 28, 33, 30, 4, -33 },
  { 9576, 23, 33, 18, -3, -33 },
  { 9671, 29, 48, 19, -7, -33 },
  { 9845, 19, 33, 15, -2, -33 },
  { 9924, 21, 54, 19, 2, -44 },
  { 10066, 2, 62, 22, 10, -47 },
  { 10082, 21, 54, 19, -4, -44 },
  { 10224, 21, 6, 25, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC62PT7B_H_
