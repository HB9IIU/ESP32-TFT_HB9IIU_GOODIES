#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC8PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0xA0, 0xC0, 0x6D, 0x6F, 0x80, 0x3B, 0x25, 0x80, 0x5D, 0xAF,
  0x76, 0x49, 0x7D, 0x80, 0xC0, 0x5A, 0xA8, 0x24, 0x92, 0xB0, 0xB0, 0x4B,
  0xA0, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x76, 0xDB, 0x80, 0xFC, 0x64,
  0xA9, 0x80, 0x64, 0xA3, 0x80, 0x25, 0x5C, 0x80, 0x73, 0x13, 0x80, 0x6B,
  0x5B, 0x80, 0x64, 0xA5, 0x00, 0x75, 0x6B, 0x80, 0x76, 0xB3, 0x80, 0x10,
  0x18, 0x2B, 0x10, 0xFC, 0x89, 0xC0, 0xD6, 0xA0, 0x35, 0xFF, 0xE8, 0x40,
  0x24, 0xB7, 0x40, 0x6E, 0xFB, 0x80, 0x2A, 0x49, 0x80, 0x6E, 0xDB, 0x80,
  0x6A, 0x69, 0x80, 0x6A, 0x69, 0x00, 0x34, 0x8B, 0xAE, 0x55, 0x9E, 0xAA,
  0x5A, 0xA0, 0x25, 0x24, 0xB0, 0x6D, 0x2D, 0x40, 0x5A, 0xB0, 0x4A, 0x55,
  0xAB, 0x68, 0x55, 0xDA, 0xAA, 0x6E, 0xDB, 0xC0, 0x6E, 0xA9, 0x00, 0x6E,
  0xDB, 0x50, 0x6E, 0xAD, 0x80, 0x72, 0x23, 0x80, 0xEA, 0xA0, 0x55, 0xAA,
  0xAE, 0xFE, 0xA0, 0xBD, 0xBD, 0xAC, 0x69, 0x2D, 0x80, 0xEA, 0xA0, 0x65,
  0x29, 0x80, 0x6A, 0x49, 0x20, 0xFC, 0x24, 0x92, 0x70, 0x4A, 0x80, 0xE0,
  0x80, 0xF6, 0xE0, 0x49, 0xDB, 0x80, 0xEB, 0x2E, 0xDB, 0x80, 0xFA, 0x60,
  0x25, 0x24, 0x94, 0xF6, 0xE5, 0x80, 0x4A, 0xDB, 0x80, 0x4A, 0xA0, 0x21,
  0x24, 0x94, 0x4A, 0xAD, 0x80, 0x5A, 0xA0, 0xFB, 0xBD, 0xF6, 0xE0, 0xF6,
  0xE0, 0xF6, 0xE9, 0x00, 0xF6, 0xE4, 0x80, 0xEA, 0xE7, 0x6A, 0x80, 0xB6,
  0xE0, 0xBA, 0x40, 0xBE, 0xAA, 0xAA, 0x60, 0x56, 0x24, 0x4C, 0x5A, 0x29,
  0x65, 0x30, 0xFF, 0x24, 0x92, 0xB0, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 1, 2, 2, 1, -6 },
  { 4, 3, 6, 3, 0, -6 },
  { 7, 3, 6, 3, 0, -6 },
  { 10, 4, 6, 4, 0, -6 },
  { 13, 3, 6, 3, 0, -6 },
  { 16, 1, 2, 1, 1, -6 },
  { 17, 2, 7, 2, 0, -6 },
  { 19, 3, 7, 2, -1, -6 },
  { 22, 2, 2, 3, 1, -6 },
  { 23, 3, 4, 3, 0, -5 },
  { 25, 1, 2, 1, 0, -1 },
  { 26, 2, 1, 2, 0, -3 },
  { 27, 1, 1, 1, 0, -1 },
  { 28, 3, 6, 2, 0, -6 },
  { 31, 3, 6, 3, 0, -6 },
  { 34, 1, 6, 3, 1, -6 },
  { 35, 3, 6, 3, 0, -6 },
  { 38, 3, 6, 3, 0, -6 },
  { 41, 3, 6, 3, 0, -6 },
  { 44, 3, 6, 3, 0, -6 },
  { 47, 3, 6, 3, 0, -6 },
  { 50, 3, 6, 3, 0, -6 },
  { 53, 3, 6, 3, 0, -6 },
  { 56, 3, 6, 3, 0, -6 },
  { 59, 1, 4, 1, 0, -4 },
  { 60, 1, 5, 1, 0, -4 },
  { 61, 3, 4, 3, 0, -5 },
  { 63, 3, 2, 3, 0, -4 },
  { 64, 3, 4, 3, 0, -5 },
  { 66, 2, 6, 2, 0, -6 },
  { 68, 4, 7, 4, 0, -6 },
  { 72, 3, 6, 3, -1, -6 },
  { 75, 3, 6, 3, 0, -6 },
  { 78, 3, 6, 3, 0, -6 },
  { 81, 3, 6, 3, 0, -6 },
  { 84, 3, 6, 3, 0, -6 },
  { 87, 3, 6, 3, 0, -6 },
  { 90, 4, 6, 4, 0, -6 },
  { 93, 4, 6, 4, 0, -6 },
  { 96, 2, 6, 1, 0, -6 },
  { 98, 3, 7, 1, -1, -6 },
  { 101, 3, 6, 3, 0, -6 },
  { 104, 2, 6, 2, 0, -6 },
  { 106, 5, 6, 5, 0, -6 },
  { 110, 4, 6, 4, 0, -6 },
  { 113, 3, 6, 4, 0, -6 },
  { 116, 3, 6, 3, 0, -6 },
  { 119, 3, 7, 4, 0, -6 },
  { 122, 3, 6, 3, 0, -6 },
  { 125, 3, 6, 3, 0, -6 },
  { 128, 2, 6, 2, 1, -6 },
  { 130, 4, 6, 3, 0, -6 },
  { 133, 2, 6, 3, 1, -6 },
  { 135, 4, 6, 5, 1, -6 },
  { 138, 3, 6, 3, 0, -6 },
  { 141, 2, 6, 2, 1, -6 },
  { 143, 3, 6, 2, 0, -6 },
  { 146, 3, 7, 2, 0, -6 },
  { 149, 1, 6, 3, 1, -6 },
  { 150, 3, 7, 2, -1, -6 },
  { 153, 3, 3, 3, 0, -6 },
  { 155, 3, 1, 2, -1, 0 },
  { 156, 1, 1, 2, 1, -6 },
  { 157, 3, 4, 3, 0, -4 },
  { 159, 3, 6, 3, 0, -6 },
  { 162, 2, 4, 2, 0, -4 },
  { 163, 3, 6, 3, 0, -6 },
  { 166, 3, 4, 3, 0, -4 },
  { 168, 3, 8, 2, -1, -6 },
  { 171, 3, 6, 3, 0, -4 },
  { 174, 3, 6, 3, 0, -6 },
  { 177, 2, 6, 1, 0, -6 },
  { 179, 3, 8, 1, -1, -6 },
  { 182, 3, 6, 2, 0, -6 },
  { 185, 2, 6, 1, 0, -6 },
  { 187, 4, 4, 4, 0, -4 },
  { 189, 3, 4, 3, 0, -4 },
  { 191, 3, 4, 3, 0, -4 },
  { 193, 3, 6, 3, 0, -4 },
  { 196, 3, 6, 3, 0, -4 },
  { 199, 2, 4, 2, 0, -4 },
  { 200, 2, 4, 2, 0, -4 },
  { 201, 2, 5, 2, 0, -5 },
  { 203, 3, 4, 3, 0, -4 },
  { 205, 3, 4, 2, 0, -4 },
  { 207, 4, 4, 4, 0, -4 },
  { 209, 3, 4, 2, 0, -4 },
  { 211, 4, 6, 2, -1, -4 },
  { 214, 2, 4, 2, 0, -4 },
  { 215, 3, 7, 3, 0, -6 },
  { 218, 1, 8, 3, 1, -6 },
  { 219, 3, 7, 3, -1, -6 },
  { 222, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC8PT7B_H_
