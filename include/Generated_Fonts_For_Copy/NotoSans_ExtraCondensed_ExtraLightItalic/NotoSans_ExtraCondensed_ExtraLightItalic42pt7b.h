#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC42PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C,
  0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x60,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0xC0, 0x31, 0x90, 0xC8, 0x4C, 0x26,
  0x32, 0x19, 0x08, 0x84, 0xC2, 0x43, 0x21, 0x00, 0x00, 0x61, 0x00, 0x20,
  0x80, 0x10, 0xC0, 0x18, 0x40, 0x08, 0x20, 0x04, 0x30, 0x06, 0x10, 0x02,
  0x08, 0x01, 0x0C, 0x0F, 0xFF, 0xC0, 0xC2, 0x00, 0x43, 0x00, 0x61, 0x80,
  0x30, 0x80, 0x10, 0x40, 0x08, 0x60, 0x0C, 0x20, 0x04, 0x10, 0x02, 0x18,
  0x1F, 0xFF, 0x81, 0x04, 0x00, 0x86, 0x00, 0xC2, 0x00, 0x61, 0x00, 0x21,
  0x80, 0x30, 0xC0, 0x18, 0x40, 0x08, 0x20, 0x04, 0x30, 0x06, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x01, 0xFF, 0x07, 0x26,
  0x0C, 0x60, 0x0C, 0x40, 0x08, 0x40, 0x08, 0x40, 0x18, 0x40, 0x08, 0xC0,
  0x08, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x02, 0x80, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0x60, 0x03, 0x30, 0x02, 0x30, 0x02, 0x10, 0x02, 0x10,
  0x02, 0x10, 0x06, 0x30, 0x04, 0x30, 0x04, 0x60, 0xC4, 0xC0, 0xFF, 0x80,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0F, 0x00, 0xC3, 0x30,
  0x10, 0x42, 0x04, 0x18, 0x40, 0x82, 0x08, 0x20, 0xC1, 0x04, 0x18, 0x21,
  0x02, 0x0C, 0x20, 0x41, 0x88, 0x18, 0x31, 0x03, 0x04, 0x40, 0x60, 0x88,
  0x08, 0x32, 0x3D, 0x04, 0x4C, 0xE0, 0x93, 0x1C, 0x32, 0x43, 0xCC, 0x98,
  0x2F, 0x13, 0x0C, 0x04, 0x41, 0x80, 0x88, 0x30, 0x23, 0x04, 0x04, 0x60,
  0x81, 0x88, 0x10, 0x21, 0x06, 0x0C, 0x20, 0xC1, 0x04, 0x10, 0x60, 0x86,
  0x08, 0x10, 0x83, 0x03, 0x30, 0xC0, 0x7C, 0x00, 0x02, 0x00, 0x01, 0xF0,
  0x0C, 0x40, 0x21, 0x81, 0x86, 0x06, 0x18, 0x18, 0x60, 0x41, 0x01, 0x0C,
  0x04, 0x30, 0x10, 0x80, 0x66, 0x01, 0xB0, 0x07, 0x80, 0x0C, 0x00, 0x70,
  0x03, 0xC0, 0x19, 0x00, 0xC4, 0x36, 0x18, 0x98, 0x66, 0xC0, 0x9B, 0x02,
  0x48, 0x0F, 0x20, 0x38, 0x80, 0x62, 0x01, 0x88, 0x0E, 0x30, 0x68, 0xC3,
  0x21, 0xF8, 0xC0, 0x32, 0x26, 0x64, 0x44, 0xCC, 0x80, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x02, 0x00, 0x30, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00,
  0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0xC0, 0x10, 0x42, 0x06, 0x42, 0x3F, 0xC3, 0x00, 0xE0,
  0x32, 0x08, 0x43, 0x04, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x03, 0xFF, 0xF8, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x0C, 0x21, 0x86, 0x10,
  0xC2, 0x18, 0xC0, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x00, 0x01, 0xF0,
  0x0C, 0x60, 0x60, 0x81, 0x03, 0x0C, 0x0C, 0x20, 0x31, 0x80, 0xC4, 0x03,
  0x30, 0x0C, 0xC0, 0x32, 0x00, 0x88, 0x02, 0x60, 0x09, 0x80, 0x64, 0x01,
  0x90, 0x06, 0x40, 0x13, 0x00, 0x4C, 0x03, 0x30, 0x0C, 0xC0, 0x22, 0x01,
  0x88, 0x06, 0x20, 0x10, 0x80, 0xC2, 0x02, 0x0C, 0x18, 0x30, 0x40, 0x67,
  0x00, 0xF8, 0x00, 0x06, 0x1C, 0x79, 0xBE, 0x70, 0x81, 0x06, 0x0C, 0x10,
  0x20, 0xC1, 0x83, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x30,
  0x40, 0x83, 0x06, 0x08, 0x10, 0x00, 0x01, 0xFC, 0x03, 0x0E, 0x02, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x07, 0x06, 0x02, 0x02,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x03, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0xC1, 0xC0, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0A, 0x00, 0x12, 0x00, 0x36, 0x00, 0x26, 0x00, 0x64, 0x00, 0xC4,
  0x00, 0x8C, 0x01, 0x8C, 0x01, 0x0C, 0x03, 0x08, 0x06, 0x08, 0x04, 0x18,
  0x0C, 0x18, 0x08, 0x10, 0x18, 0x10, 0x30, 0x30, 0x20, 0x30, 0x60, 0x30,
  0x40, 0x20, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xFF, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0xC1, 0xC0, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x7C, 0x0D, 0x8C, 0x14, 0x0C, 0x30, 0x18,
  0x60, 0x11, 0x80, 0x23, 0x00, 0x46, 0x00, 0x8C, 0x03, 0x18, 0x06, 0x30,
  0x0C, 0x60, 0x10, 0xC0, 0x61, 0x80, 0xC3, 0x03, 0x02, 0x06, 0x06, 0x18,
  0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x00, 0xFC, 0x01, 0x86,
  0x03, 0x03, 0x06, 0x03, 0x06, 0x01, 0x04, 0x01, 0x04, 0x01, 0x04, 0x03,
  0x04, 0x03, 0x06, 0x02, 0x06, 0x06, 0x03, 0x0C, 0x03, 0x18, 0x01, 0xE0,
  0x01, 0xC0, 0x07, 0x60, 0x0C, 0x30, 0x18, 0x30, 0x30, 0x18, 0x20, 0x18,
  0x60, 0x08, 0x40, 0x08, 0x40, 0x08, 0xC0, 0x08, 0xC0, 0x08, 0x40, 0x18,
  0x60, 0x18, 0x60, 0x30, 0x30, 0x60, 0x1F, 0xC0, 0x01, 0xF8, 0x06, 0x30,
  0x18, 0x30, 0x60, 0x20, 0xC0, 0x43, 0x00, 0xC6, 0x01, 0x88, 0x03, 0x10,
  0x06, 0x60, 0x08, 0xC0, 0x11, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x07,
  0x08, 0x1E, 0x18, 0x68, 0x1F, 0x90, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x08, 0x70, 0x1F, 0x80, 0x00, 0x0E, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x0E, 0x18,
  0x00, 0x01, 0x81, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x01,
  0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x00, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x04, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x01, 0x00, 0x00, 0x1F,
  0xC2, 0x1C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40,
  0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00,
  0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x06, 0x0C, 0x01, 0x80,
  0x60, 0x10, 0x02, 0x02, 0x00, 0x30, 0x40, 0x01, 0x0C, 0x00, 0x10, 0x80,
  0x01, 0x18, 0x0C, 0x11, 0x03, 0xE1, 0x30, 0x42, 0x13, 0x0C, 0x61, 0x20,
  0x86, 0x16, 0x10, 0x41, 0x61, 0x04, 0x34, 0x30, 0xC3, 0x42, 0x0C, 0x24,
  0x20, 0x82, 0xC2, 0x08, 0x6C, 0x61, 0x84, 0xC6, 0x18, 0x4C, 0x63, 0x8C,
  0x86, 0x38, 0x88, 0x24, 0x90, 0x83, 0xCE, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x02,
  0x00, 0x1F, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0x60, 0x06, 0xC0, 0x09, 0x80, 0x33, 0x00, 0x66, 0x00,
  0x8C, 0x03, 0x18, 0x04, 0x30, 0x18, 0x60, 0x30, 0xC0, 0x41, 0x81, 0x83,
  0x02, 0x06, 0x0F, 0xFC, 0x1F, 0xF8, 0x60, 0x30, 0xC0, 0x61, 0x00, 0xC6,
  0x01, 0x8C, 0x03, 0x30, 0x06, 0x60, 0x0C, 0x80, 0x1B, 0x00, 0x34, 0x00,
  0x78, 0x00, 0xC0, 0x03, 0xF8, 0x03, 0x1E, 0x02, 0x03, 0x02, 0x03, 0x06,
  0x01, 0x06, 0x01, 0x06, 0x01, 0x04, 0x01, 0x04, 0x03, 0x0C, 0x03, 0x0C,
  0x02, 0x0C, 0x06, 0x08, 0x0C, 0x08, 0xF0, 0x1F, 0xE0, 0x18, 0x30, 0x18,
  0x18, 0x10, 0x0C, 0x10, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x20, 0x0C, 0x20,
  0x0C, 0x60, 0x0C, 0x60, 0x18, 0x60, 0x18, 0x40, 0x30, 0x40, 0x60, 0xC3,
  0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xC2, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x80, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0x9F, 0x00, 0xC1, 0x80, 0x40, 0x60,
  0x60, 0x10, 0x30, 0x0C, 0x18, 0x06, 0x08, 0x03, 0x04, 0x01, 0x86, 0x00,
  0xC3, 0x00, 0x61, 0x80, 0x30, 0x80, 0x18, 0x40, 0x0C, 0x60, 0x04, 0x30,
  0x02, 0x18, 0x03, 0x08, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x43, 0x00, 0x61,
  0x00, 0x20, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x18, 0x30, 0x18, 0x10, 0x18,
  0x08, 0x18, 0x0C, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x1F,
  0xF8, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x1F, 0xF8, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x70, 0x70,
  0x30, 0x04, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xFC, 0x80, 0x02, 0x20, 0x01, 0x88,
  0x00, 0x62, 0x00, 0x18, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0xC2, 0x00,
  0x30, 0x80, 0x0C, 0x30, 0x02, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x38, 0x38,
  0x07, 0xFC, 0x00, 0x03, 0x00, 0x20, 0x60, 0x04, 0x08, 0x01, 0x81, 0x00,
  0x30, 0x60, 0x06, 0x0C, 0x00, 0x81, 0x80, 0x10, 0x20, 0x06, 0x04, 0x00,
  0xC1, 0x80, 0x10, 0x30, 0x02, 0x06, 0x00, 0xC0, 0x80, 0x18, 0x10, 0x03,
  0x07, 0xFF, 0xC0, 0xC0, 0x08, 0x10, 0x03, 0x02, 0x00, 0x60, 0xC0, 0x0C,
  0x18, 0x01, 0x03, 0x00, 0x20, 0x40, 0x0C, 0x08, 0x01, 0x83, 0x00, 0x30,
  0x60, 0x04, 0x0C, 0x01, 0x81, 0x00, 0x30, 0x20, 0x06, 0x0C, 0x00, 0x81,
  0x80, 0x10, 0x00, 0x03, 0xF8, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x7F, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x23, 0x00, 0xF8, 0x00, 0x03, 0x00, 0xC0,
  0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x06, 0x01, 0x83, 0x00, 0x60,
  0x80, 0x10, 0x60, 0x04, 0x30, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x00,
  0x09, 0x80, 0x02, 0x40, 0x01, 0xB8, 0x00, 0x76, 0x00, 0x1C, 0x80, 0x06,
  0x20, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x08, 0x10, 0x02, 0x06,
  0x01, 0x81, 0x80, 0x60, 0x60, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC0,
  0xC0, 0x30, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01,
  0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80,
  0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60,
  0x18, 0x04, 0x01, 0x00, 0xC0, 0x3F, 0xF0, 0x03, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0x70, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0A, 0x07, 0x80, 0x07, 0x81,
  0xE0, 0x01, 0x60, 0x68, 0x00, 0xD0, 0x12, 0x00, 0x24, 0x04, 0x80, 0x1B,
  0x03, 0x20, 0x04, 0xC0, 0xC8, 0x03, 0x30, 0x32, 0x00, 0xC8, 0x08, 0x80,
  0x62, 0x02, 0x20, 0x19, 0x81, 0x88, 0x0C, 0x60, 0x62, 0x03, 0x18, 0x10,
  0xC0, 0x84, 0x04, 0x30, 0x61, 0x03, 0x0C, 0x10, 0xC0, 0xC3, 0x0C, 0x30,
  0x30, 0xC2, 0x08, 0x08, 0x31, 0x82, 0x02, 0x0C, 0x41, 0x81, 0x83, 0x30,
  0x60, 0x60, 0xC8, 0x18, 0x18, 0x36, 0x04, 0x04, 0x05, 0x01, 0x01, 0x01,
  0xC0, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x00, 0x03, 0x00, 0x10,
  0x38, 0x01, 0x03, 0x80, 0x30, 0x38, 0x03, 0x06, 0x80, 0x30, 0x68, 0x02,
  0x06, 0xC0, 0x20, 0x4C, 0x06, 0x04, 0xC0, 0x60, 0xC4, 0x04, 0x0C, 0x40,
  0x40, 0xC4, 0x0C, 0x08, 0x60, 0xC0, 0x86, 0x0C, 0x18, 0x60, 0x81, 0x82,
  0x08, 0x18, 0x21, 0x81, 0x03, 0x18, 0x30, 0x31, 0x83, 0x03, 0x10, 0x30,
  0x11, 0x02, 0x01, 0x30, 0x20, 0x13, 0x06, 0x01, 0xA0, 0x60, 0x1A, 0x06,
  0x01, 0xA0, 0x40, 0x0E, 0x04, 0x00, 0xE0, 0xC0, 0x0C, 0x0C, 0x00, 0xC0,
  0x00, 0x7E, 0x00, 0xE1, 0x80, 0xC0, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x60,
  0x04, 0x20, 0x02, 0x30, 0x01, 0x18, 0x00, 0x88, 0x00, 0x4C, 0x00, 0x26,
  0x00, 0x32, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x02, 0x60, 0x01,
  0x20, 0x01, 0x90, 0x00, 0xC8, 0x00, 0x4C, 0x00, 0x66, 0x00, 0x33, 0x00,
  0x11, 0x80, 0x18, 0x40, 0x0C, 0x20, 0x0C, 0x18, 0x0C, 0x0C, 0x06, 0x03,
  0x0E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0x7C, 0x03, 0x06, 0x02, 0x02,
  0x06, 0x03, 0x06, 0x03, 0x06, 0x03, 0x04, 0x03, 0x04, 0x03, 0x0C, 0x03,
  0x0C, 0x02, 0x0C, 0x06, 0x08, 0x04, 0x08, 0x0C, 0x18, 0x18, 0x18, 0x70,
  0x1F, 0xC0, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0xE1, 0x80, 0xC0, 0x60, 0xC0,
  0x30, 0x60, 0x18, 0x60, 0x04, 0x20, 0x02, 0x30, 0x01, 0x18, 0x00, 0x88,
  0x00, 0x4C, 0x00, 0x26, 0x00, 0x32, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06,
  0xC0, 0x02, 0x60, 0x01, 0x20, 0x01, 0x90, 0x00, 0xC8, 0x00, 0x4C, 0x00,
  0x66, 0x00, 0x33, 0x00, 0x11, 0x80, 0x18, 0x40, 0x0C, 0x20, 0x0C, 0x18,
  0x0C, 0x0C, 0x06, 0x03, 0x0E, 0x00, 0xFC, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0xF0, 0x03, 0x3C, 0x03, 0x06, 0x02, 0x02, 0x06, 0x03, 0x06, 0x03, 0x06,
  0x03, 0x04, 0x03, 0x04, 0x03, 0x0C, 0x02, 0x0C, 0x06, 0x0C, 0x06, 0x08,
  0x04, 0x08, 0x0C, 0x18, 0x18, 0x1F, 0xF0, 0x1F, 0x80, 0x10, 0xC0, 0x30,
  0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x20, 0x40, 0x20, 0x40, 0x60, 0x60, 0x60,
  0x60, 0x60, 0x60, 0x40, 0x60, 0x40, 0x20, 0xC0, 0x30, 0xC0, 0x30, 0x00,
  0xFF, 0x01, 0xC1, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x0C, 0x0C,
  0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x00, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x40, 0x0C, 0x10,
  0x02, 0x0C, 0x00, 0x83, 0x00, 0x60, 0x80, 0x18, 0x20, 0x04, 0x18, 0x01,
  0x06, 0x00, 0xC1, 0x80, 0x30, 0x40, 0x0C, 0x10, 0x02, 0x0C, 0x00, 0x83,
  0x00, 0x60, 0xC0, 0x18, 0x20, 0x04, 0x08, 0x01, 0x06, 0x00, 0xC1, 0x80,
  0x30, 0x40, 0x0C, 0x10, 0x02, 0x0C, 0x00, 0x83, 0x00, 0x60, 0xC0, 0x18,
  0x30, 0x04, 0x0C, 0x03, 0x01, 0x81, 0x80, 0x70, 0xC0, 0x0F, 0xE0, 0x00,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xA0, 0x06, 0x80, 0x12, 0x00, 0xC8, 0x03,
  0x20, 0x18, 0x80, 0x62, 0x01, 0x08, 0x0C, 0x20, 0x20, 0x81, 0x82, 0x06,
  0x08, 0x30, 0x20, 0xC0, 0x82, 0x02, 0x18, 0x08, 0x40, 0x23, 0x00, 0x8C,
  0x02, 0x20, 0x09, 0x80, 0x24, 0x00, 0xB0, 0x02, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x40, 0x0C, 0x00, 0xD0, 0x03, 0x00, 0x64,
  0x01, 0xC0, 0x1B, 0x00, 0x70, 0x04, 0xC0, 0x1C, 0x03, 0x30, 0x0F, 0x00,
  0xCC, 0x02, 0xC0, 0x63, 0x01, 0xB0, 0x18, 0xC0, 0x6C, 0x04, 0x30, 0x13,
  0x03, 0x0C, 0x0C, 0xC0, 0x83, 0x02, 0x30, 0x60, 0xC1, 0x8C, 0x18, 0x30,
  0x63, 0x04, 0x0C, 0x10, 0x83, 0x03, 0x0C, 0x20, 0x80, 0xC2, 0x08, 0x60,
  0x30, 0x82, 0x18, 0x0C, 0x60, 0x84, 0x03, 0x10, 0x23, 0x00, 0xCC, 0x08,
  0x80, 0x32, 0x02, 0x60, 0x0C, 0x80, 0x98, 0x03, 0x60, 0x24, 0x00, 0xD0,
  0x0B, 0x00, 0x3C, 0x02, 0x80, 0x0F, 0x00, 0xA0, 0x03, 0x80, 0x38, 0x00,
  0xE0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x60, 0x20,
  0x18, 0x18, 0x06, 0x04, 0x01, 0x83, 0x00, 0x20, 0x80, 0x08, 0x60, 0x02,
  0x10, 0x00, 0x8C, 0x00, 0x26, 0x00, 0x0D, 0x80, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0x58, 0x00,
  0x36, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x08, 0x00, 0x82, 0x00, 0x60,
  0x80, 0x10, 0x20, 0x0C, 0x0C, 0x02, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x30,
  0x30, 0x0C, 0x00, 0xC0, 0x1A, 0x00, 0x90, 0x0C, 0x80, 0x44, 0x06, 0x30,
  0x21, 0x83, 0x0C, 0x10, 0x61, 0x83, 0x08, 0x18, 0xC0, 0x44, 0x02, 0x60,
  0x12, 0x00, 0xB0, 0x05, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFE, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xC1, 0x04,
  0x10, 0x41, 0x86, 0x18, 0x20, 0x82, 0x08, 0x30, 0xC3, 0x04, 0x10, 0x41,
  0x06, 0x18, 0x61, 0x82, 0x08, 0x20, 0xC3, 0x0C, 0x30, 0x00, 0xFE, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x80, 0x03, 0x80, 0x0F,
  0x00, 0x12, 0x00, 0x66, 0x00, 0x84, 0x03, 0x0C, 0x04, 0x08, 0x18, 0x18,
  0x20, 0x30, 0xC0, 0x21, 0x00, 0x66, 0x00, 0x48, 0x00, 0xF0, 0x01, 0x80,
  0xFF, 0xE0, 0xC4, 0x62, 0x31, 0x10, 0x00, 0x80, 0x07, 0xEC, 0x18, 0x58,
  0x60, 0x61, 0x80, 0xC3, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x20, 0x08, 0xC0,
  0x11, 0x80, 0x62, 0x00, 0xC4, 0x01, 0x18, 0x02, 0x30, 0x0C, 0x60, 0x18,
  0xC0, 0x31, 0x80, 0xC3, 0x01, 0x86, 0x05, 0x04, 0x0E, 0x0C, 0x6C, 0x0F,
  0x90, 0x00, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x60, 0x13, 0xF0, 0x28,
  0x60, 0xE0, 0x61, 0xC0, 0xC3, 0x01, 0x86, 0x03, 0x18, 0x06, 0x30, 0x0C,
  0x60, 0x18, 0x80, 0x31, 0x00, 0x46, 0x00, 0x8C, 0x03, 0x18, 0x06, 0x20,
  0x08, 0x40, 0x31, 0x80, 0x63, 0x00, 0x86, 0x03, 0x0A, 0x0C, 0x16, 0x30,
  0x67, 0xC0, 0x00, 0x40, 0x3F, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x10, 0x3F,
  0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x43, 0x00, 0xFD,
  0x80, 0xC2, 0xC0, 0xC1, 0xC0, 0xC0, 0x60, 0x40, 0x30, 0x60, 0x18, 0x30,
  0x0C, 0x10, 0x04, 0x18, 0x06, 0x0C, 0x03, 0x04, 0x01, 0x82, 0x00, 0x83,
  0x00, 0x41, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x18, 0x18, 0x0C,
  0x0C, 0x0A, 0x02, 0x07, 0x01, 0x8D, 0x80, 0x7C, 0x80, 0x00, 0xC0, 0x3F,
  0x06, 0x30, 0xC1, 0x18, 0x11, 0x01, 0x30, 0x12, 0x03, 0x60, 0x66, 0x0C,
  0x41, 0x87, 0xF0, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x40, 0x06, 0x08, 0x3F, 0x80, 0x00, 0x03, 0xC0, 0x01,
  0x90, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x1F, 0xE0, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0xB0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x7E, 0xC0,
  0x61, 0x60, 0x60, 0xE0, 0x60, 0x30, 0x20, 0x18, 0x30, 0x0C, 0x18, 0x06,
  0x08, 0x02, 0x0C, 0x03, 0x06, 0x01, 0x82, 0x00, 0xC1, 0x00, 0x41, 0x80,
  0x20, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x0C, 0x0C, 0x06, 0x06,
  0x05, 0x01, 0x07, 0x80, 0xC6, 0xC0, 0x3E, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x02, 0x03,
  0x01, 0xCF, 0x00, 0x7E, 0x00, 0x00, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x80,
  0x4F, 0x81, 0x43, 0x0E, 0x04, 0x30, 0x10, 0xC0, 0x43, 0x03, 0x08, 0x0C,
  0x60, 0x31, 0x80, 0x84, 0x02, 0x10, 0x18, 0xC0, 0x63, 0x01, 0x8C, 0x04,
  0x20, 0x10, 0x80, 0xC6, 0x03, 0x18, 0x08, 0x60, 0x21, 0x01, 0x84, 0x06,
  0x30, 0x18, 0x03, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x04,
  0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30,
  0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x09, 0x80, 0x3C, 0x00, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x04, 0x10, 0x30, 0x20, 0x40, 0xC1, 0x81, 0x86, 0x02, 0x18, 0x04, 0x20,
  0x18, 0xC0, 0x33, 0x00, 0x6C, 0x00, 0x98, 0x01, 0x50, 0x07, 0x30, 0x0E,
  0x60, 0x18, 0xC0, 0x20, 0x80, 0x41, 0x01, 0x82, 0x03, 0x06, 0x04, 0x0C,
  0x08, 0x18, 0x30, 0x30, 0x60, 0x20, 0x01, 0x01, 0x03, 0x03, 0x03, 0x02,
  0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18,
  0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40,
  0xC0, 0xC0, 0x00, 0x20, 0x20, 0x17, 0xE7, 0xE0, 0x50, 0xF0, 0xC3, 0x83,
  0x81, 0x0C, 0x0C, 0x04, 0x30, 0x30, 0x10, 0x80, 0xC0, 0xC6, 0x03, 0x03,
  0x18, 0x08, 0x0C, 0x60, 0x60, 0x21, 0x01, 0x80, 0x84, 0x06, 0x06, 0x30,
  0x10, 0x18, 0xC0, 0x40, 0x43, 0x03, 0x01, 0x08, 0x0C, 0x0C, 0x20, 0x30,
  0x31, 0x80, 0x80, 0xC6, 0x02, 0x02, 0x10, 0x18, 0x08, 0x40, 0x60, 0x61,
  0x01, 0x01, 0x8C, 0x04, 0x06, 0x00, 0x00, 0x20, 0x13, 0xE0, 0x50, 0xC3,
  0x81, 0x0C, 0x04, 0x30, 0x10, 0xC0, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x21,
  0x00, 0x84, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x08, 0x04, 0x20, 0x31,
  0x80, 0xC6, 0x02, 0x10, 0x08, 0x40, 0x61, 0x01, 0x8C, 0x06, 0x00, 0x00,
  0xC0, 0x1F, 0x81, 0x86, 0x18, 0x31, 0x80, 0x88, 0x04, 0xC0, 0x26, 0x01,
  0x60, 0x0B, 0x00, 0x58, 0x06, 0x80, 0x34, 0x01, 0xE0, 0x0F, 0x00, 0x58,
  0x06, 0xC0, 0x36, 0x01, 0x30, 0x19, 0x80, 0x84, 0x0C, 0x30, 0xC0, 0xFC,
  0x00, 0x00, 0x0C, 0x00, 0x9F, 0x80, 0x58, 0xC0, 0x70, 0x30, 0x38, 0x18,
  0x18, 0x0C, 0x0C, 0x06, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x00,
  0x60, 0x80, 0x30, 0xC0, 0x10, 0x60, 0x18, 0x30, 0x0C, 0x10, 0x06, 0x08,
  0x02, 0x0C, 0x03, 0x06, 0x01, 0x03, 0x01, 0x81, 0x41, 0x80, 0xB1, 0x80,
  0xCF, 0x80, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x07, 0xEC, 0x18, 0x58, 0x60, 0xE1, 0x80, 0xC2, 0x01, 0x8C,
  0x03, 0x18, 0x06, 0x20, 0x08, 0xC0, 0x11, 0x80, 0x62, 0x00, 0xC4, 0x01,
  0x18, 0x02, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x31, 0x80, 0xC3, 0x01, 0x86,
  0x05, 0x04, 0x0E, 0x0C, 0x6C, 0x0F, 0x90, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x00, 0x20, 0x4F, 0x05, 0x00, 0xE0, 0x0A, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x1F, 0xC3, 0x02, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x60,
  0xC3, 0xFC, 0x00, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x7F, 0x18, 0x18,
  0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0xC0,
  0xC0, 0xC0, 0x80, 0x80, 0x80, 0xC0, 0xF0, 0x08, 0x0C, 0x60, 0x31, 0x80,
  0xC6, 0x02, 0x10, 0x08, 0x40, 0x63, 0x01, 0x8C, 0x04, 0x30, 0x10, 0x80,
  0xC2, 0x03, 0x18, 0x0C, 0x60, 0x21, 0x00, 0x84, 0x06, 0x10, 0x18, 0xC0,
  0x63, 0x03, 0x0C, 0x0C, 0x30, 0x50, 0xC3, 0xC1, 0xFB, 0x00, 0xC0, 0x3C,
  0x02, 0xC0, 0x6C, 0x04, 0xC0, 0xCC, 0x0C, 0xC0, 0x8C, 0x18, 0xC1, 0x0C,
  0x30, 0xC2, 0x0C, 0x60, 0xC4, 0x04, 0xC0, 0x4C, 0x04, 0x80, 0x58, 0x05,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x60, 0x34, 0x06, 0x02,
  0x40, 0x60, 0x64, 0x0E, 0x04, 0x40, 0xA0, 0x44, 0x1A, 0x0C, 0x41, 0x20,
  0x84, 0x12, 0x18, 0x43, 0x21, 0x84, 0x22, 0x10, 0x46, 0x23, 0x04, 0x42,
  0x20, 0x44, 0x22, 0x0C, 0xC2, 0x60, 0xC8, 0x24, 0x0D, 0x82, 0xC0, 0xD0,
  0x28, 0x0D, 0x02, 0x80, 0xF0, 0x38, 0x0E, 0x03, 0x00, 0xE0, 0x30, 0x0C,
  0x02, 0x00, 0x06, 0x03, 0x02, 0x06, 0x02, 0x04, 0x03, 0x0C, 0x03, 0x18,
  0x03, 0x10, 0x01, 0x30, 0x01, 0x20, 0x01, 0x60, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0x40, 0x08, 0x40,
  0x18, 0x40, 0x30, 0x60, 0x20, 0x60, 0x60, 0x20, 0xC0, 0x20, 0x00, 0xC0,
  0x30, 0x0C, 0x02, 0x00, 0xC0, 0x60, 0x0C, 0x04, 0x00, 0xC0, 0xC0, 0x0C,
  0x08, 0x00, 0xC1, 0x80, 0x0C, 0x10, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00,
  0xC2, 0x00, 0x0C, 0x60, 0x00, 0xC4, 0x00, 0x0C, 0xC0, 0x00, 0xC8, 0x00,
  0x0D, 0x80, 0x00, 0xD0, 0x00, 0x05, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x9C, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x70, 0x00, 0x78,
  0x03, 0x80, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x30, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x02,
  0xFE, 0x07, 0x07, 0x3C, 0x03, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 30, 9, 1, -30 },
  { 31, 9, 11, 11, 4, -30 },
  { 44, 17, 30, 16, 0, -30 },
  { 108, 16, 34, 15, 0, -32 },
  { 176, 19, 31, 23, 2, -30 },
  { 250, 14, 30, 14, 0, -30 },
  { 303, 4, 11, 6, 4, -30 },
  { 309, 12, 37, 10, 1, -30 },
  { 365, 12, 37, 10, -3, -30 },
  { 421, 11, 12, 14, 5, -32 },
  { 438, 15, 20, 17, 1, -25 },
  { 476, 6, 9, 7, -2, -4 },
  { 483, 9, 1, 11, 1, -12 },
  { 485, 2, 3, 7, 1, -3 },
  { 486, 17, 30, 13, -2, -30 },
  { 550, 14, 30, 15, 1, -30 },
  { 603, 7, 30, 15, 5, -30 },
  { 630, 16, 30, 15, -1, -30 },
  { 690, 16, 30, 15, -1, -30 },
  { 750, 16, 30, 15, -1, -30 },
  { 810, 16, 30, 15, -1, -30 },
  { 870, 15, 30, 15, 1, -30 },
  { 927, 14, 30, 15, 2, -30 },
  { 980, 16, 30, 15, -1, -30 },
  { 1040, 15, 30, 15, 0, -30 },
  { 1097, 7, 22, 7, 0, -22 },
  { 1117, 9, 27, 7, -2, -22 },
  { 1148, 15, 18, 17, 1, -24 },
  { 1182, 15, 10, 17, 1, -20 },
  { 1201, 15, 18, 17, 1, -24 },
  { 1235, 11, 30, 11, 1, -30 },
  { 1277, 20, 34, 22, 1, -30 },
  { 1362, 15, 30, 14, -3, -30 },
  { 1419, 16, 30, 16, 0, -30 },
  { 1479, 16, 30, 15, 2, -30 },
  { 1539, 17, 30, 18, 0, -30 },
  { 1603, 16, 30, 14, 0, -30 },
  { 1663, 16, 30, 13, 0, -30 },
  { 1723, 18, 30, 19, 2, -30 },
  { 1791, 19, 30, 19, 0, -30 },
  { 1863, 13, 30, 8, -2, -30 },
  { 1912, 14, 37, 7, -6, -30 },
  { 1977, 18, 30, 15, 0, -30 },
  { 2045, 10, 30, 13, 0, -30 },
  { 2083, 26, 30, 25, 0, -30 },
  { 2181, 20, 30, 20, 0, -30 },
  { 2256, 17, 30, 19, 1, -30 },
  { 2320, 16, 30, 15, 0, -30 },
  { 2380, 17, 37, 19, 1, -30 },
  { 2459, 16, 30, 16, 0, -30 },
  { 2519, 17, 30, 15, -1, -30 },
  { 2583, 13, 30, 13, 3, -30 },
  { 2632, 18, 30, 18, 1, -30 },
  { 2700, 14, 30, 15, 4, -30 },
  { 2753, 26, 30, 26, 3, -30 },
  { 2851, 18, 30, 13, -2, -30 },
  { 2919, 13, 30, 13, 3, -30 },
  { 2968, 18, 30, 13, -2, -30 },
  { 3036, 15, 37, 12, -1, -30 },
  { 3106, 6, 30, 14, 4, -30 },
  { 3129, 15, 37, 12, -3, -30 },
  { 3199, 15, 15, 16, 1, -30 },
  { 3228, 11, 1, 11, -3, 4 },
  { 3230, 4, 7, 9, 6, -32 },
  { 3234, 15, 23, 16, 1, -23 },
  { 3278, 15, 32, 16, 0, -32 },
  { 3338, 12, 23, 12, 1, -23 },
  { 3373, 17, 32, 16, 1, -32 },
  { 3441, 12, 23, 14, 1, -23 },
  { 3476, 18, 42, 8, -5, -32 },
  { 3571, 17, 33, 16, -1, -23 },
  { 3642, 14, 32, 16, 0, -32 },
  { 3698, 8, 30, 7, 0, -30 },
  { 3728, 14, 40, 7, -6, -30 },
  { 3798, 15, 32, 13, 0, -32 },
  { 3858, 8, 32, 7, 0, -32 },
  { 3890, 22, 23, 23, 0, -23 },
  { 3954, 14, 23, 15, 0, -23 },
  { 3995, 13, 23, 16, 1, -23 },
  { 4033, 17, 33, 16, -2, -23 },
  { 4104, 15, 33, 16, 1, -23 },
  { 4166, 12, 23, 10, 0, -23 },
  { 4201, 13, 23, 12, -1, -23 },
  { 4239, 8, 28, 8, 1, -28 },
  { 4267, 14, 22, 16, 1, -22 },
  { 4306, 12, 22, 12, 2, -22 },
  { 4339, 20, 22, 20, 2, -22 },
  { 4394, 16, 22, 12, -2, -22 },
  { 4438, 20, 32, 13, -5, -22 },
  { 4518, 12, 22, 10, -1, -22 },
  { 4551, 15, 37, 13, 1, -30 },
  { 4621, 2, 42, 15, 6, -32 },
  { 4632, 15, 37, 13, -3, -30 },
  { 4702, 15, 4, 17, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC42PT7B_H_
