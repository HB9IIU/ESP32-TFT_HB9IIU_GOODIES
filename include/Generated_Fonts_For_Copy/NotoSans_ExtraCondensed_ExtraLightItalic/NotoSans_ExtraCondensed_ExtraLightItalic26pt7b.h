#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC26PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x84,
  0x00, 0x01, 0x0C, 0x00, 0x24, 0x94, 0x52, 0x49, 0x28, 0x80, 0x02, 0x41,
  0x10, 0x44, 0x12, 0x08, 0x82, 0x23, 0xFC, 0x24, 0x11, 0x04, 0x81, 0x20,
  0x88, 0xFF, 0x09, 0x04, 0x41, 0x10, 0x48, 0x22, 0x08, 0x80, 0x02, 0x00,
  0x80, 0x60, 0x6B, 0x12, 0x09, 0x02, 0x40, 0x90, 0x14, 0x05, 0x00, 0x80,
  0x30, 0x0A, 0x02, 0x80, 0x90, 0x44, 0x12, 0x25, 0x8F, 0x80, 0x80, 0x20,
  0x08, 0x00, 0x18, 0x22, 0x42, 0x24, 0x44, 0x44, 0x44, 0x84, 0x48, 0x85,
  0x08, 0x90, 0x8A, 0x78, 0xA9, 0x95, 0x16, 0x51, 0x09, 0x10, 0xA1, 0x12,
  0x21, 0x22, 0x22, 0x22, 0x24, 0x41, 0xC0, 0x06, 0x09, 0x11, 0x11, 0x11,
  0x12, 0x12, 0x14, 0x18, 0x18, 0x28, 0x49, 0x45, 0x85, 0x86, 0x86, 0x86,
  0x8A, 0xF2, 0x5A, 0xA8, 0x02, 0x08, 0x20, 0x41, 0x04, 0x08, 0x20, 0x40,
  0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x10,
  0x00, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x41, 0x02, 0x04, 0x10, 0x40, 0x82, 0x08, 0x30, 0x00, 0x10, 0x22,
  0x43, 0xF3, 0x09, 0x22, 0x04, 0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFC,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x25, 0x28, 0xF8, 0x70, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x00, 0x0E, 0x13, 0x11, 0x21, 0x21, 0x41, 0x41, 0x41, 0x81, 0x81,
  0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x88, 0x88, 0xF0, 0x09, 0xDD, 0x21,
  0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0x08, 0x84, 0x20, 0x07, 0x02, 0x30,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x0F, 0xE0, 0x07, 0x02, 0x30,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x01, 0x03, 0x80, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x8F, 0xC0, 0x00, 0x40, 0x30,
  0x0C, 0x05, 0x02, 0x80, 0xA0, 0x48, 0x12, 0x08, 0x84, 0x41, 0x10, 0x84,
  0x41, 0x10, 0x8F, 0xF8, 0x08, 0x02, 0x00, 0x80, 0x40, 0x07, 0xC2, 0x00,
  0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x1E, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x8F, 0xC0, 0x07, 0x84, 0x04,
  0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0xBC, 0x61, 0x20, 0x90, 0x48, 0x24,
  0x12, 0x09, 0x0C, 0x84, 0x46, 0x1E, 0x00, 0x3F, 0xA0, 0x40, 0x20, 0x20,
  0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x80, 0x80,
  0x40, 0x40, 0x20, 0x20, 0x00, 0x07, 0x0C, 0x44, 0x24, 0x12, 0x09, 0x04,
  0x42, 0x22, 0x0E, 0x0E, 0x09, 0x08, 0x48, 0x24, 0x0A, 0x05, 0x02, 0x82,
  0x41, 0x1F, 0x00, 0x06, 0x0C, 0x84, 0x24, 0x12, 0x09, 0x05, 0x02, 0x81,
  0x41, 0x90, 0xC8, 0xC3, 0xA0, 0x10, 0x10, 0x08, 0x04, 0x04, 0x04, 0x3C,
  0x00, 0x11, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC8, 0x08, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x11, 0x08, 0x80, 0x00, 0x80, 0xC1, 0x83, 0x06,
  0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x0C, 0x18,
  0x10, 0x30, 0x20, 0x00, 0x1C, 0x22, 0x01, 0x01, 0x02, 0x02, 0x06, 0x04,
  0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x00, 0x00, 0x40, 0xC0, 0x01,
  0xC0, 0x62, 0x08, 0x11, 0x01, 0x20, 0x12, 0x01, 0x47, 0x94, 0x49, 0x48,
  0x98, 0x91, 0x91, 0x19, 0x12, 0x91, 0x29, 0x22, 0x92, 0x49, 0xD8, 0x80,
  0x08, 0x00, 0x80, 0x0C, 0x00, 0x7C, 0x00, 0x00, 0x80, 0xC0, 0x60, 0x30,
  0x28, 0x14, 0x12, 0x09, 0x04, 0x84, 0x42, 0x23, 0xF1, 0x08, 0x84, 0x82,
  0x41, 0x40, 0xA0, 0x70, 0x20, 0x0F, 0x02, 0x20, 0x84, 0x41, 0x10, 0x44,
  0x11, 0x04, 0x82, 0x21, 0x0F, 0x82, 0x10, 0x86, 0x40, 0x90, 0x24, 0x11,
  0x04, 0x41, 0x20, 0x8F, 0xC0, 0x03, 0x83, 0x11, 0x80, 0x40, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x10, 0x03, 0xC0, 0x0E, 0x01, 0x30, 0x21, 0x08, 0x21, 0x04,
  0x20, 0xC4, 0x11, 0x02, 0x20, 0x44, 0x08, 0x81, 0x10, 0x24, 0x08, 0x81,
  0x10, 0x22, 0x08, 0x42, 0x10, 0x83, 0xE0, 0x00, 0x0F, 0xC2, 0x00, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x0F, 0xC2, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x0F, 0xC0, 0x0F, 0xC2, 0x00, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x03, 0xF0, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x00, 0x03, 0xC0, 0xC3, 0x18,
  0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x83,
  0xC8, 0x08, 0x80, 0x88, 0x08, 0x80, 0x88, 0x08, 0x81, 0x04, 0x10, 0x3F,
  0x00, 0x08, 0x10, 0x81, 0x08, 0x11, 0x02, 0x10, 0x21, 0x02, 0x10, 0x22,
  0x02, 0x20, 0x43, 0xFC, 0x20, 0x42, 0x04, 0x40, 0x44, 0x08, 0x40, 0x84,
  0x08, 0x40, 0x88, 0x10, 0x81, 0x00, 0x1F, 0x04, 0x04, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40,
  0xF0, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x82, 0xC0, 0x80, 0x08, 0x21, 0x08, 0x21, 0x08, 0x41, 0x10, 0x26,
  0x04, 0x81, 0x20, 0x28, 0x05, 0x00, 0xD0, 0x12, 0x04, 0x40, 0x88, 0x10,
  0x82, 0x10, 0x42, 0x10, 0x42, 0x0C, 0x00, 0x08, 0x20, 0x84, 0x10, 0x41,
  0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42, 0x0F, 0xC0, 0x08, 0x03,
  0x08, 0x03, 0x14, 0x05, 0x14, 0x06, 0x14, 0x06, 0x14, 0x0A, 0x14, 0x0A,
  0x24, 0x14, 0x24, 0x14, 0x24, 0x24, 0x24, 0x24, 0x24, 0x44, 0x44, 0x48,
  0x44, 0x88, 0x44, 0x88, 0x45, 0x08, 0x45, 0x08, 0x86, 0x10, 0x86, 0x10,
  0x08, 0x08, 0x40, 0x83, 0x04, 0x28, 0x21, 0x41, 0x0A, 0x08, 0x50, 0x84,
  0x84, 0x22, 0x21, 0x11, 0x08, 0x88, 0x44, 0x84, 0x24, 0x20, 0xA1, 0x05,
  0x08, 0x30, 0x41, 0x84, 0x0C, 0x20, 0x60, 0x07, 0x02, 0x31, 0x04, 0xC1,
  0x20, 0x58, 0x14, 0x05, 0x01, 0x40, 0x60, 0x18, 0x06, 0x02, 0x80, 0xA0,
  0x28, 0x1A, 0x04, 0x82, 0x31, 0x87, 0xC0, 0x0C, 0x02, 0x60, 0x88, 0x41,
  0x10, 0x44, 0x11, 0x04, 0x82, 0x20, 0x88, 0x43, 0xE0, 0x80, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x00, 0x07, 0x02, 0x31, 0x04, 0xC1,
  0x20, 0x58, 0x14, 0x05, 0x01, 0x40, 0x60, 0x18, 0x06, 0x02, 0x80, 0xA0,
  0x28, 0x1A, 0x04, 0x82, 0x31, 0x87, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x40,
  0x0E, 0x02, 0x60, 0x88, 0x41, 0x10, 0x44, 0x11, 0x0C, 0x82, 0x20, 0x88,
  0xC3, 0xC0, 0x90, 0x44, 0x11, 0x04, 0x41, 0x08, 0x42, 0x20, 0x88, 0x20,
  0x03, 0xC1, 0x8C, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x10,
  0x43, 0xF0, 0x00, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x10, 0x22,
  0x04, 0x81, 0x10, 0x22, 0x04, 0x40, 0x88, 0x22, 0x04, 0x40, 0x88, 0x11,
  0x02, 0x40, 0x88, 0x11, 0x02, 0x20, 0x44, 0x10, 0x82, 0x10, 0x81, 0xF0,
  0x00, 0x80, 0xC0, 0x60, 0x50, 0x28, 0x14, 0x12, 0x09, 0x08, 0x84, 0x44,
  0x22, 0x11, 0x09, 0x04, 0x82, 0x81, 0x40, 0xA0, 0x60, 0x30, 0x00, 0x81,
  0x01, 0x81, 0x02, 0x81, 0x02, 0x83, 0x06, 0x83, 0x04, 0x85, 0x04, 0x85,
  0x08, 0x85, 0x08, 0x89, 0x18, 0x89, 0x10, 0x89, 0x10, 0x91, 0x20, 0x91,
  0x20, 0xA1, 0x20, 0xA1, 0x40, 0xA1, 0x40, 0xC1, 0x80, 0xC1, 0x80, 0x81,
  0x80, 0x04, 0x10, 0x43, 0x04, 0x20, 0x44, 0x04, 0x40, 0x28, 0x02, 0x80,
  0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x09, 0x00, 0x90, 0x11, 0x02,
  0x10, 0x21, 0x04, 0x10, 0xC1, 0x00, 0x81, 0x83, 0x82, 0x84, 0x84, 0x48,
  0x48, 0x50, 0x50, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80,
  0x80, 0x0F, 0xE0, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40,
  0x18, 0x03, 0xF8, 0x00, 0x07, 0xC1, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0F, 0x80, 0x92, 0x49, 0x22,
  0x49, 0x24, 0x89, 0x24, 0x80, 0x07, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x0F, 0x80, 0x08, 0x06,
  0x05, 0x02, 0x82, 0x21, 0x11, 0x04, 0x82, 0x80, 0xC0, 0x40, 0xFE, 0xA5,
  0x0E, 0x99, 0x48, 0x48, 0x24, 0x14, 0x0A, 0x05, 0x04, 0x82, 0x41, 0x21,
  0x90, 0xC8, 0xC3, 0xA0, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x5C,
  0x31, 0x10, 0x98, 0x48, 0x24, 0x12, 0x0A, 0x05, 0x02, 0x82, 0x41, 0x21,
  0x30, 0x97, 0x80, 0x0E, 0x60, 0x82, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x0F, 0x00, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20,
  0xE8, 0xCA, 0x21, 0x10, 0x44, 0x12, 0x04, 0x81, 0x20, 0x88, 0x22, 0x08,
  0x86, 0x21, 0x88, 0xC1, 0xD0, 0x1E, 0x64, 0x8A, 0x14, 0x30, 0xA6, 0x50,
  0x81, 0x02, 0x04, 0x08, 0x0F, 0x00, 0x00, 0xE0, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x04, 0x01, 0xE0, 0x50, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x18, 0x00, 0x03, 0xA1, 0x94, 0x21, 0x08, 0x21,
  0x04, 0x40, 0x88, 0x11, 0x04, 0x20, 0x84, 0x10, 0x86, 0x10, 0xC2, 0x30,
  0x3A, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x7E, 0x00, 0x08, 0x04,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x5C, 0x31, 0x10, 0x98, 0x48, 0x24, 0x22,
  0x12, 0x09, 0x04, 0x84, 0x42, 0x21, 0x20, 0x90, 0x40, 0x08, 0x40, 0x00,
  0x08, 0x42, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44, 0x20, 0x01, 0x01, 0x00,
  0x00, 0x00, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0xC0, 0x08, 0x04,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x42, 0x22, 0x12, 0x11, 0x09, 0x05, 0x03,
  0x83, 0x41, 0xA0, 0x88, 0x44, 0x22, 0x21, 0x10, 0x80, 0x08, 0x42, 0x11,
  0x08, 0x42, 0x11, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x00, 0x17, 0x38,
  0x65, 0x11, 0x08, 0x48, 0x21, 0x21, 0x08, 0x84, 0x22, 0x10, 0x90, 0x42,
  0x42, 0x09, 0x08, 0x44, 0x21, 0x10, 0x84, 0x82, 0x12, 0x10, 0xC0, 0x17,
  0x0C, 0x44, 0x26, 0x12, 0x11, 0x08, 0x84, 0x82, 0x41, 0x21, 0x10, 0x88,
  0x48, 0x24, 0x10, 0x1E, 0x32, 0x21, 0x41, 0x41, 0x81, 0x81, 0x83, 0x82,
  0x82, 0x82, 0x84, 0x8C, 0x78, 0x0B, 0x83, 0x10, 0x84, 0x61, 0x10, 0x44,
  0x11, 0x04, 0x81, 0x20, 0x48, 0x22, 0x08, 0x84, 0x61, 0x17, 0x84, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x1E, 0x99, 0x48, 0x48, 0x24, 0x14,
  0x0A, 0x05, 0x04, 0x82, 0x41, 0x21, 0x90, 0xC8, 0xC3, 0xA0, 0x10, 0x08,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x16, 0x30, 0x41, 0x82, 0x04, 0x08, 0x20,
  0x40, 0x81, 0x02, 0x08, 0x10, 0x00, 0x1E, 0x21, 0x20, 0x40, 0x20, 0x20,
  0x10, 0x18, 0x08, 0x04, 0x04, 0x04, 0x08, 0xF8, 0x08, 0x41, 0x0F, 0x50,
  0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x60, 0x21, 0x21, 0x41,
  0x41, 0x42, 0x42, 0x42, 0x82, 0x82, 0x84, 0x84, 0x84, 0x8C, 0xF4, 0x81,
  0x82, 0x82, 0x84, 0x84, 0x88, 0x88, 0x88, 0x90, 0x90, 0x60, 0x60, 0x40,
  0x40, 0x84, 0x18, 0x42, 0x8C, 0x28, 0xC4, 0x94, 0x49, 0x44, 0x94, 0x8A,
  0x48, 0xA5, 0x0C, 0x50, 0xC5, 0x0C, 0x60, 0x86, 0x08, 0x40, 0x10, 0xC4,
  0x21, 0x10, 0x24, 0x0A, 0x03, 0x00, 0xC0, 0x30, 0x14, 0x05, 0x02, 0x41,
  0x10, 0x42, 0x20, 0x80, 0x04, 0x10, 0x41, 0x04, 0x20, 0x42, 0x04, 0x40,
  0x44, 0x04, 0x80, 0x48, 0x04, 0x80, 0x50, 0x05, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x0E, 0x00, 0x1F, 0x01,
  0x02, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0xF8,
  0x01, 0x83, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08,
  0x18, 0x06, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x04, 0x01, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x30, 0x20, 0x20, 0x10, 0x08,
  0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x83, 0x80, 0xF8, 0xC3, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 19, 5, 0, -19 },
  { 16, 6, 7, 7, 2, -19 },
  { 22, 10, 19, 10, 0, -19 },
  { 46, 10, 22, 9, 0, -20 },
  { 74, 12, 19, 14, 1, -19 },
  { 103, 8, 19, 9, 0, -19 },
  { 122, 2, 7, 4, 3, -19 },
  { 124, 7, 23, 6, 1, -19 },
  { 145, 7, 23, 6, -2, -19 },
  { 166, 7, 8, 8, 3, -20 },
  { 173, 9, 12, 11, 1, -15 },
  { 187, 3, 5, 4, -1, -2 },
  { 189, 5, 1, 7, 1, -8 },
  { 190, 2, 2, 4, 0, -2 },
  { 191, 11, 19, 8, -1, -19 },
  { 218, 8, 19, 9, 1, -19 },
  { 237, 5, 19, 9, 3, -19 },
  { 249, 10, 19, 9, -1, -19 },
  { 273, 10, 19, 9, -1, -19 },
  { 297, 10, 19, 9, -1, -19 },
  { 321, 10, 19, 9, -1, -19 },
  { 345, 9, 19, 9, 1, -19 },
  { 367, 9, 19, 9, 1, -19 },
  { 389, 9, 19, 9, 0, -19 },
  { 411, 9, 19, 9, 0, -19 },
  { 433, 4, 14, 4, 0, -14 },
  { 440, 5, 17, 4, -1, -14 },
  { 451, 9, 11, 11, 1, -15 },
  { 464, 9, 6, 11, 1, -12 },
  { 471, 9, 11, 11, 1, -15 },
  { 484, 8, 19, 7, 0, -19 },
  { 503, 12, 21, 14, 1, -19 },
  { 535, 9, 19, 9, -2, -19 },
  { 557, 10, 19, 10, 0, -19 },
  { 581, 10, 19, 9, 1, -19 },
  { 605, 11, 19, 11, 0, -19 },
  { 632, 10, 19, 9, 0, -19 },
  { 656, 10, 19, 8, 0, -19 },
  { 680, 12, 19, 12, 1, -19 },
  { 709, 12, 19, 12, 0, -19 },
  { 738, 8, 19, 5, -1, -19 },
  { 757, 9, 24, 4, -4, -19 },
  { 784, 11, 19, 9, 0, -19 },
  { 811, 6, 19, 8, 0, -19 },
  { 826, 16, 19, 16, 0, -19 },
  { 864, 13, 19, 12, 0, -19 },
  { 895, 10, 19, 12, 1, -19 },
  { 919, 10, 19, 9, 0, -19 },
  { 943, 10, 23, 12, 1, -19 },
  { 972, 10, 19, 10, 0, -19 },
  { 996, 11, 19, 9, -1, -19 },
  { 1023, 8, 19, 8, 2, -19 },
  { 1042, 11, 19, 11, 1, -19 },
  { 1069, 9, 19, 9, 2, -19 },
  { 1091, 16, 19, 16, 2, -19 },
  { 1129, 12, 19, 8, -2, -19 },
  { 1158, 8, 19, 8, 2, -19 },
  { 1177, 11, 19, 8, -1, -19 },
  { 1204, 10, 23, 7, -1, -19 },
  { 1233, 3, 19, 8, 3, -19 },
  { 1241, 10, 23, 7, -2, -19 },
  { 1270, 9, 10, 10, 1, -19 },
  { 1282, 7, 1, 7, -2, 2 },
  { 1283, 2, 4, 6, 4, -20 },
  { 1284, 9, 14, 10, 1, -14 },
  { 1300, 9, 20, 10, 0, -20 },
  { 1323, 7, 14, 7, 1, -14 },
  { 1336, 10, 20, 10, 1, -20 },
  { 1361, 7, 14, 9, 1, -14 },
  { 1374, 11, 26, 5, -3, -20 },
  { 1410, 11, 20, 10, -1, -14 },
  { 1438, 9, 20, 10, 0, -20 },
  { 1461, 5, 19, 4, 0, -19 },
  { 1473, 8, 25, 4, -3, -19 },
  { 1498, 9, 20, 8, 0, -20 },
  { 1521, 5, 20, 4, 0, -20 },
  { 1534, 14, 14, 15, 0, -14 },
  { 1559, 9, 14, 10, 0, -14 },
  { 1575, 8, 14, 10, 1, -14 },
  { 1589, 10, 20, 10, -1, -14 },
  { 1614, 9, 20, 10, 1, -14 },
  { 1637, 7, 14, 6, 0, -14 },
  { 1650, 8, 14, 7, 0, -14 },
  { 1664, 6, 17, 5, 0, -17 },
  { 1677, 8, 14, 10, 1, -14 },
  { 1691, 8, 14, 7, 1, -14 },
  { 1705, 12, 14, 12, 2, -14 },
  { 1726, 10, 14, 8, -1, -14 },
  { 1744, 12, 20, 8, -3, -14 },
  { 1774, 8, 14, 6, -1, -14 },
  { 1788, 9, 23, 8, 1, -19 },
  { 1814, 1, 26, 9, 4, -20 },
  { 1818, 9, 23, 8, -2, -19 },
  { 1844, 9, 2, 11, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC26PT7B_H_
