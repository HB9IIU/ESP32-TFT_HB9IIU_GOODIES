#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC30PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x43, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x30, 0x82,
  0x08, 0x00, 0x00, 0x10, 0xC0, 0x65, 0x14, 0xD2, 0x8A, 0x28, 0x80, 0x03,
  0x30, 0x22, 0x02, 0x20, 0x42, 0x04, 0x40, 0x44, 0x3F, 0xF0, 0x88, 0x08,
  0x80, 0x88, 0x11, 0x01, 0x10, 0x11, 0x0F, 0xFC, 0x22, 0x02, 0x20, 0x42,
  0x04, 0x40, 0x44, 0x04, 0x40, 0x88, 0x00, 0x00, 0x80, 0x20, 0x04, 0x07,
  0xF1, 0x92, 0x24, 0x04, 0x81, 0x90, 0x12, 0x02, 0x40, 0x70, 0x06, 0x00,
  0x60, 0x0C, 0x01, 0x40, 0x4C, 0x08, 0x81, 0x10, 0x26, 0x04, 0x89, 0x60,
  0xF8, 0x04, 0x00, 0x80, 0x20, 0x00, 0x0C, 0x00, 0x58, 0x22, 0x21, 0x08,
  0x84, 0x42, 0x21, 0x08, 0x84, 0x24, 0x11, 0x90, 0x44, 0x82, 0x12, 0xE8,
  0x52, 0x62, 0x51, 0x5A, 0x45, 0x8A, 0x10, 0x48, 0x41, 0x21, 0x08, 0x88,
  0x24, 0x21, 0x10, 0x84, 0x44, 0x21, 0x11, 0x83, 0x80, 0x03, 0x01, 0x60,
  0x88, 0x22, 0x08, 0x82, 0x20, 0x90, 0x24, 0x0A, 0x03, 0x00, 0xC0, 0x70,
  0x24, 0x19, 0x34, 0x4A, 0x0A, 0x83, 0xA0, 0xC8, 0x32, 0x0C, 0x85, 0x1E,
  0x40, 0x69, 0x29, 0x20, 0x03, 0x06, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20,
  0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x06, 0x02, 0x02, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x08, 0x08, 0x10, 0x30, 0x20, 0x40, 0x80, 0x08, 0x08, 0x48, 0xE9,
  0x1E, 0x18, 0x24, 0x44, 0x06, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x43, 0xFF, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x32,
  0x24, 0x48, 0x80, 0xFC, 0x70, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x00, 0x03, 0x03, 0x61, 0x88, 0x42, 0x20, 0xC8, 0x22, 0x09, 0x02, 0x40,
  0x90, 0x2C, 0x0A, 0x02, 0x81, 0xA0, 0x48, 0x12, 0x04, 0x82, 0x20, 0x88,
  0x62, 0x10, 0x88, 0x1E, 0x00, 0x0C, 0xF6, 0xB2, 0x08, 0x21, 0x04, 0x10,
  0x43, 0x08, 0x20, 0x82, 0x18, 0x41, 0x04, 0x10, 0xC0, 0x01, 0x80, 0xE6,
  0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x0F, 0xF0, 0x01, 0x80, 0xE6, 0x08, 0x20, 0x03,
  0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x0F, 0x00, 0x30,
  0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18,
  0x83, 0x0F, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x60, 0x0A, 0x00, 0xA0, 0x12,
  0x03, 0x40, 0x24, 0x04, 0x40, 0x44, 0x08, 0xC1, 0x88, 0x10, 0x82, 0x08,
  0x20, 0x84, 0x18, 0xFF, 0xC0, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x07, 0xF0, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x1E, 0x01, 0x18, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x88, 0x30, 0xFE, 0x00, 0x01, 0xC1, 0x90, 0x80,
  0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x17, 0x8E, 0x13, 0x04, 0xC1,
  0x20, 0x68, 0x12, 0x04, 0x81, 0x20, 0x48, 0x22, 0x08, 0xC4, 0x1E, 0x00,
  0x3F, 0xE0, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x0C, 0x00, 0x03, 0x81, 0x98, 0x61, 0x88, 0x11, 0x02,
  0x20, 0x44, 0x10, 0x82, 0x10, 0x81, 0x20, 0x18, 0x0F, 0x02, 0x30, 0x82,
  0x30, 0x64, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x8C, 0x30, 0xFC, 0x00,
  0x03, 0x03, 0x31, 0x84, 0x41, 0x30, 0x48, 0x12, 0x04, 0x81, 0x20, 0x48,
  0x12, 0x0C, 0x83, 0x33, 0xC3, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x20,
  0x18, 0x0C, 0x3E, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x18, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC2, 0x08, 0x41, 0x08, 0x20, 0x00, 0x40, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x40, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x0C, 0x06, 0x06, 0x06, 0x03, 0x03, 0x00, 0x80, 0x00,
  0x0E, 0x09, 0x80, 0x60, 0x10, 0x08, 0x08, 0x04, 0x06, 0x02, 0x02, 0x02,
  0x03, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40, 0x00, 0x00, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x40, 0x0E, 0xE0, 0x40, 0x82, 0x01, 0x10, 0x04, 0x40, 0x12,
  0x00, 0x48, 0x79, 0x42, 0x45, 0x11, 0x14, 0x44, 0x72, 0x11, 0x88, 0x86,
  0x22, 0x28, 0x88, 0xA2, 0x62, 0x89, 0x92, 0x2A, 0x88, 0x44, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x80, 0x0C, 0x00, 0x00, 0x40, 0x30,
  0x0C, 0x03, 0x01, 0x40, 0x50, 0x24, 0x09, 0x02, 0x41, 0x10, 0x44, 0x21,
  0x08, 0x47, 0xF1, 0x04, 0x41, 0x20, 0x48, 0x16, 0x05, 0x01, 0x40, 0x60,
  0x10, 0x0F, 0xC0, 0x82, 0x08, 0x30, 0x81, 0x08, 0x31, 0x02, 0x10, 0x21,
  0x06, 0x10, 0xC3, 0xF0, 0x21, 0x82, 0x0C, 0x20, 0x42, 0x04, 0x60, 0x44,
  0x04, 0x40, 0xC4, 0x08, 0x41, 0x8C, 0x30, 0xFC, 0x00, 0x01, 0xE0, 0x73,
  0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x03, 0xE0, 0x0F, 0xC0, 0x82, 0x08, 0x30, 0x81,
  0x08, 0x11, 0x01, 0x10, 0x11, 0x01, 0x10, 0x13, 0x01, 0x20, 0x32, 0x02,
  0x20, 0x22, 0x02, 0x60, 0x64, 0x04, 0x40, 0xC4, 0x08, 0x41, 0x08, 0x60,
  0xF8, 0x00, 0x0F, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x03, 0xF8, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x3F, 0x82, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x00, 0x00, 0xE0, 0x18, 0xC3, 0x00, 0x10,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x83, 0xE8, 0x02, 0x40, 0x12, 0x00, 0x90, 0x0C, 0x80, 0x44, 0x02, 0x30,
  0x10, 0x80, 0x86, 0x0C, 0x1F, 0xC0, 0x0C, 0x04, 0x20, 0x30, 0x80, 0x82,
  0x02, 0x08, 0x08, 0x40, 0x21, 0x01, 0x04, 0x04, 0x10, 0x10, 0xFF, 0xC2,
  0x03, 0x08, 0x08, 0x20, 0x20, 0x80, 0x86, 0x02, 0x10, 0x18, 0x40, 0x41,
  0x01, 0x04, 0x04, 0x30, 0x10, 0x80, 0x80, 0x07, 0xC0, 0x80, 0x20, 0x08,
  0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0xF8, 0x00, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08,
  0x02, 0x00, 0x80, 0x60, 0x10, 0x38, 0x00, 0x0C, 0x18, 0x41, 0x82, 0x08,
  0x10, 0x80, 0x88, 0x08, 0xC0, 0x44, 0x02, 0x40, 0x14, 0x01, 0xE0, 0x0B,
  0x00, 0x6C, 0x02, 0x20, 0x11, 0x01, 0x88, 0x08, 0x40, 0x41, 0x02, 0x08,
  0x10, 0x41, 0x82, 0x08, 0x18, 0x00, 0x0C, 0x10, 0x20, 0x40, 0x82, 0x04,
  0x08, 0x10, 0x60, 0x81, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x04, 0x0F,
  0xE0, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x14, 0x30, 0x07, 0x0C, 0x03,
  0x85, 0x00, 0xA1, 0x60, 0x68, 0x48, 0x12, 0x12, 0x0D, 0x8C, 0x82, 0x42,
  0x20, 0x90, 0x88, 0x44, 0x22, 0x11, 0x08, 0x88, 0x86, 0x22, 0x21, 0x09,
  0x08, 0x42, 0x42, 0x10, 0xA0, 0x84, 0x28, 0x42, 0x0C, 0x10, 0x83, 0x04,
  0x00, 0x0C, 0x06, 0x18, 0x08, 0x38, 0x10, 0x50, 0x20, 0xA0, 0xC2, 0x41,
  0x04, 0x82, 0x09, 0x04, 0x11, 0x08, 0x62, 0x30, 0x84, 0x41, 0x08, 0x82,
  0x11, 0x04, 0x22, 0x18, 0x28, 0x20, 0x50, 0x40, 0xA0, 0x81, 0x41, 0x02,
  0x86, 0x06, 0x08, 0x04, 0x00, 0x01, 0xC0, 0x66, 0x08, 0x31, 0x81, 0x10,
  0x12, 0x01, 0x20, 0x16, 0x01, 0x40, 0x14, 0x01, 0x40, 0x3C, 0x02, 0xC0,
  0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x0C, 0x80, 0x8C, 0x18, 0x43,
  0x03, 0xE0, 0x0F, 0xC1, 0x0C, 0x20, 0x84, 0x10, 0x82, 0x20, 0x44, 0x08,
  0x81, 0x10, 0x46, 0x18, 0x86, 0x1F, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x00, 0x01, 0xC0, 0x66, 0x08, 0x31,
  0x81, 0x10, 0x12, 0x01, 0x20, 0x16, 0x01, 0x40, 0x14, 0x01, 0x40, 0x3C,
  0x02, 0xC0, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x0C, 0x80, 0x8C,
  0x18, 0x43, 0x03, 0xE0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x0F, 0xC1, 0x0C, 0x20, 0x84, 0x10, 0x82, 0x20, 0x44, 0x08, 0x83, 0x10,
  0x46, 0x18, 0xFE, 0x11, 0x02, 0x20, 0x44, 0x18, 0x82, 0x10, 0x43, 0x08,
  0x21, 0x04, 0x60, 0x88, 0x10, 0x01, 0xE0, 0x73, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x81,
  0x0F, 0xE0, 0x7F, 0x84, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x18, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10,
  0x08, 0x00, 0x18, 0x18, 0x80, 0x84, 0x04, 0x20, 0x23, 0x03, 0x10, 0x10,
  0x80, 0x84, 0x04, 0x20, 0x22, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x60,
  0x62, 0x02, 0x10, 0x10, 0x80, 0x84, 0x08, 0x20, 0x41, 0x84, 0x07, 0xE0,
  0x00, 0x80, 0xE0, 0x28, 0x0A, 0x04, 0x81, 0x20, 0xC8, 0x22, 0x08, 0x84,
  0x21, 0x08, 0x82, 0x20, 0x98, 0x24, 0x09, 0x02, 0x80, 0xA0, 0x30, 0x0C,
  0x03, 0x00, 0x80, 0x00, 0x40, 0x40, 0x50, 0x30, 0x1C, 0x0C, 0x0B, 0x05,
  0x02, 0xC1, 0x41, 0xB0, 0x50, 0x4C, 0x24, 0x12, 0x09, 0x08, 0x86, 0x42,
  0x21, 0x11, 0x88, 0x44, 0x42, 0x21, 0x10, 0x88, 0x48, 0x22, 0x12, 0x09,
  0x05, 0x02, 0x41, 0x40, 0xA0, 0x50, 0x28, 0x28, 0x0A, 0x0A, 0x03, 0x03,
  0x00, 0xC0, 0xC0, 0x00, 0x06, 0x0C, 0x08, 0x60, 0x21, 0x00, 0x8C, 0x02,
  0x20, 0x09, 0x00, 0x24, 0x00, 0xA0, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x05, 0x00, 0x34, 0x00, 0x90, 0x06, 0x60, 0x10, 0x80, 0x82, 0x02,
  0x08, 0x10, 0x20, 0xC0, 0x80, 0xC0, 0xD0, 0x64, 0x11, 0x0C, 0x42, 0x11,
  0x84, 0x41, 0x30, 0x48, 0x14, 0x03, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x00, 0x0F, 0xF0, 0x02, 0x00,
  0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x1F, 0x80, 0x88, 0x44, 0x44, 0x44, 0x46, 0x22, 0x22, 0x22,
  0x31, 0x11, 0x10, 0x03, 0xE0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x0C, 0x1F, 0x00, 0x06, 0x01, 0x40, 0x28, 0x08, 0x81, 0x10, 0x43, 0x08,
  0x22, 0x06, 0xC0, 0x50, 0x0C, 0xFF, 0xC9, 0x12, 0x0F, 0x46, 0x33, 0x0C,
  0x83, 0x40, 0x90, 0x24, 0x0B, 0x02, 0x80, 0xA0, 0x48, 0x12, 0x04, 0x83,
  0x20, 0xCC, 0x61, 0xE8, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0xDE, 0x14, 0x43, 0x0C, 0x41, 0x88, 0x13, 0x06, 0x40, 0xC8,
  0x11, 0x02, 0x20, 0x48, 0x19, 0x02, 0x20, 0x44, 0x11, 0x46, 0x2F, 0x80,
  0x0F, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xC0, 0x78, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x60, 0xF4, 0x10, 0xC3, 0x0C, 0x20, 0xC4, 0x08, 0x40, 0x84,
  0x08, 0xC0, 0x88, 0x08, 0x81, 0x08, 0x10, 0x81, 0x08, 0x30, 0x83, 0x0C,
  0x60, 0x7A, 0x00, 0x0F, 0x08, 0x88, 0x64, 0x34, 0x12, 0x0B, 0x09, 0x78,
  0xE0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0x08, 0xF8, 0x00, 0x38, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x7C, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x70, 0x00, 0x03, 0xD0,
  0x43, 0x0C, 0x30, 0x83, 0x10, 0x21, 0x02, 0x10, 0x23, 0x02, 0x20, 0x62,
  0x04, 0x20, 0x42, 0x04, 0x20, 0xC2, 0x0C, 0x31, 0x81, 0xE8, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x01, 0x08, 0x20, 0x7C, 0x00, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x6E, 0x14, 0x46, 0x11, 0x04, 0x41,
  0x30, 0x48, 0x32, 0x08, 0x82, 0x20, 0x90, 0x24, 0x11, 0x04, 0x41, 0x30,
  0x48, 0x30, 0x04, 0x30, 0x80, 0x00, 0x01, 0x84, 0x10, 0x41, 0x08, 0x20,
  0x82, 0x08, 0x41, 0x04, 0x10, 0xC2, 0x00, 0x00, 0x40, 0x30, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0xE0, 0x00, 0x04, 0x01, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x61, 0x10, 0x84, 0x61, 0x10, 0x48, 0x24,
  0x0B, 0x02, 0xC0, 0xD0, 0x64, 0x11, 0x04, 0x21, 0x08, 0x42, 0x30, 0x88,
  0x20, 0x04, 0x10, 0xC2, 0x08, 0x20, 0x86, 0x10, 0x41, 0x04, 0x20, 0x82,
  0x08, 0x61, 0x04, 0x10, 0x43, 0x08, 0x00, 0x13, 0x9E, 0x14, 0x63, 0x18,
  0x61, 0x10, 0x41, 0x10, 0x43, 0x30, 0xC2, 0x20, 0x82, 0x20, 0x82, 0x20,
  0x82, 0x20, 0x86, 0x41, 0x04, 0x41, 0x04, 0x41, 0x04, 0x41, 0x04, 0xC3,
  0x0C, 0x82, 0x08, 0x13, 0x85, 0x11, 0x84, 0x41, 0x10, 0x4C, 0x12, 0x0C,
  0x82, 0x20, 0x88, 0x24, 0x09, 0x04, 0x41, 0x10, 0x4C, 0x12, 0x0C, 0x0F,
  0x08, 0xC8, 0x24, 0x14, 0x0A, 0x05, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x50,
  0x28, 0x34, 0x13, 0x10, 0xF0, 0x09, 0xE0, 0xA2, 0x0C, 0x30, 0x81, 0x08,
  0x11, 0x83, 0x10, 0x31, 0x02, 0x10, 0x21, 0x02, 0x30, 0x22, 0x04, 0x20,
  0x42, 0x08, 0x71, 0x85, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x00, 0x0F, 0x44, 0x72, 0x0C, 0x83, 0x40, 0x90, 0x24,
  0x0B, 0x02, 0x80, 0xA0, 0x48, 0x12, 0x04, 0x83, 0x20, 0xCC, 0x61, 0xE8,
  0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x13, 0x8A, 0x06,
  0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02,
  0x03, 0x01, 0x00, 0x1F, 0x18, 0x48, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x30,
  0x08, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x22, 0x11, 0xF0, 0x10, 0x84, 0x67,
  0x90, 0x84, 0x62, 0x10, 0x84, 0x42, 0x10, 0x84, 0x21, 0xC0, 0x30, 0x48,
  0x22, 0x08, 0x82, 0x20, 0x90, 0x24, 0x11, 0x04, 0x41, 0x30, 0x48, 0x32,
  0x08, 0x82, 0x21, 0x88, 0xA3, 0xE8, 0x81, 0x82, 0x82, 0x86, 0x84, 0x84,
  0x88, 0x88, 0x90, 0x90, 0xA0, 0xA0, 0xE0, 0xC0, 0xC0, 0x80, 0x83, 0x0E,
  0x0C, 0x28, 0x50, 0xA1, 0x84, 0x86, 0x12, 0x28, 0x48, 0xA2, 0x24, 0x88,
  0x92, 0x42, 0x49, 0x0A, 0x24, 0x28, 0xA0, 0xC2, 0x83, 0x0C, 0x0C, 0x30,
  0x20, 0xC0, 0x18, 0x61, 0x08, 0x22, 0x04, 0x40, 0x90, 0x16, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x80, 0x48, 0x19, 0x02, 0x20, 0x84, 0x10, 0x84, 0x18,
  0x04, 0x0C, 0x10, 0x20, 0x41, 0x81, 0x04, 0x04, 0x10, 0x10, 0x80, 0x42,
  0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0x68, 0x01, 0xE0, 0x05, 0x00, 0x14,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x40, 0x40, 0x20, 0x20, 0x30,
  0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0xF8, 0x01,
  0xC0, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x40, 0xE0, 0x08, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x70, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x00, 0xC0, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x30, 0x30, 0x00, 0x78, 0x63, 0xB8,
  0x38,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 21, 6, 0, -21 },
  { 17, 6, 7, 8, 3, -21 },
  { 23, 12, 21, 11, 0, -21 },
  { 55, 11, 25, 11, 0, -23 },
  { 90, 14, 22, 16, 1, -22 },
  { 129, 10, 22, 10, 0, -22 },
  { 157, 3, 7, 5, 3, -21 },
  { 160, 8, 26, 7, 1, -21 },
  { 186, 8, 26, 7, -2, -21 },
  { 212, 8, 9, 10, 3, -23 },
  { 221, 10, 14, 12, 1, -18 },
  { 239, 4, 7, 5, -1, -3 },
  { 243, 6, 1, 8, 1, -9 },
  { 244, 2, 2, 5, 0, -2 },
  { 245, 12, 21, 9, -1, -21 },
  { 277, 10, 22, 11, 1, -22 },
  { 305, 6, 21, 11, 3, -21 },
  { 321, 12, 22, 11, -1, -22 },
  { 354, 12, 22, 11, -1, -22 },
  { 387, 12, 22, 11, -1, -22 },
  { 420, 12, 21, 11, -1, -21 },
  { 452, 10, 22, 11, 1, -22 },
  { 480, 11, 21, 11, 1, -21 },
  { 509, 11, 22, 11, 0, -22 },
  { 540, 10, 22, 11, 0, -22 },
  { 568, 5, 16, 5, 0, -16 },
  { 578, 6, 20, 5, -1, -16 },
  { 593, 10, 13, 12, 1, -17 },
  { 610, 10, 7, 12, 1, -14 },
  { 619, 10, 13, 12, 1, -17 },
  { 636, 9, 22, 8, 0, -22 },
  { 661, 14, 25, 16, 1, -22 },
  { 705, 10, 22, 10, -2, -22 },
  { 733, 12, 21, 12, 0, -21 },
  { 765, 12, 22, 10, 1, -22 },
  { 798, 12, 21, 13, 0, -21 },
  { 830, 12, 21, 10, 0, -21 },
  { 862, 12, 21, 10, 0, -21 },
  { 894, 13, 22, 14, 1, -22 },
  { 930, 14, 21, 13, 0, -21 },
  { 967, 10, 21, 6, -2, -21 },
  { 994, 10, 26, 5, -4, -21 },
  { 1027, 13, 21, 11, 0, -21 },
  { 1062, 7, 21, 9, 0, -21 },
  { 1081, 18, 21, 18, 0, -21 },
  { 1129, 15, 21, 14, 0, -21 },
  { 1169, 12, 22, 14, 1, -22 },
  { 1202, 11, 21, 11, 0, -21 },
  { 1231, 12, 27, 14, 1, -22 },
  { 1272, 11, 21, 11, 0, -21 },
  { 1301, 12, 22, 10, -1, -22 },
  { 1334, 9, 21, 9, 2, -21 },
  { 1358, 13, 21, 13, 1, -21 },
  { 1393, 10, 21, 11, 3, -21 },
  { 1420, 18, 21, 18, 2, -21 },
  { 1468, 14, 21, 10, -2, -21 },
  { 1505, 10, 21, 9, 2, -21 },
  { 1532, 12, 21, 9, -1, -21 },
  { 1564, 11, 26, 8, -1, -21 },
  { 1600, 4, 21, 10, 3, -21 },
  { 1611, 11, 26, 8, -2, -21 },
  { 1647, 11, 10, 12, 1, -21 },
  { 1661, 8, 1, 8, -2, 3 },
  { 1662, 3, 5, 6, 4, -23 },
  { 1664, 10, 16, 12, 1, -16 },
  { 1684, 11, 23, 11, 0, -23 },
  { 1716, 8, 16, 8, 1, -16 },
  { 1732, 12, 23, 12, 1, -23 },
  { 1767, 9, 16, 10, 1, -16 },
  { 1785, 13, 30, 6, -4, -23 },
  { 1834, 12, 23, 12, -1, -16 },
  { 1869, 10, 23, 11, 0, -23 },
  { 1898, 6, 22, 5, 0, -22 },
  { 1915, 10, 29, 5, -4, -22 },
  { 1952, 10, 23, 9, 0, -23 },
  { 1981, 6, 23, 5, 0, -23 },
  { 1999, 16, 16, 17, 0, -16 },
  { 2031, 10, 16, 11, 0, -16 },
  { 2051, 9, 16, 11, 1, -16 },
  { 2069, 12, 23, 11, -1, -16 },
  { 2104, 10, 23, 12, 1, -16 },
  { 2133, 9, 16, 7, 0, -16 },
  { 2151, 9, 16, 8, 0, -16 },
  { 2169, 5, 20, 6, 1, -20 },
  { 2182, 10, 16, 11, 1, -16 },
  { 2202, 8, 16, 9, 2, -16 },
  { 2218, 14, 16, 14, 2, -16 },
  { 2246, 11, 16, 9, -1, -16 },
  { 2268, 14, 23, 9, -3, -16 },
  { 2309, 9, 16, 7, -1, -16 },
  { 2327, 10, 26, 9, 1, -21 },
  { 2360, 1, 30, 10, 5, -23 },
  { 2364, 10, 26, 9, -2, -21 },
  { 2397, 10, 3, 12, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC30PT7B_H_
