#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC64PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x00, 0x1C, 0x1C, 0x70, 0x61, 0x81, 0x86, 0x0E, 0x38,
  0x38, 0xE0, 0xC3, 0x03, 0x0C, 0x0C, 0x30, 0x31, 0xC1, 0x86, 0x06, 0x18,
  0x18, 0x60, 0x61, 0x81, 0x04, 0x0C, 0x30, 0x30, 0xC0, 0xC0, 0x00, 0x03,
  0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00,
  0x0C, 0x0E, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x03, 0x80,
  0x03, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x07, 0x00, 0x07, 0x03, 0x00, 0x03, 0x01,
  0x80, 0x01, 0x81, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60,
  0x70, 0x00, 0x30, 0x30, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x0C,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03,
  0x81, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x0C, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x78, 0x87, 0x00, 0x70, 0x40, 0x80, 0x30, 0x60, 0x00, 0x30, 0x30, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x08, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x06, 0x00,
  0x03, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x1C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x98, 0x00, 0x00, 0xE8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x10, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x1C, 0x00,
  0x06, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x01, 0x03, 0x80, 0x01, 0x81, 0x80,
  0x00, 0xC0, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x20, 0x60, 0x20, 0x10, 0x70,
  0x0C, 0x18, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x60,
  0x1F, 0xC0, 0x06, 0x01, 0xC7, 0x00, 0x30, 0x1C, 0x18, 0x03, 0x00, 0xC0,
  0xC0, 0x18, 0x0E, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x01, 0x80,
  0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x60, 0x0C, 0x03, 0x03, 0x00,
  0xE0, 0x38, 0x30, 0x06, 0x01, 0xC1, 0x80, 0x30, 0x0C, 0x18, 0x01, 0x80,
  0x60, 0xC0, 0x1C, 0x03, 0x0C, 0x00, 0xE0, 0x38, 0x60, 0x06, 0x01, 0x86,
  0x00, 0x30, 0x0C, 0x30, 0x79, 0x80, 0x63, 0x0F, 0xEC, 0x07, 0x18, 0xE3,
  0x60, 0x31, 0x86, 0x1F, 0x03, 0x8C, 0x60, 0x78, 0x18, 0xC7, 0x03, 0xC1,
  0xC6, 0x30, 0x1F, 0x1C, 0x63, 0x80, 0xDF, 0xC3, 0x18, 0x06, 0x7C, 0x30,
  0xC0, 0x30, 0x01, 0x8E, 0x03, 0x80, 0x18, 0x60, 0x1C, 0x00, 0xC3, 0x00,
  0xC0, 0x0C, 0x18, 0x06, 0x00, 0x60, 0xC0, 0x30, 0x06, 0x0E, 0x01, 0x80,
  0x30, 0x60, 0x1C, 0x03, 0x03, 0x00, 0xC0, 0x18, 0x18, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x81,
  0xC0, 0x60, 0x0C, 0x0C, 0x03, 0x00, 0x60, 0xE0, 0x30, 0x03, 0x86, 0x01,
  0x80, 0x0C, 0xE0, 0x1C, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xC7, 0x00, 0x0E, 0x0C, 0x00, 0x30,
  0x30, 0x01, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30,
  0x01, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x18, 0x00, 0xE0, 0x60, 0x01,
  0x83, 0x80, 0x06, 0x0C, 0x00, 0x18, 0x70, 0x00, 0x63, 0x80, 0x01, 0x8C,
  0x00, 0x07, 0x60, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x76, 0x00, 0x03, 0x98, 0x00, 0x1C, 0x60, 0x00, 0x61,
  0xC0, 0xC3, 0x83, 0x07, 0x1C, 0x0C, 0x18, 0x60, 0x30, 0x63, 0x80, 0xE3,
  0x8C, 0x01, 0x8C, 0x70, 0x06, 0x31, 0x80, 0x1D, 0xC6, 0x00, 0x76, 0x18,
  0x00, 0xF8, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x38, 0x00,
  0xE0, 0xE0, 0x07, 0xC1, 0x80, 0x3F, 0x07, 0x00, 0xCC, 0x1C, 0x0E, 0x30,
  0x3F, 0xF0, 0xE0, 0x7F, 0x83, 0x80, 0x78, 0x00, 0x00, 0x1C, 0x71, 0x86,
  0x38, 0xE3, 0x0C, 0x30, 0xC6, 0x18, 0x61, 0x84, 0x30, 0xC0, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x03, 0x06, 0x03, 0xC3, 0x00, 0x79,
  0x83, 0x0E, 0x9F, 0x81, 0xFE, 0x00, 0x70, 0x00, 0xF8, 0x00, 0xE6, 0x00,
  0xE3, 0x00, 0xE0, 0xC0, 0xE0, 0x60, 0x20, 0x18, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x03, 0x81, 0x81, 0xC0, 0xE0,
  0x60, 0x70, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x07, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x6F, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0x80, 0x0E, 0x1C, 0x00, 0xE0, 0x70, 0x0E, 0x03, 0x80, 0x60, 0x0C,
  0x07, 0x00, 0x60, 0x30, 0x03, 0x03, 0x80, 0x18, 0x18, 0x00, 0xC1, 0xC0,
  0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x87, 0x00, 0x0C, 0x30, 0x00, 0x61,
  0x80, 0x03, 0x1C, 0x00, 0x38, 0xC0, 0x01, 0xC6, 0x00, 0x0E, 0x70, 0x00,
  0x73, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x0E, 0x70,
  0x00, 0x73, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x01, 0xC6, 0x00, 0x0E,
  0x30, 0x00, 0x61, 0x80, 0x03, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00,
  0x0C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x30, 0x70, 0x03, 0x83,
  0x80, 0x18, 0x1C, 0x01, 0xC0, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x1C, 0x0E,
  0x00, 0x60, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0x61, 0xE6, 0x38, 0xE7, 0x0E,
  0xE0, 0xC4, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x1E, 0x07, 0x80, 0x04, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0xF0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x80, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x80, 0x1E, 0x00, 0xFD, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x36, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xCC, 0x00, 0x01, 0x8C,
  0x00, 0x03, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x18,
  0x00, 0x0C, 0x38, 0x00, 0x18, 0x38, 0x00, 0x38, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x70, 0x30, 0x00, 0x60, 0x70, 0x00, 0xC0, 0x70, 0x01, 0xC0, 0x60,
  0x01, 0x80, 0x60, 0x03, 0x80, 0x60, 0x03, 0x00, 0xE0, 0x06, 0x00, 0xC0,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0xC0,
  0x30, 0x01, 0x80, 0x70, 0x01, 0x80, 0x60, 0x01, 0x80, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x08, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x20,
  0x01, 0xE0, 0x18, 0x01, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x78, 0x08,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x61, 0xF8, 0x00, 0xC7, 0xFC,
  0x03, 0xBC, 0x3C, 0x07, 0x60, 0x38, 0x0D, 0x80, 0x38, 0x1E, 0x00, 0x70,
  0x38, 0x00, 0x60, 0xF0, 0x00, 0xC1, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x07,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x70, 0x60,
  0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x07, 0x00, 0x06, 0x0E, 0x00,
  0x1C, 0x1C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x01, 0xC0, 0x60, 0x03,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x38, 0x01, 0xC0, 0xE0, 0x01, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x38, 0x1E, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0xC0, 0x07, 0x01, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01,
  0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x07, 0x01, 0x80, 0x07, 0x01,
  0x80, 0x06, 0x01, 0x80, 0x0E, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x00,
  0xE0, 0x38, 0x00, 0x60, 0x70, 0x00, 0x71, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF7, 0x00, 0x01, 0xC7, 0x00, 0x07,
  0x83, 0x80, 0x0E, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x18, 0x00, 0xE0, 0x38,
  0x00, 0x60, 0x30, 0x00, 0x60, 0x70, 0x00, 0x70, 0x60, 0x00, 0x70, 0x60,
  0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x70,
  0x00, 0xC0, 0x38, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x1F, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x07,
  0x07, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0x18, 0x06, 0x00, 0x70, 0x38, 0x01,
  0xC0, 0xC0, 0x03, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC3,
  0x80, 0x03, 0x0E, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00,
  0x03, 0x0C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x0F,
  0x1C, 0x00, 0x38, 0x30, 0x00, 0xE0, 0xC0, 0x07, 0x83, 0x80, 0x3E, 0x0E,
  0x01, 0xB8, 0x1C, 0x0E, 0xC0, 0x3F, 0xF3, 0x00, 0x7F, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x00, 0x00, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x03,
  0xFF, 0xC0, 0x60, 0x78, 0x10, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x70, 0x03, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x07, 0x00, 0x60, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xE1, 0xC0, 0x0F, 0x81, 0xC3,
  0x00, 0x7F, 0x83, 0x86, 0x01, 0xC3, 0x07, 0x18, 0x06, 0x0C, 0x0C, 0x30,
  0x18, 0x18, 0x18, 0x60, 0x70, 0x30, 0x31, 0x80, 0xC0, 0xE0, 0x63, 0x03,
  0x81, 0x80, 0xC6, 0x06, 0x03, 0x01, 0x9C, 0x0C, 0x06, 0x03, 0x30, 0x30,
  0x1C, 0x0C, 0x60, 0x60, 0x30, 0x18, 0xC0, 0xC0, 0x60, 0x31, 0x83, 0x80,
  0xC0, 0x67, 0x06, 0x03, 0x81, 0xCC, 0x0C, 0x06, 0x03, 0x18, 0x18, 0x0C,
  0x06, 0x30, 0x30, 0x38, 0x1C, 0x60, 0x60, 0x70, 0x30, 0xC0, 0xC0, 0xE0,
  0x61, 0x81, 0x83, 0xC1, 0x83, 0x03, 0x05, 0x87, 0x06, 0x06, 0x1B, 0x0C,
  0x0C, 0x0E, 0x67, 0x70, 0x18, 0x0F, 0x87, 0xC0, 0x30, 0x0E, 0x02, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3C,
  0x01, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0D, 0xC0, 0x00,
  0x37, 0x00, 0x01, 0x9C, 0x00, 0x06, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xC7,
  0x00, 0x07, 0x1C, 0x00, 0x18, 0x70, 0x00, 0x61, 0xC0, 0x03, 0x87, 0x00,
  0x0C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0x81, 0xC0, 0x06, 0x07, 0x00, 0x38,
  0x1C, 0x00, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x18, 0x07, 0x00, 0x60, 0x1C,
  0x03, 0x80, 0x70, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0E,
  0x00, 0x70, 0x38, 0x01, 0xC0, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x18, 0x00,
  0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0C, 0x00, 0x1C, 0x70, 0x00, 0x71,
  0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xC0, 0x00, 0x77, 0x00,
  0x01, 0xD8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1C, 0x3F, 0x80, 0x0E, 0x01, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x00,
  0xC0, 0x03, 0x80, 0x60, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x38, 0x00, 0x70,
  0x1C, 0x00, 0x38, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x0E,
  0x03, 0x80, 0x0E, 0x01, 0xC0, 0x06, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x1F, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0C, 0x07,
  0xC0, 0x06, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x01, 0x80,
  0x07, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x70, 0x00, 0x60, 0x38,
  0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x0E, 0x07,
  0x00, 0x07, 0x03, 0x80, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x01, 0xC0,
  0x60, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x18, 0x01, 0xE0,
  0x0C, 0x07, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xC0, 0x40, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x40, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xC0, 0x78, 0x00, 0x60, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x38,
  0x03, 0x80, 0x0E, 0x00, 0xE0, 0x01, 0x80, 0x30, 0x00, 0x70, 0x0C, 0x00,
  0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x18,
  0x00, 0x1C, 0x06, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70,
  0x30, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x60, 0x70, 0x00, 0x38, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xC0, 0xE0, 0x00, 0x30, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x03,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x18, 0x00, 0x0C,
  0x06, 0x00, 0x07, 0x01, 0x80, 0x01, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00,
  0x30, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x70,
  0x03, 0xC0, 0x18, 0x01, 0xE0, 0x06, 0x01, 0xF0, 0x01, 0x83, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x01,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xC0, 0x3E, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x60, 0x00,
  0xFF, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x03, 0x80, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60, 0x38, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x60, 0x0E, 0x00, 0x03, 0x00, 0x30, 0x00, 0x18, 0x01,
  0xC0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0x60, 0x07, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x38, 0x01, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x60, 0x06,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x30, 0x03, 0x80,
  0x00, 0xC0, 0x0E, 0x00, 0x03, 0x00, 0x30, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x70, 0x03, 0x00, 0x01, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x01, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x18, 0x01, 0xC0, 0x00, 0x60, 0x07, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x38, 0x01, 0x80, 0x00, 0xC0, 0x0E, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x70, 0x03, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x06, 0x00, 0x70, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x06,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x30, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x02, 0x0E, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0x70, 0x03, 0x00, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00,
  0x70, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xC0, 0x1C, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x18, 0x1C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x18, 0x38, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x77, 0x80, 0x00, 0x06, 0x78, 0x00,
  0x00, 0x6D, 0xC0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x0F,
  0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x1C, 0x06, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x07, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x18, 0x07, 0x00, 0x03, 0x80, 0x30, 0x00, 0x38, 0x03,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x30, 0x03, 0x80, 0x07, 0x00, 0x18, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x06, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x1B, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0xDC, 0x00, 0x00, 0xDC, 0x01, 0xB8, 0x00, 0x03,
  0xB0, 0x03, 0x70, 0x00, 0x06, 0x60, 0x0E, 0x60, 0x00, 0x1C, 0xC0, 0x1C,
  0xC0, 0x00, 0x33, 0x80, 0x31, 0x80, 0x00, 0xE7, 0x00, 0x63, 0x00, 0x01,
  0x8C, 0x00, 0xC6, 0x00, 0x07, 0x18, 0x03, 0x8C, 0x00, 0x0C, 0x30, 0x07,
  0x18, 0x00, 0x38, 0xE0, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x18, 0x60, 0x00,
  0xC3, 0x00, 0x30, 0xC0, 0x03, 0x06, 0x00, 0xE1, 0x80, 0x06, 0x1C, 0x01,
  0x83, 0x00, 0x1C, 0x38, 0x03, 0x06, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00,
  0xE0, 0xC0, 0x1C, 0x18, 0x01, 0x81, 0x80, 0x38, 0x38, 0x07, 0x07, 0x00,
  0x60, 0x70, 0x0C, 0x0E, 0x00, 0xC0, 0xE0, 0x38, 0x18, 0x01, 0x81, 0xC0,
  0x60, 0x30, 0x07, 0x03, 0x81, 0xC0, 0x60, 0x0E, 0x03, 0x03, 0x01, 0xC0,
  0x18, 0x06, 0x0E, 0x03, 0x80, 0x30, 0x0C, 0x18, 0x06, 0x00, 0x60, 0x18,
  0x70, 0x0C, 0x01, 0xC0, 0x30, 0xC0, 0x38, 0x03, 0x00, 0x63, 0x80, 0x70,
  0x06, 0x00, 0xC6, 0x00, 0xC0, 0x0C, 0x01, 0x8C, 0x01, 0x80, 0x38, 0x03,
  0x30, 0x03, 0x00, 0x70, 0x06, 0x60, 0x0E, 0x00, 0xC0, 0x0D, 0xC0, 0x1C,
  0x01, 0x80, 0x1B, 0x00, 0x30, 0x03, 0x00, 0x3E, 0x00, 0x60, 0x0E, 0x00,
  0x78, 0x00, 0xC0, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x0C, 0x01, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x00,
  0x70, 0x07, 0x80, 0x00, 0xC0, 0x0F, 0x80, 0x01, 0x80, 0x3B, 0x00, 0x07,
  0x00, 0x76, 0x00, 0x0E, 0x00, 0xCC, 0x00, 0x18, 0x01, 0x98, 0x00, 0x30,
  0x03, 0x38, 0x00, 0x60, 0x0E, 0x70, 0x01, 0xC0, 0x1C, 0x60, 0x03, 0x80,
  0x30, 0xC0, 0x06, 0x00, 0x61, 0x80, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0x03,
  0x87, 0x00, 0x70, 0x07, 0x06, 0x00, 0xE0, 0x0C, 0x0C, 0x01, 0x80, 0x18,
  0x18, 0x03, 0x00, 0x30, 0x30, 0x06, 0x00, 0xE0, 0x70, 0x1C, 0x01, 0x80,
  0xE0, 0x30, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x80, 0xC0, 0x1C, 0x03,
  0x03, 0x80, 0x38, 0x06, 0x07, 0x00, 0x60, 0x0E, 0x0C, 0x00, 0xC0, 0x0C,
  0x18, 0x01, 0x80, 0x18, 0x30, 0x07, 0x00, 0x30, 0xE0, 0x0E, 0x00, 0x61,
  0xC0, 0x18, 0x00, 0xE3, 0x00, 0x30, 0x01, 0xC6, 0x00, 0x60, 0x01, 0x8C,
  0x01, 0xC0, 0x03, 0x38, 0x03, 0x80, 0x06, 0x60, 0x06, 0x00, 0x0C, 0xC0,
  0x0C, 0x00, 0x1D, 0x80, 0x38, 0x00, 0x3B, 0x00, 0x70, 0x00, 0x3E, 0x00,
  0xC0, 0x00, 0x78, 0x01, 0x80, 0x00, 0xF0, 0x03, 0x00, 0x01, 0xE0, 0x0E,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x00, 0x60, 0x1C, 0x00, 0x18, 0x06, 0x00, 0x07, 0x03, 0x80,
  0x01, 0xC0, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07,
  0x18, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x73, 0x80, 0x00, 0x18, 0xE0, 0x00,
  0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x0E, 0x70, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x0E,
  0x00, 0x07, 0x01, 0x80, 0x03, 0x80, 0x70, 0x00, 0xC0, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x00, 0xF0, 0x3C, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x70, 0x1C, 0x00, 0x60, 0x0E, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x03, 0x00,
  0xC0, 0x03, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x07, 0x01, 0x80, 0x07, 0x01,
  0x80, 0x07, 0x01, 0x80, 0x06, 0x03, 0x80, 0x06, 0x03, 0x80, 0x0E, 0x03,
  0x00, 0x0C, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x18, 0x07, 0x00, 0x38, 0x07,
  0x00, 0x70, 0x06, 0x01, 0xE0, 0x06, 0x3F, 0xC0, 0x0F, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0xE0, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0x60, 0x1C, 0x00, 0x18, 0x06, 0x00,
  0x07, 0x03, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x18,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C,
  0x70, 0x00, 0x07, 0x18, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x18, 0xE0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0C, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x38, 0x38,
  0x00, 0x0C, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x03, 0x80, 0x70, 0x00, 0xC0,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0xF0, 0x3C, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x73, 0xF8, 0x00, 0x70, 0x1C, 0x00, 0x60, 0x0E, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xC0, 0x07, 0x00,
  0xC0, 0x03, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0x80, 0x07, 0x01,
  0x80, 0x07, 0x01, 0x80, 0x06, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x0E, 0x03,
  0x00, 0x0C, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x38, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x06, 0x0F, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0E,
  0x0C, 0x00, 0x0C, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x0C, 0x06, 0x00, 0x1C,
  0x06, 0x00, 0x1C, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x07, 0x00, 0x18,
  0x07, 0x00, 0x38, 0x03, 0x00, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x80, 0x70, 0x03, 0x80, 0x70, 0x03, 0x80, 0x60, 0x01, 0x80, 0x60,
  0x01, 0x80, 0x60, 0x01, 0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xE0, 0x3C, 0x01, 0xE0, 0x02,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x08, 0x00, 0x3C, 0x03, 0x80, 0x1E, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x1C, 0x06, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x07, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x70, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x30, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x30, 0x0C,
  0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x38, 0x0C, 0x00, 0x07,
  0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x0E, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0xE0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60,
  0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x0C, 0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x70, 0x18, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01,
  0xC0, 0x70, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x01, 0xC0, 0x30,
  0x00, 0x30, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x1C, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1B,
  0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0x9C, 0x00, 0x07, 0x38,
  0x00, 0x0C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x61, 0xC0, 0x01, 0xC3, 0x80,
  0x03, 0x87, 0x00, 0x06, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x30, 0x38, 0x00,
  0xE0, 0x70, 0x01, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x18,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x06, 0x00,
  0x70, 0x0C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x60, 0x03, 0x81, 0xC0, 0x07,
  0x03, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x30, 0x00, 0x70,
  0xE0, 0x00, 0xE1, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x38,
  0x00, 0x0E, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x76, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0xC0, 0x00, 0x70, 0x00, 0x1B, 0x80, 0x00, 0xE0, 0x00, 0x77, 0x00, 0x03,
  0xC0, 0x00, 0xCE, 0x00, 0x07, 0x80, 0x03, 0x9C, 0x00, 0x1B, 0x00, 0x07,
  0x38, 0x00, 0x36, 0x00, 0x0C, 0x70, 0x00, 0x6C, 0x00, 0x38, 0xE0, 0x01,
  0xB8, 0x00, 0x61, 0xC0, 0x03, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0xC0, 0x03,
  0x87, 0x00, 0x19, 0x80, 0x06, 0x0E, 0x00, 0x33, 0x00, 0x1C, 0x1C, 0x00,
  0xE6, 0x00, 0x30, 0x38, 0x01, 0x8C, 0x00, 0xE0, 0x60, 0x07, 0x18, 0x01,
  0xC0, 0xC0, 0x0C, 0x30, 0x03, 0x01, 0x80, 0x18, 0x60, 0x0E, 0x03, 0x00,
  0x70, 0xC0, 0x18, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x0C, 0x01, 0x83, 0x00,
  0xE0, 0x18, 0x06, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x0C, 0x07, 0x00, 0x60,
  0x38, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x60,
  0x70, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x01, 0x83, 0x80, 0x0C,
  0x1C, 0x03, 0x06, 0x00, 0x18, 0x30, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x0C,
  0x38, 0x00, 0x61, 0xC0, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x31, 0xC0, 0x01,
  0x8E, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x03,
  0x9C, 0x00, 0x0C, 0xE0, 0x07, 0x30, 0x00, 0x19, 0x80, 0x0E, 0xE0, 0x00,
  0x37, 0x00, 0x19, 0x80, 0x00, 0x6C, 0x00, 0x33, 0x00, 0x00, 0xD8, 0x00,
  0x6E, 0x00, 0x01, 0xF0, 0x00, 0xD8, 0x00, 0x03, 0xC0, 0x01, 0xB0, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x98,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x18, 0x03,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x3B, 0x80, 0x01, 0x8C, 0x00, 0x1C, 0x60,
  0x00, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x60, 0xC0, 0x07, 0x06, 0x00, 0x30,
  0x30, 0x03, 0x81, 0x80, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0xC0, 0x0C, 0x0E, 0x00, 0x60, 0x60, 0x03, 0x07, 0x00, 0x18, 0x30, 0x00,
  0xC3, 0x80, 0x06, 0x18, 0x00, 0x31, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0xE0,
  0x00, 0x76, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x60, 0x60, 0x70, 0x70, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x38, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C,
  0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0E, 0x0E, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x07, 0x07, 0x03, 0x03, 0x03, 0x03, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x40, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x33, 0x00, 0x00, 0x63, 0x80, 0x00, 0x61, 0x80,
  0x00, 0xC1, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0x80, 0xE0, 0x03, 0x80, 0xE0,
  0x03, 0x00, 0x60, 0x07, 0x00, 0x70, 0x06, 0x00, 0x30, 0x0E, 0x00, 0x38,
  0x0C, 0x00, 0x18, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x0C,
  0x30, 0x00, 0x0E, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xE0, 0xC1, 0xC1, 0x83, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x00,
  0x3F, 0x0C, 0x03, 0xFE, 0x30, 0x1E, 0x0C, 0xC0, 0xE0, 0x13, 0x07, 0x00,
  0x78, 0x18, 0x01, 0xE0, 0xE0, 0x03, 0x83, 0x00, 0x0E, 0x1C, 0x00, 0x38,
  0x60, 0x00, 0xC3, 0x80, 0x03, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x71, 0xC0,
  0x01, 0xC7, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x03,
  0x8E, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xE0, 0x00, 0xC3, 0x00, 0x07, 0x0C,
  0x00, 0x1C, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x83, 0x00, 0x0E, 0x0C, 0x00,
  0x78, 0x30, 0x01, 0xE0, 0xE0, 0x0F, 0x03, 0x80, 0x2C, 0x06, 0x01, 0xB0,
  0x1C, 0x0C, 0xC0, 0x3F, 0xE2, 0x00, 0x7F, 0x18, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE3, 0xF8, 0x01, 0x8F,
  0xF8, 0x03, 0x30, 0x78, 0x06, 0xC0, 0x70, 0x0F, 0x00, 0x60, 0x3C, 0x00,
  0xC0, 0x78, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x70, 0x60, 0x00, 0xC1,
  0xC0, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x18,
  0x00, 0x38, 0x70, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x83, 0x00,
  0x07, 0x06, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x60, 0x70, 0x01,
  0xC0, 0xE0, 0x03, 0x03, 0xC0, 0x0E, 0x06, 0x80, 0x18, 0x0D, 0x80, 0x70,
  0x1B, 0x81, 0xC0, 0x33, 0xFF, 0x00, 0xC3, 0xF8, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x1E, 0x08, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x40,
  0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x7E, 0x18, 0x00, 0xFF, 0x8C,
  0x00, 0xF0, 0x6E, 0x00, 0xE0, 0x1F, 0x00, 0xE0, 0x0F, 0x00, 0x60, 0x07,
  0x80, 0x70, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x18, 0x00,
  0x30, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x07, 0x00,
  0x06, 0x03, 0x80, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0xE0, 0x70, 0x00, 0x60, 0x38, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x0C,
  0x00, 0x1C, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x01, 0x80, 0x07, 0x00,
  0xC0, 0x03, 0x80, 0x60, 0x03, 0xC0, 0x30, 0x01, 0xE0, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0xB0, 0x03, 0x00, 0xD8, 0x01, 0xC0, 0xCC, 0x00, 0x7F, 0xCC,
  0x00, 0x1F, 0xC6, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xE0, 0x1C, 0x1C, 0x0E, 0x03, 0x07, 0x00, 0xC1, 0x80, 0x30, 0xE0, 0x0C,
  0x70, 0x03, 0x18, 0x00, 0xCE, 0x00, 0x73, 0x80, 0x18, 0xC0, 0x0E, 0x70,
  0x07, 0x1C, 0x03, 0x86, 0x01, 0xC1, 0x83, 0xE0, 0xFF, 0xE0, 0x3F, 0xC0,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x20, 0x3E, 0xF8, 0x07, 0xFE,
  0x00, 0x74, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0E, 0x20, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xE1, 0x80, 0x0F, 0xF8, 0xC0, 0x0F, 0x06, 0x60, 0x0E, 0x01, 0x30,
  0x0E, 0x00, 0xF0, 0x06, 0x00, 0x78, 0x07, 0x00, 0x1C, 0x03, 0x00, 0x0E,
  0x03, 0x80, 0x07, 0x01, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01,
  0xC0, 0x60, 0x00, 0xE0, 0x70, 0x00, 0x60, 0x38, 0x00, 0x30, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x07, 0x00, 0x06, 0x03, 0x80,
  0x03, 0x01, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x3C, 0x03,
  0x00, 0x1E, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x1B, 0x00, 0x30, 0x0D, 0x80,
  0x1C, 0x0D, 0xC0, 0x07, 0xFC, 0xC0, 0x01, 0xFC, 0x60, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x04, 0x00, 0xE0, 0x03, 0x00,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x71, 0xFC, 0x01, 0xDF, 0xF8, 0x06, 0xE0, 0xE0, 0x1B,
  0x01, 0xC0, 0x78, 0x07, 0x03, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01,
  0x80, 0xE0, 0x06, 0x03, 0x00, 0x18, 0x1C, 0x00, 0x60, 0x70, 0x03, 0x81,
  0x80, 0x0E, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x00,
  0x1C, 0x0C, 0x00, 0x70, 0x30, 0x01, 0x81, 0xC0, 0x06, 0x07, 0x00, 0x38,
  0x18, 0x00, 0xE0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x0E, 0x00, 0x30, 0x30,
  0x01, 0xC0, 0xC0, 0x07, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x70, 0x01,
  0x81, 0x80, 0x0E, 0x06, 0x00, 0x38, 0x18, 0x00, 0xC0, 0xE0, 0x03, 0x00,
  0x00, 0x30, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x07, 0x01, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0x60, 0x38, 0x03, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x38, 0x00,
  0xC1, 0xC0, 0x07, 0x06, 0x00, 0x1C, 0x30, 0x00, 0x61, 0xC0, 0x01, 0x8E,
  0x00, 0x06, 0x30, 0x00, 0x39, 0xC0, 0x00, 0xEF, 0x80, 0x03, 0x7E, 0x00,
  0x0F, 0x98, 0x00, 0x3C, 0x60, 0x01, 0xE1, 0x80, 0x07, 0x06, 0x00, 0x18,
  0x1C, 0x00, 0x60, 0x70, 0x03, 0x80, 0xC0, 0x0E, 0x03, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0x30, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x01,
  0x80, 0x18, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0xE0, 0x07, 0x00, 0x00,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x00, 0x01, 0x8F, 0xE0, 0x7F, 0x00,
  0x67, 0xFC, 0x7F, 0xE0, 0x1B, 0x03, 0xB8, 0x38, 0x07, 0x80, 0x6C, 0x07,
  0x01, 0xC0, 0x1E, 0x01, 0xC0, 0xF0, 0x07, 0x00, 0x70, 0x38, 0x01, 0xC0,
  0x1C, 0x0E, 0x00, 0x60, 0x07, 0x03, 0x00, 0x18, 0x01, 0xC1, 0xC0, 0x0E,
  0x00, 0x60, 0x70, 0x03, 0x80, 0x18, 0x1C, 0x00, 0xC0, 0x0E, 0x06, 0x00,
  0x30, 0x03, 0x81, 0x80, 0x1C, 0x00, 0xC0, 0xE0, 0x07, 0x00, 0x30, 0x38,
  0x01, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x07, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0xC0, 0x0E, 0x00, 0x60, 0x70, 0x03, 0x80, 0x18, 0x1C, 0x00, 0xC0, 0x06,
  0x06, 0x00, 0x30, 0x03, 0x81, 0x80, 0x0C, 0x00, 0xE0, 0x60, 0x07, 0x00,
  0x30, 0x38, 0x01, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0x03, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0xC0, 0x0E, 0x00, 0x60, 0x70, 0x03, 0x80, 0x18, 0x1C, 0x00,
  0xC0, 0x06, 0x06, 0x00, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x00, 0xE0, 0x60,
  0x07, 0x00, 0x30, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x01, 0x87, 0xF0, 0x06,
  0x7F, 0xE0, 0x1B, 0x83, 0x80, 0x7C, 0x06, 0x01, 0xE0, 0x1C, 0x0F, 0x00,
  0x70, 0x38, 0x01, 0xC0, 0xE0, 0x06, 0x03, 0x80, 0x18, 0x1C, 0x00, 0x60,
  0x70, 0x01, 0x81, 0xC0, 0x0E, 0x06, 0x00, 0x38, 0x18, 0x00, 0xC0, 0xE0,
  0x03, 0x03, 0x80, 0x0C, 0x0C, 0x00, 0x70, 0x30, 0x01, 0x80, 0xC0, 0x06,
  0x07, 0x00, 0x18, 0x1C, 0x00, 0xE0, 0x60, 0x03, 0x81, 0x80, 0x0C, 0x06,
  0x00, 0x30, 0x38, 0x00, 0xC0, 0xC0, 0x07, 0x03, 0x00, 0x1C, 0x0C, 0x00,
  0x60, 0x70, 0x01, 0x81, 0xC0, 0x06, 0x06, 0x00, 0x38, 0x18, 0x00, 0xC0,
  0x60, 0x03, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01,
  0xC1, 0xC0, 0x38, 0x0E, 0x07, 0x00, 0x60, 0xE0, 0x06, 0x0E, 0x00, 0x71,
  0xC0, 0x07, 0x1C, 0x00, 0x71, 0x80, 0x07, 0x38, 0x00, 0x73, 0x00, 0x07,
  0x30, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00,
  0x6E, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0xC0, 0x01, 0xCC, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x38, 0xC0,
  0x03, 0x0C, 0x00, 0x70, 0xE0, 0x06, 0x0E, 0x00, 0xE0, 0x60, 0x1C, 0x07,
  0x03, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0xFE, 0x00, 0x0C, 0x7F, 0xC0, 0x03, 0x30, 0x78, 0x00, 0xD8, 0x0E, 0x00,
  0x3C, 0x01, 0x80, 0x1E, 0x00, 0x70, 0x07, 0x80, 0x1C, 0x01, 0xC0, 0x07,
  0x00, 0x70, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80,
  0x07, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x1C, 0x00, 0x18, 0x07,
  0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x38,
  0x0E, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00,
  0x70, 0x0C, 0x00, 0x18, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x70,
  0x01, 0xC0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x0C, 0x00,
  0xD8, 0x07, 0x00, 0x37, 0x07, 0x80, 0x0C, 0xFF, 0xC0, 0x07, 0x1F, 0xC0,
  0x01, 0xC1, 0x80, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x0C, 0x03, 0xFF, 0x30, 0x1C, 0x0C, 0xC0, 0xE0,
  0x3B, 0x07, 0x00, 0x78, 0x18, 0x01, 0xE0, 0xE0, 0x03, 0x83, 0x00, 0x0E,
  0x1C, 0x00, 0x38, 0x60, 0x00, 0xC3, 0x80, 0x03, 0x0E, 0x00, 0x1C, 0x30,
  0x00, 0x71, 0xC0, 0x01, 0x87, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00,
  0x61, 0x80, 0x03, 0x8E, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xE0, 0x00, 0xC3,
  0x00, 0x07, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x83, 0x00,
  0x0E, 0x0C, 0x00, 0x78, 0x30, 0x01, 0xE0, 0xE0, 0x0F, 0x03, 0x80, 0x2C,
  0x06, 0x01, 0xB0, 0x1C, 0x0D, 0xC0, 0x3F, 0xE6, 0x00, 0xFF, 0x18, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x87, 0xC0, 0x67, 0xF0, 0x1B, 0x80,
  0x06, 0xC0, 0x01, 0xE0, 0x00, 0xD0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x0F, 0xFF, 0x01, 0xC0, 0x60, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x0C, 0x03, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x0F, 0xF8, 0xFF, 0x80, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0x00,
  0x07, 0x00, 0x18, 0x30, 0x01, 0xC1, 0x80, 0x0E, 0x0C, 0x00, 0x60, 0xE0,
  0x03, 0x07, 0x00, 0x18, 0x30, 0x01, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0x60,
  0xE0, 0x03, 0x07, 0x00, 0x38, 0x30, 0x01, 0xC1, 0x80, 0x0C, 0x0C, 0x00,
  0x60, 0xE0, 0x03, 0x06, 0x00, 0x38, 0x30, 0x01, 0xC1, 0x80, 0x0C, 0x1C,
  0x00, 0x60, 0xE0, 0x03, 0x06, 0x00, 0x38, 0x30, 0x01, 0xC1, 0x80, 0x0C,
  0x1C, 0x00, 0x60, 0xE0, 0x07, 0x06, 0x00, 0x38, 0x30, 0x03, 0x81, 0x80,
  0x1C, 0x0C, 0x01, 0xE0, 0x60, 0x0B, 0x03, 0x00, 0xD8, 0x1C, 0x0D, 0x80,
  0xFF, 0xCC, 0x03, 0xFC, 0x60, 0x07, 0x00, 0x00, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xD8, 0x00, 0xEC, 0x00, 0x76, 0x00, 0x33, 0x00, 0x39, 0x80,
  0x18, 0xC0, 0x1C, 0x60, 0x0C, 0x30, 0x0E, 0x18, 0x06, 0x0C, 0x03, 0x06,
  0x03, 0x83, 0x01, 0x81, 0x81, 0xC0, 0xC0, 0xC0, 0x60, 0xE0, 0x30, 0x60,
  0x18, 0x70, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x1C, 0x01, 0x8C, 0x00, 0xCE,
  0x00, 0x66, 0x00, 0x37, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x6C,
  0x00, 0xF0, 0x07, 0x60, 0x07, 0x80, 0x33, 0x00, 0x6C, 0x01, 0x98, 0x03,
  0x60, 0x1C, 0xC0, 0x3B, 0x00, 0xC6, 0x01, 0x98, 0x06, 0x30, 0x0C, 0xC0,
  0x61, 0x80, 0xC6, 0x03, 0x0C, 0x06, 0x30, 0x38, 0x60, 0x71, 0x81, 0x83,
  0x03, 0x0C, 0x0C, 0x18, 0x18, 0x60, 0xC0, 0xC1, 0x83, 0x06, 0x06, 0x0C,
  0x18, 0x70, 0x30, 0xE0, 0xC3, 0x01, 0x86, 0x06, 0x18, 0x0C, 0x30, 0x31,
  0x80, 0x63, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0xE0, 0x19, 0xC0, 0x66, 0x00,
  0xCC, 0x03, 0x30, 0x06, 0x60, 0x1B, 0x00, 0x36, 0x00, 0xD8, 0x01, 0xB0,
  0x06, 0xC0, 0x0F, 0x80, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x07, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x60,
  0x0C, 0x00, 0x60, 0x18, 0x00, 0x60, 0x38, 0x00, 0x70, 0x30, 0x00, 0x70,
  0x70, 0x00, 0x30, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x31, 0xC0, 0x00, 0x31,
  0x80, 0x00, 0x3B, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0xC6, 0x00, 0x01, 0xC6, 0x00, 0x01, 0x86,
  0x00, 0x03, 0x86, 0x00, 0x07, 0x07, 0x00, 0x06, 0x03, 0x00, 0x0E, 0x03,
  0x00, 0x0C, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x38, 0x03, 0x80, 0x30, 0x03,
  0x80, 0x70, 0x01, 0x80, 0xE0, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x0E, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x1C, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x04, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0x00, 0x17, 0xFF, 0x00, 0x78, 0x1F, 0x07,
  0xC0, 0x1F, 0xFA, 0x00, 0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 46, 13, 1, -46 },
  { 76, 14, 17, 17, 6, -46 },
  { 106, 25, 46, 24, 0, -46 },
  { 250, 25, 53, 22, -1, -49 },
  { 416, 29, 47, 34, 3, -46 },
  { 587, 22, 47, 22, -1, -46 },
  { 717, 6, 17, 10, 6, -46 },
  { 730, 17, 56, 16, 2, -46 },
  { 849, 17, 56, 16, -4, -46 },
  { 968, 17, 18, 21, 7, -49 },
  { 1007, 22, 29, 26, 2, -37 },
  { 1087, 9, 14, 11, -3, -6 },
  { 1103, 14, 3, 17, 1, -19 },
  { 1109, 4, 5, 11, 1, -5 },
  { 1112, 27, 46, 19, -3, -46 },
  { 1268, 21, 47, 23, 1, -46 },
  { 1392, 12, 46, 23, 7, -46 },
  { 1461, 25, 46, 23, -2, -46 },
  { 1605, 24, 47, 23, -1, -46 },
  { 1746, 24, 46, 23, -1, -46 },
  { 1884, 25, 47, 23, -2, -46 },
  { 2031, 23, 47, 23, 1, -46 },
  { 2167, 23, 46, 23, 2, -46 },
  { 2300, 24, 47, 23, -1, -46 },
  { 2441, 22, 47, 23, 0, -46 },
  { 2571, 10, 34, 10, 0, -34 },
  { 2614, 13, 42, 11, -3, -34 },
  { 2683, 22, 27, 26, 2, -36 },
  { 2758, 22, 16, 26, 2, -31 },
  { 2802, 22, 27, 26, 2, -36 },
  { 2877, 18, 46, 16, 1, -46 },
  { 2981, 31, 52, 34, 2, -46 },
  { 3183, 22, 46, 22, -4, -46 },
  { 3310, 25, 46, 25, 0, -46 },
  { 3454, 25, 47, 22, 2, -46 },
  { 3601, 26, 46, 27, 0, -46 },
  { 3751, 25, 46, 22, 0, -46 },
  { 3895, 25, 46, 20, 0, -46 },
  { 4039, 29, 47, 29, 2, -46 },
  { 4210, 30, 46, 29, 0, -46 },
  { 4383, 20, 46, 12, -4, -46 },
  { 4498, 21, 57, 11, -9, -46 },
  { 4648, 28, 46, 23, 0, -46 },
  { 4809, 15, 46, 20, 0, -46 },
  { 4896, 39, 46, 38, 0, -46 },
  { 5121, 31, 46, 30, 0, -46 },
  { 5300, 26, 47, 29, 2, -46 },
  { 5453, 24, 46, 23, 0, -46 },
  { 5591, 26, 57, 29, 2, -46 },
  { 5777, 24, 46, 24, 0, -46 },
  { 5915, 26, 47, 22, -2, -46 },
  { 6068, 20, 46, 19, 4, -46 },
  { 6183, 27, 47, 28, 2, -46 },
  { 6342, 23, 46, 23, 5, -46 },
  { 6475, 39, 46, 39, 5, -46 },
  { 6700, 29, 46, 20, -4, -46 },
  { 6867, 21, 46, 19, 4, -46 },
  { 6988, 27, 46, 20, -3, -46 },
  { 7144, 23, 56, 18, -1, -46 },
  { 7305, 8, 46, 21, 7, -46 },
  { 7351, 23, 56, 18, -4, -46 },
  { 7512, 24, 23, 25, 1, -46 },
  { 7581, 17, 2, 17, -5, 6 },
  { 7586, 7, 10, 14, 9, -49 },
  { 7595, 22, 35, 25, 2, -34 },
  { 7692, 23, 50, 24, 0, -49 },
  { 7836, 18, 35, 18, 2, -34 },
  { 7915, 25, 50, 25, 2, -49 },
  { 8072, 18, 35, 22, 2, -34 },
  { 8151, 28, 64, 12, -8, -49 },
  { 8375, 25, 49, 25, -1, -34 },
  { 8529, 22, 49, 24, 0, -49 },
  { 8664, 13, 46, 10, 0, -46 },
  { 8739, 21, 61, 11, -8, -46 },
  { 8900, 22, 49, 20, 0, -49 },
  { 9035, 13, 49, 10, 0, -49 },
  { 9115, 34, 34, 36, 0, -34 },
  { 9260, 22, 34, 24, 0, -34 },
  { 9354, 20, 35, 24, 2, -34 },
  { 9442, 26, 49, 24, -3, -34 },
  { 9602, 22, 49, 25, 2, -34 },
  { 9737, 18, 34, 15, 0, -34 },
  { 9814, 20, 35, 18, -1, -34 },
  { 9902, 13, 43, 12, 1, -42 },
  { 9972, 21, 35, 24, 2, -34 },
  { 10064, 17, 34, 18, 4, -34 },
  { 10137, 29, 34, 31, 4, -34 },
  { 10261, 24, 34, 19, -3, -34 },
  { 10363, 30, 50, 19, -7, -34 },
  { 10551, 19, 34, 15, -2, -34 },
  { 10632, 22, 56, 20, 2, -46 },
  { 10786, 2, 65, 22, 10, -49 },
  { 10803, 22, 56, 20, -4, -46 },
  { 10957, 22, 6, 26, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC64PT7B_H_
