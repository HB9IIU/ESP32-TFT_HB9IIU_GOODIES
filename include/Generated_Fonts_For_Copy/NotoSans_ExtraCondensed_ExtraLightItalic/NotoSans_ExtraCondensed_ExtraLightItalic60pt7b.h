#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC60PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x18, 0x33, 0x83, 0x38, 0x33, 0x07,
  0x30, 0x63, 0x06, 0x70, 0x66, 0x06, 0x60, 0xC6, 0x0C, 0x60, 0xC4, 0x0C,
  0xC0, 0x8C, 0x18, 0xC1, 0x88, 0x18, 0x00, 0x06, 0x07, 0x00, 0x06, 0x06,
  0x00, 0x06, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C,
  0x00, 0x18, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80,
  0x03, 0x01, 0x80, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00,
  0x06, 0x06, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x0C, 0x0C, 0x00,
  0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00,
  0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0x80, 0x3E,
  0xDF, 0x01, 0xC2, 0x0C, 0x0E, 0x08, 0x00, 0x30, 0x60, 0x01, 0xC1, 0x80,
  0x06, 0x06, 0x00, 0x18, 0x10, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06,
  0x0C, 0x00, 0x18, 0x20, 0x00, 0x30, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x98,
  0x00, 0x07, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x09, 0x80, 0x00, 0x67, 0x00, 0x01,
  0x8E, 0x00, 0x06, 0x18, 0x00, 0x10, 0x60, 0x00, 0x41, 0x80, 0x03, 0x07,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0x81, 0x80, 0x02, 0x06, 0x00,
  0x18, 0x30, 0x00, 0x61, 0xC0, 0x81, 0x8E, 0x03, 0xE5, 0xF0, 0x07, 0xFF,
  0x80, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x03, 0xF0, 0x01, 0x80, 0xFE, 0x00,
  0x60, 0x38, 0x60, 0x0C, 0x06, 0x0C, 0x03, 0x01, 0x81, 0x80, 0x60, 0x30,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x18, 0x18,
  0x0C, 0x03, 0x06, 0x01, 0x80, 0x60, 0xC0, 0x30, 0x1C, 0x30, 0x06, 0x03,
  0x06, 0x01, 0xC0, 0x61, 0x80, 0x30, 0x0C, 0x30, 0x06, 0x01, 0x8C, 0x00,
  0xC0, 0x61, 0x80, 0x18, 0x0C, 0x60, 0xF3, 0x01, 0x8C, 0x7F, 0x60, 0x63,
  0x1C, 0x7C, 0x0C, 0x63, 0x07, 0x83, 0x98, 0xC0, 0xF0, 0x63, 0x18, 0x1E,
  0x18, 0xC6, 0x03, 0x7F, 0x18, 0xC0, 0x6F, 0xC6, 0x18, 0x0C, 0x00, 0xC6,
  0x01, 0x80, 0x38, 0xC0, 0x70, 0x06, 0x18, 0x0C, 0x01, 0xC3, 0x01, 0x80,
  0x30, 0xC0, 0x30, 0x0E, 0x18, 0x06, 0x01, 0x83, 0x00, 0xC0, 0x70, 0x60,
  0x30, 0x0C, 0x0C, 0x06, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x1C,
  0x06, 0x06, 0x03, 0x00, 0xC1, 0xC0, 0xE0, 0x18, 0x30, 0x18, 0x03, 0x0C,
  0x07, 0x00, 0x73, 0x80, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0C, 0x38, 0x00, 0xE0, 0xC0, 0x06, 0x06,
  0x00, 0x30, 0x30, 0x03, 0x81, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x06,
  0x07, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0,
  0x03, 0x0C, 0x00, 0x1C, 0xE0, 0x00, 0xE6, 0x00, 0x03, 0x60, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0E, 0xC0, 0x00,
  0xE7, 0x00, 0x06, 0x18, 0x08, 0x60, 0xC1, 0x87, 0x06, 0x0C, 0x30, 0x38,
  0x63, 0x00, 0xC6, 0x18, 0x06, 0x31, 0xC0, 0x31, 0x8C, 0x01, 0xD8, 0x60,
  0x06, 0xC3, 0x00, 0x3C, 0x38, 0x01, 0xE1, 0xC0, 0x06, 0x0E, 0x00, 0x70,
  0x70, 0x03, 0x81, 0x80, 0x3E, 0x0C, 0x03, 0x30, 0x70, 0x39, 0x81, 0xEF,
  0x8C, 0x07, 0xF8, 0x30, 0x04, 0x00, 0x00, 0x19, 0xCE, 0x63, 0x18, 0xCC,
  0x63, 0x18, 0x8C, 0x63, 0x10, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x04, 0x0C, 0x0C,
  0x18, 0x0E, 0x30, 0x07, 0x43, 0x83, 0xFF, 0x03, 0xC0, 0x0F, 0x00, 0x32,
  0x00, 0xC6, 0x03, 0x06, 0x1C, 0x0C, 0x10, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x0C, 0x38, 0x60, 0xC3, 0x86, 0x1C, 0x30, 0x61, 0x83, 0x0C, 0x10,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x5F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x03, 0xFC, 0x00, 0x70, 0xE0, 0x0E, 0x06, 0x01, 0xC0, 0x70, 0x18,
  0x03, 0x03, 0x80, 0x30, 0x30, 0x03, 0x07, 0x00, 0x30, 0x60, 0x03, 0x06,
  0x00, 0x30, 0xE0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x07, 0x1C, 0x00, 0x71,
  0x80, 0x07, 0x18, 0x00, 0x63, 0x80, 0x06, 0x38, 0x00, 0x63, 0x00, 0x06,
  0x30, 0x00, 0xE3, 0x00, 0x0E, 0x70, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00,
  0xC6, 0x00, 0x1C, 0x60, 0x01, 0xC6, 0x00, 0x18, 0xE0, 0x01, 0x8E, 0x00,
  0x38, 0xE0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00, 0x60, 0xC0,
  0x06, 0x0C, 0x00, 0xC0, 0xE0, 0x0C, 0x0E, 0x01, 0x80, 0x60, 0x38, 0x06,
  0x03, 0x00, 0x70, 0x60, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x40, 0x00,
  0x00, 0xE0, 0x3C, 0x0F, 0x03, 0x61, 0xCC, 0x73, 0x9C, 0x67, 0x0C, 0x41,
  0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00,
  0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xC0, 0x70, 0x02, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x1E, 0x03,
  0x80, 0x20, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x80, 0x1C, 0x03, 0xC7, 0xE0, 0x0F,
  0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x60, 0x00, 0x19,
  0x80, 0x00, 0x66, 0x00, 0x03, 0x38, 0x00, 0x1C, 0xC0, 0x00, 0x63, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x61, 0xC0, 0x03, 0x86, 0x00, 0x0C,
  0x18, 0x00, 0x60, 0x60, 0x01, 0x83, 0x80, 0x0C, 0x0C, 0x00, 0x70, 0x30,
  0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x70, 0x1C, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x18, 0x0E, 0x00, 0xE0, 0x30, 0x03,
  0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x80,
  0x3C, 0x01, 0xF7, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x63, 0xF8,
  0x03, 0x9F, 0xF0, 0x0C, 0xC0, 0xE0, 0x36, 0x01, 0x80, 0xF0, 0x07, 0x07,
  0x80, 0x1C, 0x1C, 0x00, 0x30, 0x70, 0x00, 0xC1, 0xC0, 0x03, 0x06, 0x00,
  0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x38, 0x00, 0x60, 0xE0, 0x01, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38,
  0x00, 0xC0, 0x60, 0x07, 0x01, 0x80, 0x18, 0x06, 0x00, 0xE0, 0x1C, 0x07,
  0x00, 0x30, 0x38, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x01,
  0xC0, 0xE0, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0x60,
  0x03, 0x81, 0xC0, 0x03, 0x03, 0x80, 0x06, 0x07, 0x00, 0x1C, 0x0E, 0x00,
  0x30, 0x1C, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x18, 0x00, 0xC0, 0x60, 0x01, 0xC3, 0x80, 0x01, 0xCE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x73, 0x80, 0x01,
  0xC3, 0x80, 0x0E, 0x03, 0x80, 0x38, 0x03, 0x00, 0x60, 0x07, 0x01, 0x80,
  0x06, 0x07, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x30, 0x00,
  0x30, 0xE0, 0x00, 0x61, 0xC0, 0x00, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x06,
  0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x38, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x38, 0x18, 0x03, 0x80, 0xE0, 0x18,
  0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xE0, 0xC0, 0x07, 0x06, 0x00, 0x18,
  0x70, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x86, 0x00,
  0x1C, 0x70, 0x00, 0xE3, 0x80, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x86,
  0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x0F, 0x06, 0x00, 0xF8, 0x38, 0x07,
  0x81, 0xC0, 0xEC, 0x07, 0xFE, 0x60, 0x1F, 0xC7, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x07,
  0x7E, 0x00, 0x3F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x01, 0x81, 0xC0, 0xE0,
  0x70, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x07, 0x07, 0x83, 0x81, 0xC0, 0x00, 0x10, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x01, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x07, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x01, 0xC0, 0x00, 0xC0,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x06, 0x00,
  0xFE, 0x0C, 0x18, 0x07, 0xF0, 0x30, 0xC0, 0x30, 0xC1, 0x83, 0x01, 0x83,
  0x06, 0x1C, 0x0C, 0x0C, 0x18, 0x60, 0x70, 0x60, 0x61, 0x81, 0x81, 0x81,
  0x86, 0x0E, 0x06, 0x06, 0x30, 0x30, 0x18, 0x18, 0xC0, 0xC0, 0xC0, 0x63,
  0x06, 0x03, 0x03, 0x0C, 0x18, 0x0C, 0x0C, 0x60, 0x60, 0x70, 0x31, 0x81,
  0x81, 0x80, 0xC6, 0x0E, 0x06, 0x06, 0x18, 0x30, 0x18, 0x18, 0x60, 0xC0,
  0xE0, 0x61, 0x83, 0x03, 0x03, 0x06, 0x0C, 0x1C, 0x0C, 0x18, 0x30, 0x50,
  0x60, 0x60, 0xC3, 0x41, 0x83, 0x03, 0x8D, 0x8C, 0x0C, 0x07, 0xE7, 0xE0,
  0x30, 0x0F, 0x0F, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x04, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x37, 0x00, 0x03,
  0x38, 0x00, 0x19, 0xC0, 0x01, 0x8E, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00,
  0x06, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0xC1,
  0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x03, 0x00, 0x30, 0x18, 0x03,
  0x80, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x07, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x1C, 0x00, 0xC0, 0xC0,
  0x06, 0x0E, 0x00, 0x30, 0x60, 0x01, 0x87, 0x00, 0x0C, 0x30, 0x00, 0x61,
  0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xCE, 0x00, 0x06, 0x60, 0x00,
  0x33, 0x00, 0x01, 0xB8, 0x00, 0x0C, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0,
  0x01, 0x81, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x18, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0x60, 0x03, 0x01, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x06,
  0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0xE0, 0x70, 0x01, 0x80, 0xC0,
  0x03, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x38, 0x06, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xE0, 0x30, 0x00, 0xC0,
  0xE0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C,
  0x00, 0x38, 0x38, 0x00, 0x70, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80,
  0x07, 0x03, 0x00, 0x0C, 0x0E, 0x00, 0x38, 0x18, 0x00, 0xE0, 0x30, 0x03,
  0x80, 0x60, 0x1E, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3C, 0x02, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x02, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x60, 0xF8, 0x00, 0xE0,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80,
  0x03, 0x01, 0x80, 0x03, 0x03, 0x80, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00,
  0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x07, 0x00, 0x07, 0x06, 0x00,
  0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0E, 0x00,
  0x06, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x1C, 0x00,
  0x1C, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x38, 0x18, 0x00,
  0x30, 0x38, 0x00, 0x70, 0x30, 0x00, 0x60, 0x30, 0x00, 0xE0, 0x30, 0x00,
  0xC0, 0x70, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x60, 0x07, 0x00, 0x60, 0x1E,
  0x00, 0x60, 0x7C, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x04, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x0F, 0xF0, 0x60, 0x01, 0xFE, 0x1C, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x30, 0x70, 0x00, 0x06, 0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x38, 0x30,
  0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x07,
  0x03, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x60, 0x1C, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x00, 0x38, 0x00, 0x60,
  0x03, 0xC0, 0x0C, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x60, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xC0, 0x18, 0x00,
  0x0C, 0x01, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80,
  0x38, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x38, 0x03, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x30, 0x07, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0E, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x60, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x01, 0xC0, 0x18,
  0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x38, 0x00, 0x18, 0x03, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x38, 0x03, 0x00, 0x03, 0x00, 0x70, 0x00, 0x30, 0x07,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x70, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x60, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x01, 0xC0, 0x18, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x01, 0x80,
  0x03, 0x00, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x60, 0x38, 0x00, 0x18, 0x0C,
  0x00, 0x06, 0x07, 0x00, 0x01, 0x83, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x30,
  0x60, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x01, 0xBE, 0x00,
  0x00, 0xF9, 0x80, 0x00, 0x3C, 0x60, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x06,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06,
  0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x38, 0x00, 0x38, 0x06, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0x00, 0x70, 0x00, 0xC0, 0x1C, 0x00, 0x70, 0x03,
  0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x60,
  0x03, 0x80, 0x38, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x70, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x1C,
  0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x0D, 0x80, 0x00, 0x1F,
  0x00, 0x6C, 0x00, 0x00, 0xD8, 0x03, 0x60, 0x00, 0x0F, 0xC0, 0x1B, 0x00,
  0x00, 0x6C, 0x01, 0xD8, 0x00, 0x07, 0x60, 0x0C, 0xC0, 0x00, 0x33, 0x00,
  0x66, 0x00, 0x03, 0xB8, 0x03, 0x30, 0x00, 0x19, 0xC0, 0x19, 0x80, 0x00,
  0xCC, 0x01, 0xCC, 0x00, 0x0C, 0x60, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x63,
  0x00, 0x06, 0x38, 0x03, 0x18, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x03, 0x0C,
  0x01, 0xC6, 0x00, 0x18, 0x60, 0x0C, 0x30, 0x01, 0xC3, 0x00, 0x61, 0x80,
  0x0C, 0x38, 0x03, 0x0C, 0x00, 0xE1, 0x80, 0x38, 0x70, 0x06, 0x0C, 0x01,
  0x83, 0x80, 0x70, 0x60, 0x0C, 0x0C, 0x03, 0x07, 0x00, 0x60, 0x60, 0x38,
  0x38, 0x03, 0x03, 0x01, 0x81, 0x80, 0x38, 0x18, 0x1C, 0x0C, 0x01, 0x80,
  0xC0, 0xC0, 0x60, 0x0C, 0x06, 0x0E, 0x07, 0x00, 0x60, 0x30, 0x60, 0x30,
  0x03, 0x01, 0x83, 0x01, 0x80, 0x38, 0x0C, 0x30, 0x0C, 0x01, 0x80, 0x61,
  0x80, 0x60, 0x0C, 0x03, 0x18, 0x07, 0x00, 0x60, 0x18, 0xC0, 0x30, 0x07,
  0x00, 0xCC, 0x01, 0x80, 0x30, 0x06, 0x60, 0x0C, 0x01, 0x80, 0x37, 0x00,
  0x60, 0x0C, 0x01, 0xB0, 0x07, 0x00, 0x60, 0x0F, 0x80, 0x30, 0x07, 0x00,
  0x78, 0x01, 0x80, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x18,
  0x03, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0x70, 0x0D,
  0x80, 0x03, 0x00, 0x6C, 0x00, 0x18, 0x03, 0x60, 0x00, 0xC0, 0x1B, 0x00,
  0x0E, 0x01, 0xD8, 0x00, 0x60, 0x0C, 0xE0, 0x03, 0x00, 0x63, 0x00, 0x18,
  0x03, 0x18, 0x00, 0xC0, 0x18, 0xC0, 0x0E, 0x01, 0xC6, 0x00, 0x60, 0x0C,
  0x38, 0x03, 0x00, 0x60, 0xC0, 0x18, 0x03, 0x06, 0x00, 0xC0, 0x18, 0x30,
  0x0E, 0x01, 0xC1, 0x80, 0x60, 0x0C, 0x0C, 0x03, 0x00, 0x60, 0x70, 0x18,
  0x03, 0x01, 0x81, 0xC0, 0x38, 0x0C, 0x0C, 0x01, 0x80, 0x60, 0x60, 0x0C,
  0x03, 0x03, 0x00, 0x60, 0x1C, 0x18, 0x03, 0x00, 0x61, 0xC0, 0x38, 0x03,
  0x0C, 0x01, 0x80, 0x18, 0x60, 0x0C, 0x00, 0xC3, 0x00, 0x60, 0x06, 0x18,
  0x03, 0x00, 0x39, 0xC0, 0x38, 0x00, 0xCC, 0x01, 0x80, 0x06, 0x60, 0x0C,
  0x00, 0x33, 0x00, 0x60, 0x01, 0x98, 0x07, 0x00, 0x0D, 0x80, 0x38, 0x00,
  0x7C, 0x01, 0x80, 0x01, 0xE0, 0x0C, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x78,
  0x07, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x06, 0x01,
  0xC0, 0x07, 0x03, 0x80, 0x07, 0x03, 0x00, 0x03, 0x07, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x1C,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x38, 0x00, 0x03, 0x38, 0x00, 0x07, 0x30,
  0x00, 0x07, 0x30, 0x00, 0x07, 0x70, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0xE0,
  0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x70, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0x60,
  0x01, 0x80, 0x70, 0x03, 0x80, 0x70, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xC0, 0x01, 0x87, 0xC0, 0x07, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80,
  0x1C, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x18, 0x00, 0xC0, 0x70, 0x01,
  0x80, 0xC0, 0x03, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x18, 0x06, 0x00, 0x70,
  0x1C, 0x00, 0xC0, 0x30, 0x03, 0x80, 0x60, 0x0E, 0x00, 0xC0, 0x38, 0x03,
  0x83, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x06, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x03, 0x00, 0x03,
  0x07, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x1C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x38, 0x00, 0x03,
  0x38, 0x00, 0x07, 0x30, 0x00, 0x07, 0x30, 0x00, 0x07, 0x70, 0x00, 0x06,
  0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0E,
  0x60, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0xE0,
  0xE0, 0x01, 0xC0, 0x60, 0x01, 0x80, 0x70, 0x03, 0x80, 0x70, 0x07, 0x00,
  0x38, 0x0E, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0x83, 0xC0,
  0x07, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x60, 0x06, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x06, 0x00, 0x38, 0x0C,
  0x00, 0x60, 0x18, 0x00, 0xC0, 0x70, 0x01, 0x80, 0xC0, 0x07, 0x01, 0x80,
  0x0E, 0x03, 0x00, 0x18, 0x06, 0x00, 0x70, 0x1C, 0x00, 0xC0, 0x30, 0x03,
  0x80, 0x60, 0x0E, 0x00, 0xC0, 0x78, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x38, 0x00, 0x30, 0x30, 0x00, 0xE0, 0x60, 0x01,
  0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x38,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03,
  0x01, 0xC0, 0x07, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x20, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0xC0, 0x0F, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xB8, 0x00,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x01, 0x80,
  0xC0, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x30, 0x00, 0x30,
  0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x06, 0x00, 0x06,
  0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xE0, 0x00,
  0xE0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x1C, 0x00,
  0x1C, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x01, 0x81, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30,
  0x00, 0x30, 0x18, 0x00, 0x38, 0x1C, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0x80,
  0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30,
  0x0C, 0x00, 0x18, 0x06, 0x00, 0x18, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0C,
  0x00, 0x70, 0x1C, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0D, 0x80, 0x00,
  0xEC, 0x00, 0x06, 0x60, 0x00, 0x73, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0,
  0x01, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0xE1, 0x80, 0x06, 0x0C, 0x00, 0x30,
  0x60, 0x03, 0x03, 0x00, 0x18, 0x18, 0x01, 0xC0, 0xC0, 0x0C, 0x06, 0x00,
  0xE0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x03,
  0x01, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0xE0, 0x06, 0x06, 0x00, 0x30, 0x30,
  0x01, 0x83, 0x80, 0x0C, 0x18, 0x00, 0x61, 0xC0, 0x03, 0x0C, 0x00, 0x18,
  0xE0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x33, 0x80, 0x01, 0x98, 0x00,
  0x0D, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x3B,
  0x00, 0x03, 0x80, 0x01, 0x98, 0x00, 0x1C, 0x00, 0x0C, 0xC0, 0x00, 0xE0,
  0x00, 0xE6, 0x00, 0x0F, 0x00, 0x06, 0x30, 0x00, 0x78, 0x00, 0x71, 0x80,
  0x03, 0xC0, 0x03, 0x0C, 0x00, 0x36, 0x00, 0x18, 0x60, 0x01, 0xB0, 0x01,
  0xC3, 0x00, 0x19, 0x80, 0x0C, 0x18, 0x00, 0xCC, 0x00, 0xE0, 0xC0, 0x06,
  0x60, 0x06, 0x06, 0x00, 0x63, 0x00, 0x30, 0x30, 0x03, 0x18, 0x03, 0x81,
  0x80, 0x30, 0xC0, 0x18, 0x0C, 0x01, 0x86, 0x01, 0xC0, 0x60, 0x0C, 0x30,
  0x0C, 0x03, 0x00, 0xC1, 0x80, 0x60, 0x18, 0x06, 0x0C, 0x07, 0x00, 0xC0,
  0x70, 0x60, 0x30, 0x06, 0x03, 0x03, 0x03, 0x80, 0x30, 0x18, 0x10, 0x18,
  0x01, 0x81, 0x81, 0x80, 0xC0, 0x0C, 0x0C, 0x0C, 0x0E, 0x00, 0x60, 0xE0,
  0x60, 0x60, 0x03, 0x06, 0x03, 0x07, 0x00, 0x18, 0x30, 0x18, 0x30, 0x00,
  0xC3, 0x00, 0xC1, 0x80, 0x06, 0x18, 0x06, 0x1C, 0x00, 0x31, 0xC0, 0x30,
  0xC0, 0x01, 0x8C, 0x01, 0x8E, 0x00, 0x0C, 0x60, 0x0C, 0x60, 0x00, 0x66,
  0x00, 0x63, 0x00, 0x03, 0x30, 0x03, 0x38, 0x00, 0x19, 0x80, 0x19, 0x80,
  0x01, 0xD8, 0x00, 0xCC, 0x00, 0x0E, 0xC0, 0x06, 0xC0, 0x00, 0x7E, 0x00,
  0x36, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x1B, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x00, 0xE0, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80,
  0xE0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x18, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x06, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x03,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x1C,
  0x03, 0x80, 0x06, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x06, 0x00,
  0x60, 0x01, 0x80, 0x38, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x6C, 0x00, 0x1D, 0x80, 0x03, 0x30, 0x00, 0xE7, 0x00, 0x18, 0xE0, 0x06,
  0x0C, 0x00, 0xC1, 0x80, 0x30, 0x30, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x30,
  0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x60, 0x0C, 0x1C, 0x01, 0x83, 0x00,
  0x18, 0xE0, 0x03, 0x18, 0x00, 0x67, 0x00, 0x0C, 0xC0, 0x01, 0xB8, 0x00,
  0x36, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x00, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60,
  0x60, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x38, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0E, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x66, 0x00, 0x01, 0x9C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x01,
  0x83, 0x80, 0x06, 0x06, 0x00, 0x30, 0x1C, 0x01, 0xC0, 0x30, 0x06, 0x00,
  0xE0, 0x38, 0x01, 0x80, 0xC0, 0x06, 0x07, 0x00, 0x1C, 0x18, 0x00, 0x30,
  0xE0, 0x00, 0xE3, 0x00, 0x01, 0x9C, 0x00, 0x07, 0xE0, 0x00, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x08, 0x10, 0x00,
  0x7E, 0x18, 0x07, 0xF8, 0xC0, 0xF0, 0x6C, 0x06, 0x01, 0x60, 0x70, 0x0F,
  0x07, 0x00, 0x78, 0x30, 0x03, 0x83, 0x80, 0x1C, 0x18, 0x00, 0xE1, 0xC0,
  0x07, 0x0C, 0x00, 0x38, 0x60, 0x01, 0x87, 0x00, 0x0C, 0x30, 0x00, 0x61,
  0x80, 0x03, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0x87, 0x00, 0x0C, 0x30, 0x00,
  0x61, 0x80, 0x07, 0x0C, 0x00, 0x38, 0x60, 0x01, 0x83, 0x00, 0x1C, 0x18,
  0x00, 0xE0, 0xC0, 0x07, 0x06, 0x00, 0x70, 0x30, 0x03, 0x81, 0x80, 0x3C,
  0x0E, 0x03, 0x60, 0x38, 0x33, 0x01, 0xFF, 0x10, 0x07, 0xF1, 0x80, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x3F, 0x00, 0x33, 0xFE, 0x01, 0xB0, 0x70, 0x1B,
  0x01, 0xC0, 0xD0, 0x06, 0x07, 0x80, 0x30, 0x38, 0x01, 0x83, 0x80, 0x0C,
  0x1C, 0x00, 0x60, 0xE0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x80,
  0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x1C, 0x30, 0x00, 0xC3,
  0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x86, 0x00, 0x18, 0x70, 0x00,
  0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x60, 0xE0, 0x03, 0x07, 0x00, 0x38, 0x78,
  0x01, 0x83, 0xC0, 0x18, 0x1A, 0x01, 0xC0, 0xD8, 0x1C, 0x04, 0x7F, 0xC0,
  0x61, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xC0,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7D, 0xE0, 0x1F, 0xE0, 0x02, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x7E, 0x18, 0x00, 0xFF, 0x38,
  0x03, 0xC1, 0xB0, 0x03, 0x00, 0xB0, 0x06, 0x00, 0xF0, 0x0E, 0x00, 0xF0,
  0x0C, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x38, 0x00, 0xE0,
  0x30, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0x60, 0x00, 0xC0,
  0x60, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0xE0, 0x01, 0x80, 0xC0, 0x01, 0x80,
  0xC0, 0x01, 0x80, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x00,
  0xC0, 0x07, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x0E, 0x00,
  0xC0, 0x0E, 0x00, 0xC0, 0x1E, 0x00, 0xE0, 0x36, 0x00, 0x70, 0x66, 0x00,
  0x7F, 0xC4, 0x00, 0x3F, 0x8C, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0xFF, 0x80, 0xE0, 0xE0, 0xE0, 0x30, 0x60, 0x18, 0x60, 0x0C, 0x70, 0x06,
  0x30, 0x03, 0x38, 0x03, 0x98, 0x01, 0x8C, 0x00, 0xCE, 0x00, 0xC6, 0x00,
  0xE3, 0x01, 0xE3, 0x83, 0xC1, 0xFF, 0xC0, 0xFF, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x80, 0xFB, 0xC0, 0x3F, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x71, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x11, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC3, 0x00, 0x1F,
  0xE2, 0x00, 0x78, 0x36, 0x00, 0x60, 0x16, 0x00, 0xC0, 0x1E, 0x01, 0xC0,
  0x1E, 0x01, 0x80, 0x1C, 0x03, 0x80, 0x1C, 0x03, 0x00, 0x1C, 0x07, 0x00,
  0x1C, 0x06, 0x00, 0x1C, 0x06, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x0C, 0x00,
  0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x18, 0x00,
  0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x70, 0x18, 0x00, 0x60, 0x18, 0x00,
  0x60, 0x18, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x18, 0x01,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x1C, 0x06, 0xC0, 0x0E, 0x0D,
  0xC0, 0x0F, 0xF9, 0x80, 0x07, 0xF1, 0x80, 0x01, 0x81, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0xC0, 0x38, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x8F, 0xC0, 0x19, 0xFE, 0x01, 0xB0, 0x70, 0x36, 0x03, 0x03, 0xC0,
  0x30, 0x38, 0x03, 0x03, 0x80, 0x30, 0x30, 0x03, 0x07, 0x00, 0x30, 0x70,
  0x03, 0x06, 0x00, 0x70, 0x60, 0x06, 0x0E, 0x00, 0x60, 0xC0, 0x06, 0x0C,
  0x00, 0x60, 0xC0, 0x0E, 0x0C, 0x00, 0xC1, 0xC0, 0x0C, 0x18, 0x00, 0xC1,
  0x80, 0x1C, 0x18, 0x01, 0x81, 0x80, 0x18, 0x38, 0x01, 0x83, 0x00, 0x18,
  0x30, 0x03, 0x83, 0x00, 0x30, 0x30, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03,
  0x06, 0x00, 0x70, 0x60, 0x06, 0x0E, 0x00, 0x60, 0x00, 0x60, 0x07, 0x00,
  0xF0, 0x0E, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0xE0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x06, 0x00,
  0xC0, 0x70, 0x06, 0x07, 0x00, 0x30, 0x30, 0x03, 0x83, 0x00, 0x18, 0x38,
  0x00, 0xC3, 0x80, 0x06, 0x18, 0x00, 0x31, 0x80, 0x03, 0x9C, 0x00, 0x19,
  0xE0, 0x00, 0xCF, 0x00, 0x06, 0xD8, 0x00, 0x3C, 0xC0, 0x03, 0xC6, 0x00,
  0x1E, 0x30, 0x00, 0xE1, 0xC0, 0x06, 0x06, 0x00, 0x70, 0x30, 0x03, 0x01,
  0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x80, 0x70, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x70, 0x07,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x01, 0x8F,
  0xC1, 0xFC, 0x01, 0xBF, 0xE3, 0xFE, 0x03, 0x70, 0x66, 0x0E, 0x03, 0x40,
  0x7C, 0x07, 0x03, 0xC0, 0x38, 0x07, 0x03, 0x80, 0x38, 0x07, 0x03, 0x80,
  0x30, 0x07, 0x07, 0x00, 0x30, 0x06, 0x07, 0x00, 0x70, 0x06, 0x06, 0x00,
  0x60, 0x06, 0x06, 0x00, 0x60, 0x06, 0x06, 0x00, 0x60, 0x0E, 0x0E, 0x00,
  0xE0, 0x0C, 0x0C, 0x00, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0x0C, 0x0C, 0x00,
  0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0x1C, 0x1C, 0x01, 0xC0, 0x18, 0x18, 0x01,
  0x80, 0x18, 0x18, 0x01, 0x80, 0x18, 0x18, 0x01, 0x80, 0x18, 0x38, 0x01,
  0x80, 0x38, 0x38, 0x03, 0x80, 0x30, 0x30, 0x03, 0x00, 0x30, 0x30, 0x03,
  0x00, 0x30, 0x30, 0x03, 0x00, 0x30, 0x70, 0x07, 0x00, 0x70, 0x60, 0x06,
  0x00, 0x60, 0x60, 0x06, 0x00, 0x60, 0x60, 0x06, 0x00, 0x60, 0x60, 0x06,
  0x00, 0xE0, 0xE0, 0x0E, 0x00, 0xC0, 0x01, 0x8F, 0xC0, 0x19, 0xFE, 0x03,
  0x30, 0x70, 0x36, 0x03, 0x03, 0xC0, 0x30, 0x38, 0x03, 0x03, 0x80, 0x30,
  0x70, 0x03, 0x07, 0x00, 0x30, 0x70, 0x07, 0x06, 0x00, 0x70, 0x60, 0x06,
  0x0E, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x0C, 0x0C, 0x00,
  0xC1, 0xC0, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x1C, 0x18, 0x01, 0x83, 0x80,
  0x18, 0x30, 0x01, 0x83, 0x00, 0x18, 0x30, 0x03, 0x83, 0x00, 0x30, 0x70,
  0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x60, 0x60, 0x06, 0x0E,
  0x00, 0x60, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x38, 0x38, 0x1C, 0x07, 0x06,
  0x00, 0xC3, 0x80, 0x31, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xCE, 0x00,
  0x33, 0x00, 0x0D, 0xC0, 0x03, 0x70, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1B, 0x00, 0x06, 0xC0,
  0x03, 0xB0, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x1C, 0xC0, 0x06, 0x30, 0x01,
  0x8C, 0x00, 0xC3, 0x00, 0x70, 0xE0, 0x38, 0x1C, 0x1C, 0x07, 0xDE, 0x00,
  0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x31, 0xF8, 0x00, 0x33, 0xFC, 0x00,
  0x26, 0x0E, 0x00, 0x6C, 0x07, 0x00, 0x68, 0x03, 0x00, 0x78, 0x03, 0x00,
  0x70, 0x03, 0x00, 0xF0, 0x03, 0x00, 0xE0, 0x03, 0x00, 0xE0, 0x03, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x01,
  0x80, 0x03, 0x01, 0x80, 0x07, 0x01, 0x80, 0x07, 0x03, 0x80, 0x06, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x0C, 0x07,
  0x00, 0x0C, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x38, 0x07,
  0x00, 0x30, 0x0F, 0x00, 0x60, 0x0D, 0x00, 0xE0, 0x0D, 0x81, 0xC0, 0x0C,
  0xEF, 0x80, 0x1C, 0x7F, 0x00, 0x18, 0x10, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x18, 0x0F, 0xF8, 0x80, 0xF0, 0xEC, 0x06, 0x03, 0x60, 0x60, 0x0F,
  0x07, 0x00, 0x78, 0x30, 0x03, 0x83, 0x80, 0x1C, 0x18, 0x00, 0xE1, 0xC0,
  0x07, 0x0C, 0x00, 0x38, 0x60, 0x01, 0x87, 0x00, 0x0C, 0x30, 0x00, 0x61,
  0x80, 0x03, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0x87, 0x00, 0x0C, 0x30, 0x00,
  0x61, 0x80, 0x07, 0x0C, 0x00, 0x38, 0x60, 0x01, 0x83, 0x00, 0x1C, 0x18,
  0x00, 0xE0, 0xC0, 0x07, 0x06, 0x00, 0x70, 0x30, 0x03, 0x81, 0x80, 0x3C,
  0x0E, 0x03, 0x60, 0x38, 0x37, 0x01, 0xFF, 0x30, 0x07, 0xF1, 0x80, 0x04,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x8F, 0x80, 0xCF, 0xC0, 0xCC, 0x00, 0x6C, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x3F,
  0xFC, 0x0E, 0x03, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x81, 0x00, 0x70, 0x3E, 0xFC, 0x03, 0xFE, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30,
  0x03, 0x00, 0xFF, 0x1F, 0xF2, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0x60,
  0x7E, 0x01, 0x80, 0x06, 0x00, 0x70, 0x60, 0x06, 0x0E, 0x00, 0x60, 0xC0,
  0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x0C, 0x0C, 0x00, 0xC1, 0xC0, 0x0C, 0x18,
  0x00, 0xC1, 0x80, 0x1C, 0x18, 0x01, 0x81, 0x80, 0x18, 0x38, 0x01, 0x83,
  0x00, 0x18, 0x30, 0x03, 0x83, 0x00, 0x30, 0x70, 0x03, 0x06, 0x00, 0x30,
  0x60, 0x07, 0x06, 0x00, 0x70, 0x60, 0x06, 0x0E, 0x00, 0x60, 0xC0, 0x0E,
  0x0C, 0x00, 0xE0, 0xC0, 0x0C, 0x0C, 0x01, 0xC0, 0xC0, 0x1C, 0x0C, 0x03,
  0xC0, 0xC0, 0x6C, 0x0E, 0x0E, 0x80, 0xFF, 0xD8, 0x07, 0xF1, 0x80, 0x0C,
  0x00, 0x00, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xDC, 0x00, 0xEE, 0x00,
  0x67, 0x00, 0x73, 0x80, 0x31, 0xC0, 0x18, 0xE0, 0x18, 0x70, 0x0C, 0x18,
  0x0E, 0x0C, 0x06, 0x06, 0x07, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC1, 0x80,
  0x60, 0xC0, 0x30, 0xE0, 0x18, 0x60, 0x0C, 0x70, 0x06, 0x30, 0x03, 0x18,
  0x01, 0x98, 0x00, 0xCC, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x03,
  0x00, 0x36, 0x00, 0x70, 0x03, 0x60, 0x07, 0x00, 0x66, 0x00, 0xF0, 0x06,
  0x60, 0x0F, 0x00, 0x66, 0x00, 0xF0, 0x0C, 0x60, 0x1B, 0x00, 0xC6, 0x01,
  0xB0, 0x1C, 0x60, 0x33, 0x01, 0x86, 0x03, 0x30, 0x18, 0x60, 0x33, 0x03,
  0x06, 0x06, 0x30, 0x30, 0x60, 0x63, 0x07, 0x06, 0x0C, 0x30, 0x60, 0x60,
  0xC3, 0x06, 0x06, 0x0C, 0x30, 0xC0, 0x61, 0x83, 0x0C, 0x06, 0x18, 0x30,
  0xC0, 0x63, 0x03, 0x18, 0x06, 0x30, 0x31, 0x80, 0x67, 0x03, 0x30, 0x06,
  0x60, 0x33, 0x00, 0x66, 0x03, 0x30, 0x06, 0xC0, 0x36, 0x00, 0x6C, 0x03,
  0x60, 0x06, 0xC0, 0x2C, 0x00, 0x58, 0x02, 0xC0, 0x05, 0x80, 0x2C, 0x00,
  0xF0, 0x03, 0x80, 0x0F, 0x00, 0x38, 0x00, 0xF0, 0x03, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x0E, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x07,
  0x01, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x60, 0x00, 0x61, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xCE, 0x00, 0x01, 0x98,
  0x00, 0x03, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xB0, 0x00, 0x06, 0x60, 0x00,
  0x0C, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xE3, 0x80, 0x01, 0x83, 0x00, 0x06,
  0x06, 0x00, 0x1C, 0x0C, 0x00, 0x30, 0x18, 0x00, 0xE0, 0x30, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x70, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x06,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0D,
  0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x1F,
  0x80, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x07, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x0B,
  0xFE, 0x00, 0x78, 0x3C, 0x0F, 0x80, 0x7F, 0xE8, 0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 12, 43, 13, 1, -43 },
  { 66, 12, 16, 16, 6, -43 },
  { 90, 24, 43, 23, 0, -43 },
  { 219, 22, 49, 21, 0, -46 },
  { 354, 27, 44, 32, 3, -43 },
  { 503, 21, 44, 21, -1, -43 },
  { 619, 5, 16, 9, 6, -43 },
  { 629, 17, 52, 15, 1, -43 },
  { 740, 16, 52, 15, -4, -43 },
  { 844, 15, 16, 20, 7, -45 },
  { 874, 21, 28, 24, 2, -35 },
  { 948, 7, 14, 10, -2, -6 },
  { 961, 13, 2, 16, 1, -17 },
  { 965, 3, 5, 10, 1, -5 },
  { 967, 25, 43, 18, -3, -43 },
  { 1102, 20, 44, 21, 1, -43 },
  { 1212, 11, 43, 21, 7, -43 },
  { 1272, 23, 43, 21, -2, -43 },
  { 1396, 22, 44, 21, -1, -43 },
  { 1517, 22, 43, 21, -1, -43 },
  { 1636, 23, 44, 21, -1, -43 },
  { 1763, 22, 44, 21, 1, -43 },
  { 1884, 21, 43, 21, 2, -43 },
  { 1997, 23, 44, 21, -1, -43 },
  { 2124, 21, 44, 21, 0, -43 },
  { 2240, 9, 32, 10, 0, -32 },
  { 2276, 13, 40, 10, -3, -32 },
  { 2341, 21, 25, 24, 2, -34 },
  { 2407, 21, 15, 24, 2, -29 },
  { 2447, 21, 25, 24, 2, -34 },
  { 2513, 17, 43, 15, 1, -43 },
  { 2605, 30, 48, 32, 1, -43 },
  { 2785, 21, 43, 21, -4, -43 },
  { 2898, 23, 43, 23, 0, -43 },
  { 3022, 24, 45, 21, 2, -44 },
  { 3157, 24, 43, 25, 0, -43 },
  { 3286, 23, 43, 21, 0, -43 },
  { 3410, 23, 43, 19, 0, -43 },
  { 3534, 27, 45, 28, 2, -44 },
  { 3686, 28, 43, 27, 0, -43 },
  { 3837, 18, 43, 11, -3, -43 },
  { 3934, 20, 54, 10, -9, -43 },
  { 4069, 26, 43, 21, 0, -43 },
  { 4209, 14, 43, 19, 0, -43 },
  { 4285, 37, 43, 36, 0, -43 },
  { 4484, 29, 43, 28, 0, -43 },
  { 4640, 24, 44, 27, 2, -43 },
  { 4772, 23, 43, 22, 0, -43 },
  { 4896, 24, 53, 27, 2, -43 },
  { 5055, 23, 43, 22, 0, -43 },
  { 5179, 25, 44, 21, -2, -43 },
  { 5317, 19, 43, 18, 4, -43 },
  { 5420, 25, 44, 26, 2, -43 },
  { 5558, 21, 43, 21, 5, -43 },
  { 5671, 37, 43, 37, 4, -43 },
  { 5870, 26, 43, 19, -3, -43 },
  { 6010, 19, 43, 18, 4, -43 },
  { 6113, 25, 43, 19, -3, -43 },
  { 6248, 21, 53, 17, -1, -43 },
  { 6388, 8, 43, 19, 6, -43 },
  { 6431, 22, 53, 17, -4, -43 },
  { 6577, 22, 21, 24, 1, -43 },
  { 6635, 16, 2, 16, -5, 5 },
  { 6639, 6, 10, 13, 9, -46 },
  { 6647, 21, 33, 23, 2, -32 },
  { 6734, 21, 47, 23, 0, -46 },
  { 6858, 16, 33, 17, 2, -32 },
  { 6924, 24, 47, 23, 2, -46 },
  { 7065, 17, 33, 20, 2, -32 },
  { 7136, 27, 60, 12, -8, -46 },
  { 7339, 24, 46, 23, -1, -32 },
  { 7477, 20, 46, 22, 0, -46 },
  { 7592, 12, 43, 10, 0, -43 },
  { 7657, 20, 57, 10, -8, -43 },
  { 7800, 21, 46, 19, 0, -46 },
  { 7921, 12, 46, 9, 0, -46 },
  { 7990, 32, 32, 34, 0, -32 },
  { 8118, 20, 32, 22, 0, -32 },
  { 8198, 18, 33, 22, 2, -32 },
  { 8273, 24, 46, 23, -3, -32 },
  { 8411, 21, 46, 23, 2, -32 },
  { 8532, 17, 32, 15, 0, -32 },
  { 8600, 19, 33, 17, -1, -32 },
  { 8679, 12, 40, 12, 1, -39 },
  { 8739, 20, 33, 22, 2, -32 },
  { 8822, 17, 32, 17, 3, -32 },
  { 8890, 28, 32, 29, 3, -32 },
  { 9002, 23, 32, 18, -3, -32 },
  { 9094, 28, 47, 18, -7, -32 },
  { 9259, 18, 32, 14, -2, -32 },
  { 9331, 21, 52, 19, 2, -43 },
  { 9468, 2, 61, 21, 9, -46 },
  { 9484, 21, 52, 19, -4, -43 },
  { 9621, 21, 5, 24, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC60PT7B_H_
