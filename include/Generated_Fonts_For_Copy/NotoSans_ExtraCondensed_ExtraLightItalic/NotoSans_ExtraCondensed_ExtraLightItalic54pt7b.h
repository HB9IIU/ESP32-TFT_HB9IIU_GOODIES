#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC54PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x00, 0x18, 0x71, 0x86, 0x30, 0x63,
  0x06, 0x30, 0x63, 0x0C, 0x30, 0xC6, 0x0C, 0x60, 0xC6, 0x08, 0x61, 0x84,
  0x18, 0x41, 0x8C, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x06, 0x06,
  0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x18, 0x18, 0x00, 0xC1, 0x80, 0x06,
  0x0C, 0x00, 0x20, 0x60, 0x03, 0x02, 0x00, 0x18, 0x30, 0x00, 0x81, 0x80,
  0xFF, 0xFF, 0x80, 0x60, 0xC0, 0x02, 0x06, 0x00, 0x30, 0x30, 0x01, 0x83,
  0x00, 0x0C, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01,
  0x03, 0x00, 0x18, 0x10, 0x00, 0xC1, 0x80, 0x04, 0x0C, 0x07, 0xFF, 0xFE,
  0x03, 0x06, 0x00, 0x10, 0x30, 0x01, 0x81, 0x00, 0x0C, 0x18, 0x00, 0x60,
  0xC0, 0x06, 0x06, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x18, 0x18, 0x00,
  0xC0, 0x80, 0x06, 0x0C, 0x00, 0x20, 0x60, 0x03, 0x06, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x07, 0xFE, 0x01, 0xEC, 0xF0, 0x38, 0xC2, 0x03, 0x0C, 0x00, 0x60, 0x80,
  0x06, 0x08, 0x00, 0x41, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x04, 0x10,
  0x00, 0x61, 0x00, 0x06, 0x30, 0x00, 0x33, 0x00, 0x03, 0x20, 0x00, 0x1A,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x05, 0x80, 0x00,
  0x4C, 0x00, 0x0C, 0xE0, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0x83, 0x00,
  0x08, 0x30, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x06, 0x00, 0x10, 0x60,
  0x01, 0x06, 0x08, 0x30, 0xC0, 0xC3, 0x38, 0x0F, 0xFF, 0x00, 0x1F, 0x80,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x03, 0xC0, 0x0C, 0x07, 0xE0, 0x0C, 0x0C, 0x60, 0x18, 0x18, 0x20,
  0x18, 0x10, 0x20, 0x30, 0x30, 0x20, 0x30, 0x30, 0x20, 0x60, 0x60, 0x20,
  0x60, 0x60, 0x60, 0xC0, 0x60, 0x60, 0xC0, 0xC0, 0x61, 0x80, 0xC0, 0x61,
  0x80, 0xC0, 0x63, 0x00, 0xC0, 0x43, 0x00, 0xC0, 0xC6, 0x00, 0x80, 0xC6,
  0x08, 0x80, 0xCC, 0x3E, 0x81, 0x8C, 0x66, 0x81, 0x98, 0xC3, 0x83, 0x19,
  0x83, 0x83, 0x31, 0x83, 0xC6, 0x33, 0x03, 0xFC, 0x63, 0x03, 0x78, 0x63,
  0x03, 0x00, 0xC6, 0x03, 0x00, 0xC6, 0x03, 0x01, 0x86, 0x02, 0x01, 0x86,
  0x06, 0x03, 0x0C, 0x06, 0x03, 0x0C, 0x06, 0x06, 0x0C, 0x06, 0x06, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x0C, 0x18, 0x18, 0x0C,
  0x18, 0x30, 0x0C, 0x30, 0x30, 0x06, 0x60, 0x60, 0x07, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x0C,
  0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30,
  0x30, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x33,
  0x00, 0x06, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x36, 0x00, 0x0C, 0xC0, 0x03, 0x0C, 0x18, 0xE1, 0x86, 0x18, 0x30,
  0xC6, 0x06, 0x18, 0xC0, 0x66, 0x30, 0x0C, 0xC6, 0x01, 0x98, 0xC0, 0x1E,
  0x18, 0x03, 0xC6, 0x00, 0x70, 0xC0, 0x0E, 0x18, 0x01, 0xC3, 0x80, 0x78,
  0x30, 0x1B, 0x07, 0x07, 0x20, 0x71, 0xC6, 0x07, 0xF0, 0xC0, 0x20, 0x00,
  0x18, 0xCE, 0x63, 0x18, 0xCC, 0x63, 0x18, 0x84, 0x60, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0xC1, 0x01, 0xC4, 0x01, 0xD3, 0xC1, 0xFE, 0x03, 0x00, 0x36,
  0x01, 0x88, 0x0C, 0x30, 0x60, 0x41, 0x01, 0x80, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x18, 0x30, 0x61, 0x83,
  0x0C, 0x18, 0x20, 0xC1, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x1F, 0xC0, 0x0E, 0x18, 0x07, 0x06, 0x01, 0x80, 0xC0, 0xC0,
  0x30, 0x70, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C,
  0x70, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x80, 0x18, 0xC0, 0x06, 0x30,
  0x01, 0x8C, 0x00, 0x63, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x98, 0x00,
  0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x07, 0x30, 0x01, 0x8C, 0x00, 0x63,
  0x00, 0x18, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x60, 0xC0,
  0x18, 0x30, 0x0C, 0x0C, 0x03, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x0E, 0xF0,
  0x03, 0xF0, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x70, 0x7C, 0x3E, 0x1D, 0x8E,
  0x66, 0x1B, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x0C, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00,
  0x38, 0x1C, 0x00, 0x80, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xC0, 0xE0, 0x10, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x80, 0x38, 0x0F, 0x0F, 0x00,
  0xFF, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x1B, 0x00, 0x01, 0xE0, 0x00, 0x36, 0x00, 0x02, 0x60, 0x00,
  0x66, 0x00, 0x0C, 0x60, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x01, 0x0C, 0x00,
  0x30, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x0C, 0x18, 0x00, 0x81, 0x80,
  0x18, 0x18, 0x03, 0x03, 0x00, 0x30, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0x60, 0x60, 0x06,
  0x06, 0x00, 0xE0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xC0, 0x04, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x80, 0x38, 0x0E, 0x1F, 0x00, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x00,
  0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x83,
  0x80, 0x33, 0xFC, 0x06, 0xE3, 0xC0, 0xF0, 0x18, 0x34, 0x03, 0x87, 0x00,
  0x30, 0xE0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x1C, 0x00,
  0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x71, 0x80, 0x0C, 0x30, 0x01,
  0x86, 0x00, 0x30, 0xC0, 0x0C, 0x18, 0x01, 0x81, 0x80, 0x60, 0x30, 0x1C,
  0x07, 0x03, 0x00, 0x73, 0xC0, 0x07, 0xF0, 0x00, 0x10, 0x00, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFE,
  0x00, 0x38, 0x18, 0x03, 0x80, 0x60, 0x18, 0x03, 0x01, 0x80, 0x18, 0x0C,
  0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18, 0x01, 0x80, 0xC0, 0x0C,
  0x06, 0x00, 0x60, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x03, 0x00, 0x38,
  0x30, 0x00, 0xC7, 0x00, 0x03, 0x70, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x39, 0xC0, 0x03, 0x86, 0x00, 0x38, 0x18, 0x03, 0x00, 0xE0, 0x38, 0x03,
  0x01, 0x80, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x70,
  0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x83, 0x00, 0x18,
  0x18, 0x00, 0xC0, 0xE0, 0x0C, 0x03, 0x80, 0xE0, 0x0F, 0x1E, 0x00, 0x3F,
  0xC0, 0x00, 0x20, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x07, 0x06, 0x01,
  0xC0, 0x60, 0x30, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x18, 0x70, 0x03, 0x0C,
  0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30,
  0x01, 0xC6, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x38, 0x60,
  0x07, 0x0C, 0x01, 0xE0, 0xC0, 0x78, 0x1C, 0x1B, 0x01, 0xFE, 0x60, 0x1F,
  0x8C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x01, 0x0F, 0x00, 0x3F, 0xC0,
  0x00, 0x80, 0x00, 0x01, 0x03, 0x07, 0x07, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0, 0xE0, 0x00, 0x40, 0x1C, 0x03,
  0x80, 0x60, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF0,
  0x1F, 0xF0, 0x30, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xE0, 0x70, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06,
  0x00, 0x03, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x10, 0x60, 0x00, 0x04,
  0x30, 0x07, 0x81, 0x0C, 0x07, 0xF0, 0x43, 0x03, 0x0C, 0x11, 0x81, 0x83,
  0x04, 0x60, 0x41, 0x83, 0x10, 0x30, 0x60, 0xCC, 0x18, 0x18, 0x33, 0x06,
  0x06, 0x0C, 0xC1, 0x83, 0x03, 0x20, 0xC0, 0xC0, 0x98, 0x30, 0x30, 0x66,
  0x0C, 0x0C, 0x19, 0x82, 0x06, 0x06, 0x61, 0x81, 0x81, 0x18, 0x60, 0x60,
  0xC4, 0x18, 0x38, 0x33, 0x06, 0x0C, 0x18, 0xC1, 0x87, 0x06, 0x30, 0x61,
  0x43, 0x0C, 0x0C, 0xD9, 0xC3, 0x03, 0xE7, 0xE0, 0xC0, 0x70, 0xE0, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x01, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x16, 0x00,
  0x06, 0xC0, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x06, 0x60, 0x01, 0x8C, 0x00,
  0x31, 0x80, 0x06, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x0C, 0x18, 0x01,
  0x83, 0x00, 0x30, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x30, 0x0C,
  0x06, 0x01, 0x80, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0x80, 0x60, 0x60,
  0x0C, 0x0C, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x18, 0x00, 0xC3, 0x00,
  0x18, 0xE0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00,
  0x37, 0x00, 0x06, 0xC0, 0x00, 0xF8, 0x00, 0x18, 0x00, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x30, 0x78, 0x01, 0x80, 0xE0, 0x18, 0x03, 0x80, 0xC0, 0x0C,
  0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x18, 0x00, 0xC0, 0xC0,
  0x06, 0x06, 0x00, 0x70, 0x30, 0x03, 0x01, 0x80, 0x18, 0x18, 0x01, 0x80,
  0xC0, 0x1C, 0x06, 0x01, 0xC0, 0x30, 0x38, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xC0, 0x70, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x18, 0x18,
  0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x83, 0x00, 0x0C,
  0x18, 0x00, 0x60, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x03, 0x83, 0x00,
  0x18, 0x18, 0x01, 0xC0, 0xC0, 0x1C, 0x06, 0x03, 0xC0, 0x7F, 0xFC, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x1E, 0x04, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x18, 0x00, 0x3F, 0xC0, 0x00, 0x10, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x0C, 0x3E, 0x00, 0x30, 0x1C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80,
  0x1C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C,
  0x1C, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x07, 0x06, 0x00, 0x1C, 0x18,
  0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00,
  0x60, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x01, 0xC1,
  0x80, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00,
  0x1C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x01, 0x80, 0x1C, 0x06, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0x60, 0x78, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0xF0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x78, 0x07, 0x00,
  0xE0, 0x02, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x08, 0xE0, 0x07, 0xF0, 0xC0, 0x07, 0xF0, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0xC0, 0xE0, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x70, 0x01, 0x80, 0x30,
  0x01, 0x80, 0x38, 0x01, 0x80, 0x1F, 0x8F, 0x80, 0x07, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C,
  0x03, 0x00, 0x06, 0x01, 0x80, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0xE0, 0x38, 0x00, 0x60, 0x18, 0x00,
  0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06,
  0x00, 0x1C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00,
  0xC0, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x0C,
  0x03, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x01, 0xF0,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x04, 0xF0,
  0x03, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x1C,
  0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x0E, 0x00,
  0x60, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x81, 0x80, 0x06, 0x07, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x30, 0xE0, 0x00, 0xE3, 0x80, 0x01, 0x86,
  0x00, 0x03, 0x18, 0x00, 0x06, 0x70, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x80,
  0x00, 0x6F, 0x00, 0x00, 0xF7, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x0C, 0x00,
  0x0E, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00,
  0xC0, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x80, 0x0C, 0x03, 0x00, 0x18,
  0x06, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x0D, 0x00, 0x00, 0x78, 0x06,
  0x80, 0x00, 0x6C, 0x03, 0x40, 0x00, 0x36, 0x01, 0xB0, 0x00, 0x37, 0x01,
  0x98, 0x00, 0x1B, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x66, 0x00, 0x0C, 0xC0,
  0x33, 0x00, 0x0C, 0x60, 0x31, 0x80, 0x06, 0x60, 0x18, 0xC0, 0x06, 0x30,
  0x0C, 0x60, 0x03, 0x18, 0x06, 0x30, 0x03, 0x8C, 0x03, 0x18, 0x01, 0x86,
  0x03, 0x0C, 0x01, 0xC6, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xC3, 0x00, 0x61,
  0x80, 0x61, 0x80, 0x60, 0xC0, 0x30, 0xC0, 0x30, 0xE0, 0x30, 0x60, 0x30,
  0x60, 0x18, 0x30, 0x18, 0x30, 0x0C, 0x08, 0x18, 0x18, 0x06, 0x04, 0x0C,
  0x0C, 0x03, 0x03, 0x0C, 0x0C, 0x03, 0x01, 0x86, 0x06, 0x01, 0x80, 0xC6,
  0x03, 0x00, 0xC0, 0x63, 0x01, 0x80, 0x60, 0x33, 0x00, 0xC0, 0x60, 0x19,
  0x80, 0xC0, 0x30, 0x0D, 0x80, 0x60, 0x18, 0x06, 0xC0, 0x30, 0x0C, 0x03,
  0xC0, 0x18, 0x06, 0x01, 0xE0, 0x0C, 0x06, 0x00, 0xF0, 0x0C, 0x03, 0x00,
  0x70, 0x06, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x38, 0x00, 0x30, 0x0E, 0x00,
  0x0C, 0x03, 0x80, 0x03, 0x01, 0xA0, 0x01, 0x80, 0x6C, 0x00, 0x60, 0x1B,
  0x00, 0x18, 0x06, 0xC0, 0x06, 0x01, 0xB0, 0x01, 0x80, 0xCC, 0x00, 0xC0,
  0x31, 0x80, 0x30, 0x0C, 0x60, 0x0C, 0x03, 0x18, 0x03, 0x01, 0xC6, 0x00,
  0xC0, 0x61, 0x80, 0x60, 0x18, 0x20, 0x18, 0x06, 0x0C, 0x06, 0x01, 0x83,
  0x01, 0x80, 0xC0, 0xC0, 0xC0, 0x30, 0x30, 0x30, 0x0C, 0x0C, 0x0C, 0x03,
  0x01, 0x83, 0x00, 0xC0, 0x60, 0xC0, 0x60, 0x18, 0x60, 0x18, 0x06, 0x18,
  0x06, 0x01, 0x86, 0x01, 0x80, 0x61, 0x80, 0x60, 0x0C, 0x60, 0x30, 0x03,
  0x30, 0x0C, 0x00, 0xCC, 0x03, 0x00, 0x33, 0x00, 0xC0, 0x0C, 0xC0, 0x60,
  0x01, 0xA0, 0x18, 0x00, 0x78, 0x06, 0x00, 0x1E, 0x01, 0x80, 0x07, 0x80,
  0x60, 0x01, 0xE0, 0x30, 0x00, 0x70, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x80, 0x0E, 0x07, 0x00, 0x70, 0x0C, 0x01, 0x80, 0x18,
  0x0C, 0x00, 0x60, 0x70, 0x01, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x1C, 0x30,
  0x00, 0x71, 0xC0, 0x01, 0xC6, 0x00, 0x07, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x70, 0x00, 0x19, 0x80, 0x00, 0x66,
  0x00, 0x01, 0x98, 0x00, 0x0E, 0x60, 0x00, 0x33, 0x80, 0x00, 0xCC, 0x00,
  0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06,
  0x30, 0x00, 0x38, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0x60, 0xC0, 0x03, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x60, 0x18, 0x03,
  0x00, 0x70, 0x1C, 0x00, 0xF3, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xC7, 0xC0, 0x0C, 0x0E, 0x01, 0x80,
  0x70, 0x18, 0x03, 0x01, 0x80, 0x30, 0x18, 0x03, 0x01, 0x80, 0x30, 0x30,
  0x03, 0x03, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x70, 0x03, 0x06,
  0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0xE0, 0x60, 0x0C, 0x0C, 0x01, 0x80,
  0xC0, 0x30, 0x0C, 0x1E, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x0E, 0x07, 0x00, 0x70,
  0x0C, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x60, 0x70, 0x01, 0x81, 0x80, 0x06,
  0x0C, 0x00, 0x1C, 0x30, 0x00, 0x71, 0xC0, 0x01, 0xC6, 0x00, 0x07, 0x18,
  0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x70, 0x00,
  0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x0E, 0x60, 0x00, 0x33,
  0x80, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00,
  0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x38, 0xC0, 0x00, 0xC3, 0x00, 0x03,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x03, 0x00, 0x1C, 0x06,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x70, 0x1C, 0x00, 0xF3, 0xC0, 0x01, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xC3, 0xC0, 0x0C, 0x0E,
  0x01, 0x80, 0x70, 0x18, 0x03, 0x01, 0x80, 0x30, 0x18, 0x03, 0x01, 0x80,
  0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x70,
  0x07, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0xC0, 0x60, 0x1C, 0x0E,
  0x03, 0x80, 0xC0, 0x70, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x0C, 0x30, 0x01,
  0x83, 0x00, 0x18, 0x38, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80,
  0x30, 0x18, 0x03, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x0C,
  0x06, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x06, 0x0C, 0x00,
  0x60, 0xC0, 0x06, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0x01,
  0xC0, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x40, 0x0E, 0x03, 0xE1, 0xF0,
  0x07, 0xFF, 0x00, 0x01, 0x60, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0x80, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x18, 0x0C,
  0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x01, 0x80,
  0x06, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00,
  0xC0, 0x60, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81,
  0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x80, 0x06, 0x06, 0x00,
  0x0C, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x03,
  0x80, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x00, 0xE0,
  0x06, 0x03, 0x80, 0x0F, 0x9E, 0x00, 0x07, 0xF8, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0xCC, 0x00, 0x19,
  0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x38, 0xC0, 0x06, 0x18, 0x00, 0xC3,
  0x00, 0x30, 0x60, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x0E, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x60, 0x08,
  0x0C, 0x01, 0x03, 0x80, 0x20, 0x60, 0x04, 0x0C, 0x00, 0x83, 0x00, 0x10,
  0x60, 0x02, 0x18, 0x00, 0x43, 0x00, 0x08, 0x60, 0x01, 0x18, 0x00, 0x23,
  0x00, 0x04, 0xC0, 0x00, 0x98, 0x00, 0x16, 0x00, 0x02, 0xC0, 0x00, 0x58,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0xB0, 0x00, 0xE0, 0x01, 0x98, 0x00, 0x70, 0x00, 0xC8, 0x00, 0x38,
  0x00, 0xE4, 0x00, 0x3C, 0x00, 0x66, 0x00, 0x1E, 0x00, 0x33, 0x00, 0x1B,
  0x00, 0x31, 0x80, 0x0D, 0x80, 0x18, 0xC0, 0x06, 0xC0, 0x1C, 0x60, 0x06,
  0x40, 0x0C, 0x30, 0x03, 0x20, 0x06, 0x18, 0x03, 0x10, 0x06, 0x0C, 0x01,
  0x88, 0x03, 0x06, 0x00, 0xC4, 0x01, 0x83, 0x00, 0xC2, 0x01, 0x81, 0x80,
  0x63, 0x00, 0xC0, 0xC0, 0x61, 0x80, 0xC0, 0x60, 0x30, 0xC0, 0x60, 0x30,
  0x18, 0x60, 0x30, 0x18, 0x18, 0x30, 0x30, 0x0C, 0x0C, 0x18, 0x18, 0x06,
  0x04, 0x0C, 0x18, 0x03, 0x06, 0x06, 0x0C, 0x01, 0x83, 0x03, 0x06, 0x00,
  0xC3, 0x01, 0x86, 0x00, 0x61, 0x80, 0xC3, 0x00, 0x30, 0xC0, 0x63, 0x00,
  0x18, 0xC0, 0x31, 0x80, 0x0C, 0x60, 0x18, 0xC0, 0x06, 0x60, 0x0C, 0xC0,
  0x03, 0x30, 0x06, 0x60, 0x01, 0x98, 0x03, 0x60, 0x00, 0xD8, 0x01, 0xB0,
  0x00, 0x6C, 0x00, 0xD8, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x03, 0x00, 0x60, 0x06, 0x00, 0x20, 0x06, 0x00,
  0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00,
  0x30, 0x30, 0x00, 0x30, 0x70, 0x00, 0x30, 0x60, 0x00, 0x30, 0xC0, 0x00,
  0x10, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x19, 0x80, 0x00, 0x1B, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xC4, 0x00, 0x01, 0x86, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x0C,
  0x06, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x06, 0x00, 0x38, 0x06, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x01, 0xB0, 0x01, 0x98, 0x00, 0xCC, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x61,
  0x80, 0x30, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x18, 0x18, 0x0C, 0x04, 0x0C,
  0x02, 0x06, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x31, 0x80, 0x19,
  0x80, 0x0C, 0xC0, 0x06, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x80, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0x81, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x02, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC0, 0x81, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x20,
  0x60, 0xC1, 0x80, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xDC, 0x00, 0x0C, 0xC0,
  0x01, 0x8C, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0x70, 0x30, 0x06, 0x03,
  0x00, 0xC0, 0x38, 0x0C, 0x01, 0x81, 0x80, 0x18, 0x18, 0x00, 0xC3, 0x00,
  0x0C, 0x30, 0x00, 0x66, 0x00, 0x06, 0xE0, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC7, 0x18, 0xC3, 0x08, 0x61, 0x00, 0xF8, 0x60, 0x3F, 0x88, 0x0C,
  0x1B, 0x03, 0x01, 0x60, 0xC0, 0x3C, 0x38, 0x03, 0x06, 0x00, 0x61, 0xC0,
  0x0C, 0x30, 0x01, 0x86, 0x00, 0x71, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00,
  0x31, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00,
  0xC3, 0x00, 0x18, 0x60, 0x07, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x07,
  0x06, 0x00, 0xE0, 0xC0, 0x28, 0x18, 0x0F, 0x03, 0x83, 0x60, 0x39, 0xCC,
  0x03, 0xF1, 0x80, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x31,
  0xF0, 0x06, 0x7F, 0x80, 0xD8, 0x30, 0x1E, 0x07, 0x06, 0x80, 0x60, 0xE0,
  0x0C, 0x1C, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x1C, 0x00, 0xC3, 0x00,
  0x18, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x00, 0x0C, 0x60, 0x03, 0x8C, 0x00,
  0x61, 0x80, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x71, 0x80, 0x0C, 0x30, 0x01,
  0x86, 0x00, 0x70, 0xC0, 0x0C, 0x38, 0x03, 0x87, 0x00, 0x60, 0xF0, 0x18,
  0x12, 0x07, 0x02, 0x73, 0xC0, 0xC7, 0xE0, 0x00, 0x20, 0x00, 0x00, 0xFE,
  0x03, 0xF8, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0xC6, 0x03, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x0F, 0x8C, 0x00, 0xFE, 0x60, 0x0C, 0x1B, 0x00, 0xC0,
  0x58, 0x0C, 0x03, 0xC0, 0xE0, 0x1C, 0x06, 0x00, 0x60, 0x70, 0x03, 0x03,
  0x00, 0x38, 0x18, 0x01, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03,
  0x07, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60,
  0x03, 0x03, 0x00, 0x18, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0xE0,
  0x30, 0x07, 0x01, 0x80, 0x38, 0x0C, 0x02, 0x80, 0x60, 0x3C, 0x03, 0x83,
  0x60, 0x0E, 0x73, 0x00, 0x3F, 0x18, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0xFE, 0x03, 0x83, 0x03, 0x03, 0x06, 0x03, 0x0C, 0x03, 0x0C, 0x03,
  0x18, 0x03, 0x18, 0x03, 0x30, 0x06, 0x30, 0x0E, 0x30, 0x1C, 0x70, 0x38,
  0x61, 0xF0, 0x7F, 0xC0, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x70, 0x10, 0x3C, 0x70, 0x1F, 0xF0, 0x02, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x08, 0x01, 0xFC, 0x40, 0x18, 0x36,
  0x01, 0x80, 0xB0, 0x18, 0x07, 0x81, 0xC0, 0x38, 0x0C, 0x00, 0xC0, 0xE0,
  0x06, 0x06, 0x00, 0x70, 0x30, 0x03, 0x83, 0x00, 0x18, 0x18, 0x00, 0xC0,
  0xC0, 0x06, 0x0E, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x18, 0x18, 0x00,
  0xC0, 0xC0, 0x06, 0x06, 0x00, 0x70, 0x30, 0x03, 0x01, 0x80, 0x18, 0x0C,
  0x01, 0xC0, 0x60, 0x0E, 0x03, 0x00, 0xF0, 0x18, 0x05, 0x00, 0xC0, 0x78,
  0x07, 0x06, 0xC0, 0x1C, 0xE6, 0x00, 0x7E, 0x30, 0x00, 0x83, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x02, 0x00, 0xC0, 0x18, 0x1C,
  0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x1F,
  0x00, 0xCF, 0xE0, 0x36, 0x1C, 0x0F, 0x03, 0x03, 0x80, 0xC1, 0xC0, 0x30,
  0x70, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC3, 0x80, 0x30, 0xC0, 0x18, 0x30,
  0x06, 0x0C, 0x01, 0x83, 0x00, 0x61, 0x80, 0x18, 0x60, 0x0C, 0x18, 0x03,
  0x06, 0x00, 0xC1, 0x80, 0x30, 0xC0, 0x0C, 0x30, 0x06, 0x0C, 0x01, 0x83,
  0x00, 0x61, 0x80, 0x18, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80,
  0x30, 0xC0, 0x1C, 0x00, 0x00, 0x40, 0x1C, 0x07, 0x80, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0xC0, 0x18, 0x30, 0x03, 0x0C, 0x00, 0x63, 0x80, 0x18, 0x60, 0x03,
  0x18, 0x00, 0x66, 0x00, 0x0D, 0xE0, 0x01, 0x3C, 0x00, 0x6D, 0x80, 0x0F,
  0x30, 0x01, 0xC6, 0x00, 0x30, 0xC0, 0x0E, 0x0C, 0x01, 0x81, 0x80, 0x30,
  0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x00, 0xC0,
  0x30, 0x18, 0x06, 0x02, 0x00, 0xC0, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0xC0, 0x00, 0x03, 0x1F, 0x07, 0xC0, 0x1B, 0xFC,
  0x7F, 0x80, 0xF0, 0x76, 0x0C, 0x05, 0x01, 0xE0, 0x60, 0x78, 0x0E, 0x01,
  0x83, 0x80, 0x60, 0x0C, 0x18, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x06, 0x06,
  0x01, 0x80, 0x30, 0x70, 0x0C, 0x01, 0x83, 0x00, 0x60, 0x0C, 0x18, 0x03,
  0x00, 0xC0, 0xC0, 0x18, 0x06, 0x06, 0x01, 0x80, 0x30, 0x60, 0x0C, 0x01,
  0x83, 0x00, 0x60, 0x0C, 0x18, 0x03, 0x00, 0xC0, 0xC0, 0x38, 0x06, 0x0C,
  0x01, 0x80, 0x30, 0x60, 0x0C, 0x01, 0x83, 0x00, 0x60, 0x0C, 0x18, 0x03,
  0x00, 0xC0, 0xC0, 0x30, 0x06, 0x0C, 0x01, 0x80, 0x30, 0x60, 0x0C, 0x01,
  0x83, 0x00, 0x60, 0x18, 0x18, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x06, 0x0C,
  0x01, 0x80, 0x30, 0x00, 0x03, 0x1F, 0x00, 0xCF, 0xE0, 0x36, 0x1C, 0x0B,
  0x03, 0x07, 0x80, 0xC1, 0xC0, 0x30, 0x70, 0x0C, 0x18, 0x03, 0x06, 0x00,
  0xC3, 0x80, 0x30, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x61,
  0x80, 0x18, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x30, 0xC0,
  0x18, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x61, 0x80, 0x18, 0x60, 0x0C,
  0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0xC0, 0x1C, 0x00, 0x00, 0x7C,
  0x00, 0xFF, 0x80, 0xE0, 0xC0, 0xE0, 0x30, 0x60, 0x18, 0x60, 0x0C, 0x30,
  0x06, 0x30, 0x03, 0x18, 0x01, 0x9C, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x33,
  0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x03, 0x30, 0x01,
  0x98, 0x00, 0xCC, 0x00, 0x6E, 0x00, 0x67, 0x00, 0x33, 0x80, 0x30, 0xC0,
  0x18, 0x60, 0x1C, 0x30, 0x0C, 0x1C, 0x0C, 0x07, 0xBC, 0x01, 0xFC, 0x00,
  0x10, 0x00, 0x00, 0xC3, 0xC0, 0x06, 0x7F, 0x00, 0x36, 0x0C, 0x01, 0x60,
  0x70, 0x1A, 0x01, 0x80, 0xF0, 0x0C, 0x07, 0x00, 0x60, 0x30, 0x03, 0x01,
  0x80, 0x18, 0x1C, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01,
  0x81, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30,
  0x01, 0x81, 0x80, 0x0C, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x70,
  0x30, 0x03, 0x03, 0x80, 0x38, 0x1C, 0x01, 0x80, 0xF0, 0x18, 0x06, 0x81,
  0xC0, 0x37, 0x3C, 0x03, 0x1F, 0xC0, 0x18, 0x20, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x40, 0x7F, 0x10, 0x70, 0x6C, 0x18, 0x0B, 0x0C,
  0x03, 0xC7, 0x00, 0xE1, 0x80, 0x18, 0xE0, 0x06, 0x30, 0x01, 0x8C, 0x00,
  0xE6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x33,
  0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x30, 0xC0,
  0x0C, 0x30, 0x07, 0x0C, 0x01, 0xC3, 0x00, 0x70, 0xC0, 0x28, 0x30, 0x1E,
  0x0E, 0x0D, 0x81, 0xCE, 0x60, 0x3F, 0x18, 0x02, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x03, 0x1E, 0x06, 0x7C, 0x09, 0x80, 0x16, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xC0, 0xC0, 0xC0, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x20, 0x1C, 0x1E, 0x3C, 0x07, 0xFC, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0xF9, 0xFE, 0x06,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x81, 0xF0,
  0x18, 0x00, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x0C,
  0x00, 0xC3, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x1C, 0x01, 0x86, 0x00,
  0x61, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x60,
  0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x86, 0x00, 0x61, 0x80, 0x30, 0x60,
  0x0C, 0x18, 0x03, 0x06, 0x01, 0xC3, 0x00, 0x70, 0xC0, 0x38, 0x30, 0x0E,
  0x06, 0x05, 0x81, 0xC7, 0x60, 0x3F, 0x18, 0x02, 0x00, 0x00, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x36, 0x00, 0x6C, 0x01, 0x98, 0x03, 0x30, 0x0C, 0x60,
  0x18, 0xC0, 0x71, 0x80, 0xC3, 0x01, 0x86, 0x06, 0x0C, 0x0C, 0x18, 0x30,
  0x30, 0x60, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x18, 0x06, 0x30, 0x0C,
  0xC0, 0x19, 0x80, 0x36, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x0C, 0x01, 0xE0, 0x06, 0x00, 0xF0,
  0x07, 0x00, 0xD8, 0x03, 0x80, 0x6C, 0x03, 0xC0, 0x36, 0x01, 0xE0, 0x33,
  0x00, 0xB0, 0x19, 0x80, 0xD8, 0x08, 0xC0, 0x6C, 0x0C, 0x60, 0x66, 0x06,
  0x30, 0x33, 0x06, 0x18, 0x11, 0x83, 0x0C, 0x18, 0xC1, 0x06, 0x0C, 0x61,
  0x83, 0x0C, 0x30, 0xC1, 0x86, 0x18, 0xC0, 0xC6, 0x0C, 0x60, 0x63, 0x06,
  0x30, 0x31, 0x83, 0x30, 0x19, 0x81, 0x98, 0x0C, 0xC0, 0xC8, 0x06, 0x40,
  0x6C, 0x03, 0x60, 0x36, 0x01, 0xB0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78,
  0x05, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x30, 0x30, 0x06, 0x01, 0x80, 0xE0, 0x18, 0x0C, 0x01, 0x81,
  0x80, 0x18, 0x18, 0x01, 0x83, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C,
  0xC0, 0x00, 0xCC, 0x00, 0x0D, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x01, 0xB0, 0x00, 0x1B, 0x00, 0x03, 0x30, 0x00,
  0x33, 0x00, 0x06, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x01, 0x81, 0x80,
  0x38, 0x18, 0x03, 0x01, 0x80, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x0C,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x30, 0x00,
  0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0x58,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0F, 0xFC,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x01, 0xF8,
  0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x1F, 0xE0, 0x1E, 0x3C, 0x06, 0x03, 0xEF, 0x80, 0x3F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 39, 11, 1, -39 },
  { 55, 12, 14, 15, 5, -39 },
  { 76, 21, 39, 20, 0, -39 },
  { 179, 20, 44, 19, 0, -41 },
  { 289, 24, 40, 29, 3, -39 },
  { 409, 19, 40, 19, -1, -39 },
  { 504, 5, 14, 8, 5, -39 },
  { 513, 15, 47, 13, 1, -38 },
  { 602, 15, 47, 13, -4, -38 },
  { 691, 14, 15, 18, 6, -41 },
  { 718, 18, 25, 22, 2, -32 },
  { 775, 7, 12, 9, -2, -5 },
  { 786, 12, 2, 14, 1, -16 },
  { 789, 3, 4, 9, 1, -4 },
  { 791, 22, 39, 16, -2, -39 },
  { 899, 18, 40, 19, 1, -39 },
  { 989, 10, 39, 19, 6, -39 },
  { 1038, 21, 39, 19, -2, -39 },
  { 1141, 20, 40, 19, -1, -39 },
  { 1241, 20, 39, 19, -1, -39 },
  { 1339, 20, 40, 19, -1, -39 },
  { 1439, 19, 40, 19, 1, -39 },
  { 1534, 19, 39, 19, 2, -39 },
  { 1627, 21, 40, 19, -1, -39 },
  { 1732, 19, 40, 19, 0, -39 },
  { 1827, 8, 29, 9, 0, -29 },
  { 1856, 11, 36, 9, -2, -29 },
  { 1906, 18, 22, 22, 2, -30 },
  { 1956, 18, 14, 22, 2, -26 },
  { 1988, 18, 22, 22, 2, -30 },
  { 2038, 15, 39, 14, 1, -39 },
  { 2112, 26, 44, 28, 1, -39 },
  { 2255, 19, 39, 18, -4, -39 },
  { 2348, 21, 39, 21, 0, -39 },
  { 2451, 21, 40, 19, 2, -39 },
  { 2556, 22, 39, 23, 0, -39 },
  { 2664, 21, 39, 19, 0, -39 },
  { 2767, 21, 39, 17, 0, -39 },
  { 2870, 24, 40, 25, 2, -39 },
  { 2990, 25, 39, 24, 0, -39 },
  { 3112, 17, 39, 10, -3, -39 },
  { 3195, 18, 49, 9, -8, -39 },
  { 3306, 23, 39, 19, 0, -39 },
  { 3419, 12, 39, 17, 0, -39 },
  { 3478, 33, 39, 32, 0, -39 },
  { 3639, 26, 39, 25, 0, -39 },
  { 3766, 22, 40, 25, 2, -39 },
  { 3876, 20, 39, 20, 0, -39 },
  { 3974, 22, 48, 25, 2, -39 },
  { 4106, 20, 39, 20, 0, -39 },
  { 4204, 22, 40, 19, -2, -39 },
  { 4314, 17, 39, 16, 4, -39 },
  { 4397, 23, 40, 23, 2, -39 },
  { 4512, 19, 39, 19, 5, -39 },
  { 4605, 33, 39, 33, 4, -39 },
  { 4766, 24, 39, 17, -3, -39 },
  { 4883, 17, 39, 16, 4, -39 },
  { 4966, 22, 39, 17, -2, -39 },
  { 5074, 19, 48, 15, -1, -39 },
  { 5188, 7, 39, 17, 6, -39 },
  { 5223, 19, 48, 15, -3, -39 },
  { 5337, 20, 19, 21, 1, -39 },
  { 5385, 14, 2, 15, -4, 5 },
  { 5389, 5, 8, 12, 8, -41 },
  { 5394, 19, 30, 21, 2, -29 },
  { 5466, 19, 42, 21, 0, -41 },
  { 5566, 15, 30, 15, 2, -29 },
  { 5623, 21, 42, 21, 2, -41 },
  { 5734, 16, 30, 18, 1, -29 },
  { 5794, 24, 54, 10, -7, -41 },
  { 5956, 21, 42, 21, -1, -29 },
  { 6067, 18, 41, 20, 0, -41 },
  { 6160, 11, 39, 9, 0, -39 },
  { 6214, 18, 52, 9, -7, -39 },
  { 6331, 19, 41, 17, 0, -41 },
  { 6429, 11, 41, 8, 0, -41 },
  { 6486, 29, 29, 30, 0, -29 },
  { 6592, 18, 29, 20, 0, -29 },
  { 6658, 17, 30, 20, 1, -29 },
  { 6722, 21, 41, 21, -2, -29 },
  { 6830, 18, 42, 21, 2, -29 },
  { 6925, 15, 29, 13, 0, -29 },
  { 6980, 17, 30, 15, -1, -29 },
  { 7044, 11, 36, 10, 1, -35 },
  { 7094, 18, 30, 20, 1, -29 },
  { 7162, 15, 29, 15, 3, -29 },
  { 7217, 25, 29, 26, 3, -29 },
  { 7308, 20, 29, 16, -2, -29 },
  { 7381, 25, 42, 16, -6, -29 },
  { 7513, 17, 29, 13, -2, -29 },
  { 7575, 18, 48, 17, 2, -39 },
  { 7683, 2, 54, 19, 8, -41 },
  { 7697, 19, 48, 17, -4, -39 },
  { 7811, 18, 5, 22, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC54PT7B_H_
