#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC20PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x22, 0x22, 0x44, 0x40, 0x88, 0x59, 0x9A, 0xA0, 0x09,
  0x0A, 0x12, 0x12, 0x7F, 0x24, 0x24, 0x24, 0x2A, 0xDC, 0x48, 0x50, 0x90,
  0x90, 0x04, 0x18, 0xE9, 0x42, 0x85, 0x0C, 0x08, 0x18, 0x28, 0x51, 0x22,
  0x5F, 0x08, 0x10, 0x71, 0x24, 0xA4, 0x92, 0x49, 0x44, 0xAA, 0xAB, 0x59,
  0x54, 0x8A, 0x49, 0x25, 0x24, 0x92, 0x30, 0x1C, 0x48, 0x91, 0x22, 0x85,
  0x0C, 0x29, 0x55, 0x1A, 0x34, 0x48, 0x9E, 0x80, 0x6A, 0x80, 0x04, 0x21,
  0x08, 0x21, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x04, 0x10, 0x40, 0x10,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x44, 0x21, 0x11, 0x08, 0x80, 0x14, 0x9E,
  0xA9, 0x00, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10, 0x20, 0x29,
  0x28, 0xF8, 0xC0, 0x01, 0x01, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10,
  0x20, 0x20, 0x40, 0x40, 0x80, 0x1E, 0x24, 0x89, 0x14, 0x28, 0x50, 0xA1,
  0x85, 0x0A, 0x14, 0x48, 0x8E, 0x00, 0x35, 0xA2, 0x22, 0x24, 0x44, 0x44,
  0x88, 0x1F, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x10,
  0x20, 0x40, 0xFC, 0x3E, 0x04, 0x08, 0x10, 0x20, 0x8E, 0x04, 0x04, 0x08,
  0x10, 0x40, 0x9E, 0x00, 0x02, 0x0C, 0x28, 0x61, 0x44, 0x89, 0x22, 0x49,
  0x13, 0xF0, 0x40, 0x82, 0x00, 0x1E, 0x40, 0x81, 0x04, 0x0E, 0x02, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x9E, 0x00, 0x0F, 0x10, 0x20, 0x20, 0x40, 0x58,
  0x64, 0x44, 0x44, 0x84, 0x84, 0x84, 0x48, 0x70, 0x7E, 0x08, 0x10, 0x40,
  0x81, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x00, 0x1E, 0x44, 0x89,
  0x12, 0x24, 0x86, 0x34, 0x85, 0x0A, 0x14, 0x28, 0x4F, 0x00, 0x1C, 0x45,
  0x0A, 0x14, 0x28, 0x51, 0xB5, 0x14, 0x08, 0x10, 0x41, 0x1C, 0x00, 0x24,
  0x00, 0x00, 0x12, 0x00, 0x11, 0x00, 0x00, 0x00, 0x02, 0x44, 0x88, 0x06,
  0x31, 0x84, 0x0C, 0x06, 0x02, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x80,
  0xC0, 0x60, 0x30, 0xC2, 0x18, 0x40, 0x3C, 0x10, 0x41, 0x08, 0x42, 0x08,
  0x41, 0x04, 0x00, 0x82, 0x00, 0x0F, 0x84, 0x11, 0x04, 0x81, 0x27, 0x52,
  0x54, 0xA5, 0x49, 0x52, 0x64, 0xA9, 0x4A, 0x2C, 0x80, 0x10, 0x04, 0x00,
  0xF0, 0x06, 0x08, 0x28, 0x51, 0x22, 0x44, 0x91, 0x3C, 0x85, 0x0A, 0x18,
  0x30, 0x40, 0x1E, 0x11, 0x21, 0x21, 0x22, 0x22, 0x3C, 0x44, 0x42, 0x42,
  0x42, 0x84, 0x84, 0xF8, 0x06, 0x19, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x70, 0x1E, 0x11, 0x21, 0x21, 0x21,
  0x21, 0x41, 0x41, 0x42, 0x42, 0x42, 0x84, 0x88, 0xF0, 0x1F, 0x10, 0x20,
  0x20, 0x20, 0x20, 0x3C, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0xF8, 0x1F,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x40, 0x7C, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x06, 0x0C, 0xC8, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x86, 0x41,
  0x20, 0x90, 0x48, 0x44, 0x21, 0xF0, 0x10, 0x88, 0x48, 0x24, 0x12, 0x11,
  0x08, 0xFC, 0x82, 0x41, 0x21, 0x10, 0x90, 0x48, 0x24, 0x20, 0x1C, 0x21,
  0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x43, 0x80, 0x02, 0x04, 0x10,
  0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x21,
  0x80, 0x11, 0x89, 0x08, 0x84, 0x82, 0x81, 0x81, 0x40, 0xE0, 0x48, 0x24,
  0x12, 0x11, 0x08, 0x44, 0x20, 0x10, 0x88, 0x42, 0x11, 0x08, 0x42, 0x11,
  0x08, 0x7C, 0x10, 0x11, 0x03, 0x30, 0x33, 0x05, 0x28, 0x62, 0x8A, 0x48,
  0xA4, 0x92, 0x49, 0x24, 0xA4, 0x4A, 0x48, 0xC4, 0x8C, 0x48, 0x88, 0x10,
  0x44, 0x22, 0x88, 0xA2, 0x28, 0x8A, 0x24, 0x91, 0x14, 0x45, 0x11, 0x44,
  0x52, 0x18, 0x82, 0x20, 0x80, 0x1E, 0x21, 0x41, 0x41, 0x41, 0x81, 0x81,
  0x82, 0x82, 0x82, 0x84, 0x84, 0x88, 0x70, 0x1E, 0x12, 0x21, 0x21, 0x22,
  0x22, 0x44, 0x78, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x1E, 0x21, 0x41,
  0x41, 0x41, 0x81, 0x81, 0x82, 0x82, 0x82, 0x84, 0x84, 0x88, 0x70, 0x10,
  0x10, 0x10, 0x1E, 0x12, 0x21, 0x21, 0x22, 0x22, 0x24, 0x78, 0x48, 0x48,
  0x48, 0x88, 0x88, 0x84, 0x0F, 0x88, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x47, 0xC0, 0x7E, 0x20, 0x41, 0x02,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x00, 0x21, 0x41, 0x41,
  0x42, 0x42, 0x42, 0x82, 0x82, 0x84, 0x84, 0x84, 0x84, 0x88, 0xF0, 0x87,
  0x0A, 0x14, 0x48, 0x92, 0x24, 0x48, 0xA1, 0x43, 0x06, 0x08, 0x10, 0x00,
  0x42, 0x1A, 0x10, 0x91, 0x85, 0x0C, 0x48, 0xA2, 0x45, 0x22, 0x29, 0x12,
  0x48, 0x92, 0x85, 0x14, 0x28, 0xC1, 0x46, 0x0C, 0x30, 0x61, 0x00, 0x11,
  0x88, 0x84, 0x81, 0x40, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x14, 0x09, 0x08,
  0x84, 0x44, 0x20, 0x46, 0x89, 0x22, 0x45, 0x0A, 0x18, 0x30, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x00, 0x1F, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x40, 0xFC, 0x1E, 0x20, 0x41, 0x02, 0x04, 0x08,
  0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0xE0, 0x92, 0x44, 0x92,
  0x49, 0x12, 0x40, 0x1E, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10,
  0x20, 0x41, 0x02, 0x04, 0x08, 0xE0, 0x08, 0x14, 0x14, 0x24, 0x22, 0x42,
  0x81, 0xFC, 0x94, 0x1A, 0xC9, 0x14, 0x28, 0x50, 0xA2, 0x44, 0x89, 0x33,
  0xA0, 0x10, 0x20, 0x41, 0x02, 0xC6, 0x48, 0x91, 0x42, 0x85, 0x0A, 0x24,
  0x58, 0xAE, 0x00, 0x1B, 0x11, 0x08, 0x42, 0x10, 0x84, 0x38, 0x01, 0x02,
  0x02, 0x02, 0x1A, 0x64, 0x44, 0x84, 0x84, 0x84, 0x88, 0x88, 0x88, 0x98,
  0xE8, 0x3A, 0x53, 0x19, 0xF2, 0x10, 0x84, 0x3C, 0x01, 0x81, 0x00, 0x80,
  0x40, 0xF0, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x08, 0x18, 0x00, 0x0D, 0x32, 0x22, 0x42, 0x42,
  0x42, 0x44, 0x84, 0x84, 0x4C, 0x74, 0x08, 0x08, 0x08, 0x10, 0xE0, 0x10,
  0x20, 0x41, 0x02, 0xC6, 0x48, 0x91, 0x42, 0x89, 0x12, 0x24, 0x51, 0x22,
  0x00, 0x10, 0x02, 0x22, 0x24, 0x44, 0x48, 0x88, 0x02, 0x00, 0x00, 0x20,
  0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x20, 0x43,
  0x00, 0x10, 0x20, 0x41, 0x02, 0x24, 0x8A, 0x14, 0x50, 0xE1, 0x42, 0x88,
  0x91, 0x22, 0x00, 0x11, 0x12, 0x22, 0x22, 0x44, 0x44, 0x88, 0x80, 0x2D,
  0xC6, 0x44, 0x88, 0x91, 0x24, 0x44, 0x88, 0x91, 0x12, 0x22, 0x88, 0x91,
  0x12, 0x22, 0x00, 0x2C, 0x64, 0x89, 0x14, 0x48, 0x91, 0x22, 0x85, 0x12,
  0x20, 0x39, 0x14, 0x61, 0x86, 0x18, 0x62, 0x8A, 0x4E, 0x00, 0x16, 0x19,
  0x11, 0x11, 0x21, 0x21, 0x21, 0x21, 0x22, 0x62, 0x5C, 0x40, 0x40, 0x80,
  0x80, 0x80, 0x1A, 0xC9, 0x14, 0x28, 0x50, 0xA2, 0x44, 0x89, 0x33, 0xA0,
  0x81, 0x02, 0x04, 0x08, 0x2C, 0xC2, 0x08, 0x41, 0x04, 0x10, 0x82, 0x08,
  0x00, 0x3D, 0x04, 0x10, 0x40, 0x81, 0x04, 0x10, 0x4F, 0x00, 0x12, 0x72,
  0x24, 0x44, 0x44, 0x88, 0xE0, 0x45, 0x14, 0x51, 0x8A, 0x28, 0xA2, 0x8A,
  0x4F, 0x00, 0x86, 0x28, 0xA4, 0x92, 0x4A, 0x28, 0xC3, 0x08, 0x00, 0x88,
  0xC4, 0x62, 0x33, 0x29, 0x95, 0x4A, 0xA9, 0x54, 0xCC, 0x62, 0x22, 0x00,
  0x21, 0x12, 0x14, 0x14, 0x18, 0x08, 0x18, 0x28, 0x28, 0x48, 0x88, 0x10,
  0x88, 0x44, 0x42, 0x21, 0x20, 0x90, 0x48, 0x28, 0x14, 0x04, 0x02, 0x02,
  0x01, 0x01, 0x00, 0x81, 0x80, 0x1C, 0x10, 0x42, 0x08, 0x42, 0x08, 0x41,
  0x0F, 0x00, 0x0E, 0x20, 0x40, 0x82, 0x04, 0x08, 0x30, 0x80, 0x81, 0x02,
  0x04, 0x10, 0x20, 0x40, 0x60, 0xFF, 0xFF, 0xF0, 0x1C, 0x08, 0x10, 0x20,
  0x81, 0x02, 0x04, 0x06, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0xC0, 0xE3,
  0x38,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 14, 4, 0, -14 },
  { 8, 4, 5, 5, 2, -14 },
  { 11, 8, 14, 8, 0, -14 },
  { 25, 7, 16, 7, 0, -15 },
  { 39, 9, 14, 11, 1, -14 },
  { 55, 7, 14, 7, 0, -14 },
  { 68, 2, 5, 3, 2, -14 },
  { 70, 6, 17, 5, 0, -14 },
  { 83, 5, 17, 5, -1, -14 },
  { 94, 5, 5, 7, 2, -15 },
  { 98, 7, 10, 8, 1, -12 },
  { 107, 3, 5, 3, -1, -2 },
  { 109, 5, 1, 5, 0, -6 },
  { 110, 1, 2, 3, 0, -2 },
  { 111, 8, 14, 6, -1, -14 },
  { 125, 7, 14, 7, 0, -14 },
  { 138, 4, 14, 7, 2, -14 },
  { 145, 8, 14, 7, -1, -14 },
  { 159, 7, 14, 7, 0, -14 },
  { 172, 7, 14, 7, 0, -14 },
  { 185, 7, 14, 7, 0, -14 },
  { 198, 8, 14, 7, 0, -14 },
  { 212, 7, 14, 7, 1, -14 },
  { 225, 7, 14, 7, 0, -14 },
  { 238, 7, 14, 7, 0, -14 },
  { 251, 3, 11, 3, 0, -11 },
  { 256, 4, 14, 3, -1, -11 },
  { 263, 7, 8, 8, 1, -11 },
  { 270, 7, 5, 8, 1, -10 },
  { 275, 7, 8, 8, 1, -11 },
  { 282, 6, 14, 5, 0, -14 },
  { 293, 10, 16, 11, 0, -14 },
  { 313, 7, 14, 7, -1, -14 },
  { 326, 8, 14, 8, 0, -14 },
  { 340, 8, 15, 7, 1, -15 },
  { 355, 8, 14, 8, 0, -14 },
  { 369, 8, 14, 7, 0, -14 },
  { 383, 8, 14, 6, 0, -14 },
  { 397, 9, 15, 9, 1, -15 },
  { 414, 9, 14, 9, 0, -14 },
  { 430, 6, 14, 4, -1, -14 },
  { 441, 7, 18, 3, -3, -14 },
  { 457, 9, 14, 7, 0, -14 },
  { 473, 5, 14, 6, 0, -14 },
  { 482, 12, 14, 12, 0, -14 },
  { 503, 10, 14, 9, 0, -14 },
  { 521, 8, 14, 9, 1, -14 },
  { 535, 8, 14, 7, 0, -14 },
  { 549, 8, 17, 9, 1, -14 },
  { 566, 8, 14, 7, 0, -14 },
  { 580, 9, 14, 7, -1, -14 },
  { 596, 7, 14, 6, 1, -14 },
  { 609, 8, 14, 9, 1, -14 },
  { 623, 7, 14, 7, 2, -14 },
  { 636, 13, 14, 12, 1, -14 },
  { 659, 9, 14, 6, -1, -14 },
  { 675, 7, 14, 6, 1, -14 },
  { 688, 8, 14, 6, -1, -14 },
  { 702, 7, 17, 6, 0, -14 },
  { 717, 3, 14, 6, 2, -14 },
  { 723, 7, 17, 6, -1, -14 },
  { 738, 8, 7, 8, 0, -14 },
  { 745, 6, 1, 5, -2, 2 },
  { 746, 2, 3, 4, 3, -15 },
  { 747, 7, 11, 8, 1, -11 },
  { 757, 7, 15, 8, 0, -15 },
  { 771, 5, 11, 6, 1, -11 },
  { 778, 8, 15, 8, 1, -15 },
  { 793, 5, 11, 7, 1, -11 },
  { 800, 9, 20, 4, -3, -15 },
  { 823, 8, 16, 8, 0, -11 },
  { 839, 7, 15, 7, 0, -15 },
  { 853, 4, 14, 3, 0, -14 },
  { 860, 7, 19, 3, -3, -14 },
  { 877, 7, 15, 6, 0, -15 },
  { 891, 4, 15, 3, 0, -15 },
  { 899, 11, 11, 11, 0, -11 },
  { 915, 7, 11, 7, 0, -11 },
  { 925, 6, 11, 7, 1, -11 },
  { 934, 8, 16, 8, -1, -11 },
  { 950, 7, 16, 8, 1, -11 },
  { 964, 6, 11, 5, 0, -11 },
  { 973, 6, 11, 6, 0, -11 },
  { 982, 4, 13, 4, 0, -13 },
  { 989, 6, 11, 7, 1, -11 },
  { 998, 6, 11, 6, 1, -11 },
  { 1007, 9, 11, 10, 1, -11 },
  { 1020, 8, 11, 6, -1, -11 },
  { 1031, 9, 16, 6, -2, -11 },
  { 1049, 6, 11, 5, -1, -11 },
  { 1058, 7, 17, 6, 1, -14 },
  { 1073, 1, 20, 7, 3, -15 },
  { 1076, 7, 17, 6, -1, -14 },
  { 1091, 7, 2, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC20PT7B_H_
