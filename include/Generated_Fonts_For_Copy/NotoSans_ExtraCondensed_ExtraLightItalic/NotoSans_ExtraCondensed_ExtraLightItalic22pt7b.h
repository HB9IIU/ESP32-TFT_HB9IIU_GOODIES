#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC22PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x44, 0x21, 0x08, 0x84, 0x21, 0x08, 0x80, 0x01, 0x10, 0x4A,
  0x55, 0x29, 0x48, 0x04, 0x84, 0x82, 0x41, 0x21, 0x21, 0xFC, 0x48, 0x24,
  0x24, 0x12, 0x3F, 0x89, 0x04, 0x82, 0x42, 0x41, 0x20, 0x04, 0x04, 0x1F,
  0x24, 0x24, 0x28, 0x28, 0x28, 0x18, 0x08, 0x14, 0x14, 0x12, 0x14, 0x24,
  0xF8, 0x20, 0x20, 0x30, 0x92, 0x24, 0x91, 0x24, 0x8A, 0x22, 0x89, 0x4A,
  0x55, 0x9A, 0x5A, 0x91, 0x44, 0x51, 0x24, 0x49, 0x24, 0x49, 0x1C, 0x0C,
  0x24, 0x49, 0x12, 0x42, 0x86, 0x08, 0x30, 0x96, 0x2C, 0x58, 0xD0, 0xA3,
  0x7A, 0x56, 0xA0, 0x04, 0x21, 0x08, 0x21, 0x04, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x0C, 0x00, 0x08, 0x08, 0x10, 0x20, 0x40, 0x40,
  0x81, 0x02, 0x08, 0x10, 0x20, 0x41, 0x02, 0x08, 0x10, 0x43, 0x00, 0x21,
  0x28, 0xF6, 0x48, 0x10, 0x20, 0x40, 0x81, 0x1F, 0xC4, 0x08, 0x10, 0x20,
  0x25, 0x28, 0xF8, 0x70, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10,
  0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x0E, 0x11,
  0x11, 0x21, 0x21, 0x41, 0x41, 0x42, 0x42, 0x42, 0x82, 0x84, 0x84, 0x84,
  0x48, 0x70, 0x19, 0x95, 0x21, 0x08, 0x84, 0x21, 0x10, 0x84, 0x21, 0x10,
  0x0F, 0x08, 0x80, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x02,
  0x02, 0x01, 0x01, 0x01, 0x01, 0xF8, 0x1E, 0x21, 0x01, 0x01, 0x01, 0x02,
  0x02, 0x3C, 0x08, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0xF0, 0x01, 0x03,
  0x06, 0x06, 0x0A, 0x12, 0x12, 0x24, 0x24, 0x44, 0x84, 0xF6, 0x08, 0x08,
  0x08, 0x08, 0x0F, 0x84, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x7C, 0x02,
  0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x11, 0xF0, 0x07, 0x08, 0x10, 0x20,
  0x20, 0x20, 0x58, 0x66, 0x42, 0x42, 0x42, 0x82, 0x82, 0x84, 0x44, 0x78,
  0x7F, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20,
  0x40, 0x40, 0x80, 0x80, 0x0E, 0x11, 0x21, 0x21, 0x21, 0x22, 0x14, 0x18,
  0x28, 0x44, 0x84, 0x82, 0x82, 0x84, 0x84, 0x78, 0x0E, 0x12, 0x21, 0x21,
  0x41, 0x41, 0x42, 0x42, 0x46, 0x3A, 0x02, 0x04, 0x04, 0x08, 0x08, 0xF0,
  0x24, 0x00, 0x00, 0x02, 0x40, 0x08, 0x80, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x84, 0x42, 0x00, 0x02, 0x18, 0xC6, 0x0C, 0x04, 0x06, 0x03, 0x02, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x80, 0xC0, 0x60, 0x30, 0x61, 0x0C, 0x60,
  0x80, 0x3C, 0x10, 0x41, 0x04, 0x10, 0x84, 0x20, 0x84, 0x10, 0x00, 0x04,
  0x20, 0x07, 0x02, 0x21, 0x04, 0x81, 0x40, 0x53, 0xD8, 0xA6, 0x49, 0x92,
  0x68, 0x9A, 0x4A, 0x92, 0xAD, 0x24, 0x88, 0x02, 0x00, 0x80, 0x1E, 0x00,
  0x02, 0x0C, 0x18, 0x30, 0xA1, 0x44, 0x89, 0x12, 0x7C, 0x8A, 0x14, 0x30,
  0x60, 0xC1, 0x1E, 0x08, 0x84, 0x22, 0x12, 0x11, 0x08, 0x8C, 0x78, 0x26,
  0x21, 0x10, 0x88, 0x44, 0x24, 0x12, 0x11, 0xF0, 0x0F, 0x10, 0x20, 0x20,
  0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x78,
  0x1E, 0x08, 0x84, 0x22, 0x12, 0x09, 0x04, 0x82, 0x41, 0x20, 0xA0, 0x90,
  0x48, 0x24, 0x24, 0x32, 0x31, 0xE0, 0x1F, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x20, 0x3E, 0x20, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0xF8, 0x1F, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x3E, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x80, 0x80, 0x07, 0x86, 0x12, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00,
  0x87, 0x20, 0x48, 0x12, 0x04, 0x82, 0x20, 0x8C, 0x21, 0xF8, 0x10, 0x44,
  0x11, 0x04, 0x41, 0x20, 0x88, 0x22, 0x08, 0xFE, 0x20, 0x90, 0x44, 0x11,
  0x04, 0x41, 0x20, 0x88, 0x22, 0x08, 0x1E, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x70, 0x02, 0x04, 0x08, 0x10,
  0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20,
  0x86, 0x00, 0x10, 0xC4, 0x21, 0x10, 0x48, 0x24, 0x09, 0x02, 0x80, 0xC0,
  0x28, 0x12, 0x04, 0x81, 0x20, 0x44, 0x21, 0x08, 0x42, 0x10, 0x10, 0x84,
  0x22, 0x10, 0x84, 0x22, 0x10, 0x84, 0x42, 0x1F, 0x18, 0x0C, 0x60, 0x21,
  0x81, 0x86, 0x06, 0x28, 0x28, 0xA0, 0xA2, 0x85, 0x0A, 0x14, 0x28, 0x91,
  0x22, 0x44, 0x92, 0x12, 0x48, 0x4A, 0x22, 0x28, 0x88, 0xC2, 0x21, 0x10,
  0x10, 0x23, 0x04, 0x61, 0x0C, 0x22, 0x84, 0x50, 0x89, 0x21, 0x24, 0x24,
  0x88, 0x91, 0x12, 0x22, 0x84, 0x31, 0x06, 0x20, 0xC4, 0x10, 0x0E, 0x08,
  0x88, 0x24, 0x14, 0x0A, 0x06, 0x03, 0x02, 0x81, 0x40, 0xA0, 0x50, 0x48,
  0x24, 0x22, 0x10, 0xF0, 0x1E, 0x11, 0x11, 0x11, 0x21, 0x21, 0x21, 0x22,
  0x2C, 0x50, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x0E, 0x08, 0x88, 0x24,
  0x14, 0x0A, 0x06, 0x03, 0x02, 0x81, 0x40, 0xA0, 0x50, 0x48, 0x24, 0x22,
  0x10, 0xF0, 0x10, 0x08, 0x02, 0x01, 0x00, 0x1E, 0x11, 0x11, 0x11, 0x21,
  0x21, 0x21, 0x22, 0x3C, 0x48, 0x48, 0x48, 0x44, 0x84, 0x84, 0x84, 0x07,
  0x8C, 0x44, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x09, 0xF8, 0x7E, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10,
  0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x40, 0x20, 0x90, 0x48, 0x28, 0x24,
  0x12, 0x09, 0x04, 0x82, 0x82, 0x41, 0x20, 0x90, 0x48, 0x44, 0x22, 0x11,
  0xF0, 0x81, 0x82, 0x82, 0x84, 0x84, 0x88, 0x88, 0x88, 0x90, 0x90, 0xA0,
  0xA0, 0xC0, 0xC0, 0xC0, 0x80, 0x82, 0x0C, 0x10, 0x61, 0x85, 0x0C, 0x28,
  0xA2, 0x45, 0x12, 0x28, 0x92, 0x48, 0x92, 0x45, 0x14, 0x28, 0xA1, 0x45,
  0x0C, 0x30, 0x61, 0x82, 0x08, 0x10, 0x40, 0x10, 0xC2, 0x20, 0x90, 0x24,
  0x0A, 0x02, 0x80, 0xC0, 0x30, 0x08, 0x05, 0x01, 0x40, 0x90, 0x24, 0x11,
  0x08, 0x42, 0x10, 0x43, 0x42, 0x44, 0x44, 0x48, 0x48, 0x50, 0x50, 0x20,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x80, 0x0F, 0x88, 0x40, 0x40, 0x20,
  0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01,
  0xF8, 0x0E, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x08, 0x10, 0x40, 0x81, 0x02, 0x07, 0x00, 0x92, 0x24, 0x92, 0x48, 0x92,
  0x49, 0x0E, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40,
  0x81, 0x02, 0x08, 0x10, 0x20, 0x47, 0x00, 0x08, 0x06, 0x05, 0x02, 0x42,
  0x21, 0x09, 0x05, 0x83, 0xFC, 0x95, 0x1A, 0x4D, 0x0A, 0x18, 0x30, 0xA1,
  0x42, 0x85, 0x12, 0x27, 0xC0, 0x10, 0x10, 0x10, 0x10, 0x10, 0x2E, 0x31,
  0x21, 0x21, 0x21, 0x41, 0x41, 0x42, 0x42, 0x42, 0xC4, 0xB8, 0x1C, 0x84,
  0x10, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3C, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x1A, 0x26, 0x42, 0x42, 0x82, 0x84, 0x84, 0x84, 0x84, 0x88, 0x88, 0xF8,
  0x18, 0x94, 0x51, 0x8A, 0xCC, 0x20, 0x82, 0x08, 0x3C, 0x00, 0xC0, 0x40,
  0x20, 0x08, 0x02, 0x03, 0xC0, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x38,
  0x00, 0x0D, 0x13, 0x21, 0x21, 0x41, 0x42, 0x42, 0x42, 0x42, 0x44, 0x44,
  0x7C, 0x04, 0x04, 0x08, 0x08, 0xF0, 0x08, 0x20, 0x40, 0x81, 0x05, 0xCC,
  0x91, 0x22, 0x45, 0x0A, 0x14, 0x28, 0x91, 0x42, 0x84, 0x11, 0x00, 0x22,
  0x22, 0x24, 0x44, 0x44, 0x88, 0x02, 0x04, 0x00, 0x00, 0x20, 0x81, 0x02,
  0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x0E, 0x00,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x21, 0x22, 0x24, 0x28, 0x28, 0x50, 0x68,
  0x48, 0x48, 0x48, 0x88, 0x88, 0x11, 0x11, 0x12, 0x22, 0x22, 0x44, 0x44,
  0x48, 0x80, 0x2E, 0xE3, 0x31, 0x22, 0x12, 0x21, 0x22, 0x24, 0x22, 0x42,
  0x24, 0x42, 0x44, 0x44, 0x44, 0x84, 0x48, 0x84, 0x2E, 0x64, 0x89, 0x12,
  0x28, 0x50, 0xA1, 0x44, 0x8A, 0x14, 0x20, 0x18, 0x49, 0x0A, 0x18, 0x30,
  0xA1, 0x42, 0x85, 0x12, 0x27, 0x80, 0x17, 0x0C, 0x44, 0x22, 0x11, 0x09,
  0x04, 0x82, 0x42, 0x21, 0x10, 0x98, 0x8B, 0x84, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x00, 0x1A, 0x4D, 0x0A, 0x18, 0x30, 0xA1, 0x42, 0x85, 0x12, 0x27,
  0xC0, 0x81, 0x04, 0x08, 0x10, 0x2C, 0xC2, 0x08, 0x21, 0x04, 0x10, 0x41,
  0x08, 0x20, 0x1C, 0x84, 0x10, 0x40, 0x81, 0x02, 0x08, 0x20, 0xBC, 0x10,
  0x9E, 0x42, 0x11, 0x08, 0x42, 0x11, 0x08, 0x30, 0x42, 0x85, 0x0A, 0x24,
  0x50, 0xA1, 0x44, 0x89, 0x12, 0x67, 0x40, 0x86, 0x18, 0xA2, 0x8A, 0x49,
  0x28, 0xA3, 0x0C, 0x20, 0x84, 0x61, 0x18, 0xC6, 0x32, 0x94, 0xA5, 0x29,
  0x52, 0x94, 0xA6, 0x31, 0x8C, 0x62, 0x10, 0x11, 0x11, 0x12, 0x14, 0x14,
  0x08, 0x18, 0x18, 0x28, 0x24, 0x44, 0x84, 0x08, 0x42, 0x20, 0x88, 0x24,
  0x09, 0x02, 0x40, 0xA0, 0x28, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x01, 0x00, 0x80, 0xC0, 0x00, 0x1E, 0x04, 0x10, 0x20, 0x81, 0x04, 0x10,
  0x20, 0x81, 0x07, 0xC0, 0x06, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x21,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x01, 0x80, 0xFF, 0xFF, 0xFC,
  0x18, 0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x0C, 0x30, 0x41, 0x02,
  0x04, 0x08, 0x10, 0x43, 0x80, 0x63, 0x3C,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 16, 5, 0, -16 },
  { 11, 5, 6, 6, 2, -16 },
  { 15, 9, 16, 8, 0, -16 },
  { 33, 8, 18, 8, 0, -17 },
  { 51, 10, 16, 12, 1, -16 },
  { 71, 7, 16, 8, 0, -16 },
  { 85, 2, 6, 3, 2, -16 },
  { 87, 6, 19, 5, 1, -16 },
  { 102, 7, 19, 5, -2, -16 },
  { 119, 5, 6, 7, 3, -17 },
  { 123, 7, 10, 9, 1, -13 },
  { 132, 3, 5, 4, -1, -2 },
  { 134, 5, 1, 6, 0, -6 },
  { 135, 2, 2, 4, 0, -2 },
  { 136, 9, 16, 7, -1, -16 },
  { 154, 8, 16, 8, 0, -16 },
  { 170, 5, 16, 8, 2, -16 },
  { 180, 9, 16, 8, -1, -16 },
  { 198, 8, 16, 8, 0, -16 },
  { 214, 8, 16, 8, 0, -16 },
  { 230, 9, 16, 8, -1, -16 },
  { 248, 8, 16, 8, 0, -16 },
  { 264, 8, 16, 8, 1, -16 },
  { 280, 8, 16, 8, 0, -16 },
  { 296, 8, 16, 8, 0, -16 },
  { 312, 3, 12, 4, 0, -12 },
  { 317, 5, 15, 4, -1, -12 },
  { 327, 7, 9, 9, 1, -12 },
  { 335, 7, 6, 9, 1, -11 },
  { 341, 7, 9, 9, 1, -12 },
  { 349, 6, 16, 6, 0, -16 },
  { 361, 10, 18, 12, 1, -16 },
  { 384, 7, 16, 8, -1, -16 },
  { 398, 9, 16, 8, 0, -16 },
  { 416, 8, 16, 8, 1, -16 },
  { 432, 9, 16, 9, 0, -16 },
  { 450, 8, 16, 8, 0, -16 },
  { 466, 8, 16, 7, 0, -16 },
  { 482, 10, 16, 10, 1, -16 },
  { 502, 10, 16, 10, 0, -16 },
  { 522, 7, 16, 4, -1, -16 },
  { 536, 7, 20, 4, -3, -16 },
  { 554, 10, 16, 8, 0, -16 },
  { 574, 5, 16, 7, 0, -16 },
  { 584, 14, 16, 13, 0, -16 },
  { 612, 11, 16, 10, 0, -16 },
  { 634, 9, 16, 10, 1, -16 },
  { 652, 8, 16, 8, 0, -16 },
  { 668, 9, 20, 10, 1, -16 },
  { 691, 8, 16, 8, 0, -16 },
  { 707, 9, 16, 8, -1, -16 },
  { 725, 7, 16, 7, 1, -16 },
  { 739, 9, 16, 10, 1, -16 },
  { 757, 8, 16, 8, 2, -16 },
  { 773, 13, 16, 13, 2, -16 },
  { 799, 10, 16, 7, -1, -16 },
  { 819, 8, 16, 7, 1, -16 },
  { 835, 9, 16, 7, -1, -16 },
  { 853, 7, 20, 6, 0, -16 },
  { 871, 3, 16, 7, 2, -16 },
  { 877, 7, 20, 6, -1, -16 },
  { 895, 9, 8, 9, 0, -16 },
  { 904, 6, 1, 6, -2, 2 },
  { 905, 2, 4, 5, 3, -17 },
  { 906, 7, 12, 9, 1, -12 },
  { 917, 8, 17, 8, 0, -17 },
  { 934, 6, 12, 6, 1, -12 },
  { 943, 8, 17, 9, 1, -17 },
  { 960, 6, 12, 7, 1, -12 },
  { 969, 10, 22, 4, -3, -17 },
  { 997, 8, 17, 8, 0, -12 },
  { 1014, 7, 17, 8, 0, -17 },
  { 1029, 4, 16, 4, 0, -16 },
  { 1037, 7, 21, 4, -3, -16 },
  { 1056, 8, 17, 7, 0, -17 },
  { 1073, 4, 17, 3, 0, -17 },
  { 1082, 12, 12, 12, 0, -12 },
  { 1100, 7, 12, 8, 0, -12 },
  { 1111, 7, 12, 8, 1, -12 },
  { 1122, 9, 17, 8, -1, -12 },
  { 1142, 7, 17, 9, 1, -12 },
  { 1157, 6, 12, 5, 0, -12 },
  { 1166, 6, 12, 6, 0, -12 },
  { 1175, 5, 14, 4, 0, -14 },
  { 1184, 7, 12, 8, 1, -12 },
  { 1195, 6, 12, 6, 1, -12 },
  { 1204, 10, 12, 11, 1, -12 },
  { 1219, 8, 12, 7, -1, -12 },
  { 1231, 10, 17, 7, -2, -12 },
  { 1253, 7, 12, 5, -1, -12 },
  { 1264, 7, 19, 7, 1, -16 },
  { 1281, 1, 22, 8, 3, -17 },
  { 1284, 7, 19, 7, -1, -16 },
  { 1301, 7, 2, 9, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC22PT7B_H_
