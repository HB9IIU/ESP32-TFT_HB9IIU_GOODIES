#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC19PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x22, 0x22, 0x44, 0x40, 0x08, 0x59, 0xAA, 0xA0, 0x09,
  0x0A, 0x12, 0x12, 0x7F, 0x24, 0x24, 0x28, 0x28, 0xFC, 0x50, 0x50, 0x90,
  0x90, 0x08, 0x3C, 0xA2, 0x44, 0x86, 0x04, 0x08, 0x18, 0x28, 0x91, 0x4F,
  0x84, 0x10, 0x00, 0x31, 0x51, 0x92, 0x92, 0x94, 0x94, 0xAB, 0xAD, 0xD5,
  0x19, 0x29, 0x29, 0x49, 0xCE, 0x18, 0x52, 0x49, 0x28, 0xA1, 0x0C, 0x56,
  0x58, 0xA2, 0x9B, 0xA0, 0x6A, 0x80, 0x04, 0x21, 0x04, 0x20, 0x84, 0x10,
  0x42, 0x08, 0x20, 0x82, 0x04, 0x10, 0x40, 0x10, 0x82, 0x10, 0x84, 0x21,
  0x08, 0x44, 0x21, 0x11, 0x08, 0x80, 0x27, 0x4C, 0xA9, 0x00, 0x20, 0x82,
  0x08, 0xFC, 0x82, 0x08, 0x20, 0x29, 0x60, 0xF0, 0x80, 0x01, 0x01, 0x02,
  0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x0C,
  0x24, 0x89, 0x14, 0x28, 0x51, 0x22, 0x85, 0x0A, 0x24, 0x48, 0x8E, 0x00,
  0x12, 0xE2, 0x22, 0x44, 0x44, 0x48, 0x88, 0x0E, 0x11, 0x01, 0x01, 0x01,
  0x02, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0xFC, 0x1C, 0x44, 0x08,
  0x10, 0x20, 0x8A, 0x0C, 0x08, 0x08, 0x10, 0x40, 0x9E, 0x00, 0x02, 0x0C,
  0x30, 0x61, 0x44, 0x89, 0x24, 0x49, 0x13, 0xF0, 0x41, 0x02, 0x00, 0x1E,
  0x40, 0x81, 0x04, 0x08, 0x1E, 0x02, 0x04, 0x08, 0x10, 0x40, 0x9E, 0x00,
  0x0E, 0x20, 0x81, 0x04, 0x08, 0x1F, 0x22, 0x45, 0x0A, 0x14, 0x28, 0x8E,
  0x00, 0x7C, 0x10, 0x42, 0x08, 0x41, 0x04, 0x20, 0x84, 0x10, 0x82, 0x00,
  0x1C, 0x44, 0x89, 0x12, 0x24, 0x86, 0x14, 0x49, 0x0A, 0x14, 0x28, 0x8E,
  0x00, 0x18, 0x48, 0x8A, 0x14, 0x28, 0x51, 0x26, 0x34, 0x08, 0x20, 0x41,
  0x1C, 0x00, 0x20, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x00, 0x24, 0x48,
  0x04, 0x23, 0x30, 0x81, 0x81, 0x81, 0xFC, 0x00, 0x00, 0xFC, 0x83, 0x03,
  0x03, 0x0C, 0x46, 0x20, 0x38, 0x10, 0x41, 0x08, 0x41, 0x08, 0x41, 0x04,
  0x00, 0x02, 0x00, 0x07, 0x02, 0x21, 0x04, 0x81, 0x26, 0x52, 0x95, 0x25,
  0x4A, 0x52, 0xA5, 0x29, 0x52, 0x68, 0x80, 0x10, 0x04, 0x00, 0xE0, 0x04,
  0x10, 0xC3, 0x14, 0x51, 0x49, 0x3D, 0x14, 0x51, 0x86, 0x10, 0x1C, 0x24,
  0x89, 0x12, 0x24, 0x5F, 0x22, 0x44, 0x89, 0x14, 0x28, 0x9E, 0x00, 0x0E,
  0x20, 0x82, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x0E, 0x00,
  0x1C, 0x12, 0x21, 0x21, 0x21, 0x21, 0x41, 0x42, 0x42, 0x42, 0x44, 0x84,
  0x88, 0xF0, 0x1E, 0x20, 0x81, 0x02, 0x04, 0x1F, 0x20, 0x40, 0x81, 0x04,
  0x08, 0x1F, 0x00, 0x1E, 0x20, 0x81, 0x02, 0x04, 0x10, 0x3E, 0x40, 0x81,
  0x04, 0x08, 0x10, 0x00, 0x0E, 0x11, 0x20, 0x40, 0x40, 0x80, 0x80, 0x8E,
  0x82, 0x82, 0x84, 0x84, 0x84, 0x7C, 0x10, 0x88, 0x48, 0x24, 0x22, 0x11,
  0x09, 0xF4, 0x84, 0x42, 0x21, 0x10, 0x90, 0x48, 0x44, 0x20, 0x1C, 0x21,
  0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x10, 0x43, 0x80, 0x02, 0x04, 0x10,
  0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0xE0,
  0x11, 0x11, 0x22, 0x24, 0x28, 0x28, 0x50, 0x70, 0x50, 0x48, 0x48, 0x88,
  0x88, 0x84, 0x11, 0x22, 0x22, 0x44, 0x44, 0x48, 0x8F, 0x10, 0x11, 0x02,
  0x30, 0x63, 0x06, 0x30, 0x63, 0x0A, 0x50, 0xA5, 0x14, 0x51, 0x44, 0xA4,
  0x4A, 0x48, 0xC8, 0x8C, 0x88, 0x88, 0x10, 0x88, 0x4C, 0x26, 0x12, 0x89,
  0x49, 0x24, 0x92, 0x49, 0x23, 0x11, 0x90, 0xC8, 0x64, 0x20, 0x1C, 0x44,
  0x8A, 0x14, 0x30, 0x60, 0xC1, 0x83, 0x0A, 0x14, 0x28, 0x9E, 0x00, 0x1C,
  0x24, 0x89, 0x12, 0x24, 0x51, 0x3C, 0x40, 0x81, 0x04, 0x08, 0x10, 0x00,
  0x1C, 0x44, 0x8A, 0x14, 0x30, 0x60, 0xC1, 0x83, 0x0A, 0x14, 0x28, 0x9A,
  0x08, 0x08, 0x10, 0x1C, 0x24, 0x89, 0x12, 0x24, 0x51, 0x3C, 0x50, 0x91,
  0x24, 0x48, 0x91, 0x00, 0x0E, 0x11, 0x10, 0x20, 0x20, 0x10, 0x10, 0x08,
  0x04, 0x04, 0x02, 0x04, 0x04, 0xF8, 0x7C, 0x41, 0x08, 0x20, 0x82, 0x10,
  0x41, 0x04, 0x10, 0x82, 0x00, 0x21, 0x41, 0x42, 0x42, 0x42, 0x42, 0x84,
  0x84, 0x84, 0x84, 0x84, 0x88, 0x88, 0xF0, 0x86, 0x18, 0x62, 0x8A, 0x49,
  0x28, 0xA2, 0x8C, 0x30, 0x82, 0x00, 0x82, 0x18, 0x21, 0x86, 0x28, 0x62,
  0x8A, 0x48, 0xA4, 0x92, 0x49, 0x28, 0x92, 0x8A, 0x30, 0xA3, 0x0C, 0x50,
  0xC2, 0x0C, 0x20, 0x11, 0x11, 0x12, 0x12, 0x0C, 0x0C, 0x08, 0x08, 0x18,
  0x28, 0x28, 0x48, 0x48, 0x84, 0x85, 0x14, 0x92, 0x51, 0x46, 0x18, 0x41,
  0x04, 0x10, 0x82, 0x00, 0x1F, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x40, 0xF8, 0x1C, 0x41, 0x08, 0x20, 0x82, 0x10,
  0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0xE0, 0x92, 0x49, 0x12, 0x49, 0x24,
  0x40, 0x1E, 0x04, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81,
  0x02, 0x04, 0x08, 0xE0, 0x08, 0x30, 0x51, 0x22, 0x48, 0x70, 0x80, 0xF8,
  0xAC, 0x3D, 0x18, 0x61, 0x8A, 0x28, 0xA2, 0x93, 0xC0, 0x10, 0x20, 0x81,
  0x03, 0xC4, 0x48, 0xA1, 0x42, 0x85, 0x12, 0x2C, 0x9E, 0x00, 0x3A, 0x21,
  0x08, 0x42, 0x10, 0x87, 0x00, 0x02, 0x04, 0x08, 0x23, 0xC8, 0xA1, 0x42,
  0x89, 0x12, 0x24, 0x49, 0x1E, 0x00, 0x1C, 0x94, 0x51, 0x7A, 0x08, 0x20,
  0x41, 0xE0, 0x03, 0x04, 0x04, 0x04, 0x08, 0x1C, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x80, 0x1E, 0x45,
  0x0A, 0x14, 0x48, 0xA1, 0x42, 0x88, 0xF0, 0x20, 0x40, 0x92, 0x18, 0x00,
  0x10, 0x42, 0x08, 0x3C, 0x92, 0x51, 0x45, 0x14, 0x62, 0x8A, 0x20, 0x11,
  0x00, 0x22, 0x24, 0x44, 0x48, 0x88, 0x02, 0x04, 0x00, 0x00, 0x40, 0x81,
  0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x20, 0x43, 0x00, 0x10,
  0x20, 0x81, 0x02, 0x64, 0x8A, 0x28, 0x70, 0xA1, 0x44, 0x88, 0x91, 0x00,
  0x11, 0x22, 0x22, 0x24, 0x44, 0x48, 0x88, 0x3D, 0xC8, 0x92, 0x45, 0x11,
  0x44, 0x51, 0x24, 0x8A, 0x22, 0x88, 0xA2, 0x20, 0x3C, 0x92, 0x51, 0x45,
  0x14, 0x62, 0x8A, 0x20, 0x3A, 0x63, 0x18, 0xC6, 0x31, 0x97, 0x00, 0x1E,
  0x11, 0x11, 0x21, 0x21, 0x21, 0x22, 0x22, 0x64, 0x78, 0x40, 0x40, 0x80,
  0x80, 0x3D, 0x18, 0x61, 0x8A, 0x28, 0xA2, 0x93, 0xC1, 0x04, 0x10, 0xC0,
  0x39, 0x08, 0x84, 0x21, 0x10, 0x84, 0x00, 0x3D, 0x04, 0x10, 0x20, 0x41,
  0x04, 0x13, 0x80, 0x22, 0x72, 0x44, 0x44, 0x48, 0x8E, 0x22, 0x45, 0x12,
  0x24, 0x48, 0x91, 0x44, 0x88, 0xF0, 0x8C, 0x65, 0x2A, 0x52, 0x98, 0xC4,
  0x00, 0x88, 0xC4, 0xA6, 0x53, 0x2A, 0xA5, 0x53, 0x29, 0x98, 0x8C, 0x44,
  0x00, 0x22, 0x28, 0x50, 0xC1, 0x02, 0x0A, 0x14, 0x49, 0x10, 0x10, 0x88,
  0x84, 0x42, 0x41, 0x20, 0xA0, 0x50, 0x28, 0x08, 0x04, 0x04, 0x02, 0x02,
  0x01, 0x03, 0x00, 0x1C, 0x10, 0x82, 0x10, 0x82, 0x10, 0x43, 0xC0, 0x04,
  0x61, 0x08, 0x20, 0x82, 0x08, 0xC1, 0x04, 0x10, 0x42, 0x08, 0x20, 0x60,
  0xFF, 0xFF, 0xE0, 0x18, 0x10, 0x41, 0x08, 0x20, 0x82, 0x04, 0x21, 0x04,
  0x10, 0x82, 0x08, 0xC0, 0x42, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 14, 4, 0, -14 },
  { 8, 4, 5, 5, 2, -14 },
  { 11, 8, 14, 7, 0, -14 },
  { 25, 7, 15, 7, 0, -14 },
  { 39, 8, 14, 10, 1, -14 },
  { 53, 6, 14, 7, 0, -14 },
  { 64, 2, 5, 3, 2, -14 },
  { 66, 6, 17, 5, 0, -14 },
  { 79, 5, 17, 5, -1, -14 },
  { 90, 5, 5, 6, 2, -14 },
  { 94, 6, 9, 8, 1, -11 },
  { 101, 3, 4, 3, -1, -2 },
  { 103, 4, 1, 5, 0, -6 },
  { 104, 1, 1, 3, 0, -1 },
  { 105, 8, 14, 6, -1, -14 },
  { 119, 7, 14, 7, 0, -14 },
  { 132, 4, 14, 7, 2, -14 },
  { 139, 8, 14, 7, -1, -14 },
  { 153, 7, 14, 7, 0, -14 },
  { 166, 7, 14, 7, 0, -14 },
  { 179, 7, 14, 7, 0, -14 },
  { 192, 7, 14, 7, 0, -14 },
  { 205, 6, 14, 7, 1, -14 },
  { 216, 7, 14, 7, 0, -14 },
  { 229, 7, 14, 7, 0, -14 },
  { 242, 3, 10, 3, 0, -10 },
  { 246, 4, 12, 3, -1, -10 },
  { 252, 6, 8, 8, 1, -11 },
  { 258, 6, 5, 8, 1, -9 },
  { 262, 6, 8, 8, 1, -11 },
  { 268, 6, 14, 5, 0, -14 },
  { 279, 10, 16, 10, 0, -14 },
  { 299, 6, 14, 7, -1, -14 },
  { 310, 7, 14, 7, 0, -14 },
  { 323, 7, 14, 7, 1, -14 },
  { 336, 8, 14, 8, 0, -14 },
  { 350, 7, 14, 7, 0, -14 },
  { 363, 7, 14, 6, 0, -14 },
  { 376, 8, 14, 9, 1, -14 },
  { 390, 9, 14, 9, 0, -14 },
  { 406, 6, 14, 4, -1, -14 },
  { 417, 7, 17, 3, -3, -14 },
  { 432, 8, 14, 7, 0, -14 },
  { 446, 4, 14, 6, 0, -14 },
  { 453, 12, 14, 11, 0, -14 },
  { 474, 9, 14, 9, 0, -14 },
  { 490, 7, 14, 9, 1, -14 },
  { 503, 7, 14, 7, 0, -14 },
  { 516, 7, 17, 9, 1, -14 },
  { 531, 7, 14, 7, 0, -14 },
  { 544, 8, 14, 7, -1, -14 },
  { 558, 6, 14, 6, 1, -14 },
  { 569, 8, 14, 8, 1, -14 },
  { 583, 6, 14, 7, 2, -14 },
  { 594, 12, 14, 12, 1, -14 },
  { 615, 8, 14, 6, -1, -14 },
  { 629, 6, 14, 6, 1, -14 },
  { 640, 8, 14, 6, -1, -14 },
  { 654, 6, 17, 5, 0, -14 },
  { 667, 3, 14, 6, 2, -14 },
  { 673, 7, 17, 5, -1, -14 },
  { 688, 7, 7, 7, 0, -14 },
  { 695, 5, 1, 5, -1, 1 },
  { 696, 2, 3, 4, 3, -15 },
  { 697, 6, 10, 7, 1, -10 },
  { 705, 7, 14, 7, 0, -14 },
  { 718, 5, 10, 5, 1, -10 },
  { 725, 7, 14, 7, 1, -14 },
  { 738, 6, 10, 6, 0, -10 },
  { 746, 8, 20, 4, -2, -15 },
  { 766, 7, 15, 7, 0, -10 },
  { 780, 6, 14, 7, 0, -14 },
  { 791, 4, 14, 3, 0, -14 },
  { 798, 7, 19, 3, -3, -14 },
  { 815, 7, 14, 6, 0, -14 },
  { 828, 4, 14, 3, 0, -14 },
  { 835, 10, 10, 11, 0, -10 },
  { 848, 6, 10, 7, 0, -10 },
  { 856, 5, 10, 7, 1, -10 },
  { 863, 8, 14, 7, -1, -10 },
  { 877, 6, 14, 7, 1, -10 },
  { 888, 5, 10, 5, 0, -10 },
  { 895, 6, 10, 5, 0, -10 },
  { 903, 4, 12, 4, 0, -12 },
  { 909, 7, 10, 7, 0, -10 },
  { 918, 5, 10, 5, 1, -10 },
  { 925, 9, 10, 9, 1, -10 },
  { 937, 7, 10, 6, -1, -10 },
  { 946, 9, 15, 6, -2, -10 },
  { 963, 6, 10, 5, -1, -10 },
  { 971, 6, 17, 6, 1, -14 },
  { 984, 1, 19, 7, 3, -14 },
  { 987, 6, 17, 6, -1, -14 },
  { 1000, 6, 2, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC19PT7B_H_
