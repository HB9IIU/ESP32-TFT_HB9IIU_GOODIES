#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC52PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x00,
  0x38, 0x66, 0x0C, 0xC3, 0x18, 0x63, 0x0C, 0xC1, 0x98, 0x23, 0x0C, 0x61,
  0x88, 0x33, 0x04, 0x60, 0x8C, 0x30, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80,
  0x06, 0x0C, 0x00, 0x60, 0x40, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0x81,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x02, 0x04, 0x00, 0x30, 0x62, 0x1F,
  0xFF, 0xE0, 0x08, 0x10, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x20, 0x60,
  0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x04, 0x08, 0x00, 0x60,
  0xC0, 0x03, 0x06, 0x00, 0x10, 0x20, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80,
  0x40, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x03, 0x00, 0x18, 0x30,
  0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x60, 0x40, 0x03, 0x06, 0x00, 0x18,
  0x30, 0x00, 0x81, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x00, 0x7F,
  0xF8, 0x1C, 0x43, 0x07, 0x08, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x06, 0x08,
  0x00, 0xC1, 0x00, 0x18, 0x20, 0x03, 0x0C, 0x00, 0x21, 0x80, 0x06, 0x20,
  0x00, 0xE4, 0x00, 0x0C, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x02, 0xC0, 0x00, 0xDC, 0x00, 0x19, 0x80, 0x02, 0x18,
  0x00, 0x43, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x41, 0x80, 0x08, 0x30,
  0x01, 0x06, 0x00, 0x61, 0x80, 0x0C, 0x70, 0x61, 0x1C, 0x0F, 0xFF, 0x00,
  0x7F, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x0C, 0x06, 0x70, 0x0C,
  0x0C, 0x30, 0x18, 0x18, 0x30, 0x18, 0x18, 0x30, 0x30, 0x10, 0x30, 0x30,
  0x30, 0x30, 0x60, 0x30, 0x30, 0x60, 0x20, 0x30, 0xC0, 0x60, 0x20, 0xC0,
  0x60, 0x61, 0x80, 0x60, 0x61, 0x80, 0x60, 0x63, 0x00, 0x40, 0x63, 0x00,
  0x40, 0x46, 0x08, 0xC0, 0xC6, 0x3E, 0xC0, 0xCC, 0x63, 0xC1, 0x8C, 0xC3,
  0xC1, 0x99, 0x83, 0x43, 0x19, 0x83, 0x67, 0x31, 0x03, 0x7E, 0x33, 0x03,
  0x18, 0x63, 0x03, 0x00, 0x62, 0x03, 0x00, 0xC6, 0x03, 0x00, 0xC6, 0x06,
  0x01, 0x86, 0x06, 0x01, 0x86, 0x06, 0x03, 0x04, 0x06, 0x03, 0x04, 0x04,
  0x06, 0x0C, 0x0C, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x0C, 0x04, 0x18,
  0x18, 0x04, 0x30, 0x18, 0x06, 0x70, 0x30, 0x07, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x0F, 0xC0, 0x06, 0x30, 0x03, 0x06, 0x00, 0xC1, 0x80,
  0x30, 0x60, 0x18, 0x18, 0x06, 0x06, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18,
  0x30, 0x06, 0x18, 0x01, 0x86, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x03, 0x60,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0x60, 0x03,
  0x98, 0x00, 0xC6, 0x0C, 0x60, 0xC3, 0x38, 0x31, 0x8C, 0x0C, 0x66, 0x01,
  0x19, 0x80, 0x6C, 0x60, 0x1B, 0x18, 0x06, 0x8C, 0x00, 0xE3, 0x00, 0x30,
  0xC0, 0x0C, 0x38, 0x07, 0x06, 0x03, 0x61, 0x81, 0x98, 0x38, 0xC6, 0x0F,
  0xE0, 0xC0, 0x40, 0x00, 0x39, 0x8C, 0x63, 0x31, 0x8C, 0x62, 0x11, 0x8C,
  0x00, 0x00, 0x0E, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x08, 0x00, 0x41, 0x06, 0x0E, 0x30, 0x1D,
  0x0C, 0x3F, 0xE0, 0xE0, 0x0D, 0x00, 0xC8, 0x0C, 0x21, 0xC1, 0x84, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x06, 0x18, 0x30, 0x61,
  0x83, 0x0C, 0x18, 0x60, 0xC3, 0x04, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x3F, 0x00, 0x39, 0xC0, 0x30, 0x70, 0x38,
  0x18, 0x18, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xC3,
  0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03,
  0x30, 0x03, 0x98, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00,
  0x19, 0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x03, 0x18,
  0x01, 0x8C, 0x00, 0xC6, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x60, 0xC0, 0x30,
  0x60, 0x30, 0x18, 0x18, 0x0C, 0x18, 0x07, 0x38, 0x01, 0xF8, 0x00, 0x30,
  0x00, 0x01, 0x83, 0xC3, 0xE3, 0xB3, 0x93, 0x1B, 0x0D, 0x06, 0x03, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFC,
  0x00, 0xE0, 0xE0, 0x0C, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x03,
  0xE1, 0xC0, 0x18, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x08, 0x03, 0x80,
  0xE0, 0xF0, 0x0F, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00,
  0x06, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0x80,
  0x03, 0x18, 0x00, 0x21, 0x80, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x10,
  0x01, 0x83, 0x00, 0x10, 0x30, 0x03, 0x03, 0x00, 0x60, 0x30, 0x06, 0x06,
  0x00, 0xC0, 0x60, 0x08, 0x06, 0x01, 0x80, 0x60, 0x30, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x0C, 0x0C, 0x00, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x80, 0x38, 0x0E, 0x1F,
  0x00, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x07, 0xA0, 0x03, 0xF8, 0x01,
  0xE1, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x87, 0x00, 0x33, 0xF8, 0x06, 0xC3,
  0x81, 0xB0, 0x38, 0x3C, 0x03, 0x07, 0x00, 0x60, 0xE0, 0x0C, 0x18, 0x00,
  0x83, 0x00, 0x30, 0xE0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03,
  0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x38, 0x03, 0x9E, 0x00, 0x3F, 0x80,
  0x01, 0x80, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x07, 0xF8, 0x00, 0xE1, 0xC0, 0x1C,
  0x06, 0x01, 0x80, 0x60, 0x30, 0x03, 0x03, 0x00, 0x30, 0x30, 0x03, 0x03,
  0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60,
  0x30, 0x0C, 0x01, 0x81, 0x80, 0x18, 0x30, 0x00, 0xC6, 0x00, 0x0F, 0xC0,
  0x00, 0x70, 0x00, 0x1F, 0x80, 0x03, 0x9C, 0x00, 0xE0, 0xC0, 0x1C, 0x06,
  0x01, 0x80, 0x60, 0x30, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00,
  0x30, 0x60, 0x01, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x60,
  0x03, 0x06, 0x00, 0x60, 0x60, 0x06, 0x03, 0x00, 0xC0, 0x1C, 0x38, 0x00,
  0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xC0, 0x1C, 0x38,
  0x0E, 0x06, 0x03, 0x01, 0x81, 0x80, 0x30, 0x60, 0x0C, 0x30, 0x03, 0x0C,
  0x00, 0xC3, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00,
  0x31, 0x80, 0x0C, 0x60, 0x07, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x38,
  0x60, 0x1E, 0x0C, 0x0D, 0x83, 0x86, 0x60, 0x7F, 0x30, 0x07, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x87, 0x80, 0x3F, 0x80, 0x01, 0x00, 0x00, 0x02, 0x07, 0x07,
  0x07, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0,
  0xC0, 0x00, 0x40, 0x30, 0x1C, 0x07, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x3F, 0xC1, 0xC3, 0x82, 0x07, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x0C,
  0x00, 0x18, 0x0C, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x06, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x43, 0x00, 0xF0, 0x21, 0x80, 0xFC, 0x11,
  0x81, 0xC6, 0x08, 0xC0, 0xC3, 0x04, 0x60, 0xC1, 0x02, 0x60, 0xC1, 0x83,
  0x30, 0x60, 0xC1, 0x98, 0x20, 0x60, 0xC8, 0x30, 0x20, 0x6C, 0x18, 0x30,
  0x26, 0x08, 0x18, 0x33, 0x0C, 0x0C, 0x19, 0x86, 0x04, 0x0C, 0x83, 0x06,
  0x04, 0x41, 0x83, 0x06, 0x60, 0xC1, 0x83, 0x30, 0x61, 0xC3, 0x18, 0x30,
  0xE1, 0x8C, 0x18, 0xB1, 0x86, 0x0F, 0xCF, 0x83, 0x03, 0xC7, 0x81, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x10, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xA0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x6C, 0x00,
  0x36, 0x00, 0x13, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x0C, 0x60, 0x06, 0x30,
  0x02, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x40,
  0xC0, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x1F, 0xFC, 0x1F, 0xFE, 0x0C,
  0x03, 0x06, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x63, 0x80, 0x31, 0x80, 0x18,
  0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x18, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0x80,
  0xE0, 0x18, 0x07, 0x01, 0x80, 0x30, 0x18, 0x03, 0x01, 0x80, 0x30, 0x30,
  0x03, 0x03, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x20, 0x06, 0x06,
  0x00, 0x60, 0x60, 0x0E, 0x06, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x1F, 0x00,
  0xFF, 0x80, 0x0C, 0x3E, 0x00, 0xC0, 0x70, 0x0C, 0x03, 0x01, 0x80, 0x18,
  0x18, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x18, 0x30, 0x01,
  0x83, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x38, 0x20, 0x03, 0x06, 0x00,
  0x30, 0x60, 0x06, 0x06, 0x00, 0xC0, 0x60, 0x38, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFF, 0x00, 0x78, 0x30, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x30, 0x00, 0xFF,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x60, 0x38,
  0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x60,
  0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x30,
  0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00,
  0x38, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x0C,
  0x00, 0x38, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x80, 0x06,
  0x0C, 0x00, 0x30, 0x60, 0x03, 0x83, 0x00, 0x18, 0x18, 0x01, 0x81, 0x80,
  0x1C, 0x0C, 0x00, 0xC0, 0x60, 0x0C, 0x03, 0x01, 0xC0, 0x18, 0x1C, 0x01,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x3F, 0xF0, 0x01, 0xF0, 0x78, 0x07, 0x00, 0x20,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x3F, 0x8C, 0x00, 0xFE,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61,
  0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0,
  0x03, 0x01, 0xC0, 0x04, 0x01, 0xC0, 0x18, 0x01, 0xF0, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x01,
  0x80, 0x03, 0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x01,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x08, 0x06, 0x00, 0x18, 0x06,
  0x00, 0x18, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0F, 0xFF, 0xF0, 0x0C,
  0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x60, 0x18, 0x00, 0x60, 0x18, 0x00, 0x60, 0x10, 0x00, 0x60, 0x30,
  0x00, 0x40, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x00, 0x00, 0xFF, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x00,
  0x00, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x60, 0x06, 0x03, 0x00, 0x10, 0x1C, 0x00, 0xC0, 0x60, 0x03, 0x03,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0xE0, 0x01, 0x83, 0x00, 0x06, 0x18, 0x00,
  0x18, 0xE0, 0x00, 0x63, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x37,
  0x80, 0x00, 0xD6, 0x00, 0x03, 0xD8, 0x00, 0x0E, 0x60, 0x00, 0x70, 0xC0,
  0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x40, 0xE0, 0x03,
  0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0,
  0x30, 0x01, 0x80, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x36, 0x01, 0x60, 0x00, 0x36, 0x03, 0x60, 0x00, 0x6C, 0x03, 0x60,
  0x00, 0x6C, 0x03, 0x60, 0x00, 0xCC, 0x03, 0x60, 0x00, 0xCC, 0x06, 0x60,
  0x01, 0x8C, 0x06, 0x20, 0x01, 0x98, 0x06, 0x20, 0x03, 0x18, 0x06, 0x20,
  0x03, 0x18, 0x06, 0x30, 0x03, 0x18, 0x0C, 0x30, 0x06, 0x30, 0x0C, 0x30,
  0x06, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x08, 0x30,
  0x18, 0x30, 0x18, 0x30, 0x18, 0x60, 0x18, 0x30, 0x30, 0x60, 0x18, 0x30,
  0x30, 0x60, 0x18, 0x30, 0x60, 0x60, 0x10, 0x30, 0x60, 0x60, 0x30, 0x30,
  0xC0, 0xC0, 0x30, 0x30, 0xC0, 0xC0, 0x30, 0x31, 0x80, 0xC0, 0x30, 0x31,
  0x80, 0xC0, 0x60, 0x33, 0x00, 0x80, 0x60, 0x33, 0x01, 0x80, 0x60, 0x16,
  0x01, 0x80, 0x60, 0x16, 0x01, 0x80, 0x60, 0x1E, 0x01, 0x80, 0xC0, 0x1C,
  0x03, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x70, 0x00,
  0xC0, 0x78, 0x00, 0x60, 0x3C, 0x00, 0x30, 0x1E, 0x00, 0x30, 0x0D, 0x00,
  0x18, 0x04, 0xC0, 0x0C, 0x06, 0x60, 0x06, 0x03, 0x30, 0x02, 0x01, 0x98,
  0x03, 0x00, 0xCC, 0x01, 0x80, 0xC2, 0x00, 0xC0, 0x61, 0x80, 0x60, 0x30,
  0xC0, 0x20, 0x18, 0x60, 0x30, 0x0C, 0x30, 0x18, 0x0C, 0x18, 0x0C, 0x06,
  0x06, 0x06, 0x03, 0x03, 0x06, 0x01, 0x81, 0x83, 0x00, 0xC0, 0xC1, 0x80,
  0xC0, 0x60, 0xC0, 0x60, 0x10, 0x60, 0x30, 0x0C, 0x60, 0x18, 0x06, 0x30,
  0x08, 0x03, 0x18, 0x0C, 0x01, 0x8C, 0x06, 0x00, 0xC4, 0x03, 0x00, 0x36,
  0x01, 0x80, 0x1B, 0x01, 0x80, 0x0D, 0x80, 0xC0, 0x06, 0xC0, 0x60, 0x03,
  0x40, 0x30, 0x01, 0xE0, 0x18, 0x00, 0x70, 0x18, 0x00, 0x38, 0x0C, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFE, 0x00, 0x3C, 0x78, 0x03, 0x80,
  0xC0, 0x18, 0x03, 0x01, 0x80, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x07, 0x0C,
  0x00, 0x18, 0x60, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x33, 0x80, 0x01,
  0x98, 0x00, 0x1C, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00,
  0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x6E, 0x00, 0x06, 0x60, 0x00, 0x33,
  0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0xE6, 0x00, 0x06, 0x30, 0x00,
  0x31, 0x80, 0x03, 0x8C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x0C, 0x18,
  0x00, 0x60, 0xC0, 0x06, 0x07, 0x00, 0x70, 0x18, 0x07, 0x00, 0xE0, 0x70,
  0x03, 0x8F, 0x00, 0x0F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x01, 0x81, 0xC0, 0x18, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x70, 0x30, 0x03, 0x03, 0x00, 0x30, 0x30, 0x07, 0x03, 0x00,
  0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0xC0, 0x60,
  0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x38, 0x0C, 0x07, 0x00, 0xCF, 0xC0, 0x0F,
  0xF0, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFE, 0x00,
  0x3C, 0x78, 0x03, 0x80, 0xC0, 0x18, 0x03, 0x01, 0x80, 0x18, 0x18, 0x00,
  0xC0, 0xC0, 0x07, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC6, 0x00, 0x06, 0x30,
  0x00, 0x33, 0x80, 0x01, 0x98, 0x00, 0x1C, 0xC0, 0x00, 0xC6, 0x00, 0x06,
  0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x6E, 0x00,
  0x07, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0xE6,
  0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x03, 0x8C, 0x00, 0x18, 0x60, 0x00,
  0xC3, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x06, 0x07, 0x00, 0x70, 0x18,
  0x07, 0x00, 0xE0, 0x70, 0x03, 0x8F, 0x00, 0x0F, 0xF0, 0x00, 0x0B, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x01, 0x81, 0xC0, 0x18, 0x0E, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x70, 0x30, 0x03, 0x03, 0x00, 0x70, 0x30, 0x06, 0x03,
  0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x0E, 0x06, 0x00, 0xC0,
  0x60, 0x1C, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x0E, 0x00, 0xFF, 0xC0,
  0x0F, 0xF0, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x18, 0x30,
  0x01, 0x03, 0x00, 0x30, 0x18, 0x03, 0x01, 0x80, 0x30, 0x18, 0x03, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60,
  0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFF,
  0x80, 0x3C, 0x1E, 0x03, 0x80, 0x20, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x01, 0x00, 0x70, 0x0F, 0x8F, 0x00, 0x7F, 0xF0, 0x00, 0x10,
  0x00, 0x00, 0x3F, 0xFF, 0xBF, 0xFF, 0xC0, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x0C,
  0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x10,
  0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00,
  0xC1, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81,
  0x80, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18,
  0x18, 0x00, 0x40, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x03,
  0x00, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x06, 0x03, 0x80, 0x1E, 0x3C, 0x00,
  0x3F, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00,
  0x07, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00,
  0x30, 0xC0, 0x06, 0x18, 0x01, 0xC3, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x01,
  0x81, 0x80, 0x30, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C,
  0x03, 0x01, 0x80, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x30, 0x60,
  0x06, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x18, 0x00, 0x63, 0x00,
  0x0C, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0xC0, 0x03, 0x80, 0x06, 0xC0, 0x03, 0x80, 0x0C, 0xC0, 0x03,
  0x80, 0x0C, 0xC0, 0x07, 0x80, 0x0C, 0xC0, 0x07, 0x80, 0x18, 0xC0, 0x0D,
  0x80, 0x18, 0xC0, 0x0D, 0x80, 0x30, 0xC0, 0x09, 0x80, 0x30, 0xC0, 0x19,
  0x80, 0x30, 0xC0, 0x19, 0x80, 0x60, 0xC0, 0x31, 0x80, 0x60, 0xC0, 0x31,
  0x80, 0xC0, 0xC0, 0x31, 0x80, 0xC0, 0xC0, 0x61, 0x80, 0xC0, 0xC0, 0x61,
  0x01, 0x80, 0xC0, 0x41, 0x01, 0x80, 0xC0, 0xC1, 0x03, 0x00, 0xC0, 0xC1,
  0x03, 0x00, 0xC1, 0x81, 0x03, 0x00, 0xC1, 0x81, 0x06, 0x00, 0xC1, 0x01,
  0x06, 0x00, 0xC3, 0x03, 0x0C, 0x00, 0xC3, 0x03, 0x0C, 0x00, 0xC6, 0x03,
  0x0C, 0x00, 0xC6, 0x03, 0x18, 0x00, 0xC4, 0x03, 0x18, 0x00, 0xCC, 0x03,
  0x30, 0x00, 0xCC, 0x03, 0x30, 0x00, 0xD8, 0x03, 0x30, 0x00, 0xD8, 0x03,
  0x60, 0x00, 0xD8, 0x03, 0x60, 0x00, 0xF0, 0x03, 0x40, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03,
  0x00, 0xC0, 0x02, 0x01, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x8C,
  0x00, 0x01, 0x30, 0x00, 0x02, 0x60, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x01,
  0x8C, 0x00, 0x07, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60,
  0x40, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x06,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60,
  0x00, 0x60, 0x01, 0xB0, 0x01, 0x88, 0x00, 0xC6, 0x00, 0xC3, 0x00, 0x61,
  0x80, 0x60, 0xC0, 0x30, 0x60, 0x30, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x0C,
  0x06, 0x0C, 0x03, 0x06, 0x00, 0x86, 0x00, 0x43, 0x00, 0x33, 0x00, 0x19,
  0x80, 0x0D, 0x80, 0x06, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xF8, 0x00, 0xC0, 0x81, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x20, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x08, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x81,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x00, 0x7F, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x19, 0x80,
  0x03, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0,
  0x30, 0x0C, 0x06, 0x01, 0x81, 0x80, 0x18, 0x30, 0x03, 0x0C, 0x00, 0x31,
  0x80, 0x06, 0x60, 0x00, 0xDC, 0x00, 0x0C, 0xFF, 0xFC, 0xC6, 0x30, 0xC6,
  0x18, 0x43, 0x00, 0x78, 0x00, 0x3F, 0xCC, 0x0E, 0x09, 0x03, 0x81, 0xE0,
  0x60, 0x1C, 0x18, 0x03, 0x83, 0x00, 0x70, 0xC0, 0x0C, 0x18, 0x01, 0x86,
  0x00, 0x30, 0xC0, 0x06, 0x18, 0x01, 0x87, 0x00, 0x30, 0xC0, 0x06, 0x18,
  0x00, 0xC3, 0x00, 0x18, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x60,
  0x07, 0x0C, 0x00, 0xE1, 0x80, 0x18, 0x18, 0x07, 0x03, 0x00, 0xE0, 0x60,
  0x2C, 0x0E, 0x0D, 0x00, 0xE7, 0x20, 0x0F, 0xCC, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x31, 0xF0, 0x06, 0x7F, 0x00, 0xD8, 0x70, 0x34,
  0x06, 0x07, 0x80, 0xC0, 0xE0, 0x18, 0x18, 0x03, 0x03, 0x00, 0x70, 0xE0,
  0x0E, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x08, 0x00, 0xC3, 0x00,
  0x18, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x18, 0x60, 0x03, 0x0C, 0x00,
  0x61, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x61, 0xC0, 0x18, 0x38, 0x07,
  0x07, 0x80, 0xC0, 0xB0, 0x30, 0x13, 0x9C, 0x06, 0x3F, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xFC, 0x0F, 0xF0, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x18,
  0x0F, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x07, 0xC6, 0x00, 0xFF, 0x30, 0x0E, 0x1B, 0x00, 0xE0, 0x78, 0x06, 0x01,
  0xC0, 0x60, 0x0E, 0x03, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x18,
  0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x18,
  0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80,
  0x18, 0x18, 0x01, 0xC0, 0xC0, 0x0E, 0x06, 0x00, 0x60, 0x18, 0x07, 0x00,
  0xC0, 0x38, 0x06, 0x02, 0xC0, 0x38, 0x34, 0x00, 0xE7, 0x20, 0x03, 0xF3,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x78, 0x01, 0xFE, 0x03, 0x86, 0x07, 0x03,
  0x06, 0x03, 0x0C, 0x03, 0x1C, 0x03, 0x18, 0x06, 0x38, 0x06, 0x30, 0x0E,
  0x30, 0x0C, 0x70, 0x38, 0x60, 0x70, 0x7F, 0xC0, 0x7F, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x10, 0x38, 0x60, 0x1F, 0xE0,
  0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x07, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x02, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03,
  0xFC, 0xC0, 0x38, 0x64, 0x03, 0x81, 0xE0, 0x18, 0x07, 0x01, 0x80, 0x38,
  0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00,
  0x18, 0x18, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x03,
  0x00, 0x18, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x60, 0x07,
  0x03, 0x00, 0x38, 0x18, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18,
  0x0B, 0x00, 0xC0, 0xD0, 0x03, 0x9D, 0x80, 0x0F, 0xCC, 0x00, 0x10, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x40, 0x38, 0x03,
  0x87, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x1F, 0x00, 0xDF,
  0xE0, 0x2C, 0x18, 0x1A, 0x03, 0x07, 0x00, 0xC1, 0xC0, 0x30, 0x60, 0x08,
  0x18, 0x06, 0x0E, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x04, 0x08,
  0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x02, 0x04, 0x01,
  0x83, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x06, 0x00, 0xC1,
  0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x01, 0x83, 0x00, 0x60, 0x00,
  0xC0, 0x70, 0x1C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x01, 0x38, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x40, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x06, 0x01, 0x83, 0x00,
  0x61, 0xC0, 0x10, 0x60, 0x0C, 0x30, 0x03, 0x18, 0x00, 0xCE, 0x00, 0x33,
  0x00, 0x19, 0xC0, 0x06, 0xF0, 0x01, 0xE6, 0x00, 0x71, 0x80, 0x1C, 0x60,
  0x0E, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x30, 0x08, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x01, 0x03, 0x00,
  0x60, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x01, 0x1E, 0x07, 0x80,
  0x27, 0xF1, 0xFE, 0x02, 0xC1, 0xB0, 0x60, 0x78, 0x1E, 0x06, 0x07, 0x01,
  0xC0, 0x30, 0x70, 0x1C, 0x02, 0x06, 0x01, 0x80, 0x60, 0x60, 0x18, 0x06,
  0x0C, 0x01, 0x80, 0x60, 0xC0, 0x18, 0x06, 0x0C, 0x03, 0x00, 0x60, 0xC0,
  0x30, 0x0C, 0x08, 0x03, 0x00, 0xC1, 0x80, 0x30, 0x0C, 0x18, 0x02, 0x00,
  0xC1, 0x80, 0x60, 0x08, 0x18, 0x06, 0x01, 0x83, 0x00, 0x60, 0x18, 0x30,
  0x06, 0x01, 0x83, 0x00, 0xC0, 0x18, 0x30, 0x0C, 0x01, 0x03, 0x00, 0xC0,
  0x30, 0x60, 0x0C, 0x03, 0x06, 0x00, 0xC0, 0x30, 0x60, 0x18, 0x03, 0x06,
  0x01, 0x80, 0x60, 0x40, 0x18, 0x06, 0x0C, 0x01, 0x80, 0x60, 0x01, 0x1E,
  0x00, 0x9F, 0xE0, 0x2C, 0x18, 0x1A, 0x07, 0x07, 0x00, 0xC1, 0xC0, 0x30,
  0x60, 0x08, 0x18, 0x06, 0x0E, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x30,
  0x04, 0x08, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x06,
  0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x06,
  0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x04, 0x01, 0x83, 0x00,
  0x60, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xE1, 0xC0, 0xE0, 0x60, 0xE0, 0x30,
  0x60, 0x0C, 0x70, 0x06, 0x30, 0x03, 0x18, 0x01, 0x98, 0x00, 0xCC, 0x00,
  0x66, 0x00, 0x36, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60,
  0x03, 0x30, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0xC6, 0x00, 0x63,
  0x00, 0x70, 0xC0, 0x30, 0x60, 0x30, 0x38, 0x38, 0x0E, 0x78, 0x03, 0xF8,
  0x00, 0x20, 0x00, 0x00, 0x47, 0xC0, 0x04, 0x7F, 0x00, 0x26, 0x1C, 0x03,
  0x60, 0x60, 0x1E, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x60, 0x30, 0x03,
  0x03, 0x80, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x20,
  0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x60,
  0x60, 0x03, 0x03, 0x00, 0x18, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00,
  0x60, 0x70, 0x06, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xF0, 0x30, 0x06,
  0xC7, 0x00, 0x63, 0xF0, 0x03, 0x04, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x3F, 0xCC, 0x0E, 0x19, 0x03, 0x81, 0xE0, 0x60, 0x1C,
  0x18, 0x03, 0x83, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x86, 0x00, 0x30,
  0xC0, 0x06, 0x18, 0x00, 0x83, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3,
  0x00, 0x18, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x03, 0x0C,
  0x00, 0xE1, 0x80, 0x18, 0x18, 0x07, 0x03, 0x00, 0xE0, 0x60, 0x2C, 0x0C,
  0x0D, 0x00, 0xE7, 0x60, 0x0F, 0xCC, 0x00, 0x41, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01,
  0x1E, 0x04, 0xFC, 0x0B, 0x80, 0x34, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0x03, 0x06, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x80, 0x60, 0xF1, 0xE0, 0x7F, 0x80,
  0x04, 0x00, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0xFF,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE4, 0x1F, 0x03, 0x00, 0x06, 0x00,
  0xC1, 0x80, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x41,
  0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x60, 0xC0,
  0x18, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x60, 0x80, 0x30, 0x60, 0x0C,
  0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x60, 0x40, 0x18, 0x30, 0x0E, 0x0C,
  0x03, 0x83, 0x01, 0xE0, 0xE0, 0xD0, 0x1C, 0x64, 0x03, 0xF3, 0x00, 0x20,
  0x00, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xB0, 0x06, 0xC0, 0x33, 0x00, 0xCC,
  0x06, 0x30, 0x18, 0xC0, 0xC3, 0x03, 0x0C, 0x0C, 0x30, 0x60, 0xC1, 0x83,
  0x0C, 0x0C, 0x30, 0x31, 0x80, 0xC6, 0x03, 0x10, 0x0C, 0xC0, 0x33, 0x00,
  0xD8, 0x03, 0x60, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x06, 0xC0, 0x38, 0x06, 0xC0, 0x38,
  0x06, 0xC0, 0x68, 0x0C, 0xC0, 0x68, 0x0C, 0xC0, 0x48, 0x08, 0xC0, 0xC8,
  0x18, 0xC0, 0xC8, 0x18, 0xC1, 0x88, 0x30, 0xC1, 0x88, 0x30, 0xC1, 0x08,
  0x20, 0xC3, 0x08, 0x60, 0xC3, 0x08, 0x60, 0xC6, 0x08, 0xC0, 0xC6, 0x08,
  0xC0, 0xC4, 0x08, 0x80, 0xCC, 0x19, 0x80, 0xCC, 0x19, 0x80, 0xD8, 0x19,
  0x00, 0xD8, 0x1B, 0x00, 0xD0, 0x1B, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E,
  0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x00,
  0xE0, 0x60, 0x18, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x30, 0x03, 0x0C,
  0x00, 0x61, 0x80, 0x04, 0x60, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0D, 0x00,
  0x03, 0x30, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00,
  0x30, 0x30, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x30, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0x30, 0x18, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x31, 0x80, 0x00, 0x31, 0x80, 0x00, 0x31, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x36, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x8E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xFF, 0x02, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x1F, 0x80, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x1C, 0x1C, 0x1E,
  0x01, 0xFE, 0x80, 0x1E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 37, 11, 1, -37 },
  { 48, 11, 13, 14, 5, -37 },
  { 66, 21, 37, 20, 0, -37 },
  { 164, 19, 43, 18, 0, -40 },
  { 267, 24, 39, 28, 2, -38 },
  { 384, 18, 39, 18, -1, -38 },
  { 472, 5, 13, 8, 5, -37 },
  { 481, 15, 45, 13, 1, -37 },
  { 566, 15, 45, 13, -4, -37 },
  { 651, 13, 14, 17, 6, -39 },
  { 674, 18, 24, 21, 2, -30 },
  { 728, 7, 12, 9, -2, -5 },
  { 739, 11, 2, 14, 1, -15 },
  { 742, 3, 4, 9, 1, -4 },
  { 744, 21, 37, 16, -2, -37 },
  { 842, 17, 39, 18, 1, -38 },
  { 925, 9, 37, 18, 6, -37 },
  { 967, 20, 38, 18, -2, -38 },
  { 1062, 20, 39, 18, -1, -38 },
  { 1160, 20, 38, 18, -1, -38 },
  { 1255, 20, 38, 18, -1, -37 },
  { 1350, 19, 39, 18, 1, -38 },
  { 1443, 18, 37, 18, 2, -37 },
  { 1527, 20, 39, 18, -1, -38 },
  { 1625, 18, 39, 18, 0, -38 },
  { 1713, 8, 28, 8, 0, -28 },
  { 1741, 10, 35, 9, -2, -28 },
  { 1785, 18, 21, 21, 2, -29 },
  { 1833, 18, 13, 21, 2, -25 },
  { 1863, 18, 21, 21, 2, -29 },
  { 1911, 14, 38, 13, 1, -38 },
  { 1978, 25, 42, 27, 1, -37 },
  { 2110, 17, 37, 18, -3, -37 },
  { 2189, 20, 37, 20, 0, -37 },
  { 2282, 20, 39, 18, 2, -38 },
  { 2380, 21, 37, 22, 0, -37 },
  { 2478, 20, 37, 18, 0, -37 },
  { 2571, 20, 37, 17, 0, -37 },
  { 2664, 23, 39, 24, 2, -38 },
  { 2777, 24, 37, 23, 0, -37 },
  { 2888, 16, 37, 10, -3, -37 },
  { 2962, 17, 46, 9, -7, -37 },
  { 3060, 22, 37, 19, 0, -37 },
  { 3162, 12, 37, 16, 0, -37 },
  { 3218, 32, 37, 31, 0, -37 },
  { 3366, 25, 37, 25, 0, -37 },
  { 3482, 21, 39, 24, 2, -38 },
  { 3585, 20, 37, 19, 0, -37 },
  { 3678, 21, 47, 24, 2, -38 },
  { 3802, 20, 37, 19, 0, -37 },
  { 3895, 21, 39, 18, -1, -38 },
  { 3998, 17, 37, 16, 3, -37 },
  { 4077, 22, 38, 23, 2, -37 },
  { 4182, 19, 37, 19, 4, -37 },
  { 4270, 32, 37, 32, 4, -37 },
  { 4418, 23, 37, 16, -3, -37 },
  { 4525, 17, 37, 16, 3, -37 },
  { 4604, 21, 37, 16, -2, -37 },
  { 4702, 19, 45, 14, -1, -37 },
  { 4809, 7, 37, 17, 5, -37 },
  { 4842, 18, 45, 14, -3, -37 },
  { 4944, 19, 18, 20, 1, -37 },
  { 4987, 14, 1, 14, -4, 5 },
  { 4989, 5, 8, 11, 8, -40 },
  { 4994, 19, 29, 20, 1, -28 },
  { 5063, 19, 41, 20, 0, -40 },
  { 5161, 14, 29, 15, 2, -28 },
  { 5212, 21, 41, 20, 1, -40 },
  { 5320, 16, 29, 18, 1, -28 },
  { 5378, 23, 52, 10, -7, -40 },
  { 5528, 21, 40, 20, -1, -28 },
  { 5633, 18, 40, 19, 0, -40 },
  { 5723, 10, 37, 8, 0, -37 },
  { 5770, 17, 49, 9, -7, -37 },
  { 5875, 18, 40, 16, 0, -40 },
  { 5965, 11, 40, 8, 0, -40 },
  { 6020, 28, 28, 29, 0, -28 },
  { 6118, 18, 28, 19, 0, -28 },
  { 6181, 17, 29, 19, 1, -28 },
  { 6243, 21, 40, 20, -2, -28 },
  { 6348, 19, 40, 20, 1, -28 },
  { 6443, 15, 28, 13, 0, -28 },
  { 6496, 16, 29, 15, -1, -28 },
  { 6554, 10, 35, 10, 1, -34 },
  { 6598, 18, 28, 19, 1, -27 },
  { 6661, 14, 27, 15, 3, -27 },
  { 6709, 24, 27, 25, 3, -27 },
  { 6790, 19, 27, 15, -2, -27 },
  { 6855, 24, 40, 16, -6, -27 },
  { 6975, 16, 27, 13, -2, -27 },
  { 7029, 18, 45, 16, 2, -37 },
  { 7131, 2, 53, 18, 8, -40 },
  { 7145, 17, 45, 16, -3, -37 },
  { 7241, 18, 5, 21, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC52PT7B_H_
