#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC57PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x00, 0x1C, 0x38,
  0xC1, 0x86, 0x0C, 0x30, 0x63, 0x86, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x30,
  0x63, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x20, 0x43, 0x06, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x01,
  0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x04, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x30, 0x00, 0x60, 0x60, 0x00, 0x81, 0x80, 0x03, 0x03, 0x00, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0x80, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC1, 0x80,
  0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x30, 0x00,
  0x60, 0x60, 0x00, 0xC0, 0x80, 0x01, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C,
  0x0C, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x00, 0xC0, 0xC0, 0x01, 0x83,
  0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0x60,
  0x00, 0xC0, 0xC0, 0x01, 0x81, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x3F,
  0xF8, 0x03, 0xD9, 0xE0, 0x30, 0xC3, 0x03, 0x04, 0x00, 0x38, 0x20, 0x01,
  0x83, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x04, 0x00, 0x18, 0x20,
  0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x38, 0x80, 0x00, 0xC4, 0x00, 0x03,
  0x60, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0x70, 0x00, 0x19, 0x80, 0x00, 0x86, 0x00, 0x04,
  0x30, 0x00, 0x61, 0xC0, 0x03, 0x06, 0x00, 0x10, 0x30, 0x00, 0x81, 0x80,
  0x04, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x10, 0x60, 0x40, 0x87,
  0x03, 0x8D, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x03, 0xE0,
  0x03, 0x03, 0xF8, 0x03, 0x03, 0x0C, 0x01, 0x83, 0x86, 0x01, 0x81, 0x83,
  0x00, 0xC1, 0x81, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x60,
  0x30, 0x30, 0x30, 0x18, 0x30, 0x18, 0x0C, 0x18, 0x0C, 0x06, 0x18, 0x0C,
  0x07, 0x0C, 0x06, 0x03, 0x0C, 0x03, 0x01, 0x86, 0x01, 0x80, 0xC6, 0x00,
  0xC0, 0x63, 0x0E, 0x60, 0x63, 0x1F, 0xF0, 0x31, 0x8C, 0x78, 0x31, 0x8C,
  0x3C, 0x18, 0xCC, 0x1E, 0x18, 0xC6, 0x07, 0x0C, 0x66, 0x03, 0xFC, 0x63,
  0x03, 0x7C, 0x31, 0x81, 0x80, 0x31, 0x80, 0xC0, 0x18, 0xC0, 0x60, 0x18,
  0x60, 0x30, 0x0C, 0x30, 0x18, 0x0C, 0x30, 0x0C, 0x06, 0x18, 0x0C, 0x06,
  0x0C, 0x06, 0x03, 0x06, 0x03, 0x03, 0x03, 0x03, 0x81, 0x81, 0x81, 0x81,
  0x80, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0xC0, 0x30, 0x60, 0x60, 0x18, 0x60,
  0x60, 0x0E, 0x60, 0x70, 0x03, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x70, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x0C,
  0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x1C, 0x00,
  0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC6, 0x00,
  0x0C, 0xE0, 0x00, 0xCC, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x3B, 0x00, 0x07, 0x30, 0x00, 0xE3, 0x03, 0x0C, 0x38,
  0x61, 0x81, 0x86, 0x38, 0x18, 0x63, 0x01, 0x8C, 0x70, 0x0C, 0xC6, 0x00,
  0xCC, 0x60, 0x0D, 0x86, 0x00, 0xD8, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x06, 0x0E, 0x00, 0xF0, 0x60, 0x0F, 0x06, 0x01, 0xB0, 0x70, 0x33, 0x03,
  0xDE, 0x18, 0x1F, 0xC1, 0x80, 0x20, 0x00, 0x39, 0x8C, 0x67, 0x31, 0x8C,
  0x62, 0x31, 0x8C, 0x42, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0xC3, 0x03, 0xCC, 0x03,
  0xB1, 0xC3, 0xFF, 0x07, 0x00, 0x34, 0x01, 0x98, 0x0C, 0x20, 0x60, 0xC3,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x06, 0x1C, 0x30, 0x61, 0x83,
  0x0E, 0x18, 0x30, 0xC1, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x03, 0x87, 0x00, 0x60, 0x60,
  0x18, 0x0E, 0x07, 0x00, 0xC0, 0xC0, 0x18, 0x38, 0x03, 0x06, 0x00, 0x60,
  0xC0, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x31, 0xC0, 0x06, 0x30, 0x00, 0xC6,
  0x00, 0x38, 0xC0, 0x06, 0x38, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18,
  0x00, 0x67, 0x00, 0x1C, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60,
  0x01, 0x8C, 0x00, 0x73, 0x80, 0x0C, 0x70, 0x01, 0x8C, 0x00, 0x31, 0x80,
  0x0C, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00,
  0x60, 0x60, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0xE0, 0x1C, 0x38, 0x01, 0xDE,
  0x00, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x3C, 0x0F, 0x03, 0xE0,
  0xEC, 0x71, 0x9C, 0x37, 0x0C, 0x41, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x0E, 0x03, 0x80,
  0x10, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0x00, 0x70, 0x1C, 0x01, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x02,
  0x00, 0xF0, 0x1E, 0x3E, 0x00, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xB0, 0x00, 0x0F,
  0x00, 0x00, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00,
  0x33, 0x00, 0x03, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x18, 0x70,
  0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x60,
  0x60, 0x07, 0x03, 0x00, 0x30, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x0E, 0x01,
  0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x0E,
  0x06, 0x00, 0x60, 0x70, 0x03, 0x03, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x08, 0x03, 0xC0, 0x3C, 0x7C,
  0x00, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0xF8, 0x03, 0x3F, 0xE0, 0x37, 0x07, 0x03, 0x40, 0x30, 0x78, 0x03, 0x87,
  0x80, 0x18, 0x70, 0x01, 0x87, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x18,
  0x60, 0x01, 0x8E, 0x00, 0x18, 0xE0, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x03,
  0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0xE0, 0x06, 0x06, 0x00,
  0xE0, 0x60, 0x0C, 0x06, 0x01, 0xC0, 0x30, 0x38, 0x03, 0xDF, 0x00, 0x1F,
  0xC0, 0x00, 0x20, 0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x0E, 0x07, 0x00, 0x30, 0x0E, 0x01, 0x80,
  0x18, 0x06, 0x00, 0x70, 0x38, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C,
  0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x38, 0x06,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0x70, 0x38, 0x00, 0xC1, 0xC0, 0x03, 0x8E,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0x30, 0x00,
  0x70, 0x60, 0x03, 0x81, 0xC0, 0x1C, 0x03, 0x00, 0xE0, 0x06, 0x03, 0x00,
  0x18, 0x1C, 0x00, 0x70, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x0E, 0x00, 0x0C,
  0x38, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0E, 0x00, 0x18, 0x18,
  0x00, 0x60, 0x60, 0x03, 0x81, 0xC0, 0x0C, 0x03, 0x80, 0xE0, 0x07, 0xDF,
  0x00, 0x0F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFC,
  0x00, 0xE0, 0xC0, 0x18, 0x06, 0x03, 0x80, 0x60, 0x30, 0x06, 0x06, 0x00,
  0x70, 0x60, 0x03, 0x0E, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0,
  0x03, 0x1C, 0x00, 0x31, 0x80, 0x07, 0x18, 0x00, 0x71, 0x80, 0x06, 0x18,
  0x00, 0x61, 0x80, 0x0E, 0x18, 0x00, 0xE1, 0x80, 0x1E, 0x1C, 0x01, 0xE0,
  0xC0, 0x3C, 0x0E, 0x06, 0xC0, 0x7F, 0xCC, 0x03, 0xF0, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x0C, 0xFC, 0x00, 0xFF,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x1C, 0x0E,
  0x07, 0x00, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x0C, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0E,
  0x03, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x06, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x30,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x01, 0xF8,
  0x30, 0xC0, 0x79, 0x83, 0x0C, 0x0E, 0x18, 0x31, 0x80, 0xC1, 0x83, 0x18,
  0x18, 0x30, 0x31, 0x83, 0x03, 0x03, 0x30, 0x30, 0x30, 0x23, 0x03, 0x03,
  0x06, 0x30, 0x60, 0x60, 0x63, 0x06, 0x06, 0x06, 0x60, 0x60, 0x60, 0x66,
  0x0C, 0x06, 0x04, 0x60, 0xC0, 0xC0, 0xC6, 0x0C, 0x0C, 0x0C, 0x60, 0xC0,
  0xC0, 0xC6, 0x0C, 0x1C, 0x18, 0x60, 0xC1, 0x81, 0x84, 0x0C, 0x38, 0x30,
  0xC0, 0xC2, 0x83, 0x0C, 0x0C, 0x6C, 0x60, 0xC0, 0xEC, 0xCC, 0x0C, 0x07,
  0xC7, 0x80, 0xC0, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x20,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0B, 0x00, 0x01, 0xB0, 0x00, 0x1B, 0x00,
  0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30,
  0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01, 0xC3, 0x00, 0x18, 0x30, 0x01, 0x83,
  0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x70, 0x30, 0x06, 0x03, 0x00, 0x60,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x03, 0x00, 0x70, 0x30, 0x07, 0x07, 0x00, 0x70, 0x60, 0x07, 0x0E,
  0x00, 0x70, 0xC0, 0x07, 0x0C, 0x00, 0x71, 0xC0, 0x07, 0x18, 0x00, 0x73,
  0x80, 0x07, 0x30, 0x00, 0x73, 0x00, 0x07, 0x70, 0x00, 0x76, 0x00, 0x07,
  0xE0, 0x00, 0x70, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x80, 0x0C, 0x0F, 0x00,
  0x30, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0x60,
  0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xE0, 0x03,
  0x03, 0x00, 0x1C, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x80, 0xC0, 0x0C, 0x06,
  0x00, 0x60, 0x18, 0x07, 0x00, 0x60, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x30, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xE0,
  0x70, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60,
  0x01, 0x83, 0x80, 0x0E, 0x0C, 0x00, 0x38, 0x30, 0x00, 0xC0, 0xC0, 0x03,
  0x03, 0x00, 0x18, 0x18, 0x00, 0xE0, 0x60, 0x03, 0x01, 0x80, 0x3C, 0x06,
  0x01, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0xF0, 0x03, 0x80, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xCE, 0x00, 0x0F, 0xF8,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0x07,
  0xC0, 0x06, 0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x70, 0x03,
  0x00, 0xC0, 0x07, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18,
  0x1C, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x83,
  0x80, 0x03, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x30,
  0x00, 0x60, 0xE0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00,
  0x0E, 0x0C, 0x00, 0x18, 0x38, 0x00, 0x30, 0x60, 0x00, 0xE0, 0xC0, 0x01,
  0x81, 0x80, 0x03, 0x03, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x70,
  0x30, 0x00, 0xC0, 0x60, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0x00, 0x38, 0x06,
  0x00, 0xE0, 0x0C, 0x03, 0x80, 0x18, 0x1E, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xF0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0x00, 0xE0, 0x0E, 0x00,
  0x10, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x1F, 0xE3, 0x80, 0x0F, 0xE1,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0E,
  0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x30, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x1C, 0x07, 0x00, 0x0C, 0x01, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x38, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x1C, 0x00, 0x18, 0x06,
  0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0xE0, 0x18, 0x00, 0x30,
  0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00,
  0x60, 0x1C, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60,
  0x00, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0xC0, 0x30, 0x00, 0x70, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x06,
  0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x30, 0x06, 0x00,
  0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x70, 0x0C,
  0x00, 0x18, 0x07, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60,
  0x18, 0x00, 0x38, 0x06, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x87, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x70, 0x03, 0x80, 0x30, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x0C, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x03,
  0x00, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x60, 0x00, 0x30, 0x70, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x0E, 0x38, 0x00, 0x06, 0x38, 0x00, 0x03, 0x18, 0x00, 0x01, 0x98, 0x00,
  0x00, 0xDE, 0x00, 0x00, 0xFB, 0x00, 0x00, 0x6D, 0x80, 0x00, 0x3C, 0xC0,
  0x00, 0x1C, 0x70, 0x00, 0x0C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xC0,
  0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0E, 0x00, 0x18, 0x03, 0x00, 0x1C,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x01, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x1E, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0D, 0x80, 0x6C, 0x00, 0x01, 0xB0,
  0x0D, 0x80, 0x00, 0x6E, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x36, 0x00, 0x03,
  0xB0, 0x06, 0xC0, 0x00, 0x66, 0x01, 0x98, 0x00, 0x1C, 0xC0, 0x33, 0x00,
  0x03, 0x30, 0x06, 0x60, 0x00, 0xE6, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x38,
  0xC0, 0x03, 0x18, 0x06, 0x18, 0x00, 0xC7, 0x00, 0xC3, 0x00, 0x18, 0xC0,
  0x18, 0x60, 0x06, 0x18, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0xE1, 0x80, 0x30,
  0x60, 0x18, 0x30, 0x06, 0x1C, 0x03, 0x06, 0x01, 0x83, 0x00, 0x60, 0xC0,
  0x30, 0x60, 0x0C, 0x18, 0x0C, 0x0C, 0x03, 0x03, 0x01, 0x81, 0x80, 0x60,
  0x60, 0x60, 0x60, 0x0C, 0x0C, 0x0C, 0x0C, 0x01, 0x81, 0x83, 0x81, 0x80,
  0x30, 0x30, 0x60, 0x30, 0x0C, 0x06, 0x1C, 0x06, 0x01, 0x80, 0xC3, 0x01,
  0x80, 0x30, 0x18, 0xE0, 0x30, 0x06, 0x03, 0x18, 0x06, 0x01, 0xC0, 0x73,
  0x00, 0xC0, 0x30, 0x06, 0xC0, 0x38, 0x06, 0x00, 0xD8, 0x06, 0x00, 0xC0,
  0x1E, 0x00, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x07, 0x00, 0x70, 0x03, 0x00,
  0xC0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x30, 0x0F, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x60, 0x0F, 0x00, 0x06, 0x00, 0xF0, 0x00, 0x60, 0x0F,
  0x00, 0x06, 0x01, 0xF0, 0x00, 0xC0, 0x19, 0x80, 0x0C, 0x01, 0x98, 0x00,
  0xC0, 0x19, 0x80, 0x0C, 0x01, 0x98, 0x01, 0xC0, 0x31, 0x80, 0x18, 0x03,
  0x0C, 0x01, 0x80, 0x30, 0xC0, 0x18, 0x03, 0x0C, 0x01, 0x80, 0x70, 0xC0,
  0x38, 0x06, 0x0C, 0x03, 0x00, 0x60, 0xC0, 0x30, 0x06, 0x06, 0x03, 0x00,
  0x60, 0x60, 0x30, 0x0E, 0x06, 0x06, 0x00, 0xC0, 0x60, 0x60, 0x0C, 0x06,
  0x06, 0x00, 0xC0, 0x70, 0x60, 0x0C, 0x03, 0x06, 0x01, 0xC0, 0x30, 0xC0,
  0x18, 0x03, 0x0C, 0x01, 0x80, 0x30, 0xC0, 0x18, 0x03, 0x0C, 0x01, 0x80,
  0x19, 0xC0, 0x30, 0x01, 0x98, 0x03, 0x00, 0x19, 0x80, 0x30, 0x01, 0x98,
  0x03, 0x00, 0x19, 0x80, 0x70, 0x01, 0xF0, 0x06, 0x00, 0x0F, 0x00, 0x60,
  0x00, 0xF0, 0x06, 0x00, 0x0F, 0x00, 0x60, 0x00, 0xF0, 0x0E, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x01,
  0xC0, 0xE0, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x70, 0x01, 0x80, 0xC0,
  0x03, 0x83, 0x80, 0x07, 0x06, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0xE0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x01, 0xCE, 0x00, 0x03,
  0x98, 0x00, 0x07, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x19, 0xC0, 0x00, 0x33,
  0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x98, 0x00, 0x06, 0x70,
  0x00, 0x0C, 0xE0, 0x00, 0x19, 0x80, 0x00, 0x73, 0x00, 0x00, 0xC6, 0x00,
  0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00,
  0x70, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x83, 0x80, 0x06, 0x07, 0x00, 0x1C,
  0x06, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x1F, 0x7C, 0x00,
  0x0F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFE, 0x00,
  0x30, 0xF8, 0x01, 0x80, 0xE0, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x07, 0x00,
  0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x07,
  0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0xE0, 0xE0, 0x06,
  0x06, 0x00, 0x30, 0x30, 0x03, 0x81, 0x80, 0x38, 0x0C, 0x03, 0x80, 0xE0,
  0x38, 0x06, 0x07, 0x80, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0,
  0x01, 0xC0, 0xE0, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x70, 0x01, 0x80,
  0xC0, 0x03, 0x83, 0x80, 0x07, 0x06, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x30,
  0x00, 0x18, 0xE0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x01, 0xCE, 0x00,
  0x03, 0x98, 0x00, 0x07, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x19, 0xC0, 0x00,
  0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x98, 0x00, 0x06,
  0x70, 0x00, 0x0C, 0xE0, 0x00, 0x19, 0x80, 0x00, 0x73, 0x00, 0x00, 0xC6,
  0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60,
  0x00, 0x70, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x83, 0x80, 0x06, 0x07, 0x00,
  0x1C, 0x06, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x1F, 0x7C,
  0x00, 0x0F, 0xF0, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0x00,
  0x07, 0xFE, 0x00, 0x30, 0x78, 0x01, 0x80, 0xE0, 0x0C, 0x03, 0x80, 0x60,
  0x0C, 0x07, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0,
  0x60, 0x06, 0x07, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00,
  0xE0, 0xE0, 0x06, 0x06, 0x00, 0x70, 0x30, 0x03, 0x01, 0x80, 0x38, 0x0C,
  0x03, 0x80, 0xE0, 0x78, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0x83, 0x00,
  0x0C, 0x18, 0x00, 0xE0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x38, 0x01, 0x80,
  0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x70, 0x1C, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03,
  0x01, 0x80, 0x18, 0x1C, 0x00, 0xE0, 0xC0, 0x03, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xFC, 0x01, 0xE0, 0x38, 0x07, 0x00, 0x10, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x30, 0x03,
  0x80, 0x7E, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xE0, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x03, 0x03, 0x00,
  0x07, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x07, 0x00,
  0x06, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00,
  0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00,
  0x18, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x38, 0x18, 0x00, 0x30, 0x18, 0x00,
  0x30, 0x18, 0x00, 0x30, 0x38, 0x00, 0x30, 0x30, 0x00, 0x60, 0x30, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x60, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0xC0, 0x01,
  0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x03,
  0x00, 0xC0, 0x03, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0x70, 0x1C, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0,
  0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00, 0x60, 0xC0, 0x0E, 0x0C, 0x00, 0xC0,
  0xC0, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x03, 0x80, 0xC0, 0x30,
  0x0C, 0x07, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x0C,
  0x00, 0xC1, 0xC0, 0x0C, 0x18, 0x00, 0xC3, 0x80, 0x0C, 0x30, 0x00, 0xC3,
  0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0xE0, 0x00, 0xCC, 0x00, 0x0C,
  0xC0, 0x00, 0xD8, 0x00, 0x0D, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x6C, 0x00, 0x1C, 0x00, 0x19, 0x80, 0x03, 0x80, 0x03, 0x30, 0x00, 0x70,
  0x00, 0xE6, 0x00, 0x1E, 0x00, 0x18, 0xC0, 0x03, 0xC0, 0x03, 0x18, 0x00,
  0xD8, 0x00, 0xC3, 0x00, 0x1B, 0x00, 0x18, 0x60, 0x03, 0x60, 0x07, 0x0C,
  0x00, 0xCC, 0x00, 0xC1, 0x80, 0x19, 0x80, 0x18, 0x30, 0x07, 0x30, 0x06,
  0x06, 0x00, 0xC6, 0x00, 0xC0, 0xC0, 0x18, 0xC0, 0x38, 0x18, 0x06, 0x18,
  0x06, 0x03, 0x00, 0xC2, 0x00, 0xC0, 0x60, 0x18, 0x40, 0x30, 0x0C, 0x06,
  0x08, 0x06, 0x01, 0x80, 0xC1, 0x01, 0xC0, 0x30, 0x30, 0x60, 0x30, 0x0E,
  0x06, 0x0C, 0x06, 0x01, 0xC0, 0xC1, 0x81, 0x80, 0x38, 0x30, 0x30, 0x30,
  0x06, 0x06, 0x06, 0x0E, 0x00, 0xC1, 0x80, 0xC1, 0x80, 0x18, 0x30, 0x18,
  0x30, 0x03, 0x06, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x61, 0x80, 0x0C, 0x30,
  0x0C, 0x70, 0x01, 0x8E, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x31, 0x80, 0x06,
  0x30, 0x06, 0x60, 0x00, 0xCC, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x1B, 0x80,
  0x03, 0x70, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x0F,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60,
  0x01, 0x80, 0x60, 0x00, 0xC0, 0x70, 0x00, 0x70, 0x30, 0x00, 0x18, 0x38,
  0x00, 0x0C, 0x18, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x73, 0x00, 0x00, 0x31, 0x80, 0x00, 0x38, 0xC0, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x0E, 0x00,
  0x0E, 0x03, 0x00, 0x06, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x03, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0xC0, 0x03, 0x80, 0x00, 0x60, 0x00, 0xD8, 0x00, 0x66, 0x00, 0x19,
  0x80, 0x0C, 0x60, 0x03, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x30, 0x70,
  0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x18,
  0x03, 0x06, 0x00, 0xC3, 0x00, 0x31, 0xC0, 0x0C, 0x60, 0x03, 0x38, 0x00,
  0x4C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x02, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60,
  0x60, 0x60, 0x60, 0x60, 0x60, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x03, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00,
  0x63, 0x00, 0x03, 0x18, 0x00, 0x30, 0xE0, 0x01, 0x83, 0x00, 0x18, 0x18,
  0x01, 0xC0, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x0C, 0x06, 0x00, 0x60, 0x70,
  0x03, 0x83, 0x00, 0x0C, 0x38, 0x00, 0x61, 0x80, 0x01, 0x9C, 0x00, 0x0D,
  0xC0, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFC, 0xE1, 0x87, 0x0C, 0x10, 0x60,
  0x83, 0x00, 0x18, 0x00, 0x0F, 0xE3, 0x01, 0xC7, 0x60, 0x30, 0x36, 0x06,
  0x01, 0x60, 0xE0, 0x1E, 0x0C, 0x01, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC3,
  0x00, 0x1C, 0x30, 0x01, 0xC7, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x18,
  0x60, 0x01, 0x8E, 0x00, 0x38, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x70, 0xC0, 0x07, 0x0C, 0x00, 0x60, 0xC0, 0x0E, 0x0C, 0x00,
  0xE0, 0xC0, 0x0E, 0x0C, 0x01, 0xC0, 0xC0, 0x1C, 0x0E, 0x02, 0xC0, 0x60,
  0x6C, 0x07, 0xBC, 0xC0, 0x3F, 0x88, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x87, 0x00, 0x39, 0xFC, 0x03, 0x39, 0xE0, 0x36,
  0x06, 0x03, 0xC0, 0x70, 0x38, 0x03, 0x07, 0x80, 0x30, 0x70, 0x03, 0x07,
  0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0xE0, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x07, 0x18, 0x00, 0x61, 0x80, 0x06,
  0x18, 0x00, 0x61, 0x80, 0x0E, 0x38, 0x00, 0xC3, 0x80, 0x0C, 0x30, 0x01,
  0xC3, 0x00, 0x18, 0x30, 0x01, 0x87, 0x80, 0x30, 0x78, 0x07, 0x07, 0x80,
  0x60, 0x6C, 0x0C, 0x04, 0xF7, 0x80, 0xC7, 0xF0, 0x00, 0x08, 0x00, 0x00,
  0x1C, 0x00, 0xFF, 0x03, 0xE6, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x79, 0xC0, 0x3F,
  0xC0, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x18, 0x30, 0x03, 0xF9, 0xC0, 0x3C, 0x76, 0x00, 0xC0, 0xD8, 0x06,
  0x01, 0x60, 0x38, 0x07, 0x80, 0xC0, 0x1C, 0x06, 0x00, 0x70, 0x18, 0x01,
  0xC0, 0xC0, 0x07, 0x03, 0x00, 0x1C, 0x1C, 0x00, 0x60, 0x60, 0x01, 0x81,
  0x80, 0x06, 0x06, 0x00, 0x18, 0x38, 0x00, 0xE0, 0xC0, 0x03, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x30, 0x30, 0x01, 0xC0, 0xC0, 0x07, 0x03, 0x00, 0x18,
  0x0C, 0x00, 0xE0, 0x30, 0x03, 0x80, 0xC0, 0x0E, 0x03, 0x00, 0x70, 0x0C,
  0x03, 0xC0, 0x38, 0x0B, 0x00, 0x60, 0x6C, 0x01, 0xEF, 0x30, 0x03, 0xF8,
  0x80, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x3F, 0x80, 0x78, 0xE0, 0x70,
  0x30, 0x30, 0x18, 0x30, 0x0C, 0x38, 0x06, 0x18, 0x03, 0x1C, 0x01, 0x8C,
  0x01, 0xCE, 0x00, 0xC6, 0x00, 0xE3, 0x00, 0xE1, 0x80, 0xE1, 0xC3, 0xE0,
  0xFF, 0xC0, 0x7E, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x81, 0xF3, 0xC0, 0x7F, 0xC0, 0x02, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1E, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0x8C, 0x00, 0xE3, 0xB0, 0x03,
  0x03, 0x60, 0x0C, 0x02, 0xC0, 0x38, 0x07, 0x80, 0x60, 0x0E, 0x01, 0x80,
  0x1C, 0x03, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x70, 0x01,
  0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x0E, 0x00, 0x38,
  0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x07, 0x01,
  0x80, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x70, 0x0C, 0x00, 0xE0, 0x18,
  0x01, 0xC0, 0x30, 0x07, 0x00, 0x60, 0x1E, 0x00, 0xE0, 0x2C, 0x00, 0xC0,
  0xD8, 0x01, 0xEF, 0x30, 0x01, 0xFC, 0xC0, 0x00, 0x41, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x01,
  0x00, 0x70, 0x03, 0x83, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x70, 0x03, 0x3F, 0x80, 0xCE, 0x78,
  0x1B, 0x03, 0x03, 0xC0, 0x60, 0x70, 0x0C, 0x0C, 0x01, 0x83, 0x80, 0x30,
  0x70, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x38, 0x70, 0x06, 0x0C, 0x00, 0xC1,
  0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0xE1, 0x80, 0x18, 0x30, 0x03, 0x06,
  0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18,
  0x01, 0x83, 0x00, 0x30, 0xE0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60,
  0x06, 0x0C, 0x01, 0xC3, 0x80, 0x30, 0x00, 0x00, 0x60, 0x1C, 0x03, 0x80,
  0x70, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x08, 0xE0, 0x01, 0xF8, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x07, 0x03, 0x00, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x30, 0x30,
  0x07, 0x07, 0x00, 0x60, 0xE0, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x38,
  0x00, 0xC7, 0x00, 0x0C, 0x60, 0x00, 0xCE, 0x00, 0x0D, 0xE0, 0x00, 0xF6,
  0x00, 0x1B, 0x70, 0x01, 0xE3, 0x00, 0x1C, 0x30, 0x01, 0x83, 0x00, 0x38,
  0x30, 0x03, 0x03, 0x00, 0x30, 0x38, 0x03, 0x01, 0x80, 0x30, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x06, 0x00, 0xC0,
  0xC0, 0x0C, 0x00, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x0C, 0x7F, 0x1F, 0xE0, 0x37, 0x1C, 0xE3, 0x80, 0xD0, 0x3E, 0x07, 0x03,
  0x80, 0x70, 0x0C, 0x0E, 0x01, 0xC0, 0x30, 0x70, 0x06, 0x00, 0xC1, 0xC0,
  0x18, 0x03, 0x06, 0x00, 0xE0, 0x0C, 0x18, 0x03, 0x00, 0x70, 0x60, 0x0C,
  0x01, 0x83, 0x80, 0x30, 0x06, 0x0C, 0x00, 0xC0, 0x18, 0x30, 0x07, 0x00,
  0x60, 0xC0, 0x18, 0x03, 0x83, 0x00, 0x60, 0x0C, 0x18, 0x01, 0x80, 0x30,
  0x60, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x03, 0x06, 0x00, 0xC0, 0x18, 0x38,
  0x03, 0x00, 0x60, 0xC0, 0x0C, 0x01, 0x83, 0x00, 0x70, 0x06, 0x0C, 0x01,
  0x80, 0x18, 0x30, 0x06, 0x00, 0xC1, 0xC0, 0x18, 0x03, 0x06, 0x00, 0x60,
  0x0C, 0x18, 0x03, 0x80, 0x30, 0x60, 0x0C, 0x01, 0xC1, 0x80, 0x30, 0x06,
  0x0C, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x07, 0x00, 0x63, 0xF8, 0x0C, 0xE7,
  0x81, 0xB0, 0x30, 0x3C, 0x06, 0x07, 0x00, 0xC1, 0xC0, 0x18, 0x38, 0x03,
  0x07, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x87, 0x00, 0x60, 0xC0, 0x0C,
  0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x0E, 0x18, 0x01, 0x83, 0x00, 0x30,
  0x60, 0x06, 0x0C, 0x00, 0xC3, 0x80, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC1,
  0x80, 0x18, 0x30, 0x07, 0x0E, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x06,
  0x00, 0x60, 0xC0, 0x1C, 0x30, 0x03, 0x00, 0x00, 0x38, 0x00, 0xFF, 0x00,
  0xF1, 0xC0, 0xE0, 0x60, 0xE0, 0x18, 0x60, 0x0C, 0x70, 0x06, 0x30, 0x03,
  0x38, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x6E, 0x00, 0x36, 0x00, 0x1B, 0x00,
  0x0D, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xB0, 0x00, 0xD8,
  0x00, 0x6C, 0x00, 0x36, 0x00, 0x33, 0x00, 0x19, 0x80, 0x1C, 0xC0, 0x0C,
  0x60, 0x0E, 0x30, 0x06, 0x1C, 0x07, 0x06, 0x07, 0x03, 0xDF, 0x00, 0xFE,
  0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x01, 0x1F, 0xC0, 0x0C, 0xE7, 0x80,
  0x36, 0x06, 0x00, 0xD0, 0x1C, 0x03, 0x80, 0x30, 0x1E, 0x00, 0xC0, 0x70,
  0x03, 0x01, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xE0, 0x03,
  0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x06,
  0x00, 0x1C, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00,
  0x30, 0x38, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60,
  0x70, 0x03, 0x01, 0xE0, 0x1C, 0x06, 0x80, 0x60, 0x1B, 0x07, 0x00, 0x6F,
  0x78, 0x03, 0x9F, 0xC0, 0x0C, 0x08, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xE3, 0x03, 0xC7, 0x60,
  0x70, 0x36, 0x06, 0x01, 0x60, 0xC0, 0x1E, 0x1C, 0x01, 0xC1, 0x80, 0x1C,
  0x18, 0x01, 0xC3, 0x00, 0x1C, 0x30, 0x01, 0xC7, 0x00, 0x18, 0x60, 0x01,
  0x86, 0x00, 0x18, 0x60, 0x01, 0x8E, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00,
  0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00, 0x60, 0xC0,
  0x0E, 0x0C, 0x00, 0xE0, 0xC0, 0x0E, 0x0C, 0x01, 0xC0, 0xC0, 0x3C, 0x0C,
  0x02, 0xC0, 0xE0, 0x6C, 0x07, 0xBD, 0xC0, 0x3F, 0x98, 0x00, 0x41, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x1F, 0x03, 0x39,
  0x03, 0x60, 0x03, 0xC0, 0x02, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x3F,
  0xE0, 0x3C, 0x7C, 0x0C, 0x02, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x80,
  0x70, 0x3C, 0x78, 0x07, 0xFC, 0x00, 0x10, 0x00, 0x01, 0x80, 0x30, 0x04,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0xFF, 0x3F, 0xE0, 0xC0, 0x18, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x72, 0x07, 0xC0, 0x30,
  0x00, 0x07, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60,
  0x0E, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80,
  0x30, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x0E, 0x00,
  0xC1, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x1C, 0x30, 0x03,
  0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x83, 0x00, 0x70, 0x60, 0x1C,
  0x1C, 0x03, 0x81, 0x80, 0xF0, 0x30, 0x36, 0x07, 0xBC, 0x80, 0x7F, 0x30,
  0x01, 0x00, 0x00, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0,
  0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x30, 0xC0,
  0x60, 0xC0, 0x60, 0xC0, 0xE0, 0xC0, 0xC0, 0xC1, 0xC0, 0xC1, 0x80, 0xC1,
  0x80, 0xC3, 0x00, 0xC3, 0x00, 0xC6, 0x00, 0xC6, 0x00, 0xCE, 0x00, 0xCC,
  0x00, 0xCC, 0x00, 0xD8, 0x00, 0xD8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x60, 0x06, 0x00, 0xEC, 0x01, 0xC0, 0x19, 0x80, 0x38,
  0x03, 0x30, 0x0F, 0x00, 0xC6, 0x01, 0xE0, 0x18, 0x80, 0x2C, 0x03, 0x10,
  0x0D, 0x80, 0xC2, 0x01, 0xB0, 0x18, 0xC0, 0x66, 0x06, 0x18, 0x0C, 0xC0,
  0xC3, 0x01, 0x98, 0x18, 0x60, 0x63, 0x06, 0x0C, 0x0C, 0x60, 0xC1, 0x83,
  0x0C, 0x30, 0x30, 0x61, 0x86, 0x06, 0x18, 0x30, 0xC0, 0xC3, 0x06, 0x30,
  0x18, 0x60, 0xC6, 0x03, 0x18, 0x18, 0x80, 0x63, 0x03, 0x30, 0x0C, 0xC0,
  0x66, 0x01, 0x98, 0x0D, 0x80, 0x33, 0x01, 0xB0, 0x06, 0xC0, 0x34, 0x00,
  0xD8, 0x07, 0x80, 0x1A, 0x00, 0xB0, 0x03, 0xC0, 0x1C, 0x00, 0x78, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x1C,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0x60, 0x01,
  0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x63, 0x80, 0x01, 0x8C,
  0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0x60, 0x00, 0x0D,
  0x80, 0x00, 0x63, 0x00, 0x03, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0xC0,
  0x01, 0x83, 0x00, 0x0C, 0x06, 0x00, 0x70, 0x18, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x70, 0x06, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x38, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x80, 0x18, 0x00, 0xE0, 0x0E, 0x00, 0x18, 0x03,
  0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00,
  0x18, 0x38, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x18, 0x60, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x23, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xF0,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0xFC, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x27,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x07, 0xF8, 0x01, 0xE1, 0xE0, 0x7C, 0x07, 0xFE, 0x80, 0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 41, 12, 1, -41 },
  { 58, 13, 15, 16, 5, -41 },
  { 83, 23, 41, 22, 0, -41 },
  { 201, 21, 46, 20, 0, -43 },
  { 322, 25, 42, 31, 3, -41 },
  { 454, 20, 42, 20, -1, -41 },
  { 559, 5, 15, 9, 6, -41 },
  { 569, 16, 50, 14, 1, -41 },
  { 669, 16, 50, 14, -4, -41 },
  { 769, 14, 16, 19, 7, -43 },
  { 797, 19, 26, 23, 2, -33 },
  { 859, 7, 12, 9, -2, -5 },
  { 870, 12, 2, 15, 1, -16 },
  { 873, 3, 4, 9, 1, -4 },
  { 875, 24, 41, 17, -3, -41 },
  { 998, 19, 42, 20, 1, -41 },
  { 1098, 11, 41, 20, 6, -41 },
  { 1155, 22, 41, 20, -2, -41 },
  { 1268, 21, 42, 20, -1, -41 },
  { 1379, 21, 41, 20, -1, -41 },
  { 1487, 22, 42, 20, -1, -41 },
  { 1603, 20, 42, 20, 1, -41 },
  { 1708, 20, 41, 20, 2, -41 },
  { 1811, 22, 42, 20, -1, -41 },
  { 1927, 20, 42, 20, 0, -41 },
  { 2032, 9, 30, 9, 0, -30 },
  { 2066, 12, 37, 9, -3, -30 },
  { 2122, 19, 24, 23, 2, -32 },
  { 2179, 19, 14, 23, 2, -27 },
  { 2213, 20, 24, 23, 2, -32 },
  { 2273, 16, 41, 14, 1, -41 },
  { 2355, 28, 46, 30, 1, -41 },
  { 2516, 20, 41, 20, -4, -41 },
  { 2619, 22, 41, 22, 0, -41 },
  { 2732, 22, 42, 20, 2, -41 },
  { 2848, 23, 41, 24, 0, -41 },
  { 2966, 22, 41, 20, 0, -41 },
  { 3079, 22, 41, 18, 0, -41 },
  { 3192, 25, 42, 26, 2, -41 },
  { 3324, 26, 41, 26, 0, -41 },
  { 3458, 18, 41, 10, -3, -41 },
  { 3551, 19, 51, 9, -8, -41 },
  { 3673, 25, 41, 20, 0, -41 },
  { 3802, 13, 41, 18, 0, -41 },
  { 3869, 35, 41, 34, 0, -41 },
  { 4049, 28, 41, 27, 0, -41 },
  { 4193, 23, 42, 26, 2, -41 },
  { 4314, 21, 41, 21, 0, -41 },
  { 4422, 23, 51, 26, 2, -41 },
  { 4569, 21, 41, 21, 0, -41 },
  { 4677, 23, 42, 20, -2, -41 },
  { 4798, 18, 41, 17, 4, -41 },
  { 4891, 24, 42, 25, 2, -41 },
  { 5017, 20, 41, 20, 5, -41 },
  { 5120, 35, 41, 35, 4, -41 },
  { 5300, 25, 41, 18, -3, -41 },
  { 5429, 18, 41, 17, 4, -41 },
  { 5522, 23, 41, 18, -2, -41 },
  { 5640, 20, 50, 16, -1, -41 },
  { 5765, 8, 41, 18, 6, -41 },
  { 5806, 21, 50, 16, -4, -41 },
  { 5938, 21, 20, 22, 1, -41 },
  { 5991, 15, 2, 15, -4, 5 },
  { 5995, 6, 8, 12, 8, -43 },
  { 6001, 20, 32, 22, 2, -31 },
  { 6081, 20, 44, 22, 0, -43 },
  { 6191, 16, 32, 16, 2, -31 },
  { 6255, 22, 44, 22, 2, -43 },
  { 6376, 17, 32, 19, 1, -31 },
  { 6444, 25, 58, 11, -7, -44 },
  { 6626, 23, 45, 22, -1, -31 },
  { 6756, 19, 43, 21, 0, -43 },
  { 6859, 11, 41, 9, 0, -41 },
  { 6916, 19, 55, 10, -8, -41 },
  { 7047, 20, 43, 18, 0, -43 },
  { 7155, 12, 43, 9, 0, -43 },
  { 7220, 30, 31, 32, 0, -31 },
  { 7337, 19, 31, 21, 0, -31 },
  { 7411, 17, 32, 21, 2, -31 },
  { 7479, 22, 44, 22, -2, -31 },
  { 7600, 20, 44, 22, 2, -31 },
  { 7710, 16, 31, 14, 0, -31 },
  { 7772, 18, 32, 16, -1, -31 },
  { 7844, 11, 38, 11, 1, -37 },
  { 7897, 19, 31, 21, 1, -30 },
  { 7971, 16, 30, 16, 3, -30 },
  { 8031, 27, 30, 27, 3, -30 },
  { 8133, 22, 30, 17, -3, -30 },
  { 8216, 26, 44, 17, -6, -30 },
  { 8359, 18, 30, 14, -2, -30 },
  { 8427, 19, 50, 18, 2, -41 },
  { 8546, 2, 57, 20, 9, -43 },
  { 8561, 20, 50, 18, -4, -41 },
  { 8686, 20, 5, 23, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC57PT7B_H_
