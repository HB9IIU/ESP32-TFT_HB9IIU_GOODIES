#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_ExtraCondensed_ExtraLightItalic
// Headers: 67

#include "NotoSans_ExtraCondensed_ExtraLightItalic6pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic7pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic8pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic9pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic10pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic11pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic12pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic13pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic14pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic15pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic16pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic17pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic18pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic19pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic20pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic21pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic22pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic23pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic24pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic25pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic26pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic27pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic28pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic29pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic30pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic31pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic32pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic33pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic34pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic35pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic36pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic37pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic38pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic39pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic40pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic41pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic42pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic43pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic44pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic45pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic46pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic47pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic48pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic49pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic50pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic51pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic52pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic53pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic54pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic55pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic56pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic57pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic58pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic59pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic60pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic61pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic62pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic63pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic64pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic65pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic66pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic67pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic68pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic69pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic70pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic71pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLightItalic72pt7b.h"
