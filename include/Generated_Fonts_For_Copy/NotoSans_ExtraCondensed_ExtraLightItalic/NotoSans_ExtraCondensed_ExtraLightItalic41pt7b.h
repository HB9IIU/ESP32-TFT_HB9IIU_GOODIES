#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC41PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x08,
  0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x60, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0xC0, 0x31, 0x90, 0x98, 0xCC, 0x64, 0x22,
  0x11, 0x09, 0x8C, 0x84, 0x42, 0x00, 0x00, 0x63, 0x00, 0x43, 0x00, 0xC2,
  0x00, 0x82, 0x00, 0x86, 0x01, 0x84, 0x01, 0x04, 0x01, 0x0C, 0x1F, 0xFF,
  0x1F, 0xFF, 0x02, 0x18, 0x06, 0x10, 0x06, 0x10, 0x04, 0x30, 0x04, 0x20,
  0x0C, 0x20, 0x08, 0x60, 0x08, 0x60, 0xFF, 0xF8, 0x10, 0x40, 0x10, 0xC0,
  0x30, 0x80, 0x20, 0x80, 0x21, 0x80, 0x61, 0x00, 0x61, 0x00, 0x43, 0x00,
  0x42, 0x00, 0xC2, 0x00, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x07, 0x80,
  0x3F, 0xE0, 0xC8, 0x43, 0x10, 0x04, 0x20, 0x18, 0x40, 0x31, 0x80, 0x62,
  0x00, 0x44, 0x00, 0x88, 0x01, 0x90, 0x01, 0xE0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x05, 0x80, 0x19, 0x00, 0x23, 0x00, 0x46, 0x00, 0x84, 0x01,
  0x18, 0x04, 0x30, 0x08, 0x40, 0x11, 0x84, 0x26, 0x0F, 0xF8, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x61, 0x98,
  0x10, 0xC2, 0x0C, 0x20, 0x82, 0x18, 0x21, 0x86, 0x18, 0x41, 0x06, 0x30,
  0x41, 0x88, 0x30, 0x46, 0x0C, 0x11, 0x02, 0x04, 0xC0, 0x83, 0x23, 0xA0,
  0x99, 0xB8, 0x24, 0xC7, 0x1B, 0x21, 0xCC, 0x98, 0x5E, 0x64, 0x13, 0x11,
  0x04, 0x0C, 0xC1, 0x02, 0x20, 0x41, 0x88, 0x30, 0x42, 0x0C, 0x30, 0x82,
  0x08, 0x60, 0x86, 0x18, 0x61, 0x06, 0x10, 0xC1, 0x8C, 0x20, 0x22, 0x18,
  0x0F, 0x00, 0x00, 0xC0, 0x0F, 0x80, 0xC4, 0x04, 0x20, 0x61, 0x02, 0x08,
  0x10, 0x40, 0x86, 0x04, 0x30, 0x21, 0x01, 0x18, 0x0D, 0x80, 0x78, 0x03,
  0x80, 0x18, 0x01, 0xE0, 0x1B, 0x01, 0x88, 0x48, 0x42, 0xC3, 0x34, 0x19,
  0x60, 0x4A, 0x02, 0xD0, 0x1C, 0x80, 0xE4, 0x06, 0x20, 0x39, 0x83, 0xCC,
  0x32, 0x3F, 0x10, 0x32, 0x66, 0x44, 0x4C, 0x88, 0x00, 0x60, 0x18, 0x02,
  0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18,
  0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00,
  0x60, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x03, 0x00, 0x00, 0x04, 0x01,
  0x00, 0x43, 0x10, 0x64, 0x47, 0xF0, 0xC0, 0xD0, 0x62, 0x30, 0x80, 0x10,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x03, 0xFF, 0xF0, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x0C, 0x21,
  0x86, 0x10, 0xC2, 0x18, 0xC0, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x0F, 0x80, 0xC6, 0x0C, 0x30, 0xC0, 0x84, 0x04, 0x60, 0x23, 0x01,
  0x10, 0x09, 0x80, 0x4C, 0x02, 0x40, 0x36, 0x01, 0xB0, 0x0D, 0x00, 0x68,
  0x02, 0x40, 0x16, 0x01, 0xB0, 0x0D, 0x80, 0x4C, 0x02, 0x40, 0x32, 0x01,
  0x90, 0x08, 0x80, 0xC4, 0x04, 0x30, 0x61, 0x86, 0x06, 0x60, 0x3E, 0x00,
  0x03, 0x0F, 0x1B, 0x32, 0x62, 0x46, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C,
  0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20,
  0x60, 0x60, 0x60, 0x40, 0xC0, 0x00, 0x70, 0x03, 0xFC, 0x02, 0x06, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x70, 0x03, 0xFC, 0x06, 0x06, 0x02,
  0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x03, 0xC0, 0x07,
  0xE0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0xC1, 0xC0, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0A, 0x00, 0x1E, 0x00, 0x36, 0x00, 0x24, 0x00, 0x64, 0x00, 0x4C, 0x00,
  0x8C, 0x01, 0x8C, 0x01, 0x08, 0x03, 0x08, 0x02, 0x18, 0x04, 0x18, 0x0C,
  0x10, 0x08, 0x10, 0x18, 0x10, 0x10, 0x30, 0x20, 0x30, 0x60, 0x20, 0x40,
  0x20, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0xFF, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x1F, 0xE0, 0x08, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x81,
  0xC0, 0xFF, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x38, 0x00, 0x80, 0x06, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x67, 0xC1, 0xBB, 0x85, 0x06, 0x18, 0x0C, 0x60, 0x33, 0x00, 0xCC, 0x03,
  0x30, 0x0C, 0xC0, 0x33, 0x00, 0xC8, 0x02, 0x20, 0x08, 0x80, 0x63, 0x01,
  0x0C, 0x0C, 0x10, 0x20, 0x63, 0x80, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x07, 0xF0, 0x18, 0x30, 0x20, 0x30, 0xC0,
  0x61, 0x00, 0xC2, 0x01, 0x84, 0x03, 0x08, 0x04, 0x10, 0x08, 0x30, 0x30,
  0x60, 0xC0, 0x63, 0x00, 0x5C, 0x00, 0xE0, 0x03, 0xC0, 0x1C, 0xC0, 0x60,
  0xC1, 0x80, 0x82, 0x01, 0x8C, 0x03, 0x10, 0x02, 0x20, 0x04, 0x40, 0x08,
  0x80, 0x31, 0x00, 0x62, 0x00, 0x86, 0x03, 0x06, 0x0C, 0x07, 0xF0, 0x00,
  0x00, 0xE0, 0x0F, 0xE0, 0x61, 0x81, 0x03, 0x0C, 0x0C, 0x20, 0x11, 0x80,
  0x44, 0x01, 0x10, 0x04, 0xC0, 0x13, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0xC0,
  0x33, 0x01, 0xC4, 0x0E, 0x18, 0x68, 0x3F, 0x60, 0x71, 0x80, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x87, 0x03, 0xF0, 0x00, 0x04, 0x30, 0xC2, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xC3, 0x00, 0x01, 0x01,
  0xC0, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x03, 0x01, 0x80, 0x80, 0xC0,
  0x40, 0x60, 0x20, 0x30, 0x00, 0x00, 0x04, 0x00, 0x30, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70,
  0x00, 0x80, 0x00, 0x07, 0x03, 0xF8, 0x41, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x0C, 0x0C, 0x01, 0x80, 0x60, 0x30, 0x02, 0x06, 0x00, 0x20, 0x40, 0x03,
  0x08, 0x00, 0x31, 0x80, 0x03, 0x10, 0x3E, 0x11, 0x06, 0x63, 0x30, 0xC6,
  0x32, 0x08, 0x43, 0x21, 0x04, 0x36, 0x10, 0xC2, 0x43, 0x0C, 0x24, 0x20,
  0x82, 0x42, 0x08, 0x6C, 0x61, 0x84, 0xC6, 0x18, 0x4C, 0x61, 0x0C, 0x86,
  0x30, 0x88, 0x63, 0x18, 0x86, 0x51, 0x08, 0x3C, 0xE0, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x20, 0x01, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x05, 0x00, 0x34, 0x00, 0x90, 0x06, 0x40, 0x19, 0x00, 0x44,
  0x03, 0x10, 0x08, 0x40, 0x61, 0x01, 0x84, 0x04, 0x10, 0x30, 0x40, 0x81,
  0x07, 0xFC, 0x1F, 0xF0, 0x40, 0x43, 0x01, 0x08, 0x04, 0x60, 0x11, 0x80,
  0x4C, 0x01, 0x30, 0x04, 0x80, 0x16, 0x00, 0x58, 0x01, 0xC0, 0x04, 0x03,
  0xFC, 0x02, 0x0E, 0x02, 0x02, 0x06, 0x03, 0x06, 0x03, 0x06, 0x03, 0x04,
  0x03, 0x04, 0x03, 0x0C, 0x02, 0x0C, 0x06, 0x0C, 0x06, 0x08, 0x0C, 0x08,
  0x38, 0x1F, 0xE0, 0x18, 0x70, 0x18, 0x18, 0x10, 0x08, 0x10, 0x0C, 0x30,
  0x0C, 0x30, 0x0C, 0x20, 0x0C, 0x20, 0x08, 0x60, 0x08, 0x60, 0x18, 0x60,
  0x18, 0x40, 0x30, 0x40, 0x60, 0xC3, 0xC0, 0xFF, 0x00, 0x00, 0x38, 0x01,
  0xFC, 0x0E, 0x08, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x08, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0x07, 0x00, 0x81,
  0x80, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x08, 0x10, 0x04, 0x08, 0x03, 0x0C,
  0x01, 0x86, 0x00, 0xC3, 0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0xC0, 0x18,
  0x60, 0x0C, 0x20, 0x06, 0x10, 0x03, 0x18, 0x01, 0x0C, 0x01, 0x86, 0x00,
  0xC2, 0x00, 0x41, 0x00, 0x61, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x30, 0x20,
  0x30, 0x10, 0x30, 0x19, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x08, 0x1F, 0xF0,
  0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xF8, 0x07, 0x01, 0x81,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0xF8, 0x40, 0x3F, 0x08, 0x00, 0x61, 0x00,
  0x08, 0x60, 0x01, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x82, 0x00,
  0x20, 0x40, 0x04, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x18, 0x06, 0x01, 0x81,
  0x80, 0x1F, 0xF0, 0x00, 0x03, 0x00, 0x60, 0x40, 0x0C, 0x08, 0x01, 0x03,
  0x00, 0x20, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x00, 0x30, 0x20, 0x04, 0x0C,
  0x00, 0x81, 0x80, 0x30, 0x30, 0x06, 0x04, 0x00, 0xC0, 0x80, 0x10, 0x3F,
  0xFE, 0x06, 0x00, 0xC0, 0x80, 0x18, 0x10, 0x02, 0x06, 0x00, 0x40, 0xC0,
  0x18, 0x18, 0x03, 0x02, 0x00, 0x60, 0x40, 0x08, 0x18, 0x01, 0x03, 0x00,
  0x60, 0x60, 0x0C, 0x08, 0x01, 0x81, 0x00, 0x20, 0x60, 0x04, 0x0C, 0x01,
  0x80, 0x03, 0xF0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0xFC, 0x00, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x09, 0xC0, 0x3E, 0x00,
  0x03, 0x01, 0xC0, 0x80, 0x40, 0x20, 0x30, 0x18, 0x18, 0x06, 0x0C, 0x01,
  0x83, 0x00, 0x41, 0x80, 0x10, 0xC0, 0x0C, 0x20, 0x03, 0x18, 0x00, 0xCC,
  0x00, 0x26, 0x00, 0x09, 0x00, 0x06, 0xC0, 0x01, 0xF8, 0x00, 0x56, 0x00,
  0x18, 0x80, 0x0C, 0x20, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x20, 0xC0, 0x08,
  0x10, 0x06, 0x04, 0x01, 0x81, 0x80, 0x60, 0x60, 0x10, 0x18, 0x04, 0x02,
  0x03, 0x00, 0xC0, 0xC0, 0x30, 0x00, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20,
  0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10,
  0x18, 0x0F, 0xF8, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00,
  0xE0, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x50, 0x3C, 0x00, 0x78, 0x16, 0x00,
  0x2C, 0x0B, 0x00, 0x36, 0x0D, 0x80, 0x12, 0x06, 0x40, 0x19, 0x03, 0x20,
  0x09, 0x81, 0x10, 0x0C, 0xC0, 0x88, 0x04, 0x60, 0xC4, 0x06, 0x20, 0x62,
  0x02, 0x10, 0x21, 0x03, 0x18, 0x10, 0x81, 0x0C, 0x18, 0x41, 0x84, 0x0C,
  0x20, 0x82, 0x06, 0x10, 0xC3, 0x02, 0x0C, 0x61, 0x81, 0x06, 0x60, 0xC1,
  0x83, 0x30, 0x40, 0xC1, 0x90, 0x20, 0x60, 0xD8, 0x30, 0x20, 0x68, 0x18,
  0x10, 0x3C, 0x0C, 0x18, 0x1C, 0x04, 0x0C, 0x0E, 0x06, 0x00, 0x03, 0x00,
  0x30, 0x30, 0x03, 0x03, 0x80, 0x20, 0x78, 0x02, 0x06, 0x80, 0x60, 0x68,
  0x06, 0x04, 0x80, 0x60, 0x4C, 0x04, 0x0C, 0xC0, 0x40, 0xCC, 0x0C, 0x0C,
  0x40, 0xC0, 0x84, 0x08, 0x08, 0x40, 0x81, 0x86, 0x08, 0x18, 0x61, 0x81,
  0x02, 0x18, 0x10, 0x21, 0x03, 0x02, 0x10, 0x30, 0x33, 0x03, 0x03, 0x30,
  0x20, 0x33, 0x02, 0x01, 0x20, 0x60, 0x12, 0x06, 0x01, 0x60, 0x60, 0x1E,
  0x04, 0x01, 0xC0, 0x40, 0x1C, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x7F, 0x00, 0x60, 0xC0, 0x60, 0x60, 0x60, 0x18, 0x60, 0x0C,
  0x30, 0x06, 0x30, 0x03, 0x18, 0x01, 0x88, 0x00, 0xCC, 0x00, 0x66, 0x00,
  0x32, 0x00, 0x1B, 0x00, 0x09, 0x80, 0x04, 0xC0, 0x06, 0x60, 0x03, 0x20,
  0x01, 0x90, 0x00, 0x88, 0x00, 0x4C, 0x00, 0x66, 0x00, 0x33, 0x00, 0x31,
  0x80, 0x18, 0xC0, 0x08, 0x20, 0x0C, 0x18, 0x0C, 0x0C, 0x0C, 0x03, 0x0C,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x04, 0x38, 0x08, 0x18, 0x30, 0x30, 0x60,
  0x20, 0xC0, 0x41, 0x00, 0x82, 0x01, 0x0C, 0x02, 0x18, 0x0C, 0x30, 0x18,
  0x40, 0x20, 0x80, 0xC3, 0x03, 0x06, 0x0C, 0x0F, 0xF0, 0x1F, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x7F, 0x00, 0x60, 0xC0, 0x60, 0x60, 0x60, 0x18, 0x60, 0x0C, 0x30,
  0x06, 0x30, 0x03, 0x18, 0x01, 0x88, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x32,
  0x00, 0x1B, 0x00, 0x09, 0x80, 0x04, 0xC0, 0x06, 0x60, 0x03, 0x20, 0x01,
  0x90, 0x00, 0x88, 0x00, 0x4C, 0x00, 0x66, 0x00, 0x23, 0x00, 0x31, 0x80,
  0x18, 0xC0, 0x08, 0x20, 0x0C, 0x18, 0x0C, 0x0C, 0x0C, 0x03, 0x0C, 0x00,
  0xFC, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0xF8, 0x04, 0x38, 0x08, 0x18, 0x30,
  0x30, 0x60, 0x20, 0xC0, 0x41, 0x00, 0x82, 0x01, 0x0C, 0x02, 0x18, 0x0C,
  0x30, 0x18, 0x40, 0x60, 0x80, 0xC3, 0x03, 0x06, 0x1C, 0x0F, 0xE0, 0x10,
  0x80, 0x61, 0x00, 0xC3, 0x01, 0x86, 0x02, 0x0C, 0x04, 0x08, 0x18, 0x10,
  0x30, 0x30, 0x60, 0x60, 0x80, 0xC1, 0x01, 0x86, 0x01, 0x0C, 0x02, 0x00,
  0x00, 0x38, 0x01, 0xFF, 0x03, 0x01, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0xC0, 0xC0, 0xFF, 0x80,
  0x7F, 0xFC, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x00,
  0x06, 0x00, 0xC1, 0x00, 0x20, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x82,
  0x00, 0x40, 0x80, 0x10, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x00, 0x81, 0x00,
  0x20, 0x40, 0x08, 0x30, 0x06, 0x0C, 0x01, 0x82, 0x00, 0x40, 0x80, 0x10,
  0x20, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x00, 0x20, 0x40, 0x08, 0x30,
  0x06, 0x0C, 0x01, 0x83, 0x00, 0x40, 0xC0, 0x30, 0x30, 0x08, 0x06, 0x06,
  0x01, 0xC3, 0x00, 0x3F, 0x80, 0x00, 0xC0, 0x07, 0x80, 0x1B, 0x00, 0x36,
  0x00, 0x4C, 0x01, 0x98, 0x02, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x21, 0x80,
  0xC3, 0x01, 0x06, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x30, 0x60, 0x60, 0x80,
  0xC3, 0x01, 0x84, 0x03, 0x18, 0x06, 0x20, 0x0C, 0xC0, 0x19, 0x80, 0x32,
  0x00, 0x6C, 0x00, 0xD0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x0C, 0x01, 0xE0, 0x0C, 0x00, 0xB0, 0x06, 0x00, 0xD8, 0x03,
  0x00, 0x4C, 0x03, 0x80, 0x66, 0x01, 0x40, 0x33, 0x01, 0xA0, 0x11, 0x80,
  0x90, 0x18, 0xC0, 0x48, 0x08, 0x60, 0x64, 0x0C, 0x30, 0x22, 0x06, 0x18,
  0x31, 0x02, 0x0C, 0x10, 0x83, 0x06, 0x08, 0x41, 0x03, 0x0C, 0x21, 0x81,
  0x84, 0x10, 0xC0, 0xC6, 0x08, 0x40, 0x63, 0x04, 0x60, 0x31, 0x02, 0x20,
  0x19, 0x81, 0x30, 0x0C, 0x81, 0x98, 0x06, 0xC0, 0xC8, 0x03, 0x60, 0x6C,
  0x01, 0xA0, 0x34, 0x00, 0xF0, 0x1A, 0x00, 0x50, 0x0F, 0x00, 0x28, 0x07,
  0x00, 0x1C, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x00, 0x01, 0x00, 0xC0, 0x40,
  0x60, 0x18, 0x10, 0x06, 0x0C, 0x01, 0x82, 0x00, 0x61, 0x80, 0x08, 0x40,
  0x02, 0x30, 0x00, 0x88, 0x00, 0x26, 0x00, 0x0B, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x40, 0x00, 0xD8,
  0x00, 0x26, 0x00, 0x19, 0x80, 0x0C, 0x60, 0x02, 0x18, 0x01, 0x82, 0x00,
  0x40, 0x80, 0x30, 0x20, 0x08, 0x08, 0x06, 0x02, 0x03, 0x00, 0xC0, 0xC0,
  0x30, 0x00, 0xC0, 0x1A, 0x01, 0x90, 0x08, 0x80, 0xC4, 0x04, 0x20, 0x61,
  0x02, 0x0C, 0x30, 0x61, 0x03, 0x18, 0x18, 0x80, 0x4C, 0x02, 0x40, 0x16,
  0x00, 0xA0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x02, 0x0F, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0xC3, 0x04, 0x10, 0x41, 0x06, 0x18, 0x60, 0x82, 0x08, 0x20, 0xC3, 0x0C,
  0x10, 0x41, 0x04, 0x18, 0x61, 0x82, 0x08, 0x20, 0x83, 0x0C, 0x00, 0xFE,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x01, 0x80, 0x03, 0x80, 0x0F, 0x00,
  0x12, 0x00, 0x66, 0x01, 0x84, 0x03, 0x0C, 0x0C, 0x18, 0x10, 0x10, 0x60,
  0x30, 0x80, 0x23, 0x00, 0x64, 0x00, 0x58, 0x00, 0xC0, 0xFF, 0xE0, 0xC4,
  0x62, 0x21, 0x01, 0xE6, 0x0E, 0x68, 0x30, 0x50, 0xC0, 0xA1, 0x80, 0xC6,
  0x01, 0x8C, 0x02, 0x10, 0x0C, 0x60, 0x18, 0xC0, 0x31, 0x00, 0x42, 0x00,
  0x8C, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x10, 0xC0, 0x61, 0x80, 0xC3,
  0x03, 0x82, 0x0F, 0x06, 0x34, 0x07, 0xC8, 0x00, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x09, 0xF0, 0x16, 0x70, 0x78, 0x60, 0xE0, 0x41, 0x80, 0xC3, 0x01,
  0x8C, 0x03, 0x18, 0x06, 0x30, 0x08, 0x40, 0x10, 0x80, 0x23, 0x00, 0xC6,
  0x01, 0x88, 0x02, 0x10, 0x04, 0x20, 0x18, 0xC0, 0x21, 0x80, 0xC3, 0x01,
  0x87, 0x06, 0x0A, 0x18, 0x33, 0xE0, 0x00, 0x01, 0xF0, 0x72, 0x0C, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04,
  0x00, 0x61, 0x03, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x01,
  0xF3, 0x01, 0xCD, 0x01, 0x82, 0x81, 0x81, 0xC0, 0xC0, 0x60, 0xC0, 0x20,
  0x60, 0x30, 0x20, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x08, 0x02, 0x04, 0x01,
  0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x20, 0x60, 0x30, 0x30,
  0x18, 0x18, 0x1C, 0x04, 0x1E, 0x03, 0x1A, 0x00, 0xF9, 0x00, 0x03, 0xE0,
  0x73, 0x0C, 0x31, 0x81, 0x10, 0x13, 0x03, 0x20, 0x36, 0x06, 0x60, 0x64,
  0x1C, 0x7F, 0x0F, 0x80, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x83, 0xF8, 0x00, 0x07, 0xC0, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x79, 0x80, 0xE6, 0x80, 0xC1, 0x40, 0xC0,
  0xA0, 0x60, 0x30, 0x60, 0x10, 0x30, 0x18, 0x10, 0x0C, 0x18, 0x06, 0x0C,
  0x03, 0x04, 0x01, 0x02, 0x00, 0x83, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30,
  0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0E, 0x02, 0x0F, 0x01, 0x8D,
  0x00, 0x7C, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x04, 0x0C, 0x03, 0xFC, 0x00, 0x7C, 0x00,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x13, 0xE0, 0x59, 0x83, 0x83, 0x0E, 0x0C, 0x30,
  0x30, 0xC0, 0xC2, 0x03, 0x18, 0x08, 0x60, 0x21, 0x01, 0x84, 0x06, 0x30,
  0x10, 0xC0, 0x43, 0x01, 0x08, 0x0C, 0x20, 0x31, 0x80, 0x86, 0x02, 0x10,
  0x18, 0x40, 0x61, 0x01, 0x8C, 0x04, 0x00, 0x03, 0x03, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10,
  0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x78, 0x03, 0x80, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x30, 0x40, 0x83,
  0x06, 0x0C, 0x30, 0x21, 0x80, 0x84, 0x06, 0x30, 0x19, 0x80, 0x6C, 0x01,
  0x30, 0x05, 0x40, 0x3D, 0x00, 0xE4, 0x03, 0x18, 0x08, 0x60, 0x21, 0x81,
  0x82, 0x06, 0x08, 0x10, 0x20, 0x40, 0xC3, 0x03, 0x0C, 0x0C, 0x00, 0x01,
  0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C,
  0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20,
  0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0x04, 0xF0, 0xF0, 0x36, 0x66, 0x60,
  0xE0, 0xA0, 0xC3, 0x03, 0x03, 0x0C, 0x0C, 0x0C, 0x20, 0x30, 0x21, 0x80,
  0x80, 0x86, 0x06, 0x02, 0x18, 0x18, 0x18, 0x40, 0x60, 0x61, 0x01, 0x01,
  0x0C, 0x04, 0x04, 0x30, 0x30, 0x30, 0xC0, 0xC0, 0xC2, 0x03, 0x03, 0x08,
  0x08, 0x08, 0x60, 0x20, 0x21, 0x81, 0x81, 0x84, 0x06, 0x06, 0x10, 0x10,
  0x18, 0x40, 0x40, 0x43, 0x03, 0x01, 0x00, 0x04, 0xF8, 0x36, 0x60, 0xE0,
  0xC2, 0x83, 0x0C, 0x0C, 0x30, 0x31, 0x80, 0x86, 0x02, 0x18, 0x08, 0x40,
  0x61, 0x01, 0x8C, 0x04, 0x30, 0x10, 0xC0, 0x42, 0x03, 0x08, 0x0C, 0x60,
  0x21, 0x80, 0x84, 0x06, 0x10, 0x18, 0x40, 0x63, 0x01, 0x00, 0x03, 0xE0,
  0x39, 0x83, 0x04, 0x30, 0x31, 0x01, 0x98, 0x0C, 0xC0, 0x64, 0x03, 0x60,
  0x1B, 0x00, 0xD0, 0x06, 0x80, 0x2C, 0x01, 0x60, 0x1B, 0x00, 0xD8, 0x04,
  0xC0, 0x66, 0x03, 0x30, 0x30, 0x81, 0x06, 0x38, 0x1F, 0x00, 0x01, 0x3E,
  0x00, 0xB3, 0x80, 0xF0, 0xC0, 0x70, 0x20, 0x30, 0x18, 0x18, 0x0C, 0x18,
  0x06, 0x0C, 0x03, 0x06, 0x01, 0x82, 0x00, 0x81, 0x00, 0x41, 0x80, 0x60,
  0xC0, 0x30, 0x60, 0x18, 0x20, 0x08, 0x10, 0x0C, 0x18, 0x06, 0x0C, 0x06,
  0x06, 0x03, 0x02, 0x83, 0x01, 0x43, 0x01, 0x9F, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x00, 0x03, 0xE6, 0x0E, 0xE8, 0x30, 0x50, 0xC0, 0xA1,
  0x80, 0xC6, 0x01, 0x0C, 0x02, 0x10, 0x0C, 0x60, 0x18, 0xC0, 0x31, 0x00,
  0x42, 0x00, 0x8C, 0x01, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x10, 0xC0, 0x61,
  0x80, 0xC3, 0x03, 0x82, 0x0F, 0x06, 0x34, 0x07, 0xC8, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x04, 0xF0, 0xDD, 0x0F, 0x00, 0xA0, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0x03, 0xF0, 0x39, 0xC3, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x0C, 0x18, 0x7F,
  0x80, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x3F, 0x7F, 0x18, 0x10, 0x10, 0x30,
  0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80,
  0x80, 0x80, 0x80, 0xF0, 0x08, 0x0C, 0x60, 0x21, 0x80, 0x86, 0x02, 0x10,
  0x18, 0x40, 0x63, 0x01, 0x0C, 0x04, 0x20, 0x10, 0x80, 0xC2, 0x03, 0x18,
  0x08, 0x60, 0x21, 0x01, 0x84, 0x06, 0x30, 0x18, 0xC0, 0x43, 0x03, 0x0C,
  0x0C, 0x30, 0x70, 0xC2, 0xC1, 0xF2, 0x00, 0xC0, 0x3C, 0x02, 0xC0, 0x6C,
  0x04, 0xC0, 0xCC, 0x08, 0xC1, 0x8C, 0x18, 0xC1, 0x0C, 0x30, 0xC2, 0x0C,
  0x60, 0xC4, 0x0C, 0xC0, 0xC8, 0x0D, 0x80, 0xD8, 0x0D, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0x40, 0x60, 0x28, 0x0C, 0x0D, 0x01, 0x81, 0xA0,
  0x50, 0x24, 0x0A, 0x0C, 0x83, 0x41, 0x30, 0x48, 0x26, 0x19, 0x0C, 0xC3,
  0x21, 0x18, 0x44, 0x63, 0x18, 0x88, 0x62, 0x31, 0x0C, 0xC6, 0x61, 0x90,
  0xC8, 0x32, 0x1B, 0x06, 0xC3, 0x40, 0xD0, 0x68, 0x1E, 0x0F, 0x03, 0x81,
  0xC0, 0x70, 0x38, 0x0E, 0x06, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x06,
  0x06, 0x02, 0x04, 0x02, 0x0C, 0x02, 0x18, 0x03, 0x10, 0x03, 0x30, 0x01,
  0x20, 0x01, 0x60, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x06,
  0x80, 0x04, 0xC0, 0x0C, 0xC0, 0x08, 0x40, 0x18, 0x40, 0x30, 0x40, 0x20,
  0x60, 0x60, 0x60, 0xC0, 0x20, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x00, 0xC0,
  0x60, 0x0C, 0x04, 0x00, 0xC0, 0xC0, 0x0C, 0x08, 0x00, 0xC1, 0x80, 0x0C,
  0x10, 0x00, 0xC3, 0x00, 0x0C, 0x20, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00,
  0xC4, 0x00, 0x0C, 0xC0, 0x00, 0xC8, 0x00, 0x0D, 0x80, 0x00, 0xD0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0F, 0xF0, 0x00, 0x3C,
  0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x70, 0x03, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x30, 0x0F, 0x80,
  0x00, 0x7E, 0x03, 0x87, 0x0E, 0x03, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 29, 9, 1, -29 },
  { 30, 9, 10, 11, 4, -29 },
  { 42, 16, 29, 16, 0, -29 },
  { 100, 15, 33, 14, 0, -31 },
  { 162, 18, 30, 22, 2, -30 },
  { 230, 13, 30, 14, 0, -30 },
  { 279, 4, 10, 6, 4, -29 },
  { 284, 11, 35, 10, 1, -29 },
  { 333, 11, 35, 10, -3, -29 },
  { 382, 10, 11, 13, 5, -31 },
  { 396, 14, 19, 17, 1, -24 },
  { 430, 6, 9, 7, -2, -4 },
  { 437, 9, 2, 11, 1, -12 },
  { 440, 2, 3, 7, 1, -3 },
  { 441, 17, 29, 12, -2, -29 },
  { 503, 13, 30, 14, 1, -30 },
  { 552, 8, 29, 14, 4, -29 },
  { 581, 16, 30, 14, -1, -30 },
  { 641, 16, 30, 14, -1, -30 },
  { 701, 16, 30, 14, -1, -30 },
  { 761, 16, 29, 14, -1, -29 },
  { 819, 14, 30, 14, 1, -30 },
  { 872, 15, 29, 14, 1, -29 },
  { 927, 15, 30, 14, 0, -30 },
  { 984, 14, 30, 14, 0, -30 },
  { 1037, 6, 22, 7, 0, -22 },
  { 1054, 9, 27, 7, -2, -22 },
  { 1085, 14, 17, 17, 1, -23 },
  { 1115, 14, 11, 17, 1, -20 },
  { 1135, 15, 17, 17, 1, -23 },
  { 1167, 11, 30, 10, 1, -30 },
  { 1209, 20, 33, 22, 1, -29 },
  { 1292, 14, 29, 14, -3, -29 },
  { 1343, 16, 29, 16, 0, -29 },
  { 1401, 15, 30, 14, 2, -30 },
  { 1458, 17, 29, 17, 0, -29 },
  { 1520, 16, 29, 14, 0, -29 },
  { 1578, 16, 29, 13, 0, -29 },
  { 1636, 19, 30, 19, 1, -30 },
  { 1708, 19, 29, 18, 0, -29 },
  { 1777, 12, 29, 8, -2, -29 },
  { 1821, 14, 36, 7, -6, -29 },
  { 1884, 18, 29, 15, 0, -29 },
  { 1950, 9, 29, 13, 0, -29 },
  { 1983, 25, 29, 25, 0, -29 },
  { 2074, 20, 29, 19, 0, -29 },
  { 2147, 17, 30, 19, 1, -30 },
  { 2211, 15, 29, 15, 0, -29 },
  { 2266, 17, 37, 19, 1, -30 },
  { 2345, 15, 29, 15, 0, -29 },
  { 2400, 16, 30, 14, -1, -30 },
  { 2460, 13, 29, 12, 3, -29 },
  { 2508, 18, 29, 18, 1, -29 },
  { 2574, 15, 29, 15, 3, -29 },
  { 2629, 25, 29, 25, 3, -29 },
  { 2720, 18, 29, 13, -2, -29 },
  { 2786, 13, 29, 12, 3, -29 },
  { 2834, 17, 29, 13, -2, -29 },
  { 2896, 15, 36, 11, -1, -29 },
  { 2964, 6, 29, 13, 4, -29 },
  { 2986, 15, 36, 11, -3, -29 },
  { 3054, 15, 14, 16, 1, -29 },
  { 3081, 11, 1, 11, -3, 4 },
  { 3083, 4, 6, 9, 6, -31 },
  { 3086, 15, 22, 16, 1, -22 },
  { 3128, 15, 31, 16, 0, -31 },
  { 3187, 12, 22, 11, 1, -22 },
  { 3220, 17, 31, 16, 1, -31 },
  { 3286, 12, 22, 14, 1, -22 },
  { 3319, 18, 41, 8, -5, -31 },
  { 3412, 17, 32, 16, -1, -22 },
  { 3480, 14, 31, 15, 0, -31 },
  { 3535, 8, 29, 7, 0, -29 },
  { 3564, 13, 39, 7, -5, -29 },
  { 3628, 14, 31, 13, 0, -31 },
  { 3683, 8, 31, 6, 0, -31 },
  { 3714, 22, 22, 23, 0, -22 },
  { 3775, 14, 22, 15, 0, -22 },
  { 3814, 13, 22, 15, 1, -22 },
  { 3850, 17, 31, 16, -2, -22 },
  { 3916, 15, 32, 16, 1, -22 },
  { 3976, 12, 22, 10, 0, -22 },
  { 4009, 13, 22, 12, -1, -22 },
  { 4045, 8, 27, 8, 1, -27 },
  { 4072, 14, 22, 15, 1, -22 },
  { 4111, 12, 22, 12, 2, -22 },
  { 4144, 19, 22, 20, 2, -22 },
  { 4197, 16, 22, 12, -2, -22 },
  { 4241, 20, 32, 12, -5, -22 },
  { 4321, 12, 22, 10, -1, -22 },
  { 4354, 14, 35, 13, 1, -29 },
  { 4416, 2, 41, 14, 6, -31 },
  { 4427, 14, 35, 13, -3, -29 },
  { 4489, 15, 3, 17, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC41PT7B_H_
