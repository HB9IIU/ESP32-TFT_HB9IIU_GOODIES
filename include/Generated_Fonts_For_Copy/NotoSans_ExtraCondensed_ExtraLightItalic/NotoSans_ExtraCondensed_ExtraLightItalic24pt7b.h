#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC24PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44, 0x00, 0x08, 0xC0,
  0x4A, 0x52, 0x99, 0x48, 0x04, 0x82, 0x42, 0x21, 0x20, 0x91, 0xFC, 0x48,
  0x24, 0x12, 0x11, 0x09, 0x1F, 0xE4, 0x42, 0x41, 0x21, 0x10, 0x90, 0x00,
  0x02, 0x01, 0x07, 0xE6, 0x82, 0x41, 0x20, 0x90, 0x50, 0x18, 0x04, 0x03,
  0x01, 0x41, 0x20, 0x90, 0x48, 0x28, 0xF8, 0x10, 0x08, 0x00, 0x38, 0x48,
  0x89, 0x12, 0x24, 0x48, 0x91, 0x12, 0x22, 0x94, 0x95, 0x95, 0x3C, 0xA4,
  0x28, 0x85, 0x11, 0x22, 0x24, 0x88, 0x91, 0x12, 0x43, 0x80, 0x0E, 0x12,
  0x12, 0x12, 0x12, 0x14, 0x14, 0x18, 0x30, 0x68, 0x49, 0x8A, 0x86, 0x84,
  0x84, 0x8C, 0xF2, 0x55, 0xA0, 0x04, 0x21, 0x04, 0x21, 0x04, 0x10, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x40, 0x04, 0x08, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x10,
  0x20, 0x82, 0x08, 0x00, 0x12, 0x46, 0xCC, 0x52, 0x40, 0x80, 0x10, 0x10,
  0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x25, 0x28, 0xF8,
  0x70, 0x00, 0x40, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08,
  0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x00, 0x0F,
  0x11, 0x11, 0x21, 0x21, 0x21, 0x41, 0x41, 0x41, 0x41, 0x42, 0x42, 0x82,
  0x84, 0x84, 0x48, 0x78, 0x35, 0x92, 0x22, 0x22, 0x44, 0x44, 0x88, 0x88,
  0x80, 0x0F, 0x80, 0x20, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0xFE, 0x00, 0x0F,
  0x84, 0x20, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x18, 0x0E, 0x00, 0x80,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x18, 0xFC, 0x00, 0x01, 0x81, 0x80,
  0xC0, 0xA0, 0x90, 0x50, 0x48, 0x24, 0x22, 0x21, 0x11, 0x10, 0x8F, 0xF0,
  0x20, 0x20, 0x10, 0x08, 0x00, 0x0F, 0xC2, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x00, 0xF8, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20,
  0x18, 0xFC, 0x00, 0x0F, 0x10, 0x20, 0x20, 0x40, 0x40, 0x98, 0xA4, 0xC4,
  0x82, 0x82, 0x82, 0x84, 0x84, 0x84, 0x88, 0xF0, 0x7F, 0x01, 0x02, 0x02,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x80, 0x1F, 0x08, 0xC8, 0x24, 0x12, 0x11, 0x08, 0x48, 0x38, 0x18, 0x32,
  0x10, 0x90, 0x48, 0x24, 0x12, 0x09, 0x08, 0x78, 0x00, 0x1F, 0x11, 0x21,
  0x21, 0x41, 0x41, 0x41, 0x41, 0x43, 0x3D, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x08, 0xF0, 0x13, 0x00, 0x00, 0x00, 0x00, 0x08, 0x80, 0x08, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x44, 0x21, 0x10, 0x03, 0x0C, 0x30, 0x40, 0x80,
  0x60, 0x18, 0x04, 0x03, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x20, 0x08, 0x06, 0x01, 0x06, 0x18, 0x20, 0xC0, 0x80, 0x3C, 0x04, 0x08,
  0x10, 0x20, 0x82, 0x04, 0x10, 0x40, 0x82, 0x04, 0x00, 0x00, 0x20, 0xC0,
  0x07, 0xC1, 0x04, 0x40, 0x90, 0x14, 0x02, 0x8E, 0x52, 0x4C, 0x49, 0x91,
  0x32, 0x46, 0x49, 0x49, 0x29, 0x65, 0x37, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x01, 0xF0, 0x00, 0x01, 0x80, 0xC0, 0xA0, 0x50, 0x48, 0x24, 0x12, 0x11,
  0x08, 0x88, 0x47, 0xE2, 0x12, 0x09, 0x05, 0x02, 0x81, 0xC0, 0x80, 0x0F,
  0x08, 0x44, 0x22, 0x11, 0x09, 0x04, 0x84, 0x4C, 0x3E, 0x10, 0x90, 0x48,
  0x24, 0x12, 0x09, 0x09, 0x0C, 0xF8, 0x00, 0x0F, 0x88, 0x0C, 0x04, 0x04,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00,
  0x80, 0x78, 0x00, 0x0F, 0x04, 0x21, 0x08, 0x41, 0x10, 0x48, 0x12, 0x04,
  0x81, 0x20, 0x88, 0x24, 0x09, 0x02, 0x41, 0x10, 0x44, 0x22, 0x10, 0xF8,
  0x00, 0x0F, 0x88, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x3E, 0x10,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0xFC, 0x00, 0x0F, 0x88, 0x04,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x3E, 0x10, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x00, 0x80, 0x00, 0x0F, 0xE3, 0x00, 0xC0, 0x10, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x83, 0x90, 0x12, 0x02, 0x40, 0x88, 0x11, 0x02,
  0x20, 0x42, 0x08, 0x3E, 0x00, 0x18, 0x22, 0x04, 0x40, 0x88, 0x21, 0x04,
  0x40, 0x88, 0x11, 0x02, 0x3F, 0x84, 0x11, 0x02, 0x20, 0x44, 0x10, 0x82,
  0x10, 0x44, 0x08, 0x81, 0x00, 0x1E, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08,
  0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0xF0, 0x03, 0x02, 0x02, 0x02,
  0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x10, 0x20, 0xE0, 0x18, 0x44, 0x21, 0x10, 0x44, 0x12, 0x09,
  0x02, 0xC0, 0xA0, 0x38, 0x0A, 0x04, 0x41, 0x10, 0x44, 0x11, 0x04, 0x42,
  0x08, 0x82, 0x00, 0x18, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0x10,
  0x41, 0x04, 0x20, 0xFC, 0x08, 0x06, 0x30, 0x08, 0x60, 0x30, 0xC0, 0x61,
  0x81, 0x45, 0x02, 0x8A, 0x0A, 0x14, 0x14, 0x28, 0x48, 0x48, 0x91, 0x12,
  0x22, 0x24, 0x84, 0x51, 0x08, 0xA2, 0x11, 0x84, 0x43, 0x10, 0x84, 0x20,
  0x08, 0x11, 0x82, 0x18, 0x21, 0x82, 0x14, 0x22, 0x42, 0x24, 0x42, 0x44,
  0x24, 0x42, 0x24, 0x42, 0x84, 0x28, 0x42, 0x84, 0x28, 0x42, 0x88, 0x10,
  0x81, 0x00, 0x0F, 0x08, 0x48, 0x24, 0x14, 0x0A, 0x05, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x28, 0x14, 0x12, 0x09, 0x08, 0x78, 0x00, 0x0F, 0x08,
  0x44, 0x22, 0x11, 0x09, 0x04, 0x84, 0x42, 0x22, 0x1E, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x00, 0x0F, 0x08, 0x48, 0x24, 0x14, 0x0A,
  0x05, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x28, 0x14, 0x12, 0x09, 0x08,
  0x78, 0x08, 0x02, 0x01, 0x00, 0xC0, 0x0F, 0x08, 0x44, 0x22, 0x11, 0x09,
  0x04, 0x84, 0x42, 0x36, 0x14, 0x11, 0x08, 0x84, 0x42, 0x21, 0x11, 0x08,
  0x82, 0x00, 0x0F, 0xC6, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0xFC, 0x00,
  0xFE, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10,
  0x20, 0x40, 0x80, 0x20, 0x48, 0x12, 0x08, 0x82, 0x20, 0x90, 0x24, 0x09,
  0x04, 0x41, 0x20, 0x48, 0x12, 0x08, 0x82, 0x20, 0x88, 0x22, 0x10, 0x78,
  0x00, 0x81, 0x81, 0x82, 0x82, 0x82, 0x84, 0x84, 0x88, 0x88, 0x90, 0x90,
  0x90, 0xA0, 0xA0, 0xC0, 0xC0, 0x80, 0x81, 0x06, 0x0C, 0x18, 0x30, 0xA1,
  0x42, 0x85, 0x0A, 0x14, 0x48, 0x91, 0x22, 0x48, 0x92, 0x22, 0x48, 0x89,
  0x24, 0x28, 0x90, 0xA2, 0x83, 0x0A, 0x0C, 0x28, 0x30, 0xC0, 0x83, 0x00,
  0x08, 0x42, 0x20, 0x88, 0x24, 0x09, 0x02, 0x80, 0xA0, 0x10, 0x0C, 0x03,
  0x01, 0x40, 0x50, 0x24, 0x09, 0x04, 0x42, 0x08, 0x82, 0x00, 0x83, 0x0A,
  0x14, 0x48, 0x92, 0x14, 0x30, 0x60, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40,
  0x80, 0x0F, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x60, 0x10, 0x08,
  0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0xFE, 0x00, 0x0F,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0xF0, 0x84, 0x44, 0x44, 0x44,
  0x22, 0x22, 0x22, 0x21, 0x10, 0x0F, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0xF0, 0x08, 0x18, 0x14, 0x24, 0x42, 0x42, 0x81, 0x81, 0xFE, 0xC8,
  0x80, 0x1D, 0x23, 0x43, 0x42, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x84,
  0x8C, 0xF4, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0xB0, 0xA4, 0x62, 0x20,
  0x90, 0x48, 0x48, 0x24, 0x12, 0x09, 0x08, 0x84, 0xC4, 0x5C, 0x00, 0x1C,
  0x84, 0x10, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xF0, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x10, 0xE8, 0x8C, 0x86, 0x42, 0x21, 0x20, 0x90, 0x48, 0x24,
  0x22, 0x11, 0x08, 0x8C, 0x7A, 0x00, 0x1C, 0x45, 0x0A, 0x18, 0x51, 0x3C,
  0x40, 0x81, 0x02, 0x04, 0x07, 0x80, 0x01, 0xC0, 0x40, 0x10, 0x08, 0x02,
  0x03, 0xE0, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x03, 0x00,
  0x0E, 0x88, 0xC8, 0x64, 0x22, 0x12, 0x09, 0x04, 0x82, 0x42, 0x21, 0x10,
  0x88, 0xC7, 0xA0, 0x20, 0x10, 0x08, 0x08, 0x44, 0x3C, 0x00, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x16, 0x29, 0x31, 0x21, 0x21, 0x21, 0x42, 0x42, 0x42,
  0x42, 0x42, 0x84, 0x84, 0x18, 0x80, 0x01, 0x10, 0x84, 0x21, 0x10, 0x84,
  0x21, 0x10, 0x80, 0x01, 0x02, 0x00, 0x00, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20,
  0x20, 0xC0, 0x08, 0x08, 0x10, 0x10, 0x10, 0x11, 0x22, 0x22, 0x24, 0x28,
  0x38, 0x58, 0x68, 0x48, 0x48, 0x44, 0x84, 0x84, 0x08, 0x44, 0x21, 0x08,
  0x84, 0x21, 0x08, 0x84, 0x21, 0x08, 0x84, 0x00, 0x1E, 0x71, 0x8C, 0xCC,
  0x42, 0x42, 0x12, 0x11, 0x11, 0x09, 0x08, 0x48, 0x42, 0x42, 0x12, 0x11,
  0x11, 0x09, 0x08, 0x48, 0x42, 0x00, 0x16, 0x39, 0x31, 0x21, 0x21, 0x21,
  0x42, 0x42, 0x42, 0x42, 0x42, 0x84, 0x84, 0x1C, 0x45, 0x0A, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x0A, 0x14, 0x4F, 0x00, 0x0B, 0x05, 0x21, 0x84, 0x41,
  0x10, 0x44, 0x22, 0x08, 0x82, 0x20, 0x88, 0x42, 0x11, 0x88, 0x5C, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x00, 0x1D, 0x23, 0x43, 0x42, 0x42,
  0x82, 0x82, 0x82, 0x84, 0x84, 0x84, 0x8C, 0xF4, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x10, 0x16, 0x50, 0xC1, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04,
  0x08, 0x00, 0x1E, 0x45, 0x02, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x10, 0x20,
  0x4F, 0x00, 0x10, 0x84, 0xF2, 0x10, 0x84, 0x22, 0x10, 0x84, 0x42, 0x0C,
  0x21, 0x42, 0x42, 0x42, 0x42, 0x42, 0x84, 0x84, 0x84, 0x84, 0x88, 0x88,
  0xF8, 0x83, 0x06, 0x14, 0x28, 0x91, 0x24, 0x48, 0xA1, 0x42, 0x86, 0x0C,
  0x00, 0x82, 0x18, 0x62, 0x86, 0x28, 0xA4, 0x8A, 0x49, 0x24, 0x92, 0x89,
  0x28, 0xA3, 0x0A, 0x30, 0xC3, 0x0C, 0x20, 0xC2, 0x00, 0x10, 0x88, 0x84,
  0x42, 0x40, 0xC0, 0x60, 0x20, 0x30, 0x14, 0x12, 0x11, 0x08, 0x88, 0x40,
  0x04, 0x30, 0x42, 0x04, 0x20, 0x44, 0x04, 0x40, 0x48, 0x04, 0x80, 0x50,
  0x05, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x10, 0x01, 0x00, 0xE0, 0x00, 0x1F, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x40, 0xF8, 0x07, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0xC0, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x30, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x80, 0x40, 0x20, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xE0, 0x80, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x04, 0x02, 0x0E, 0x00, 0x20, 0x99, 0x84,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 17, 5, 0, -17 },
  { 12, 5, 6, 7, 2, -17 },
  { 16, 9, 17, 9, 0, -17 },
  { 36, 9, 19, 8, 0, -18 },
  { 58, 11, 17, 13, 1, -17 },
  { 82, 8, 17, 8, 0, -17 },
  { 99, 2, 6, 4, 2, -17 },
  { 101, 6, 21, 6, 1, -17 },
  { 117, 7, 21, 6, -2, -17 },
  { 136, 6, 7, 8, 3, -18 },
  { 142, 8, 11, 10, 1, -14 },
  { 153, 3, 5, 4, -1, -2 },
  { 155, 5, 1, 6, 1, -7 },
  { 156, 2, 2, 4, 0, -2 },
  { 157, 10, 17, 7, -1, -17 },
  { 179, 8, 17, 8, 0, -17 },
  { 196, 4, 17, 8, 3, -17 },
  { 205, 10, 17, 8, -1, -17 },
  { 227, 10, 17, 8, -1, -17 },
  { 249, 9, 17, 8, 0, -17 },
  { 269, 10, 17, 8, -1, -17 },
  { 291, 8, 17, 8, 1, -17 },
  { 308, 8, 17, 8, 1, -17 },
  { 325, 9, 17, 8, 0, -17 },
  { 345, 8, 17, 8, 0, -17 },
  { 362, 4, 13, 4, 0, -13 },
  { 369, 5, 16, 4, -1, -13 },
  { 379, 8, 10, 10, 1, -13 },
  { 389, 8, 6, 10, 1, -11 },
  { 395, 8, 10, 10, 1, -13 },
  { 405, 7, 17, 6, 0, -17 },
  { 420, 11, 19, 13, 1, -17 },
  { 447, 9, 17, 8, -2, -17 },
  { 467, 9, 17, 9, 0, -17 },
  { 487, 9, 17, 8, 1, -17 },
  { 507, 10, 17, 10, 0, -17 },
  { 529, 9, 17, 8, 0, -17 },
  { 549, 9, 17, 8, 0, -17 },
  { 569, 11, 17, 11, 1, -17 },
  { 593, 11, 17, 11, 0, -17 },
  { 617, 7, 17, 4, -1, -17 },
  { 632, 8, 21, 4, -3, -17 },
  { 653, 10, 17, 9, 0, -17 },
  { 675, 6, 17, 7, 0, -17 },
  { 688, 15, 17, 14, 0, -17 },
  { 720, 12, 17, 11, 0, -17 },
  { 746, 9, 17, 11, 1, -17 },
  { 766, 9, 17, 9, 0, -17 },
  { 786, 9, 21, 11, 1, -17 },
  { 810, 9, 17, 9, 0, -17 },
  { 830, 10, 17, 8, -1, -17 },
  { 852, 7, 17, 7, 2, -17 },
  { 867, 10, 17, 10, 1, -17 },
  { 889, 8, 17, 9, 2, -17 },
  { 906, 14, 17, 15, 2, -17 },
  { 936, 10, 17, 8, -1, -17 },
  { 958, 7, 17, 7, 2, -17 },
  { 973, 10, 17, 7, -1, -17 },
  { 995, 8, 21, 7, 0, -17 },
  { 1016, 4, 17, 8, 2, -17 },
  { 1025, 8, 21, 7, -1, -17 },
  { 1046, 8, 8, 9, 1, -17 },
  { 1054, 7, 1, 6, -2, 2 },
  { 1055, 3, 3, 5, 3, -18 },
  { 1057, 8, 13, 9, 1, -13 },
  { 1070, 9, 18, 9, 0, -18 },
  { 1091, 6, 13, 7, 1, -13 },
  { 1101, 9, 18, 9, 1, -18 },
  { 1122, 7, 13, 8, 1, -13 },
  { 1134, 10, 24, 5, -3, -18 },
  { 1164, 9, 19, 9, 0, -13 },
  { 1186, 8, 18, 9, 0, -18 },
  { 1204, 5, 17, 4, 0, -17 },
  { 1215, 8, 23, 4, -3, -17 },
  { 1238, 8, 18, 7, 0, -18 },
  { 1256, 5, 18, 4, 0, -18 },
  { 1268, 13, 13, 13, 0, -13 },
  { 1290, 8, 13, 9, 0, -13 },
  { 1303, 7, 13, 9, 1, -13 },
  { 1315, 10, 19, 9, -1, -13 },
  { 1339, 8, 19, 9, 1, -13 },
  { 1358, 7, 13, 6, 0, -13 },
  { 1370, 7, 13, 7, 0, -13 },
  { 1382, 5, 16, 5, 0, -16 },
  { 1392, 8, 13, 9, 1, -13 },
  { 1405, 7, 13, 7, 1, -13 },
  { 1417, 12, 13, 11, 1, -13 },
  { 1437, 9, 13, 7, -1, -13 },
  { 1452, 12, 19, 7, -3, -13 },
  { 1481, 8, 13, 6, -1, -13 },
  { 1494, 8, 21, 8, 1, -17 },
  { 1515, 1, 24, 8, 4, -18 },
  { 1518, 9, 21, 7, -2, -17 },
  { 1542, 8, 3, 10, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC24PT7B_H_
