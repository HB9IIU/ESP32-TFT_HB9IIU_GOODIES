#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC7PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0x80, 0xC0, 0x6F, 0x68, 0x69, 0x2C, 0xEA, 0xE5, 0xA0, 0x7B,
  0xC0, 0xC0, 0x6A, 0xA0, 0xFC, 0xD0, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x29,
  0x48, 0x7F, 0xC0, 0xF8, 0x56, 0xC0, 0x65, 0x2C, 0x6B, 0x64, 0xF1, 0x2C,
  0x73, 0xDC, 0x69, 0x28, 0xF5, 0x6C, 0xFD, 0xC0, 0x90, 0x98, 0x71, 0x80,
  0xE0, 0xC7, 0x00, 0x5A, 0x80, 0x7B, 0xEA, 0xC4, 0x5F, 0xC0, 0x75, 0x5C,
  0x72, 0x4C, 0x76, 0xDC, 0x73, 0x4C, 0x71, 0x48, 0x72, 0xDE, 0x77, 0xDA,
  0x6A, 0x80, 0x55, 0x70, 0x7A, 0x6C, 0x6A, 0xC0, 0x55, 0x7F, 0xD0, 0x6F,
  0xDA, 0x76, 0xDC, 0x77, 0x48, 0x76, 0xDC, 0x80, 0x77, 0x6C, 0xF1, 0x2C,
  0x69, 0x48, 0x76, 0xDC, 0xEA, 0x80, 0xDD, 0xEC, 0xC0, 0xA9, 0x6C, 0xBA,
  0x48, 0x69, 0x4C, 0x6A, 0xA0, 0xF8, 0x55, 0xA0, 0x54, 0xC0, 0x80, 0x76,
  0xE0, 0x5F, 0xC0, 0x6B, 0x2E, 0xDC, 0x7B, 0x2D, 0x24, 0xA0, 0x76, 0xE5,
  0x00, 0x5F, 0xC0, 0xF8, 0x55, 0x58, 0x76, 0xC0, 0xF8, 0xFB, 0xDD, 0x7F,
  0x7F, 0x56, 0xE9, 0x00, 0x76, 0xE4, 0x80, 0x6A, 0xE7, 0x6A, 0x80, 0xB7,
  0x60, 0xFA, 0xBD, 0xAA, 0xDB, 0x6C, 0xA5, 0x00, 0x5A, 0x69, 0x49, 0x00,
  0xFE, 0x55, 0xA0, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 5, 1, 0, -5 },
  { 3, 1, 2, 2, 1, -5 },
  { 4, 3, 5, 3, 0, -5 },
  { 6, 3, 5, 2, 0, -5 },
  { 8, 4, 5, 4, 0, -5 },
  { 11, 2, 5, 2, 0, -5 },
  { 13, 1, 2, 1, 0, -5 },
  { 14, 2, 6, 2, 0, -5 },
  { 16, 1, 6, 2, 0, -5 },
  { 17, 2, 2, 2, 1, -5 },
  { 18, 3, 3, 3, 0, -4 },
  { 20, 1, 2, 1, 0, -1 },
  { 21, 2, 1, 2, 0, -2 },
  { 22, 1, 1, 1, 0, -1 },
  { 23, 3, 5, 2, 0, -5 },
  { 25, 2, 5, 2, 0, -5 },
  { 27, 1, 5, 2, 1, -5 },
  { 28, 2, 5, 2, 0, -5 },
  { 30, 3, 5, 2, 0, -5 },
  { 32, 3, 5, 2, 0, -5 },
  { 34, 3, 5, 2, 0, -5 },
  { 36, 3, 5, 2, 0, -5 },
  { 38, 3, 5, 2, 0, -5 },
  { 40, 3, 5, 2, 0, -5 },
  { 42, 2, 5, 2, 0, -5 },
  { 44, 1, 4, 1, 0, -4 },
  { 45, 1, 5, 1, 0, -4 },
  { 46, 3, 3, 3, 0, -4 },
  { 48, 3, 1, 3, 0, -3 },
  { 49, 3, 3, 3, 0, -4 },
  { 51, 2, 5, 2, 0, -5 },
  { 53, 4, 6, 4, 0, -5 },
  { 56, 2, 5, 2, 0, -5 },
  { 58, 3, 5, 3, 0, -5 },
  { 60, 3, 5, 2, 0, -5 },
  { 62, 3, 5, 3, 0, -5 },
  { 64, 3, 5, 2, 0, -5 },
  { 66, 3, 5, 2, 0, -5 },
  { 68, 3, 5, 3, 0, -5 },
  { 70, 3, 5, 3, 0, -5 },
  { 72, 2, 5, 1, 0, -5 },
  { 74, 2, 6, 1, -1, -5 },
  { 76, 3, 5, 3, 0, -5 },
  { 78, 2, 5, 2, 0, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 3, 5, 3, 0, -5 },
  { 85, 3, 5, 3, 0, -5 },
  { 87, 3, 5, 3, 0, -5 },
  { 89, 3, 6, 3, 0, -5 },
  { 92, 3, 5, 3, 0, -5 },
  { 94, 3, 5, 2, 0, -5 },
  { 96, 3, 5, 2, 0, -5 },
  { 98, 3, 5, 3, 0, -5 },
  { 100, 2, 5, 2, 1, -5 },
  { 102, 4, 5, 4, 1, -5 },
  { 105, 3, 5, 2, 0, -5 },
  { 107, 3, 5, 2, 0, -5 },
  { 109, 3, 5, 2, 0, -5 },
  { 111, 2, 6, 2, 0, -5 },
  { 113, 1, 5, 2, 1, -5 },
  { 114, 2, 6, 2, 0, -5 },
  { 116, 3, 2, 3, 0, -5 },
  { 117, 2, 1, 2, -1, 0 },
  { 118, 1, 1, 2, 1, -5 },
  { 119, 3, 4, 3, 0, -4 },
  { 121, 2, 5, 3, 0, -5 },
  { 123, 2, 4, 2, 0, -4 },
  { 124, 3, 5, 3, 0, -5 },
  { 126, 2, 4, 2, 0, -4 },
  { 127, 3, 7, 1, -1, -5 },
  { 130, 3, 6, 3, 0, -4 },
  { 133, 2, 5, 3, 0, -5 },
  { 135, 1, 5, 1, 0, -5 },
  { 136, 2, 7, 1, -1, -5 },
  { 138, 2, 5, 2, 0, -5 },
  { 140, 1, 5, 1, 0, -5 },
  { 141, 4, 4, 4, 0, -4 },
  { 143, 2, 4, 3, 0, -4 },
  { 144, 2, 4, 3, 0, -4 },
  { 145, 3, 6, 3, 0, -4 },
  { 148, 3, 6, 3, 0, -4 },
  { 151, 2, 4, 2, 0, -4 },
  { 152, 2, 4, 2, 0, -4 },
  { 153, 2, 5, 1, 0, -5 },
  { 155, 3, 4, 3, 0, -4 },
  { 157, 2, 4, 2, 0, -4 },
  { 158, 4, 4, 3, 0, -4 },
  { 160, 2, 4, 2, 0, -4 },
  { 161, 3, 6, 2, -1, -4 },
  { 164, 2, 4, 2, 0, -4 },
  { 165, 3, 6, 2, 0, -5 },
  { 168, 1, 7, 2, 1, -5 },
  { 169, 2, 6, 2, 0, -5 },
  { 171, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC7PT7B_H_
