#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC71PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x38, 0x1C, 0x70,
  0x30, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x06, 0x18, 0x0C, 0x30, 0x38,
  0xE0, 0x71, 0xC0, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x0E, 0x18, 0x18, 0x60,
  0x30, 0xC0, 0x61, 0x80, 0xC3, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x1C, 0x06, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x0E, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x1C, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x03, 0x80, 0x00, 0xE0,
  0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x06, 0x00,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0xE0, 0x00, 0x38,
  0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x60, 0x18, 0x00, 0x06, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x06, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x18, 0x0E, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x18,
  0x00, 0x06, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0xC0, 0x70, 0x00, 0x1C, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x0E,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x30, 0x1C, 0x00, 0x07, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x03,
  0x80, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x63,
  0xE0, 0x07, 0x0C, 0x0C, 0x01, 0xC1, 0x80, 0x00, 0x70, 0x30, 0x00, 0x0C,
  0x06, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x30, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x73, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x30, 0x38, 0x00, 0x06, 0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x1C,
  0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x1C, 0x02, 0x03, 0x0F, 0x00,
  0xFC, 0x6F, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x0C, 0x01, 0xFE, 0x00, 0x1C, 0x03, 0x86, 0x00, 0x18, 0x07, 0x07,
  0x00, 0x38, 0x07, 0x03, 0x00, 0x30, 0x0E, 0x03, 0x00, 0x70, 0x0C, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xC0, 0x18, 0x07,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0x80, 0x38, 0x07, 0x03, 0x80, 0x30, 0x07,
  0x03, 0x00, 0x30, 0x06, 0x07, 0x00, 0x70, 0x06, 0x06, 0x00, 0x70, 0x06,
  0x0E, 0x00, 0x60, 0x0E, 0x0C, 0x00, 0x60, 0x0E, 0x1C, 0x00, 0x60, 0x0C,
  0x18, 0x00, 0x60, 0x0C, 0x38, 0x00, 0xE0, 0x1C, 0x30, 0x3C, 0xE0, 0x1C,
  0x70, 0xFE, 0xE0, 0x18, 0x61, 0xE7, 0xE0, 0x38, 0xE3, 0x83, 0xE0, 0x30,
  0xC3, 0x03, 0xE0, 0x71, 0xC7, 0x03, 0xE0, 0x61, 0x8E, 0x03, 0x60, 0xE3,
  0x8E, 0x03, 0x71, 0xC3, 0x0C, 0x03, 0x7F, 0x87, 0x1C, 0x03, 0x3F, 0x06,
  0x18, 0x03, 0x00, 0x0E, 0x18, 0x03, 0x00, 0x0C, 0x38, 0x03, 0x00, 0x1C,
  0x38, 0x07, 0x00, 0x18, 0x30, 0x07, 0x00, 0x38, 0x30, 0x07, 0x00, 0x30,
  0x70, 0x06, 0x00, 0x70, 0x70, 0x06, 0x00, 0x60, 0x70, 0x0E, 0x00, 0xE0,
  0x60, 0x0E, 0x00, 0xC0, 0x60, 0x0C, 0x01, 0xC0, 0x60, 0x0C, 0x01, 0x80,
  0x60, 0x1C, 0x03, 0x80, 0x60, 0x18, 0x03, 0x00, 0x60, 0x38, 0x07, 0x00,
  0x60, 0x38, 0x06, 0x00, 0x60, 0x70, 0x0E, 0x00, 0x60, 0x60, 0x0C, 0x00,
  0x70, 0xE0, 0x1C, 0x00, 0x3B, 0xC0, 0x18, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00,
  0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x70, 0x1C, 0x00,
  0x70, 0x1C, 0x00, 0x70, 0x18, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00,
  0x70, 0x30, 0x00, 0x70, 0x70, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00,
  0x31, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xEC, 0x00, 0x01,
  0xCE, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x06, 0x07, 0x0E, 0x06, 0x07, 0x0C,
  0x07, 0x07, 0x1C, 0x07, 0x06, 0x38, 0x03, 0x0E, 0x38, 0x03, 0x0E, 0x30,
  0x03, 0x8C, 0x70, 0x03, 0x9C, 0x70, 0x01, 0x98, 0x60, 0x01, 0xB8, 0xE0,
  0x01, 0xF8, 0xE0, 0x01, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0,
  0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xE0, 0x70, 0x07, 0x70, 0x70,
  0x0E, 0x70, 0x78, 0x1C, 0x30, 0x3F, 0xF8, 0x30, 0x1F, 0xF0, 0x38, 0x03,
  0x80, 0x00, 0x1C, 0x71, 0xC6, 0x38, 0xE3, 0x8C, 0x30, 0xC7, 0x18, 0x61,
  0x86, 0x38, 0xC3, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x10, 0x18, 0x0F, 0x06, 0x00,
  0xE1, 0x01, 0x0E, 0x43, 0xC1, 0xFF, 0xF0, 0x1F, 0x80, 0x07, 0x00, 0x03,
  0x60, 0x01, 0x8C, 0x01, 0xC3, 0x00, 0xE0, 0x60, 0x70, 0x18, 0x18, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x01, 0x81, 0xC0,
  0xE0, 0x70, 0x70, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03,
  0x81, 0x81, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x27, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x1E, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x03,
  0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x18,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x60, 0x00, 0x30, 0x60,
  0x00, 0x70, 0x60, 0x00, 0x70, 0x60, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0xE0,
  0x00, 0xE0, 0xE0, 0x00, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x60,
  0x03, 0x80, 0x60, 0x03, 0x80, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0x30, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x3E, 0x03, 0xE0,
  0x7B, 0x07, 0xB8, 0x79, 0xC7, 0x0E, 0x70, 0x67, 0x07, 0x10, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xF8, 0x1E, 0x00, 0x1C, 0x01, 0xE0, 0x01, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x10, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x04,
  0x00, 0x1E, 0x00, 0xE0, 0x0F, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x07,
  0x60, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x18, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x1C, 0x00, 0x01, 0x87, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x06, 0x0E,
  0x00, 0x03, 0x03, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x38,
  0x1C, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x01, 0xC0, 0x03, 0x80, 0x60, 0x00,
  0xC0, 0x18, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x01,
  0xC0, 0x18, 0x00, 0x60, 0x0E, 0x00, 0x18, 0x03, 0x00, 0x0E, 0x01, 0xC0,
  0x03, 0x80, 0xE0, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1C, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x08,
  0x00, 0x3C, 0x00, 0xE0, 0x0F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x03, 0xE0, 0x40, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x87, 0xF0, 0x01, 0xC7,
  0xFC, 0x00, 0xCF, 0x8F, 0x00, 0x6E, 0x01, 0xC0, 0x76, 0x00, 0xF0, 0x3E,
  0x00, 0x38, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x06, 0x07, 0x00, 0x03, 0x07,
  0x80, 0x01, 0xC3, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x30,
  0x70, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x07,
  0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0x81, 0x80, 0x01, 0xC0, 0xC0, 0x00,
  0xE0, 0x60, 0x00, 0x70, 0x30, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x0E, 0x00,
  0x38, 0x07, 0x00, 0x1C, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0x38,
  0x1E, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0C,
  0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x06, 0x00, 0x0C, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x01, 0x80, 0x1C, 0x00, 0x38, 0x07, 0x00,
  0x03, 0x03, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x78, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x70, 0x38, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38,
  0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x60, 0x1E, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x03,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x01,
  0xC0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x80,
  0x06, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C,
  0x00, 0x06, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x80, 0x01, 0xC1,
  0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x78, 0x38, 0x00, 0x3C,
  0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x1F, 0x01, 0xC0, 0x1F,
  0x80, 0xE0, 0x1D, 0xC0, 0x3C, 0x1C, 0xE0, 0x1F, 0xFC, 0x60, 0x03, 0xF8,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x80, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x1C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xFC, 0x07, 0x83, 0xC0, 0x20, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x70, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00,
  0x70, 0x0C, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x70, 0x00, 0x60, 0x0C, 0x18, 0x01,
  0xFF, 0x03, 0x06, 0x00, 0xFF, 0xC0, 0xC3, 0x80, 0x70, 0x60, 0x30, 0xC0,
  0x38, 0x18, 0x0C, 0x70, 0x0C, 0x0E, 0x03, 0x18, 0x06, 0x03, 0x81, 0xC6,
  0x03, 0x80, 0xC0, 0x73, 0x80, 0xC0, 0x30, 0x1C, 0xE0, 0x70, 0x1C, 0x06,
  0x30, 0x18, 0x07, 0x01, 0x8C, 0x06, 0x01, 0x80, 0x67, 0x03, 0x80, 0x60,
  0x39, 0xC0, 0xC0, 0x38, 0x0E, 0x60, 0x30, 0x0E, 0x03, 0x18, 0x0C, 0x03,
  0x00, 0xC6, 0x07, 0x01, 0xC0, 0x73, 0x81, 0xC0, 0x70, 0x1C, 0xE0, 0x60,
  0x1C, 0x06, 0x38, 0x18, 0x06, 0x03, 0x8E, 0x06, 0x03, 0x80, 0xC3, 0x01,
  0x80, 0xE0, 0x30, 0xC0, 0x60, 0x78, 0x1C, 0x30, 0x18, 0x1E, 0x06, 0x0C,
  0x06, 0x0D, 0x83, 0x83, 0x01, 0xC3, 0x61, 0xC0, 0xC0, 0x79, 0x9D, 0xE0,
  0x30, 0x0F, 0xC3, 0xF0, 0x0C, 0x01, 0xE0, 0x70, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x10, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x1C, 0x70, 0x00,
  0x0E, 0x38, 0x00, 0x06, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x60, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x18, 0x07,
  0x00, 0x1C, 0x03, 0x80, 0x0C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0xE0, 0x03, 0x00, 0xE0, 0x01, 0x80, 0x70, 0x00, 0xC0, 0x30,
  0x00, 0x60, 0x38, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x0E,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x80, 0x00, 0xC3,
  0x80, 0x00, 0x61, 0xC0, 0x00, 0x31, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0C,
  0x70, 0x00, 0x06, 0x70, 0x00, 0x03, 0x38, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0x80, 0x3C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0xE0, 0x07, 0x00, 0x06, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x60, 0x0E,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0xE0, 0x0C, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0xC0, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x38, 0x01,
  0x80, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0x00, 0x78, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xE0, 0x06, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x60, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70,
  0x0C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x60, 0x18, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E,
  0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0x60, 0x3F, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x03, 0x00, 0x0F,
  0x00, 0x20, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x01, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x03,
  0x80, 0x3C, 0x00, 0x18, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x18, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x60, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0xE0, 0x18, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x18, 0x0E, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xF0, 0x03,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x0F, 0x00, 0x0C, 0x01,
  0xF0, 0x00, 0x61, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x40, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x43, 0x80, 0x01, 0xFF, 0x07, 0x00, 0x03, 0xFE, 0x0E,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x38, 0x03, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x0C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xC0, 0x07, 0x00,
  0x00, 0x60, 0x03, 0x80, 0x00, 0x70, 0x01, 0x80, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x06, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x18, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x70, 0x01,
  0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x07, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x01,
  0xC0, 0x06, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x30, 0x01, 0xC0, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x30, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0xE0, 0x03, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x06, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x83, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x30, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80,
  0x00, 0xE0, 0x0E, 0x00, 0x01, 0x80, 0x38, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x3E,
  0x00, 0x00, 0x06, 0xFC, 0x00, 0x00, 0x1D, 0xB8, 0x00, 0x00, 0x3E, 0x30,
  0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x18, 0x07, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x06, 0x00, 0x70, 0x00, 0x0C, 0x00, 0xE0, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x01,
  0x80, 0x07, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x60, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x00, 0x06, 0xC0, 0x07, 0x60, 0x00, 0x00, 0xEC, 0x00, 0x76, 0x00,
  0x00, 0x0D, 0xC0, 0x06, 0x60, 0x00, 0x01, 0xDC, 0x00, 0x66, 0x00, 0x00,
  0x19, 0xC0, 0x0E, 0x60, 0x00, 0x03, 0x98, 0x00, 0xE6, 0x00, 0x00, 0x33,
  0x80, 0x0E, 0x60, 0x00, 0x07, 0x38, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x80,
  0x0C, 0x60, 0x00, 0x0E, 0x30, 0x01, 0xC6, 0x00, 0x00, 0xE3, 0x00, 0x1C,
  0x70, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x01, 0xC7, 0x00, 0x18, 0x70,
  0x00, 0x38, 0x70, 0x01, 0x87, 0x00, 0x03, 0x86, 0x00, 0x38, 0x70, 0x00,
  0x70, 0xE0, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x00, 0x60,
  0xE0, 0x03, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x30, 0x70, 0x00, 0xC0, 0xC0,
  0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x30, 0x01, 0x81, 0xC0, 0x07,
  0x03, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x0E, 0x03,
  0x00, 0x70, 0x18, 0x00, 0xE0, 0x30, 0x06, 0x03, 0x80, 0x0E, 0x03, 0x00,
  0xE0, 0x38, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x0C, 0x03, 0x01, 0xC0,
  0x30, 0x01, 0xC0, 0x30, 0x1C, 0x03, 0x00, 0x1C, 0x03, 0x03, 0x80, 0x70,
  0x01, 0xC0, 0x38, 0x38, 0x07, 0x00, 0x18, 0x03, 0x87, 0x00, 0x70, 0x01,
  0x80, 0x38, 0x70, 0x06, 0x00, 0x38, 0x03, 0x8E, 0x00, 0xE0, 0x03, 0x80,
  0x38, 0xE0, 0x0E, 0x00, 0x38, 0x03, 0x8C, 0x00, 0xE0, 0x03, 0x00, 0x39,
  0xC0, 0x0C, 0x00, 0x30, 0x03, 0x98, 0x00, 0xC0, 0x07, 0x00, 0x3B, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0xB0, 0x01, 0xC0, 0x06, 0x00, 0x1F, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0xE0, 0x01, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0x18, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x18, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x00, 0xE0,
  0x03, 0xE0, 0x00, 0x1C, 0x00, 0x6C, 0x00, 0x03, 0x00, 0x0D, 0x80, 0x00,
  0x60, 0x03, 0xB0, 0x00, 0x1C, 0x00, 0x77, 0x00, 0x03, 0x80, 0x0E, 0xE0,
  0x00, 0x70, 0x01, 0x9C, 0x00, 0x0C, 0x00, 0x71, 0x80, 0x01, 0x80, 0x0E,
  0x30, 0x00, 0x70, 0x01, 0xC7, 0x00, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xC0,
  0x06, 0x1C, 0x00, 0x30, 0x01, 0xC1, 0x80, 0x06, 0x00, 0x38, 0x30, 0x01,
  0xC0, 0x07, 0x06, 0x00, 0x38, 0x00, 0xC0, 0xE0, 0x06, 0x00, 0x18, 0x1C,
  0x00, 0xC0, 0x07, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x30, 0x07, 0x00, 0x1C,
  0x06, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x1C, 0x03, 0x00,
  0x1C, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x70, 0x1C, 0x00, 0x70, 0x06, 0x03,
  0x80, 0x0C, 0x00, 0xC0, 0x60, 0x03, 0x80, 0x1C, 0x0C, 0x00, 0x70, 0x03,
  0x83, 0x80, 0x0E, 0x00, 0x70, 0x70, 0x01, 0x80, 0x06, 0x0E, 0x00, 0x30,
  0x00, 0xC1, 0x80, 0x0E, 0x00, 0x18, 0x30, 0x01, 0xC0, 0x03, 0x8E, 0x00,
  0x38, 0x00, 0x71, 0xC0, 0x06, 0x00, 0x0E, 0x30, 0x00, 0xC0, 0x00, 0xC6,
  0x00, 0x38, 0x00, 0x19, 0xC0, 0x07, 0x00, 0x03, 0xB8, 0x00, 0xE0, 0x00,
  0x77, 0x00, 0x18, 0x00, 0x0E, 0xC0, 0x03, 0x00, 0x01, 0xD8, 0x00, 0xE0,
  0x00, 0x1B, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x03, 0x80, 0x00, 0x7C, 0x00,
  0x60, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x38,
  0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x38, 0x0E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x38, 0x60, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0xE0, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0x83, 0x80, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x1C, 0x07,
  0xC0, 0x03, 0x80, 0x38, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0x80, 0x03,
  0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38,
  0x00, 0x38, 0x06, 0x00, 0x06, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38,
  0x07, 0x00, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x38, 0x07, 0x00,
  0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x07, 0x80, 0x1C, 0x07, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x38, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x60, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x1C, 0x07, 0x80, 0x03, 0x80, 0x38, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x00, 0xE0,
  0x0E, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00,
  0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x30, 0x06, 0x00, 0x0E, 0x01,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x06, 0x00, 0xE0, 0x01,
  0xC0, 0x18, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0xC0, 0x1C,
  0x00, 0x70, 0x03, 0x00, 0x3C, 0x00, 0x60, 0x1F, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x03, 0x80, 0x01, 0x80, 0x70, 0x00,
  0x30, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x38, 0x03,
  0x00, 0x06, 0x00, 0x70, 0x00, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x70, 0x03, 0x00, 0x0E,
  0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x60,
  0x00, 0x60, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3C, 0x00,
  0x60, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x10, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x70,
  0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x18, 0x07,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70,
  0x0E, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x38, 0x07,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x70, 0x06, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x18, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x70, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x70, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x18, 0x70,
  0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xC0,
  0x70, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x30,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x03,
  0x80, 0x07, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0x30, 0x30, 0x00, 0x18, 0x38, 0x00, 0x0C,
  0x1C, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x86, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x63, 0x00, 0x00, 0x33, 0x80, 0x00, 0x19, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x77, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x70, 0x00, 0x1E,
  0x00, 0x01, 0xC7, 0x00, 0x01, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x1E, 0x00,
  0x03, 0x86, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x36, 0x00, 0x07,
  0x06, 0x00, 0x07, 0x60, 0x00, 0x70, 0x60, 0x00, 0x76, 0x00, 0x06, 0x06,
  0x00, 0x06, 0x60, 0x00, 0xE0, 0x60, 0x00, 0xE6, 0x00, 0x0E, 0x06, 0x00,
  0x0C, 0x60, 0x01, 0xC0, 0x60, 0x01, 0xC6, 0x00, 0x1C, 0x06, 0x00, 0x1C,
  0x60, 0x01, 0x80, 0x60, 0x01, 0x86, 0x00, 0x38, 0x06, 0x00, 0x38, 0x60,
  0x03, 0x80, 0x60, 0x03, 0x06, 0x00, 0x70, 0x06, 0x00, 0x70, 0x60, 0x07,
  0x00, 0x60, 0x07, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x60, 0x0E, 0x00,
  0x60, 0x0E, 0x06, 0x00, 0xE0, 0x06, 0x00, 0xC0, 0x60, 0x1C, 0x00, 0x60,
  0x0C, 0x0E, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0xE0, 0x18, 0x00, 0x60, 0x18,
  0x0E, 0x03, 0x80, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x60, 0x30, 0x0E,
  0x07, 0x00, 0x06, 0x03, 0x00, 0xE0, 0x70, 0x00, 0x60, 0x70, 0x0E, 0x06,
  0x00, 0x06, 0x06, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00,
  0x0E, 0x0E, 0x00, 0xE1, 0xC0, 0x00, 0xE0, 0xC0, 0x0E, 0x1C, 0x00, 0x0E,
  0x1C, 0x00, 0xC1, 0x80, 0x00, 0xE1, 0x80, 0x0C, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0xC3, 0x80, 0x00, 0xE3, 0x80, 0x0C, 0x70, 0x00, 0x0E, 0x30, 0x00,
  0xC7, 0x00, 0x00, 0xE7, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x60, 0x00, 0xCE,
  0x00, 0x00, 0xEE, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0xCC, 0x00,
  0x00, 0xEC, 0x00, 0x0D, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xD8, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x03, 0x80, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x06, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x38, 0x00, 0x70, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0D, 0xC0, 0x00, 0x77, 0x00, 0x01,
  0x9C, 0x00, 0x0E, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x0E, 0x0C,
  0x00, 0x38, 0x30, 0x01, 0xC0, 0xC0, 0x07, 0x03, 0x00, 0x38, 0x0C, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80,
  0x38, 0x1C, 0x00, 0x60, 0x70, 0x01, 0x83, 0x80, 0x06, 0x0E, 0x00, 0x18,
  0x70, 0x00, 0x61, 0xC0, 0x01, 0x8E, 0x00, 0x06, 0x30, 0x00, 0x1D, 0xC0,
  0x00, 0x76, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x10, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xE0, 0x38, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x01,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x18,
  0x06, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x38,
  0x00, 0x38, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0x83, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x71, 0x80, 0x00, 0x39, 0xC0,
  0x00, 0x0D, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x70, 0x70, 0x30, 0x38, 0x18, 0x1C,
  0x0C, 0x06, 0x06, 0x03, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0xC0, 0x1F,
  0x3C, 0xE0, 0x1C, 0x06, 0x60, 0x1C, 0x01, 0xB0, 0x1C, 0x00, 0xD8, 0x1C,
  0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0C,
  0x1C, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x06, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0x38, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00,
  0x0F, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x07, 0x80, 0xE0, 0x02, 0xC0, 0x38,
  0x03, 0x60, 0x1C, 0x03, 0x30, 0x0F, 0x03, 0x38, 0x03, 0xFF, 0x18, 0x00,
  0xFF, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE1, 0xF8, 0x00,
  0x73, 0xFF, 0x00, 0x33, 0xC7, 0xC0, 0x1B, 0x80, 0xE0, 0x1D, 0x80, 0x30,
  0x0F, 0x80, 0x1C, 0x06, 0x80, 0x0E, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x03,
  0x81, 0xE0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x70, 0x38, 0x00,
  0x38, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x06, 0x00,
  0x03, 0x83, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x70, 0x60, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x1C,
  0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x03, 0x80, 0x03, 0x83,
  0x80, 0x01, 0xC1, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0xE0,
  0x3C, 0x00, 0x70, 0x3E, 0x00, 0x70, 0x19, 0x80, 0x70, 0x0C, 0xE0, 0xF0,
  0x06, 0x3F, 0xF0, 0x07, 0x0F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x03, 0xFF, 0x00, 0x78, 0x60, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xC3, 0x80,
  0x03, 0xFE, 0x38, 0x00, 0x7C, 0xF3, 0x80, 0x0E, 0x03, 0xB0, 0x01, 0xC0,
  0x1B, 0x00, 0x38, 0x01, 0xF0, 0x07, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xE0,
  0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0xE0, 0x18, 0x00, 0x0C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C,
  0x03, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x18, 0x07, 0x00, 0x03, 0x80, 0x60, 0x00, 0x38, 0x0E, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0xE0, 0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x00,
  0xE0, 0x06, 0xC0, 0x07, 0x00, 0x6C, 0x00, 0x70, 0x0D, 0xC0, 0x07, 0x83,
  0x9C, 0x00, 0x3F, 0xF1, 0x80, 0x01, 0xFE, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x3E, 0x3C, 0x03, 0xC0, 0xE0,
  0x1C, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0xC0, 0x07, 0x0E, 0x00,
  0x38, 0x60, 0x01, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x1C,
  0x00, 0x70, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0x70, 0x0F, 0x03, 0x83, 0xF0,
  0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x80, 0x70, 0x0C, 0x03,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0E, 0x10, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0xC3, 0x00, 0x0F, 0x9E, 0x70, 0x01, 0xC0, 0x66, 0x00, 0x38,
  0x03, 0x60, 0x07, 0x00, 0x36, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x1C,
  0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38,
  0x00, 0x1C, 0x03, 0x00, 0x01, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x0E,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x70, 0x1C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00,
  0x3C, 0x01, 0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x80,
  0x1C, 0x00, 0xD8, 0x00, 0xE0, 0x0F, 0x80, 0x0E, 0x01, 0xB8, 0x00, 0xF0,
  0x73, 0x80, 0x07, 0xFE, 0x30, 0x00, 0x3F, 0xC3, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x80, 0x07, 0x00, 0x08, 0x01, 0xE0, 0x00, 0xFC, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE1, 0xF8,
  0x00, 0xE7, 0xFE, 0x00, 0xCF, 0x1E, 0x00, 0xDC, 0x07, 0x00, 0xF0, 0x07,
  0x01, 0xF0, 0x07, 0x01, 0xE0, 0x07, 0x01, 0xE0, 0x07, 0x01, 0xC0, 0x07,
  0x03, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x06, 0x03, 0x80, 0x06,
  0x03, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0C,
  0x06, 0x00, 0x1C, 0x06, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x18,
  0x0C, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38,
  0x1C, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x70, 0x38, 0x00, 0x70,
  0x38, 0x00, 0x70, 0x38, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0xE0,
  0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xC0, 0x60, 0x01, 0xC0,
  0xE0, 0x01, 0xC0, 0x00, 0x18, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x01, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x80, 0x70, 0x03, 0x80, 0x30, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x07, 0x01,
  0xC0, 0x03, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x70, 0x00, 0x0E, 0x78, 0x00, 0x06, 0x3C, 0x00, 0x03, 0x3E, 0x00, 0x03,
  0xBB, 0x00, 0x01, 0xF9, 0x80, 0x00, 0xF8, 0xE0, 0x00, 0x78, 0x70, 0x00,
  0x38, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x06, 0x00, 0x0C, 0x03, 0x00,
  0x06, 0x01, 0x80, 0x03, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x0C, 0x00, 0x70, 0x06, 0x00, 0x18, 0x07, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0x1F, 0xF0, 0xFF, 0xC0, 0x0C,
  0xE1, 0xE7, 0x8F, 0x80, 0x36, 0x03, 0xB8, 0x0E, 0x01, 0xF0, 0x06, 0xC0,
  0x18, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x70,
  0x01, 0xC0, 0x06, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x00,
  0x60, 0x38, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x0E, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0x03,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x18, 0x00,
  0x70, 0x01, 0xC0, 0xE0, 0x01, 0x80, 0x06, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x03, 0x80, 0xC0, 0x03,
  0x00, 0x0C, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x70, 0x01, 0xC0, 0x07, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x38, 0x00, 0x60, 0x01, 0x80, 0xE0, 0x03, 0x80, 0x0E, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x30, 0x00, 0xC0,
  0x03, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x18,
  0x00, 0x70, 0x01, 0xC0, 0x60, 0x01, 0x80, 0x07, 0x03, 0x80, 0x0E, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xC7, 0xFE, 0x00, 0xCF, 0x1E, 0x00,
  0xDC, 0x07, 0x01, 0xF0, 0x07, 0x01, 0xF0, 0x07, 0x01, 0xE0, 0x07, 0x01,
  0xC0, 0x07, 0x01, 0xC0, 0x07, 0x03, 0xC0, 0x07, 0x03, 0x80, 0x06, 0x03,
  0x80, 0x06, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07,
  0x00, 0x0E, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E,
  0x00, 0x1C, 0x0E, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x60, 0x30,
  0x00, 0xE0, 0x30, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0x60, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0x80, 0x0F, 0x8F, 0x00, 0x78, 0x0E, 0x03, 0xC0, 0x38, 0x0E, 0x00,
  0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x31,
  0xC0, 0x00, 0xC7, 0x00, 0x03, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80,
  0x01, 0xCC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01,
  0xD8, 0x00, 0x06, 0x60, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8,
  0x00, 0x0C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00,
  0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0,
  0xE0, 0x03, 0x81, 0xC0, 0x1C, 0x07, 0x00, 0xE0, 0x1E, 0x07, 0x80, 0x3F,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x01, 0x87, 0xFC, 0x00, 0x19, 0xE3, 0xE0, 0x01, 0x98, 0x0E, 0x00, 0x3B,
  0x00, 0x70, 0x03, 0xE0, 0x07, 0x00, 0x36, 0x00, 0x70, 0x03, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0x30, 0x07, 0x80, 0x03, 0x00, 0x78, 0x00, 0x30, 0x07,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xE0, 0x18, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0C, 0x03, 0x80, 0x01, 0xC0,
  0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0x80, 0x38, 0x00, 0x38, 0x07, 0x80,
  0x03, 0x80, 0x78, 0x00, 0x70, 0x07, 0x80, 0x07, 0x00, 0x78, 0x00, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0xF8, 0x01, 0xC0, 0x0E, 0xC0, 0x38, 0x00, 0xCE,
  0x0F, 0x00, 0x0C, 0x7F, 0xE0, 0x00, 0xC3, 0xFC, 0x00, 0x1C, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0xC0,
  0x3E, 0x3C, 0xE0, 0x1C, 0x07, 0x60, 0x1C, 0x01, 0xB0, 0x1C, 0x00, 0xD8,
  0x1C, 0x00, 0x7C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07,
  0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0x80, 0x00, 0xC1, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x38, 0x00,
  0x0C, 0x1C, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x06, 0x00, 0x03, 0x83, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07,
  0x00, 0x0F, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x07, 0x80, 0xE0, 0x06, 0xC0,
  0x38, 0x03, 0xE0, 0x1C, 0x03, 0x70, 0x0F, 0x07, 0x38, 0x03, 0xFF, 0x18,
  0x00, 0xFF, 0x0C, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF0,
  0x0C, 0x7F, 0x00, 0xCF, 0x90, 0x0D, 0xC0, 0x01, 0xD8, 0x00, 0x1B, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0xF0, 0x0F, 0x07, 0x80, 0x70, 0x06, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x08, 0x00, 0xE0, 0x30, 0x0F, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x01, 0xFF, 0xC7, 0xFF, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0x80, 0x03, 0x80, 0x06, 0x06,
  0x00, 0x1C, 0x0C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xC0, 0xE0,
  0x01, 0x81, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x30, 0x30, 0x00, 0x60, 0x60, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07,
  0x07, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x03, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0x60, 0x60, 0x01, 0xC0, 0xC0, 0x03, 0x83, 0x80,
  0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x30, 0x01,
  0xE0, 0x60, 0x03, 0xC0, 0xE0, 0x0F, 0x81, 0xC0, 0x36, 0x03, 0xC0, 0xEC,
  0x03, 0xFF, 0x98, 0x03, 0xFC, 0x30, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x7E, 0x00, 0x0E, 0xE0, 0x00, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00,
  0x38, 0xE0, 0x03, 0x8E, 0x00, 0x30, 0xE0, 0x07, 0x0E, 0x00, 0x60, 0xE0,
  0x0E, 0x0E, 0x00, 0xC0, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x30, 0x0E, 0x07, 0x00, 0xE0, 0x60, 0x0E, 0x0E, 0x00,
  0xE0, 0xE0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x18, 0x00, 0xE3, 0x80,
  0x0E, 0x30, 0x00, 0xE7, 0x00, 0x0E, 0x60, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0xEC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xF0,
  0x00, 0xE0, 0x01, 0xB8, 0x00, 0x70, 0x01, 0xDC, 0x00, 0x78, 0x00, 0xEE,
  0x00, 0x3C, 0x00, 0x67, 0x00, 0x3E, 0x00, 0x73, 0x80, 0x1B, 0x00, 0x31,
  0xC0, 0x0D, 0x80, 0x38, 0xE0, 0x0C, 0xC0, 0x1C, 0x70, 0x06, 0x60, 0x0C,
  0x38, 0x07, 0x30, 0x0E, 0x1C, 0x03, 0x18, 0x06, 0x0E, 0x03, 0x8C, 0x07,
  0x07, 0x01, 0x86, 0x03, 0x83, 0x80, 0xC3, 0x01, 0x81, 0xC0, 0xE1, 0x81,
  0xC0, 0xE0, 0x60, 0xC0, 0xC0, 0x70, 0x70, 0x60, 0x60, 0x38, 0x30, 0x30,
  0x70, 0x1C, 0x18, 0x18, 0x30, 0x0E, 0x1C, 0x0C, 0x38, 0x07, 0x0C, 0x06,
  0x18, 0x03, 0x8E, 0x03, 0x0C, 0x01, 0xC6, 0x01, 0x8E, 0x00, 0xE3, 0x00,
  0xC6, 0x00, 0x73, 0x80, 0x67, 0x00, 0x39, 0x80, 0x33, 0x00, 0x1D, 0xC0,
  0x19, 0x80, 0x0E, 0xC0, 0x0D, 0xC0, 0x07, 0x60, 0x06, 0xC0, 0x03, 0x70,
  0x03, 0x60, 0x01, 0xB0, 0x01, 0xF0, 0x00, 0xD8, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x03, 0x80,
  0x03, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x38, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x63, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x07,
  0x70, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07,
  0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x07, 0x00,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x01, 0xC0, 0x03,
  0x80, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x38, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x08,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x9F, 0xFC, 0x00, 0x5E, 0x1F, 0x00, 0xFC, 0x03, 0xF1,
  0xEC, 0x00, 0x7F, 0xE4, 0x00, 0x0F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 14, 51, 15, 1, -51 },
  { 91, 15, 19, 19, 7, -51 },
  { 127, 28, 51, 27, 0, -51 },
  { 306, 27, 58, 25, -1, -54 },
  { 502, 32, 52, 38, 3, -51 },
  { 710, 24, 52, 24, -1, -51 },
  { 866, 6, 19, 11, 7, -51 },
  { 881, 19, 62, 17, 2, -51 },
  { 1029, 20, 62, 17, -5, -51 },
  { 1184, 18, 20, 23, 8, -54 },
  { 1229, 25, 32, 29, 2, -41 },
  { 1329, 9, 16, 12, -3, -7 },
  { 1347, 15, 3, 19, 2, -21 },
  { 1353, 4, 6, 12, 1, -6 },
  { 1356, 29, 51, 21, -3, -51 },
  { 1541, 24, 52, 25, 1, -51 },
  { 1697, 13, 51, 25, 8, -51 },
  { 1780, 27, 51, 25, -2, -51 },
  { 1953, 27, 52, 25, -2, -51 },
  { 2129, 26, 51, 25, -1, -51 },
  { 2295, 28, 52, 25, -2, -51 },
  { 2477, 25, 52, 25, 2, -51 },
  { 2640, 25, 51, 25, 3, -51 },
  { 2800, 27, 52, 25, -1, -51 },
  { 2976, 25, 52, 25, 0, -51 },
  { 3139, 11, 38, 12, 0, -38 },
  { 3192, 15, 47, 12, -3, -38 },
  { 3281, 25, 30, 29, 2, -40 },
  { 3375, 25, 18, 29, 2, -34 },
  { 3432, 25, 30, 29, 2, -40 },
  { 3526, 20, 51, 18, 1, -51 },
  { 3654, 34, 57, 37, 2, -51 },
  { 3897, 25, 51, 24, -5, -51 },
  { 4057, 28, 51, 27, 0, -51 },
  { 4236, 27, 52, 25, 3, -51 },
  { 4412, 29, 51, 30, 0, -51 },
  { 4597, 27, 51, 24, 0, -51 },
  { 4770, 27, 51, 23, 0, -51 },
  { 4943, 31, 52, 33, 3, -51 },
  { 5145, 33, 51, 32, 0, -51 },
  { 5356, 22, 51, 13, -4, -51 },
  { 5497, 24, 64, 12, -10, -51 },
  { 5689, 31, 51, 25, 0, -51 },
  { 5887, 16, 51, 22, 0, -51 },
  { 5989, 44, 51, 43, 0, -51 },
  { 6270, 35, 51, 34, 0, -51 },
  { 6494, 29, 52, 32, 2, -51 },
  { 6683, 27, 51, 26, 0, -51 },
  { 6856, 29, 63, 32, 2, -51 },
  { 7085, 27, 51, 26, 0, -51 },
  { 7258, 29, 52, 25, -2, -51 },
  { 7447, 22, 51, 22, 5, -51 },
  { 7588, 30, 52, 31, 2, -51 },
  { 7783, 25, 51, 25, 6, -51 },
  { 7943, 44, 51, 43, 5, -51 },
  { 8224, 32, 51, 23, -4, -51 },
  { 8428, 22, 51, 22, 5, -51 },
  { 8569, 29, 51, 22, -3, -51 },
  { 8754, 25, 62, 20, -1, -51 },
  { 8948, 10, 51, 23, 7, -51 },
  { 9012, 25, 62, 20, -4, -51 },
  { 9206, 25, 25, 28, 2, -51 },
  { 9285, 19, 3, 19, -5, 6 },
  { 9293, 8, 11, 15, 10, -54 },
  { 9304, 25, 39, 28, 2, -38 },
  { 9426, 25, 55, 27, 0, -54 },
  { 9598, 20, 39, 20, 2, -38 },
  { 9696, 28, 55, 28, 2, -54 },
  { 9889, 21, 39, 24, 2, -38 },
  { 9992, 31, 71, 14, -9, -54 },
  { 10268, 28, 55, 27, -1, -38 },
  { 10461, 24, 54, 26, 0, -54 },
  { 10623, 14, 51, 12, 0, -51 },
  { 10713, 23, 68, 12, -9, -51 },
  { 10909, 25, 54, 22, 0, -54 },
  { 11078, 14, 54, 11, 0, -54 },
  { 11173, 38, 38, 40, 0, -38 },
  { 11354, 24, 38, 26, 0, -38 },
  { 11468, 22, 39, 26, 2, -38 },
  { 11576, 28, 54, 27, -3, -38 },
  { 11765, 25, 55, 28, 2, -38 },
  { 11937, 20, 38, 17, 0, -38 },
  { 12032, 22, 39, 20, -1, -38 },
  { 12140, 14, 48, 14, 1, -47 },
  { 12224, 23, 38, 26, 2, -37 },
  { 12334, 20, 37, 20, 4, -37 },
  { 12427, 33, 37, 34, 4, -37 },
  { 12580, 26, 37, 21, -3, -37 },
  { 12701, 33, 54, 22, -8, -37 },
  { 12924, 21, 37, 17, -2, -37 },
  { 13022, 25, 62, 22, 2, -51 },
  { 13216, 2, 71, 25, 11, -54 },
  { 13234, 25, 62, 22, -5, -51 },
  { 13428, 25, 6, 29, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic71pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC71PT7B_H_
