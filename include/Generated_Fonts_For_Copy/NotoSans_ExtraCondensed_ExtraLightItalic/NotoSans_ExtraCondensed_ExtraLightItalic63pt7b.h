#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC63PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x1C, 0x18, 0xC0, 0xC6, 0x0E, 0x70, 0x73, 0x83, 0x18,
  0x18, 0xC0, 0xC6, 0x0E, 0x70, 0x63, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x0C,
  0x20, 0x63, 0x03, 0x18, 0x18, 0x00, 0x03, 0x03, 0x80, 0x01, 0x81, 0x80,
  0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x30,
  0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x06, 0x06, 0x00, 0x07, 0x03, 0x00, 0x03, 0x01, 0x80, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0E,
  0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01,
  0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x80, 0x18, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00,
  0x06, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x81, 0x80,
  0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30,
  0x00, 0x30, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x3E, 0xBF, 0x00, 0x71, 0x83, 0x00, 0xE1, 0x80, 0x01, 0xC1, 0x80, 0x01,
  0x81, 0x80, 0x01, 0x81, 0x00, 0x03, 0x83, 0x00, 0x03, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x02, 0x00, 0x03, 0x82, 0x00, 0x01, 0x86, 0x00, 0x01,
  0x86, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xE4, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x10, 0xC0, 0x00,
  0x10, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00,
  0x20, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00,
  0x60, 0xE0, 0x00, 0x40, 0xC0, 0x00, 0xC1, 0x80, 0x60, 0xC7, 0x80, 0xFF,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0x00, 0x0C, 0x03, 0xB8, 0x00,
  0xC0, 0x61, 0xC0, 0x18, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x00, 0xC0,
  0xC0, 0x30, 0x1C, 0x0C, 0x07, 0x01, 0xC1, 0x80, 0x60, 0x18, 0x18, 0x06,
  0x01, 0x83, 0x00, 0x60, 0x18, 0x30, 0x06, 0x01, 0x86, 0x00, 0xE0, 0x38,
  0x60, 0x0C, 0x03, 0x0C, 0x00, 0xC0, 0x30, 0xC0, 0x0C, 0x03, 0x18, 0x7E,
  0xC0, 0x61, 0x8F, 0xFC, 0x06, 0x31, 0xC3, 0xC0, 0xE3, 0x18, 0x3C, 0x0C,
  0x63, 0x03, 0xC1, 0xC6, 0x30, 0x3E, 0x18, 0xC7, 0x03, 0x77, 0x0C, 0x60,
  0x37, 0xE1, 0x86, 0x03, 0x08, 0x18, 0xC0, 0x30, 0x03, 0x0C, 0x03, 0x00,
  0x30, 0xC0, 0x30, 0x06, 0x1C, 0x03, 0x00, 0x61, 0x80, 0x70, 0x0C, 0x18,
  0x06, 0x00, 0xC1, 0x80, 0x60, 0x18, 0x18, 0x06, 0x01, 0x81, 0x80, 0xE0,
  0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x1C, 0x06, 0x01,
  0x81, 0x80, 0xC0, 0x18, 0x18, 0x0C, 0x01, 0x83, 0x01, 0x80, 0x18, 0x70,
  0x18, 0x01, 0xCE, 0x03, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0E, 0x1C, 0x00, 0x30,
  0x70, 0x01, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30,
  0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x18, 0x00, 0xE0, 0x60, 0x03,
  0x83, 0x80, 0x0E, 0x0C, 0x00, 0x18, 0x70, 0x00, 0x61, 0x80, 0x01, 0x8C,
  0x00, 0x06, 0x70, 0x00, 0x1B, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x60, 0x00, 0x71,
  0x80, 0x43, 0x87, 0x06, 0x1C, 0x0C, 0x18, 0x60, 0x30, 0xE3, 0x80, 0xC3,
  0x0C, 0x03, 0x8C, 0x70, 0x06, 0x71, 0x80, 0x19, 0x86, 0x00, 0x66, 0x18,
  0x01, 0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x38, 0x00,
  0xE0, 0xE0, 0x07, 0x81, 0x80, 0x3E, 0x07, 0x01, 0xDC, 0x1C, 0x0E, 0x30,
  0x3F, 0xF0, 0xC0, 0x7F, 0x83, 0x80, 0x30, 0x00, 0x00, 0x1C, 0x61, 0x8E,
  0x38, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x61, 0x0C, 0x30, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x40,
  0xC0, 0xE0, 0xC0, 0x78, 0x80, 0x1C, 0x87, 0x07, 0xFF, 0x01, 0xE0, 0x03,
  0x80, 0x06, 0xC0, 0x0C, 0x60, 0x38, 0x60, 0x70, 0x30, 0x60, 0x30, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x81, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06,
  0x06, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x6F, 0xFE, 0xE0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xE0, 0xE0,
  0x06, 0x03, 0x00, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x30, 0x03, 0x03, 0x80,
  0x18, 0x18, 0x00, 0xC1, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x87,
  0x00, 0x0C, 0x30, 0x00, 0xE1, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01,
  0xC6, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x80, 0x03, 0x18, 0x00, 0x38, 0xC0,
  0x01, 0xC6, 0x00, 0x0E, 0x70, 0x00, 0x63, 0x80, 0x03, 0x1C, 0x00, 0x18,
  0xC0, 0x01, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0x61, 0x80, 0x03, 0x1C, 0x00,
  0x38, 0xE0, 0x01, 0x87, 0x00, 0x0C, 0x38, 0x00, 0xE1, 0xC0, 0x06, 0x0E,
  0x00, 0x30, 0x70, 0x03, 0x83, 0x80, 0x18, 0x1C, 0x01, 0xC0, 0x60, 0x0C,
  0x03, 0x00, 0xC0, 0x1C, 0x0E, 0x00, 0x60, 0xE0, 0x03, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x03, 0xE0, 0x76, 0x0E,
  0xE1, 0xCE, 0x38, 0xCF, 0x0C, 0x40, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x70,
  0x1E, 0x00, 0x20, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0xE0, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x04, 0x00,
  0xF0, 0x0F, 0xDF, 0x80, 0x1F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xCC, 0x00,
  0x01, 0x9C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x06, 0x18, 0x00,
  0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00,
  0x30, 0x30, 0x00, 0x70, 0x70, 0x00, 0x60, 0x70, 0x00, 0xC0, 0x60, 0x00,
  0xC0, 0x60, 0x01, 0x80, 0x60, 0x03, 0x80, 0xE0, 0x03, 0x00, 0xC0, 0x06,
  0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x30, 0x01, 0x80, 0x70, 0x01, 0x80, 0x60, 0x03, 0x80, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xDF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x38, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x30, 0x03, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x60, 0x00, 0xC7, 0xF8, 0x03,
  0x9F, 0xF8, 0x07, 0x60, 0x78, 0x0D, 0x80, 0x70, 0x1E, 0x00, 0x60, 0x38,
  0x00, 0xE0, 0xF0, 0x01, 0xC1, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x07, 0x00,
  0x06, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x30, 0x00, 0x70, 0x60, 0x00,
  0xC1, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C,
  0x1C, 0x00, 0x30, 0x18, 0x00, 0xE0, 0x30, 0x01, 0x80, 0x60, 0x07, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0xE0, 0x01, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x78, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x06, 0x01, 0xC0,
  0x07, 0x01, 0x80, 0x07, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80,
  0x07, 0x01, 0x80, 0x07, 0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x01, 0x80,
  0x0E, 0x01, 0x80, 0x0C, 0x01, 0xC0, 0x18, 0x00, 0xC0, 0x38, 0x00, 0xE0,
  0x70, 0x00, 0x70, 0xE0, 0x00, 0x33, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xE7, 0x00, 0x03, 0x83, 0x80, 0x07, 0x01,
  0x80, 0x0E, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x38, 0x00, 0xE0, 0x30, 0x00,
  0x60, 0x70, 0x00, 0x60, 0x60, 0x00, 0x70, 0x60, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x60, 0xE0, 0x00,
  0x60, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x38, 0x01,
  0x80, 0x3C, 0x07, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x3C, 0x1C,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x38, 0x01, 0x80, 0xC0, 0x07, 0x07,
  0x00, 0x1C, 0x1C, 0x00, 0x70, 0x60, 0x00, 0xC3, 0x80, 0x03, 0x0E, 0x00,
  0x1C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x1C,
  0x70, 0x00, 0x61, 0xC0, 0x01, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70,
  0x01, 0xE0, 0xC0, 0x07, 0x83, 0x00, 0x3E, 0x0E, 0x01, 0xB0, 0x1C, 0x0E,
  0xC0, 0x7F, 0xF3, 0x00, 0xFF, 0x1C, 0x00, 0x70, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0xF0, 0x3C, 0x0E, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x1C,
  0x0F, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x01, 0xFF,
  0x03, 0xFF, 0xC0, 0xC0, 0xF0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x60, 0x0E, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x30,
  0x07, 0xF8, 0x30, 0xC0, 0x3D, 0xC0, 0xC6, 0x01, 0x83, 0x03, 0x18, 0x0E,
  0x0C, 0x0C, 0x60, 0x30, 0x30, 0x33, 0x01, 0x81, 0x80, 0xCC, 0x0E, 0x06,
  0x07, 0x30, 0x30, 0x18, 0x19, 0xC0, 0xC0, 0xE0, 0x66, 0x06, 0x03, 0x01,
  0x98, 0x18, 0x0C, 0x06, 0x60, 0x60, 0x30, 0x19, 0x83, 0x81, 0xC0, 0xCE,
  0x0C, 0x06, 0x03, 0x30, 0x30, 0x18, 0x0C, 0xC0, 0xC0, 0x60, 0x63, 0x03,
  0x03, 0x81, 0x8C, 0x0C, 0x0E, 0x06, 0x30, 0x30, 0x70, 0x30, 0xC0, 0xC1,
  0x40, 0xC3, 0x03, 0x0D, 0x06, 0x0C, 0x0C, 0x34, 0x38, 0x30, 0x39, 0x99,
  0xC0, 0xC0, 0x7C, 0x7E, 0x03, 0x00, 0xE0, 0x60, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x40, 0x00, 0x1F, 0x9F,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x1C,
  0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00,
  0x38, 0x60, 0x01, 0x83, 0x00, 0x1C, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06,
  0x00, 0x70, 0x30, 0x03, 0x01, 0x80, 0x38, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x18, 0x01, 0x81, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xE0, 0x03, 0x06, 0x00,
  0x18, 0x70, 0x00, 0xC3, 0x80, 0x06, 0x18, 0x00, 0x31, 0xC0, 0x01, 0x8C,
  0x00, 0x0C, 0xE0, 0x00, 0x67, 0x00, 0x03, 0x30, 0x00, 0x1B, 0x80, 0x00,
  0xD8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x18, 0x0F, 0x80, 0x0C, 0x01, 0xC0, 0x06, 0x00,
  0x70, 0x07, 0x00, 0x18, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x07, 0x00, 0xC0,
  0x03, 0x80, 0x60, 0x01, 0xC0, 0x70, 0x00, 0xC0, 0x38, 0x00, 0x60, 0x18,
  0x00, 0x30, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x18, 0x07, 0x00, 0x1C, 0x03,
  0x80, 0x0C, 0x01, 0x80, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x1E, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x18, 0x3F, 0x00, 0x0C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x18, 0x03, 0x00, 0x0E, 0x01, 0x80, 0x07,
  0x00, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x60, 0x30, 0x00,
  0x70, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x1C, 0x0E, 0x00, 0x0C, 0x07, 0x00,
  0x06, 0x03, 0x00, 0x07, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x80, 0xE0,
  0x03, 0x80, 0x60, 0x01, 0xC0, 0x30, 0x03, 0xC0, 0x18, 0x0F, 0xC0, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x03, 0xC0, 0x20, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x40, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x1C, 0x1F, 0x00, 0x0C, 0x01, 0xC0, 0x06, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x01, 0x80, 0x07, 0x00, 0xC0,
  0x01, 0x80, 0x60, 0x00, 0xC0, 0x70, 0x00, 0x60, 0x38, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x07, 0x00, 0x03, 0x03,
  0x80, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x70,
  0x70, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x06,
  0x0E, 0x00, 0x03, 0x07, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x30, 0x30, 0x00,
  0x38, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x06, 0x00,
  0x0E, 0x03, 0x00, 0x07, 0x01, 0x80, 0x07, 0x01, 0xC0, 0x07, 0x00, 0xE0,
  0x07, 0x00, 0x60, 0x07, 0x00, 0x30, 0x0F, 0x00, 0x18, 0x3F, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0x20, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0xFF, 0x06, 0x00, 0x1F, 0xF0, 0x60, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x0C, 0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x18, 0x07, 0x00, 0x01, 0x80, 0x30, 0x00, 0x38, 0x03,
  0x80, 0x03, 0x00, 0x1C, 0x00, 0x30, 0x01, 0xE0, 0x07, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x18, 0x03, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x70,
  0x06, 0x00, 0x03, 0x00, 0x70, 0x00, 0x18, 0x03, 0x80, 0x00, 0xC0, 0x18,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x18, 0x03, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x60,
  0x06, 0x00, 0x03, 0x00, 0x70, 0x00, 0x18, 0x03, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60,
  0x0E, 0x00, 0x03, 0x00, 0x70, 0x00, 0x38, 0x03, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x0E, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x38, 0x03, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60,
  0x0E, 0x00, 0x03, 0x00, 0x60, 0x00, 0x38, 0x03, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0x60, 0x0E, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x38, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x60,
  0x0E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x43, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x30, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0xC0, 0x38, 0x00, 0x18, 0x06, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x0C, 0x70, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x0C, 0xF0, 0x00, 0x01, 0xB6, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x0F, 0x9C,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x38, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0, 0x30,
  0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x18,
  0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x38, 0x01, 0x80,
  0x07, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x0F, 0xFF, 0xEF, 0xFF, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x06, 0xC0, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x36, 0x00, 0x6C, 0x00, 0x00,
  0x6C, 0x00, 0xD8, 0x00, 0x01, 0x98, 0x01, 0xB0, 0x00, 0x03, 0x70, 0x07,
  0x70, 0x00, 0x0C, 0xE0, 0x0E, 0xE0, 0x00, 0x19, 0x80, 0x19, 0xC0, 0x00,
  0x73, 0x00, 0x33, 0x80, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x03, 0x9C, 0x01,
  0xC6, 0x00, 0x06, 0x30, 0x03, 0x0C, 0x00, 0x1C, 0x60, 0x06, 0x18, 0x00,
  0x30, 0xC0, 0x0C, 0x30, 0x00, 0xE3, 0x80, 0x18, 0x60, 0x01, 0x87, 0x00,
  0x70, 0xC0, 0x07, 0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x01, 0x83, 0x00,
  0x38, 0x30, 0x03, 0x06, 0x00, 0x60, 0xE0, 0x0E, 0x0C, 0x01, 0xC1, 0xC0,
  0x1C, 0x18, 0x03, 0x03, 0x00, 0x30, 0x30, 0x06, 0x06, 0x00, 0x60, 0x60,
  0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x30, 0x38, 0x03, 0x81, 0xC0, 0xC0, 0x60,
  0x06, 0x03, 0x81, 0x80, 0xC0, 0x0C, 0x07, 0x07, 0x01, 0x80, 0x18, 0x0E,
  0x0C, 0x07, 0x00, 0x30, 0x1C, 0x38, 0x0E, 0x00, 0xE0, 0x18, 0x60, 0x18,
  0x01, 0x80, 0x31, 0xC0, 0x30, 0x03, 0x00, 0x63, 0x00, 0x60, 0x06, 0x00,
  0xCE, 0x01, 0xC0, 0x1C, 0x01, 0x98, 0x03, 0x80, 0x38, 0x03, 0x70, 0x06,
  0x00, 0x60, 0x06, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0x80, 0x18, 0x01, 0x80,
  0x1E, 0x00, 0x70, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x18, 0x01, 0xE0,
  0x00, 0x30, 0x03, 0xC0, 0x00, 0x60, 0x07, 0x80, 0x01, 0xC0, 0x1F, 0x80,
  0x03, 0x80, 0x3F, 0x00, 0x06, 0x00, 0x66, 0x00, 0x0C, 0x00, 0xCC, 0x00,
  0x18, 0x01, 0x98, 0x00, 0x70, 0x07, 0x30, 0x00, 0xC0, 0x0E, 0x70, 0x01,
  0x80, 0x18, 0x60, 0x03, 0x00, 0x30, 0xC0, 0x0E, 0x00, 0x61, 0x80, 0x1C,
  0x01, 0xC3, 0x00, 0x30, 0x03, 0x87, 0x00, 0x60, 0x06, 0x0E, 0x00, 0xC0,
  0x0C, 0x0C, 0x03, 0x80, 0x18, 0x18, 0x07, 0x00, 0x70, 0x30, 0x0C, 0x00,
  0xC0, 0x60, 0x18, 0x01, 0x80, 0xE0, 0x30, 0x03, 0x00, 0xC0, 0xE0, 0x0E,
  0x01, 0x81, 0x80, 0x1C, 0x03, 0x03, 0x00, 0x30, 0x06, 0x06, 0x00, 0x60,
  0x0C, 0x0C, 0x00, 0xC0, 0x1C, 0x38, 0x03, 0x80, 0x18, 0x60, 0x07, 0x00,
  0x30, 0xC0, 0x0C, 0x00, 0x61, 0x80, 0x18, 0x00, 0xC7, 0x00, 0x30, 0x01,
  0xCE, 0x00, 0xE0, 0x03, 0x98, 0x01, 0x80, 0x03, 0x30, 0x03, 0x00, 0x06,
  0x60, 0x06, 0x00, 0x0D, 0xC0, 0x1C, 0x00, 0x1B, 0x80, 0x38, 0x00, 0x3E,
  0x00, 0x60, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x78, 0x01, 0x80, 0x00, 0xF0,
  0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0x81, 0xE0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x03, 0x80,
  0x01, 0x81, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xE0,
  0x00, 0x18, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x38, 0x00, 0x03, 0x18,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x67, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x06,
  0x70, 0x00, 0x03, 0x30, 0x00, 0x03, 0x98, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x67, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00,
  0x18, 0xE0, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x06, 0x1C, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0x80, 0xC0,
  0x01, 0xC0, 0x60, 0x01, 0xC0, 0x38, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x81, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x70, 0xF8, 0x00, 0x60, 0x1C,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0xC0, 0x07,
  0x00, 0xC0, 0x07, 0x00, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07,
  0x01, 0x80, 0x07, 0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x03, 0x80, 0x0E,
  0x03, 0x80, 0x0E, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x18,
  0x07, 0x00, 0x38, 0x06, 0x00, 0x70, 0x06, 0x01, 0xE0, 0x06, 0x0F, 0xC0,
  0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x07, 0x81, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x03, 0x00,
  0x0E, 0x03, 0x00, 0x03, 0x03, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC1, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x38, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x73, 0x00, 0x00, 0x39, 0x80, 0x00, 0x1D,
  0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x06, 0x70, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x98, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0C, 0x70, 0x00,
  0x0E, 0x38, 0x00, 0x06, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0x38,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x81, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x70, 0x78, 0x00,
  0x60, 0x1C, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00,
  0xC0, 0x07, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01,
  0xC0, 0x07, 0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x03,
  0x80, 0x0E, 0x03, 0x80, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x1C, 0x03,
  0x00, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x06, 0x03, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C,
  0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x06, 0x00, 0x18,
  0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x07, 0x00, 0x38, 0x07, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x03, 0x00, 0x70,
  0x03, 0x80, 0x60, 0x03, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0xE0,
  0x01, 0x80, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0xF0, 0x06, 0x00, 0x70, 0x00, 0x80, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x08, 0x00, 0x38,
  0x03, 0x80, 0x3E, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x30,
  0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C,
  0x07, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x70, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x30, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0x80, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x0E,
  0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0xE0, 0x18, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60,
  0x18, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x1C, 0x00,
  0x0C, 0x03, 0x80, 0x01, 0x80, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x0C, 0x01,
  0x80, 0x01, 0x80, 0x30, 0x00, 0x70, 0x07, 0x00, 0x0C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xCE,
  0x00, 0x07, 0x38, 0x00, 0x18, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x0E, 0x00,
  0x0C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x30,
  0x38, 0x01, 0xC0, 0xE0, 0x06, 0x03, 0x80, 0x18, 0x0E, 0x00, 0xE0, 0x38,
  0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0E, 0x03, 0x80, 0x38, 0x0C,
  0x00, 0xE0, 0x30, 0x03, 0x81, 0xC0, 0x0E, 0x06, 0x00, 0x38, 0x38, 0x00,
  0xE0, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x60, 0x00, 0xE3,
  0x80, 0x03, 0x8C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0x80, 0x00, 0xE6, 0x00,
  0x03, 0xB8, 0x00, 0x0E, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xD8, 0x00, 0x03,
  0x60, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x6E, 0x00, 0x07, 0x00,
  0x01, 0xB8, 0x00, 0x1C, 0x00, 0x0E, 0xE0, 0x00, 0xF0, 0x00, 0x33, 0x80,
  0x03, 0xC0, 0x01, 0xCE, 0x00, 0x0F, 0x00, 0x06, 0x30, 0x00, 0x6C, 0x00,
  0x18, 0xC0, 0x01, 0xB0, 0x00, 0xE3, 0x00, 0x0E, 0xC0, 0x03, 0x0C, 0x00,
  0x33, 0x00, 0x1C, 0x30, 0x00, 0xCC, 0x00, 0x60, 0xC0, 0x06, 0x30, 0x01,
  0x83, 0x00, 0x18, 0xC0, 0x0E, 0x0C, 0x00, 0xE3, 0x00, 0x30, 0x30, 0x03,
  0x0C, 0x01, 0xC0, 0xC0, 0x0C, 0x30, 0x06, 0x03, 0x00, 0x60, 0xC0, 0x18,
  0x0C, 0x01, 0x83, 0x00, 0xE0, 0x30, 0x0E, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x30, 0x1C, 0x03, 0x00, 0xC0, 0xC0, 0x60, 0x0C, 0x07, 0x03, 0x01, 0x80,
  0x30, 0x18, 0x0C, 0x0E, 0x00, 0xC0, 0xE0, 0x30, 0x30, 0x03, 0x03, 0x01,
  0xC1, 0xC0, 0x0C, 0x0C, 0x07, 0x06, 0x00, 0x30, 0x70, 0x1C, 0x18, 0x00,
  0xC1, 0x80, 0x60, 0xE0, 0x03, 0x06, 0x01, 0x83, 0x00, 0x0C, 0x30, 0x06,
  0x1C, 0x00, 0x30, 0xC0, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x61, 0x80, 0x03,
  0x18, 0x01, 0x8E, 0x00, 0x0C, 0x60, 0x06, 0x30, 0x00, 0x33, 0x00, 0x19,
  0xC0, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x03, 0x70, 0x01, 0x98, 0x00, 0x0D,
  0x80, 0x06, 0xE0, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x0E, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x98, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x07, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x1C,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x00,
  0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x37, 0x00, 0x07, 0x70, 0x00, 0x63, 0x00, 0x0E, 0x30, 0x00, 0xC3,
  0x00, 0x1C, 0x30, 0x01, 0x83, 0x00, 0x38, 0x30, 0x03, 0x03, 0x00, 0x60,
  0x30, 0x0E, 0x03, 0x80, 0xC0, 0x38, 0x1C, 0x01, 0x81, 0x80, 0x18, 0x38,
  0x01, 0x83, 0x00, 0x18, 0x70, 0x01, 0x86, 0x00, 0x18, 0xE0, 0x01, 0x8C,
  0x00, 0x19, 0xC0, 0x01, 0x98, 0x00, 0x1B, 0x80, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x00, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0xC0, 0xE0, 0x30, 0x18, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x70, 0x00,
  0x0E, 0x60, 0x00, 0x18, 0xE0, 0x00, 0x70, 0xC0, 0x00, 0xC1, 0xC0, 0x03,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x18, 0x07, 0x00, 0x70, 0x06, 0x00, 0xC0,
  0x0E, 0x03, 0x80, 0x0C, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x30, 0x00,
  0x30, 0xE0, 0x00, 0x71, 0x80, 0x00, 0x67, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0xC1, 0xC1, 0x83, 0x03, 0x06,
  0x06, 0x0C, 0x0C, 0x00, 0x1E, 0x00, 0x01, 0xFE, 0x30, 0x1F, 0x3C, 0xC0,
  0xF0, 0x36, 0x03, 0x80, 0x58, 0x1C, 0x01, 0xE0, 0xE0, 0x07, 0x83, 0x00,
  0x1E, 0x1C, 0x00, 0x70, 0x60, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x30, 0x00, 0x61, 0xC0, 0x01, 0x87, 0x00, 0x06, 0x18, 0x00, 0x38, 0x60,
  0x00, 0xE1, 0x80, 0x03, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xC0, 0x01,
  0xC3, 0x00, 0x07, 0x0C, 0x00, 0x18, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x83,
  0x00, 0x0E, 0x0C, 0x00, 0x78, 0x30, 0x01, 0xC0, 0xC0, 0x0F, 0x03, 0x80,
  0x6C, 0x06, 0x01, 0xB0, 0x1C, 0x0D, 0x80, 0x3F, 0xE6, 0x00, 0x7F, 0x18,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x63, 0xFC,
  0x01, 0x9C, 0x78, 0x06, 0xC0, 0x60, 0x1E, 0x01, 0xC0, 0xF8, 0x03, 0x03,
  0xC0, 0x0C, 0x0E, 0x00, 0x30, 0x38, 0x00, 0xC1, 0xC0, 0x03, 0x07, 0x00,
  0x0C, 0x1C, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x0E, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0xC0, 0x01, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x18, 0x70,
  0x00, 0x61, 0x80, 0x03, 0x86, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x60, 0x01,
  0xC3, 0x80, 0x07, 0x0E, 0x00, 0x18, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x07,
  0x80, 0x1C, 0x1A, 0x00, 0xE0, 0x6C, 0x03, 0x01, 0xB8, 0x3C, 0x06, 0x7F,
  0xE0, 0x30, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xC0,
  0x7C, 0x60, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x20, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x78, 0x30, 0x00, 0xFF, 0x38,
  0x01, 0xF3, 0xDC, 0x01, 0xE0, 0x6C, 0x00, 0xE0, 0x16, 0x00, 0xE0, 0x0F,
  0x00, 0xE0, 0x07, 0x80, 0x60, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x30, 0x00,
  0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x0C, 0x00, 0x18, 0x0E, 0x00,
  0x0C, 0x07, 0x00, 0x06, 0x03, 0x00, 0x07, 0x01, 0x80, 0x03, 0x80, 0xC0,
  0x01, 0x80, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x60, 0x30, 0x00, 0x70, 0x18,
  0x00, 0x38, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x01,
  0x80, 0x07, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x03, 0x80, 0x30, 0x03, 0xC0,
  0x1C, 0x03, 0x60, 0x06, 0x01, 0xB0, 0x03, 0x83, 0xB0, 0x00, 0xFF, 0x98,
  0x00, 0x3F, 0x8C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F,
  0xE0, 0x1E, 0x38, 0x0E, 0x07, 0x07, 0x00, 0xC1, 0x80, 0x30, 0xE0, 0x0C,
  0x30, 0x03, 0x1C, 0x00, 0xC6, 0x00, 0x73, 0x80, 0x18, 0xC0, 0x0E, 0x70,
  0x03, 0x1C, 0x03, 0x86, 0x01, 0xE1, 0x81, 0xE0, 0xFF, 0xF0, 0x3F, 0xE0,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x20, 0x3E, 0xF8, 0x07, 0xFC,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1C, 0x20, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xF8, 0xC0, 0x0F, 0x9E, 0x60, 0x0F, 0x03, 0x60, 0x07, 0x00, 0xB0,
  0x07, 0x00, 0x78, 0x07, 0x00, 0x3C, 0x03, 0x00, 0x1C, 0x03, 0x80, 0x0E,
  0x01, 0x80, 0x07, 0x00, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x60, 0x00,
  0xC0, 0x70, 0x00, 0x60, 0x38, 0x00, 0x30, 0x18, 0x00, 0x38, 0x0C, 0x00,
  0x1C, 0x06, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x03, 0x80, 0x03, 0x01, 0x80,
  0x03, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0xC0, 0x30, 0x00, 0xE0, 0x18,
  0x00, 0x70, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x38, 0x03, 0x00, 0x1C, 0x01,
  0x80, 0x1E, 0x00, 0xE0, 0x1B, 0x00, 0x30, 0x1F, 0x80, 0x1C, 0x1D, 0x80,
  0x07, 0xFC, 0xC0, 0x01, 0xFC, 0x60, 0x00, 0x30, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x04, 0x00, 0xE0, 0x03, 0x81, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x0F, 0x00, 0x31, 0xFE,
  0x01, 0x9C, 0x78, 0x0D, 0x81, 0xC0, 0x78, 0x06, 0x06, 0x80, 0x30, 0x3C,
  0x01, 0x81, 0xC0, 0x0C, 0x0E, 0x00, 0x60, 0x60, 0x03, 0x07, 0x00, 0x38,
  0x38, 0x01, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0xE0, 0x03, 0x07, 0x00,
  0x38, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0xE0, 0x03, 0x06,
  0x00, 0x38, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0xE0, 0x07,
  0x06, 0x00, 0x38, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0xE0,
  0x07, 0x06, 0x00, 0x38, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x1C, 0x00, 0xE0,
  0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x40, 0x60, 0x06, 0x01, 0x80, 0x38, 0x06, 0x01, 0xC0,
  0x18, 0x0E, 0x00, 0xE0, 0x30, 0x03, 0x01, 0xC0, 0x0C, 0x0E, 0x00, 0x30,
  0x70, 0x01, 0xC1, 0x80, 0x07, 0x0E, 0x00, 0x18, 0x70, 0x00, 0x63, 0x80,
  0x01, 0x8C, 0x00, 0x0E, 0x70, 0x00, 0x33, 0xC0, 0x00, 0xDF, 0x80, 0x03,
  0x6E, 0x00, 0x0F, 0x18, 0x00, 0x78, 0x60, 0x01, 0xC1, 0x80, 0x07, 0x06,
  0x00, 0x18, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x80, 0xC0, 0x0C, 0x03, 0x00,
  0x30, 0x0C, 0x00, 0xC0, 0x30, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x80, 0x60,
  0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x38, 0x01, 0x80, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0xCF, 0xF0, 0xFF,
  0x80, 0x6E, 0x1C, 0xF1, 0xE0, 0x36, 0x07, 0x60, 0x70, 0x1E, 0x03, 0xE0,
  0x18, 0x1E, 0x00, 0xE0, 0x0C, 0x0E, 0x00, 0x70, 0x06, 0x07, 0x00, 0x30,
  0x03, 0x03, 0x00, 0x38, 0x01, 0x83, 0x80, 0x1C, 0x00, 0xC1, 0xC0, 0x0C,
  0x00, 0xE0, 0xE0, 0x06, 0x00, 0x60, 0x60, 0x07, 0x00, 0x30, 0x30, 0x03,
  0x80, 0x18, 0x38, 0x01, 0x80, 0x1C, 0x1C, 0x00, 0xC0, 0x0E, 0x0C, 0x00,
  0x60, 0x06, 0x06, 0x00, 0x70, 0x03, 0x03, 0x00, 0x38, 0x01, 0x83, 0x80,
  0x18, 0x01, 0xC1, 0x80, 0x0C, 0x00, 0xE0, 0xC0, 0x06, 0x00, 0x60, 0x60,
  0x07, 0x00, 0x30, 0x30, 0x03, 0x00, 0x18, 0x38, 0x01, 0x80, 0x1C, 0x18,
  0x00, 0xC0, 0x0C, 0x0C, 0x00, 0xE0, 0x06, 0x06, 0x00, 0x70, 0x03, 0x07,
  0x00, 0x30, 0x01, 0x83, 0x80, 0x18, 0x01, 0xC1, 0x80, 0x0C, 0x00, 0xC0,
  0xC0, 0x0E, 0x00, 0x60, 0x60, 0x07, 0x00, 0x30, 0x70, 0x03, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x0C, 0x7F, 0x80, 0x67, 0x1E, 0x03, 0x60, 0x70,
  0x1E, 0x01, 0x81, 0xA0, 0x0C, 0x0F, 0x00, 0x60, 0x70, 0x03, 0x03, 0x80,
  0x18, 0x38, 0x00, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x60, 0x60, 0x03, 0x03,
  0x00, 0x18, 0x38, 0x00, 0xC1, 0xC0, 0x0E, 0x0C, 0x00, 0x60, 0x60, 0x03,
  0x03, 0x00, 0x18, 0x38, 0x01, 0xC1, 0x80, 0x0E, 0x0C, 0x00, 0x60, 0x60,
  0x03, 0x03, 0x00, 0x18, 0x38, 0x01, 0xC1, 0x80, 0x0E, 0x0C, 0x00, 0x60,
  0x60, 0x03, 0x07, 0x00, 0x18, 0x38, 0x01, 0xC1, 0x80, 0x0C, 0x0C, 0x00,
  0x60, 0x60, 0x03, 0x07, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xF0,
  0x07, 0x8F, 0x01, 0xC0, 0x60, 0x70, 0x0E, 0x0C, 0x00, 0xC3, 0x80, 0x18,
  0x60, 0x03, 0x1C, 0x00, 0x63, 0x00, 0x0C, 0xE0, 0x01, 0x98, 0x00, 0x33,
  0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x03, 0xB0,
  0x00, 0x76, 0x00, 0x0C, 0xC0, 0x03, 0x98, 0x00, 0x63, 0x00, 0x0C, 0x60,
  0x03, 0x8C, 0x00, 0xE1, 0xC0, 0x18, 0x38, 0x07, 0x03, 0x81, 0xC0, 0x3F,
  0xF0, 0x03, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x18,
  0xFF, 0x00, 0x0C, 0xE3, 0xC0, 0x06, 0xC0, 0x60, 0x03, 0x40, 0x38, 0x03,
  0x60, 0x0C, 0x01, 0xE0, 0x06, 0x00, 0xE0, 0x03, 0x00, 0x70, 0x01, 0x80,
  0x30, 0x00, 0xC0, 0x38, 0x00, 0x60, 0x1C, 0x00, 0x30, 0x0C, 0x00, 0x18,
  0x06, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x03, 0x80, 0x03, 0x01, 0x80, 0x03,
  0x80, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0xC0, 0x70, 0x00, 0x60, 0x38, 0x00,
  0x30, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x07, 0x00,
  0x0E, 0x03, 0x80, 0x06, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x00, 0x70,
  0x03, 0x80, 0x78, 0x03, 0x80, 0x36, 0x03, 0x80, 0x1B, 0x83, 0xC0, 0x0C,
  0xFF, 0xC0, 0x0E, 0x3F, 0x80, 0x07, 0x06, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x03, 0xFE, 0x30, 0x1F, 0x3C, 0xC0, 0xE0, 0x36,
  0x03, 0x00, 0xD8, 0x1C, 0x01, 0xE0, 0xE0, 0x07, 0x83, 0x00, 0x1C, 0x1C,
  0x00, 0x70, 0x60, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x30, 0x00,
  0x60, 0xC0, 0x01, 0x87, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0xE1,
  0x80, 0x03, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xC0, 0x01, 0xC3, 0x00,
  0x07, 0x0C, 0x00, 0x18, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x83, 0x00, 0x0E,
  0x0C, 0x00, 0x70, 0x30, 0x01, 0xC0, 0xC0, 0x0F, 0x03, 0x80, 0x6C, 0x0E,
  0x01, 0xF0, 0x1C, 0x1D, 0x80, 0x7F, 0xE6, 0x00, 0xFF, 0x18, 0x00, 0x60,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x63, 0xF0, 0x19, 0xE4, 0x06,
  0xC0, 0x01, 0x60, 0x00, 0xD0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x1F, 0xFC, 0x07, 0x87, 0x81, 0xC0, 0x20, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x06, 0x01,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x1F, 0xF1, 0xFF,
  0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0F, 0xE0, 0x7E, 0x01, 0x80,
  0x07, 0x00, 0x38, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x1C, 0x00, 0x60, 0xE0,
  0x07, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x1C, 0x00, 0xE0,
  0xC0, 0x07, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x1C, 0x00,
  0xE0, 0xC0, 0x07, 0x06, 0x00, 0x30, 0x30, 0x01, 0x83, 0x80, 0x0C, 0x1C,
  0x00, 0xE0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x83, 0x80, 0x1C,
  0x1C, 0x00, 0xE0, 0xC0, 0x06, 0x06, 0x00, 0x70, 0x30, 0x03, 0x81, 0x80,
  0x3C, 0x0C, 0x01, 0xE0, 0x60, 0x1E, 0x03, 0x81, 0xB0, 0x1F, 0xF9, 0x80,
  0x7F, 0x8C, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x03, 0xE0, 0x01, 0xB0, 0x01,
  0xD8, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x73, 0x00, 0x31, 0x80, 0x38, 0xC0,
  0x18, 0x60, 0x1C, 0x30, 0x0C, 0x18, 0x0E, 0x0C, 0x06, 0x06, 0x03, 0x03,
  0x03, 0x81, 0x81, 0x80, 0xC1, 0xC0, 0x60, 0xC0, 0x30, 0xE0, 0x18, 0x60,
  0x0C, 0x30, 0x06, 0x30, 0x03, 0x18, 0x01, 0x9C, 0x00, 0xCC, 0x00, 0x6E,
  0x00, 0x36, 0x00, 0x1B, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x3E, 0x00, 0x38, 0x01,
  0xB0, 0x03, 0xC0, 0x0D, 0x80, 0x1E, 0x00, 0xCC, 0x00, 0xF0, 0x06, 0x60,
  0x0D, 0x80, 0x73, 0x00, 0x6C, 0x03, 0x18, 0x06, 0x60, 0x18, 0xC0, 0x33,
  0x01, 0x86, 0x01, 0x98, 0x0C, 0x30, 0x18, 0xC0, 0xE1, 0x80, 0xC6, 0x06,
  0x0C, 0x0C, 0x30, 0x30, 0x60, 0x61, 0x83, 0x03, 0x03, 0x0C, 0x18, 0x18,
  0x30, 0x60, 0xC0, 0xC1, 0x83, 0x0C, 0x06, 0x18, 0x18, 0x60, 0x30, 0xC0,
  0xC7, 0x01, 0x8E, 0x06, 0x30, 0x0C, 0x60, 0x31, 0x80, 0x63, 0x01, 0x98,
  0x03, 0x30, 0x0C, 0xC0, 0x19, 0x80, 0x6E, 0x00, 0xCC, 0x06, 0x60, 0x06,
  0xC0, 0x33, 0x00, 0x36, 0x01, 0xB0, 0x01, 0xE0, 0x0D, 0x80, 0x0F, 0x00,
  0x6C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0xC0, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0x60, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x60, 0x38, 0x00, 0x60, 0x30, 0x00,
  0x70, 0x70, 0x00, 0x70, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x31, 0xC0, 0x00,
  0x31, 0x80, 0x00, 0x33, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xCE, 0x00, 0x01, 0xC6, 0x00, 0x01,
  0x86, 0x00, 0x03, 0x86, 0x00, 0x03, 0x06, 0x00, 0x06, 0x07, 0x00, 0x0E,
  0x03, 0x00, 0x0C, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x38, 0x03, 0x00, 0x30,
  0x03, 0x80, 0x70, 0x03, 0x80, 0xE0, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0xC0, 0x06, 0x00, 0x06, 0x00, 0x70, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80,
  0x38, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x0F, 0xE0, 0x00, 0x3C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x05, 0xFF, 0x80, 0x1E, 0x0F,
  0x81, 0xF0, 0x0F, 0xFE, 0x80, 0x0F, 0xF0, 0x00, 0x04, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 45, 13, 1, -45 },
  { 75, 13, 16, 17, 6, -45 },
  { 101, 25, 45, 24, 0, -45 },
  { 242, 24, 52, 22, -1, -48 },
  { 398, 28, 47, 34, 3, -46 },
  { 563, 22, 47, 22, -1, -46 },
  { 693, 6, 16, 10, 6, -45 },
  { 705, 17, 55, 15, 2, -45 },
  { 822, 17, 55, 15, -4, -45 },
  { 939, 16, 18, 21, 7, -48 },
  { 975, 22, 29, 26, 2, -37 },
  { 1055, 9, 14, 10, -3, -6 },
  { 1071, 14, 2, 16, 1, -18 },
  { 1075, 4, 5, 10, 1, -5 },
  { 1078, 26, 45, 19, -3, -45 },
  { 1225, 21, 47, 22, 1, -46 },
  { 1349, 12, 45, 22, 7, -45 },
  { 1417, 24, 46, 22, -2, -46 },
  { 1555, 23, 47, 22, -1, -46 },
  { 1691, 24, 45, 22, -1, -45 },
  { 1826, 25, 46, 22, -2, -45 },
  { 1970, 23, 47, 22, 1, -46 },
  { 2106, 23, 45, 22, 2, -45 },
  { 2236, 24, 47, 22, -1, -46 },
  { 2377, 22, 47, 22, 0, -46 },
  { 2507, 10, 33, 10, 0, -33 },
  { 2549, 13, 41, 10, -3, -33 },
  { 2616, 22, 26, 26, 2, -35 },
  { 2688, 22, 16, 26, 2, -30 },
  { 2732, 22, 26, 26, 2, -35 },
  { 2804, 17, 46, 16, 1, -46 },
  { 2902, 30, 51, 33, 2, -45 },
  { 3094, 21, 45, 22, -4, -45 },
  { 3213, 25, 45, 24, 0, -45 },
  { 3354, 25, 47, 22, 2, -46 },
  { 3501, 25, 45, 27, 0, -45 },
  { 3642, 24, 45, 22, 0, -45 },
  { 3777, 24, 45, 20, 0, -45 },
  { 3912, 28, 47, 29, 2, -46 },
  { 4077, 29, 45, 28, 0, -45 },
  { 4241, 20, 45, 12, -4, -45 },
  { 4354, 21, 56, 10, -9, -45 },
  { 4501, 27, 45, 23, 0, -45 },
  { 4653, 15, 45, 19, 0, -45 },
  { 4738, 39, 45, 38, 0, -45 },
  { 4958, 31, 45, 30, 0, -45 },
  { 5133, 25, 47, 29, 2, -46 },
  { 5280, 24, 45, 23, 0, -45 },
  { 5415, 25, 57, 29, 2, -46 },
  { 5594, 24, 45, 23, 0, -45 },
  { 5729, 26, 47, 22, -2, -46 },
  { 5882, 20, 45, 19, 4, -45 },
  { 5995, 27, 46, 27, 2, -45 },
  { 6151, 22, 45, 22, 5, -45 },
  { 6275, 38, 45, 38, 5, -45 },
  { 6489, 28, 45, 20, -4, -45 },
  { 6647, 20, 45, 19, 4, -45 },
  { 6760, 26, 45, 20, -3, -45 },
  { 6907, 22, 55, 17, -1, -45 },
  { 7059, 9, 45, 20, 6, -45 },
  { 7110, 23, 55, 17, -4, -45 },
  { 7269, 23, 22, 25, 1, -45 },
  { 7333, 17, 2, 17, -5, 6 },
  { 7338, 7, 10, 13, 9, -48 },
  { 7347, 22, 35, 24, 2, -34 },
  { 7444, 22, 49, 24, 0, -48 },
  { 7579, 17, 35, 18, 2, -34 },
  { 7654, 25, 49, 24, 2, -48 },
  { 7808, 18, 35, 21, 2, -34 },
  { 7887, 28, 63, 12, -8, -48 },
  { 8108, 25, 49, 24, -1, -34 },
  { 8262, 21, 48, 23, 0, -48 },
  { 8388, 12, 45, 10, 0, -45 },
  { 8456, 21, 60, 11, -8, -45 },
  { 8614, 22, 48, 19, 0, -48 },
  { 8746, 13, 48, 10, 0, -48 },
  { 8824, 33, 34, 35, 0, -34 },
  { 8965, 21, 34, 23, 0, -34 },
  { 9055, 19, 35, 23, 2, -34 },
  { 9139, 25, 48, 24, -3, -34 },
  { 9289, 22, 49, 25, 2, -34 },
  { 9424, 18, 34, 15, 0, -34 },
  { 9501, 19, 35, 18, -1, -34 },
  { 9585, 12, 42, 12, 1, -41 },
  { 9648, 21, 34, 23, 2, -33 },
  { 9738, 17, 33, 18, 4, -33 },
  { 9809, 29, 33, 30, 4, -33 },
  { 9929, 24, 33, 19, -3, -33 },
  { 10028, 29, 48, 19, -7, -33 },
  { 10202, 19, 33, 15, -2, -33 },
  { 10281, 22, 55, 20, 2, -45 },
  { 10433, 2, 63, 22, 10, -48 },
  { 10449, 22, 55, 20, -4, -45 },
  { 10601, 22, 6, 26, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC63PT7B_H_
