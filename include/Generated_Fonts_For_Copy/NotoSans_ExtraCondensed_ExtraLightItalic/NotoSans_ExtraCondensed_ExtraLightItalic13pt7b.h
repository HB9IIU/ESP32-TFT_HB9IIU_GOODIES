#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC13PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x90, 0x80, 0xB6, 0x80, 0x29, 0x5E, 0xA5, 0x69, 0x94,
  0xA0, 0x11, 0xD4, 0xC6, 0x10, 0xCA, 0x57, 0x10, 0xED, 0xAD, 0xDF, 0xAD,
  0xB5, 0xB8, 0x35, 0x52, 0x4B, 0xBA, 0xF0, 0xE0, 0x12, 0x44, 0x88, 0x88,
  0x88, 0x40, 0x21, 0x11, 0x11, 0x22, 0x24, 0x80, 0x57, 0x20, 0x21, 0x09,
  0xF2, 0x10, 0x58, 0xE0, 0x80, 0x04, 0x20, 0x84, 0x10, 0x84, 0x10, 0x80,
  0x3A, 0x53, 0x19, 0x4A, 0x52, 0xE0, 0x74, 0xA4, 0x94, 0x80, 0x78, 0x42,
  0x21, 0x11, 0x10, 0xE0, 0x78, 0x42, 0x26, 0x08, 0x42, 0xE0, 0x18, 0x8C,
  0xA5, 0x4B, 0xC4, 0x20, 0x7A, 0x10, 0xC1, 0x08, 0x42, 0xE0, 0x3A, 0x10,
  0xC9, 0x4A, 0x52, 0xE0, 0x78, 0x44, 0x22, 0x11, 0x08, 0x80, 0x7A, 0x52,
  0xA6, 0x4A, 0x52, 0xE0, 0x7A, 0x53, 0x15, 0x18, 0x44, 0xE0, 0x40, 0x08,
  0x20, 0x00, 0x12, 0x80, 0x1B, 0x30, 0x41, 0x80, 0xF8, 0x3E, 0xC1, 0x82,
  0x6C, 0x00, 0x71, 0x12, 0x44, 0x80, 0x80, 0x3C, 0x45, 0x6B, 0x5A, 0xB5,
  0xAD, 0x54, 0x80, 0xE0, 0x08, 0xC6, 0x52, 0xAD, 0x29, 0x88, 0x3A, 0x52,
  0x97, 0x26, 0x32, 0xE0, 0x3D, 0x04, 0x10, 0x82, 0x08, 0x20, 0x70, 0x3A,
  0x52, 0x94, 0xC6, 0x32, 0xE0, 0x3A, 0x10, 0x87, 0x42, 0x10, 0xE0, 0x3A,
  0x10, 0x87, 0x22, 0x10, 0x80, 0x3D, 0x04, 0x10, 0x8A, 0x28, 0xA2, 0x78,
  0x25, 0x14, 0x52, 0x7A, 0x28, 0xA2, 0x90, 0x32, 0x22, 0x22, 0x44, 0xC0,
  0x11, 0x11, 0x11, 0x22, 0x22, 0xC0, 0x2D, 0x25, 0x18, 0x61, 0x8A, 0x24,
  0x90, 0x29, 0x25, 0x24, 0xE0, 0x21, 0x23, 0x62, 0x66, 0x66, 0xAA, 0xAA,
  0xB2, 0x94, 0x24, 0x96, 0x55, 0x56, 0x69, 0xA2, 0x88, 0x3D, 0x14, 0x51,
  0x86, 0x28, 0xA2, 0x70, 0x3A, 0x52, 0x97, 0x22, 0x10, 0x80, 0x3D, 0x14,
  0x51, 0x86, 0x28, 0xA2, 0x50, 0x81, 0x00, 0x3A, 0x52, 0x97, 0x52, 0x92,
  0x90, 0x7A, 0x10, 0x82, 0x08, 0x42, 0xE0, 0xF4, 0x44, 0x48, 0x88, 0x80,
  0x25, 0x14, 0x52, 0x4A, 0x28, 0xA4, 0x70, 0x8C, 0xA5, 0x4A, 0x63, 0x10,
  0x80, 0x91, 0x92, 0xB2, 0xB2, 0xB4, 0xD4, 0xD8, 0x88, 0x90, 0x24, 0xA1,
  0x84, 0x10, 0xC5, 0x14, 0x90, 0x9A, 0xAC, 0x48, 0x88, 0x80, 0x3C, 0x20,
  0x84, 0x10, 0x84, 0x10, 0xF0, 0x32, 0x44, 0x44, 0x88, 0x88, 0xC0, 0xA9,
  0x55, 0x40, 0x18, 0x44, 0x21, 0x08, 0x44, 0x21, 0x38, 0x22, 0x93, 0x10,
  0xE0, 0xC0, 0x3A, 0x53, 0x29, 0x4B, 0xC0, 0x21, 0x10, 0xE4, 0xA5, 0x32,
  0x97, 0x00, 0x34, 0x48, 0x88, 0xE0, 0x04, 0x10, 0x8E, 0x49, 0x29, 0x24,
  0x93, 0xC0, 0x35, 0x9E, 0x88, 0xE0, 0x0C, 0x21, 0x06, 0x10, 0x41, 0x08,
  0x20, 0x82, 0x08, 0xC0, 0x3A, 0x53, 0x29, 0x4B, 0xC2, 0x27, 0x00, 0x22,
  0x47, 0x55, 0x59, 0x99, 0x21, 0x24, 0xA4, 0x80, 0x08, 0x04, 0x21, 0x08,
  0x84, 0x21, 0x09, 0x80, 0x21, 0x10, 0xB5, 0x31, 0x94, 0xA5, 0x00, 0x25,
  0x24, 0x94, 0x90, 0x7E, 0x95, 0x4A, 0x99, 0x52, 0xA9, 0x00, 0x75, 0x55,
  0x99, 0x90, 0x35, 0x59, 0x99, 0xE0, 0x38, 0x92, 0x49, 0x49, 0x27, 0x10,
  0x82, 0x00, 0x3A, 0x53, 0x29, 0x4B, 0xC2, 0x21, 0x00, 0x74, 0x44, 0x88,
  0x80, 0x78, 0x44, 0x22, 0xE0, 0x29, 0xA5, 0x24, 0xC0, 0x4A, 0x54, 0xA9,
  0x4B, 0x80, 0xB6, 0xE9, 0x20, 0xA6, 0x9E, 0xBA, 0xB2, 0x4A, 0x00, 0x29,
  0x4C, 0x42, 0x2A, 0x40, 0x24, 0xA2, 0x8C, 0x30, 0x82, 0x08, 0x43, 0x00,
  0x72, 0x24, 0x48, 0xC0, 0x19, 0x08, 0x42, 0x61, 0x08, 0x42, 0x18, 0xFF,
  0xF8, 0x30, 0x84, 0x21, 0x0C, 0x84, 0x21, 0x30, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 3, 4, 1, -9 },
  { 7, 5, 9, 5, 0, -9 },
  { 13, 5, 11, 5, 0, -10 },
  { 20, 5, 9, 7, 1, -9 },
  { 26, 4, 9, 4, 0, -9 },
  { 31, 1, 3, 2, 1, -9 },
  { 32, 4, 11, 3, 0, -9 },
  { 38, 4, 11, 3, -1, -9 },
  { 44, 3, 4, 4, 2, -10 },
  { 46, 5, 6, 5, 0, -8 },
  { 50, 2, 3, 2, -1, -1 },
  { 51, 3, 1, 3, 0, -4 },
  { 52, 1, 1, 2, 0, -1 },
  { 53, 6, 9, 4, -1, -9 },
  { 60, 5, 9, 5, 0, -9 },
  { 66, 3, 9, 5, 1, -9 },
  { 70, 5, 9, 5, 0, -9 },
  { 76, 5, 9, 5, 0, -9 },
  { 82, 5, 9, 5, 0, -9 },
  { 88, 5, 9, 5, 0, -9 },
  { 94, 5, 9, 5, 0, -9 },
  { 100, 5, 9, 5, 0, -9 },
  { 106, 5, 9, 5, 0, -9 },
  { 112, 5, 9, 5, 0, -9 },
  { 118, 2, 7, 2, 0, -7 },
  { 120, 3, 9, 2, -1, -7 },
  { 124, 5, 5, 5, 0, -7 },
  { 128, 5, 3, 5, 0, -6 },
  { 130, 5, 5, 5, 0, -7 },
  { 134, 4, 9, 3, 0, -9 },
  { 139, 7, 10, 7, 0, -9 },
  { 148, 5, 9, 4, -1, -9 },
  { 154, 5, 9, 5, 0, -9 },
  { 160, 6, 9, 5, 0, -9 },
  { 167, 5, 9, 5, 0, -9 },
  { 173, 5, 9, 4, 0, -9 },
  { 179, 5, 9, 4, 0, -9 },
  { 185, 6, 9, 6, 0, -9 },
  { 192, 6, 9, 6, 0, -9 },
  { 199, 4, 9, 2, -1, -9 },
  { 204, 4, 11, 2, -2, -9 },
  { 210, 6, 9, 5, 0, -9 },
  { 217, 3, 9, 4, 0, -9 },
  { 221, 8, 9, 8, 0, -9 },
  { 230, 6, 9, 6, 0, -9 },
  { 237, 6, 9, 6, 0, -9 },
  { 244, 5, 9, 5, 0, -9 },
  { 250, 6, 11, 6, 0, -9 },
  { 259, 5, 9, 5, 0, -9 },
  { 265, 5, 9, 5, 0, -9 },
  { 271, 4, 9, 4, 1, -9 },
  { 276, 6, 9, 6, 0, -9 },
  { 283, 5, 9, 5, 1, -9 },
  { 289, 8, 9, 8, 1, -9 },
  { 298, 6, 9, 4, -1, -9 },
  { 305, 4, 9, 4, 1, -9 },
  { 310, 6, 9, 4, -1, -9 },
  { 317, 4, 11, 4, 0, -9 },
  { 323, 2, 9, 4, 1, -9 },
  { 326, 5, 11, 4, -1, -9 },
  { 333, 5, 4, 5, 0, -9 },
  { 336, 3, 1, 4, -1, 1 },
  { 337, 1, 2, 3, 2, -10 },
  { 338, 5, 7, 5, 0, -7 },
  { 343, 5, 10, 5, 0, -10 },
  { 350, 4, 7, 4, 0, -7 },
  { 354, 6, 10, 5, 0, -10 },
  { 362, 4, 7, 4, 0, -7 },
  { 366, 6, 13, 3, -2, -10 },
  { 376, 5, 10, 5, 0, -7 },
  { 383, 4, 10, 5, 0, -10 },
  { 388, 3, 9, 2, 0, -9 },
  { 392, 5, 12, 2, -2, -9 },
  { 400, 5, 10, 4, 0, -10 },
  { 407, 3, 10, 2, 0, -10 },
  { 411, 7, 7, 7, 0, -7 },
  { 418, 4, 7, 5, 0, -7 },
  { 422, 4, 7, 5, 0, -7 },
  { 426, 6, 10, 5, -1, -7 },
  { 434, 5, 10, 5, 0, -7 },
  { 441, 4, 7, 3, 0, -7 },
  { 445, 4, 7, 4, 0, -7 },
  { 449, 3, 9, 3, 0, -9 },
  { 453, 5, 7, 5, 0, -7 },
  { 458, 3, 7, 4, 1, -7 },
  { 461, 6, 7, 6, 1, -7 },
  { 467, 5, 7, 4, -1, -7 },
  { 472, 6, 10, 4, -1, -7 },
  { 480, 4, 7, 3, 0, -7 },
  { 484, 5, 11, 4, 0, -9 },
  { 491, 1, 13, 5, 2, -10 },
  { 493, 5, 11, 4, -1, -9 },
  { 500, 5, 1, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC13PT7B_H_
