#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC31PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81,
  0x06, 0x08, 0x10, 0x20, 0x00, 0x00, 0x04, 0x18, 0x00, 0x66, 0x89, 0x12,
  0x24, 0x91, 0x22, 0x44, 0x01, 0x10, 0x21, 0x02, 0x20, 0x22, 0x06, 0x20,
  0x44, 0x3F, 0xF0, 0x44, 0x08, 0x80, 0x88, 0x08, 0x81, 0x18, 0x11, 0x01,
  0x10, 0xFF, 0xC2, 0x20, 0x22, 0x06, 0x20, 0x44, 0x04, 0x40, 0x44, 0x08,
  0x80, 0x00, 0x80, 0x08, 0x01, 0x00, 0x7F, 0x09, 0x21, 0x10, 0x11, 0x01,
  0x20, 0x12, 0x01, 0x20, 0x12, 0x00, 0xA0, 0x04, 0x00, 0x60, 0x05, 0x00,
  0x58, 0x08, 0x80, 0x88, 0x08, 0x80, 0x88, 0x09, 0x0D, 0x60, 0x7C, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x1E, 0x0C, 0x48, 0x22, 0x21, 0x08, 0x84, 0x42,
  0x21, 0x08, 0x84, 0x24, 0x10, 0x90, 0x44, 0x8B, 0x12, 0xF8, 0x52, 0x52,
  0x51, 0x72, 0x44, 0x0B, 0x10, 0x48, 0x41, 0x21, 0x08, 0x84, 0x22, 0x31,
  0x08, 0x84, 0x22, 0x20, 0x91, 0x83, 0xC0, 0x07, 0x83, 0x20, 0x88, 0x22,
  0x08, 0x82, 0x20, 0x90, 0x24, 0x0A, 0x03, 0x00, 0xC0, 0x50, 0x24, 0x51,
  0x14, 0x2E, 0x0A, 0x82, 0xA0, 0xC8, 0x32, 0x0C, 0x85, 0x1E, 0x60, 0x69,
  0x25, 0x24, 0x01, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40,
  0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x40, 0x40, 0x60, 0x02, 0x02, 0x03, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02, 0x04,
  0x04, 0x0C, 0x08, 0x10, 0x30, 0x20, 0x40, 0x80, 0x10, 0x08, 0x10, 0xD0,
  0x3F, 0x30, 0x48, 0x88, 0x04, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x07, 0xFF, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x00, 0x32, 0x26, 0x48, 0x80, 0xFC, 0x70, 0x00, 0x10, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x80, 0x08, 0x00, 0x07, 0x82, 0x21, 0x04, 0x41, 0x20, 0x48, 0x16,
  0x05, 0x03, 0x40, 0xD0, 0x2C, 0x0A, 0x02, 0x80, 0xA0, 0x68, 0x12, 0x04,
  0x83, 0x20, 0x88, 0x22, 0x10, 0x8C, 0x1E, 0x00, 0x0C, 0x72, 0xF2, 0x08,
  0x20, 0x86, 0x10, 0x41, 0x04, 0x30, 0x82, 0x08, 0x21, 0x04, 0x10, 0x43,
  0x00, 0x0F, 0xE0, 0x42, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00,
  0xC0, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x0F, 0xF8, 0x07, 0xE0,
  0x83, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40,
  0x08, 0x0F, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x18, 0x83, 0x0F, 0xE0, 0x00, 0x30, 0x05, 0x00, 0x60,
  0x0A, 0x00, 0xA0, 0x12, 0x02, 0x60, 0x24, 0x04, 0x40, 0xC4, 0x08, 0x41,
  0x0C, 0x10, 0x82, 0x08, 0x60, 0x84, 0x08, 0xFF, 0xE0, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x20, 0x07, 0xF0, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0xF0, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x18, 0x83, 0x0F,
  0xE0, 0x03, 0xE1, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x44, 0x0B, 0xE3, 0x84, 0x60, 0xCC, 0x09, 0x01, 0x20, 0x24, 0x0C, 0x81,
  0x10, 0x22, 0x0C, 0x41, 0x0C, 0x60, 0xF8, 0x00, 0x3F, 0xE0, 0x04, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x30, 0x04,
  0x01, 0x80, 0x00, 0x07, 0xC1, 0x0C, 0x40, 0x88, 0x11, 0x02, 0x20, 0x44,
  0x18, 0x82, 0x08, 0x81, 0xE0, 0x38, 0x0D, 0x02, 0x10, 0x83, 0x30, 0x24,
  0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0xCC, 0x30, 0xFC, 0x00, 0x07, 0xC1,
  0x08, 0x41, 0x88, 0x13, 0x02, 0x40, 0x48, 0x09, 0x03, 0x20, 0x64, 0x08,
  0x83, 0x10, 0xE1, 0xF4, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x0C,
  0x03, 0x00, 0xC1, 0xF0, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x18, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC2, 0x08, 0x41, 0x08, 0x20, 0x00, 0x60, 0x30, 0x18, 0x0C, 0x07,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x02,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x03,
  0x01, 0x80, 0x60, 0x08, 0x00, 0x1F, 0x00, 0xC0, 0x20, 0x10, 0x08, 0x0C,
  0x04, 0x06, 0x02, 0x02, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40,
  0x00, 0x00, 0x00, 0x04, 0x06, 0x00, 0x01, 0xF8, 0x0C, 0x18, 0x30, 0x10,
  0x40, 0x21, 0x00, 0x26, 0x00, 0x48, 0x78, 0x91, 0x91, 0x42, 0x22, 0x88,
  0x8D, 0x11, 0x14, 0x42, 0x28, 0x84, 0x51, 0x10, 0xA2, 0x22, 0x44, 0x44,
  0x89, 0x91, 0x1D, 0xE2, 0x10, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x80, 0x1E, 0x00, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x16,
  0x02, 0xC0, 0x98, 0x13, 0x06, 0x60, 0x8C, 0x11, 0x84, 0x30, 0xFE, 0x3F,
  0xC4, 0x18, 0x83, 0x20, 0x64, 0x0D, 0x81, 0xA0, 0x34, 0x07, 0x00, 0xC0,
  0x07, 0xC0, 0xC2, 0x08, 0x10, 0x81, 0x08, 0x10, 0x81, 0x18, 0x31, 0x02,
  0x10, 0x61, 0x0C, 0x1F, 0x02, 0x08, 0x20, 0x42, 0x04, 0x20, 0x46, 0x04,
  0x40, 0x44, 0x04, 0x40, 0x84, 0x18, 0xC3, 0x0F, 0xE0, 0x03, 0xF0, 0x60,
  0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x03, 0xE0, 0x07, 0xC0, 0x63, 0x02, 0x0C, 0x10,
  0x20, 0x81, 0x04, 0x0C, 0x60, 0x62, 0x02, 0x10, 0x10, 0x80, 0x8C, 0x04,
  0x40, 0x22, 0x03, 0x10, 0x10, 0x80, 0x8C, 0x0C, 0x40, 0x42, 0x06, 0x10,
  0x20, 0x82, 0x0C, 0x60, 0x7E, 0x00, 0x07, 0xF0, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x3F, 0x82, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0xF8, 0x20, 0x02, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00,
  0x03, 0xF8, 0x18, 0x10, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x3C, 0x80, 0x32, 0x00,
  0x88, 0x02, 0x20, 0x08, 0x80, 0x22, 0x01, 0x8C, 0x04, 0x10, 0x10, 0x60,
  0x40, 0x7F, 0x00, 0x04, 0x04, 0x30, 0x10, 0x80, 0x42, 0x03, 0x08, 0x08,
  0x20, 0x21, 0x00, 0x84, 0x02, 0x10, 0x18, 0x40, 0x43, 0xFF, 0x08, 0x04,
  0x20, 0x10, 0x80, 0x82, 0x02, 0x18, 0x08, 0x40, 0x21, 0x01, 0x84, 0x04,
  0x10, 0x10, 0xC0, 0x42, 0x01, 0x00, 0x07, 0xC0, 0x40, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x3E, 0x00, 0x00, 0x40,
  0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C,
  0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x0F, 0x00, 0x04, 0x08, 0x60, 0x82,
  0x08, 0x10, 0xC0, 0x84, 0x04, 0x40, 0x46, 0x02, 0x60, 0x12, 0x00, 0xA0,
  0x0F, 0x00, 0x5C, 0x03, 0x20, 0x11, 0x00, 0x88, 0x0C, 0x60, 0x41, 0x02,
  0x08, 0x10, 0x40, 0x82, 0x0C, 0x18, 0x40, 0x40, 0x04, 0x18, 0x20, 0x40,
  0x81, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81,
  0x02, 0x0C, 0x1F, 0xC0, 0x04, 0x00, 0x61, 0x80, 0x1C, 0x38, 0x03, 0x87,
  0x00, 0x60, 0xA0, 0x14, 0x14, 0x02, 0x84, 0x80, 0xB0, 0x90, 0x14, 0x12,
  0x04, 0x82, 0x40, 0x90, 0xC8, 0x22, 0x11, 0x04, 0xC2, 0x21, 0x10, 0x44,
  0x22, 0x08, 0x8C, 0x43, 0x11, 0x08, 0x42, 0x63, 0x08, 0x48, 0x41, 0x0B,
  0x08, 0x21, 0x41, 0x0C, 0x38, 0x21, 0x06, 0x08, 0x00, 0x04, 0x02, 0x18,
  0x04, 0x28, 0x18, 0x50, 0x20, 0xA0, 0x41, 0x40, 0x86, 0x81, 0x09, 0x84,
  0x11, 0x08, 0x22, 0x10, 0xC4, 0x21, 0x08, 0xC2, 0x11, 0x04, 0x32, 0x08,
  0x24, 0x30, 0x48, 0x40, 0xB0, 0x81, 0x41, 0x03, 0x82, 0x03, 0x0C, 0x06,
  0x10, 0x0C, 0x00, 0x03, 0xE0, 0x21, 0x82, 0x04, 0x20, 0x21, 0x01, 0x10,
  0x0C, 0x80, 0x4C, 0x02, 0x40, 0x12, 0x00, 0x90, 0x05, 0x80, 0x2C, 0x03,
  0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x44, 0x02, 0x20, 0x21, 0x83, 0x04,
  0x30, 0x1F, 0x00, 0x07, 0xC0, 0xC6, 0x08, 0x20, 0x83, 0x08, 0x30, 0x83,
  0x18, 0x31, 0x02, 0x10, 0x21, 0x04, 0x30, 0xC2, 0x38, 0x3C, 0x02, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00,
  0x03, 0xE0, 0x21, 0x82, 0x04, 0x20, 0x21, 0x01, 0x10, 0x0C, 0x80, 0x4C,
  0x02, 0x40, 0x12, 0x00, 0x90, 0x05, 0x80, 0x2C, 0x03, 0x40, 0x12, 0x00,
  0x90, 0x04, 0x80, 0x44, 0x02, 0x20, 0x21, 0x83, 0x04, 0x30, 0x1F, 0x00,
  0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x07, 0xC0, 0xC6, 0x08,
  0x20, 0x83, 0x08, 0x30, 0x83, 0x18, 0x21, 0x02, 0x10, 0x21, 0x04, 0x30,
  0xC3, 0xF0, 0x22, 0x02, 0x20, 0x22, 0x06, 0x30, 0x43, 0x04, 0x10, 0x41,
  0x04, 0x10, 0xC1, 0x08, 0x18, 0x03, 0xF8, 0x20, 0x82, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x08, 0x10, 0x7F, 0x00, 0x7F, 0xC3, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x00, 0x18, 0x08, 0x80,
  0x44, 0x06, 0x20, 0x21, 0x01, 0x18, 0x08, 0x80, 0xC4, 0x04, 0x20, 0x21,
  0x01, 0x18, 0x08, 0x80, 0xC4, 0x04, 0x20, 0x23, 0x01, 0x10, 0x18, 0x80,
  0x84, 0x04, 0x20, 0x21, 0x02, 0x0C, 0x30, 0x3F, 0x00, 0x80, 0x70, 0x0A,
  0x02, 0x40, 0x48, 0x19, 0x02, 0x20, 0xC4, 0x10, 0x82, 0x10, 0x82, 0x10,
  0x46, 0x08, 0x81, 0x30, 0x24, 0x04, 0x80, 0xA0, 0x14, 0x03, 0x80, 0x60,
  0x0C, 0x01, 0x00, 0x00, 0x40, 0x60, 0x28, 0x08, 0x0D, 0x03, 0x01, 0x20,
  0x60, 0x64, 0x0C, 0x08, 0x82, 0x81, 0x10, 0x50, 0x62, 0x12, 0x08, 0xC2,
  0x43, 0x18, 0x48, 0x43, 0x11, 0x08, 0x62, 0x23, 0x0C, 0xC4, 0x41, 0x90,
  0x98, 0x22, 0x12, 0x04, 0x82, 0x40, 0x90, 0x58, 0x16, 0x0A, 0x02, 0x81,
  0x40, 0x50, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x00, 0x02, 0x0C, 0x08,
  0x20, 0x21, 0x80, 0x84, 0x02, 0x20, 0x08, 0x80, 0x24, 0x00, 0x50, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x14, 0x00, 0xD8, 0x02,
  0x20, 0x18, 0x80, 0x42, 0x02, 0x08, 0x08, 0x20, 0x40, 0x83, 0x02, 0x00,
  0x40, 0xD0, 0x24, 0x19, 0x04, 0x43, 0x10, 0x84, 0x61, 0x10, 0x4C, 0x1A,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x00, 0x0F, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x03, 0xF0, 0x00, 0x88, 0x44, 0x44, 0x44, 0x42, 0x22,
  0x22, 0x22, 0x11, 0x11, 0x11, 0x03, 0xE0, 0x04, 0x01, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x83, 0xE0, 0x00, 0x06, 0x00, 0xC0, 0x28, 0x04,
  0x81, 0x10, 0x61, 0x08, 0x23, 0x06, 0x40, 0x58, 0x0A, 0x00, 0x80, 0xFF,
  0x93, 0x26, 0x06, 0x01, 0xB4, 0x43, 0x10, 0x62, 0x04, 0x81, 0x90, 0x32,
  0x04, 0xC0, 0x90, 0x12, 0x06, 0x40, 0x88, 0x11, 0x06, 0x20, 0xC6, 0x28,
  0x7A, 0x00, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x4C, 0x1E, 0xC2, 0x8C, 0x60, 0x88, 0x11, 0x02, 0x60, 0x48, 0x09, 0x03,
  0x20, 0x44, 0x09, 0x81, 0x20, 0x64, 0x08, 0xC3, 0x28, 0xC4, 0xF0, 0x07,
  0x86, 0x84, 0x04, 0x02, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x80, 0x7C, 0x00, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x62, 0x0D, 0xE1, 0x0C, 0x20, 0xC2,
  0x0C, 0x40, 0xC4, 0x0C, 0x40, 0x8C, 0x08, 0x80, 0x88, 0x18, 0x81, 0x08,
  0x10, 0x83, 0x08, 0x30, 0xC5, 0x07, 0xA0, 0x06, 0x06, 0xC4, 0x24, 0x16,
  0x0A, 0x09, 0x05, 0x8C, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x84, 0x7C, 0x00, 0x00, 0x18, 0x00, 0x90, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x03, 0xE0, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x1B, 0x41, 0x0C, 0x10, 0x60, 0x83, 0x08, 0x18, 0x40, 0xC2, 0x04, 0x30,
  0x21, 0x01, 0x08, 0x18, 0x40, 0x82, 0x04, 0x10, 0x60, 0x83, 0x06, 0x28,
  0x1E, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x82, 0x08, 0x1F,
  0x80, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x4C,
  0x1E, 0xC3, 0x08, 0x61, 0x88, 0x21, 0x04, 0x60, 0x88, 0x11, 0x06, 0x20,
  0x84, 0x11, 0x02, 0x20, 0x44, 0x18, 0x82, 0x30, 0x44, 0x08, 0x0C, 0x30,
  0x00, 0x00, 0x01, 0x84, 0x10, 0x41, 0x0C, 0x20, 0x82, 0x08, 0x41, 0x04,
  0x10, 0xC2, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x40, 0xE0, 0x00, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x41, 0x18, 0x42, 0x10, 0x46, 0x08, 0x81, 0x20, 0x48, 0x0B,
  0x01, 0x60, 0x34, 0x0C, 0xC1, 0x08, 0x21, 0x04, 0x20, 0x84, 0x30, 0x84,
  0x18, 0x04, 0x10, 0x43, 0x08, 0x20, 0x82, 0x18, 0x41, 0x04, 0x10, 0x82,
  0x08, 0x21, 0x84, 0x10, 0x41, 0x0C, 0x20, 0x09, 0x86, 0x16, 0xDB, 0x18,
  0x61, 0x18, 0x61, 0x10, 0x41, 0x10, 0x41, 0x30, 0x41, 0x20, 0xC3, 0x20,
  0x82, 0x20, 0x82, 0x20, 0x82, 0x40, 0x82, 0x41, 0x06, 0x41, 0x04, 0x41,
  0x04, 0xC1, 0x04, 0x83, 0x0C, 0x09, 0x85, 0xB1, 0x84, 0x61, 0x10, 0x44,
  0x13, 0x04, 0x81, 0x20, 0xC8, 0x22, 0x09, 0x02, 0x40, 0x90, 0x44, 0x13,
  0x04, 0x81, 0x00, 0x06, 0x06, 0x61, 0x08, 0x82, 0x60, 0xD0, 0x34, 0x0D,
  0x02, 0x80, 0xA0, 0x28, 0x0A, 0x06, 0x81, 0x20, 0x48, 0x23, 0x18, 0x7C,
  0x00, 0x04, 0xC0, 0xB6, 0x0A, 0x30, 0xC1, 0x08, 0x10, 0x81, 0x18, 0x11,
  0x01, 0x10, 0x11, 0x03, 0x10, 0x23, 0x02, 0x20, 0x62, 0x04, 0x30, 0xC7,
  0x18, 0x4F, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x06, 0x01, 0xB4, 0x43, 0x10, 0x62, 0x04, 0x81, 0x90, 0x32, 0x04,
  0xC0, 0x90, 0x12, 0x02, 0x40, 0x88, 0x11, 0x06, 0x20, 0xC6, 0x38, 0x7A,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x09, 0x8B,
  0x46, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x01, 0x80, 0x80, 0x00, 0x06, 0x0C, 0xC8, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x19, 0x08,
  0xF8, 0x00, 0x10, 0x41, 0x0D, 0x78, 0x82, 0x08, 0x61, 0x04, 0x10, 0x42,
  0x08, 0x20, 0x82, 0x08, 0x38, 0x30, 0x48, 0x12, 0x0C, 0x82, 0x20, 0x90,
  0x24, 0x09, 0x04, 0x41, 0x30, 0x48, 0x12, 0x0C, 0x82, 0x21, 0x88, 0x63,
  0xE8, 0x81, 0x83, 0x82, 0x86, 0x84, 0x84, 0x88, 0x88, 0x90, 0x90, 0xB0,
  0xA0, 0xA0, 0xC0, 0xC0, 0x80, 0x83, 0x06, 0x0C, 0x28, 0x50, 0xA1, 0x42,
  0x85, 0x12, 0x24, 0x48, 0x92, 0x24, 0x48, 0x91, 0x22, 0x45, 0x0A, 0x14,
  0x28, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x20, 0x40, 0x18, 0x61, 0x08,
  0x22, 0x04, 0x40, 0x90, 0x0E, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x40, 0x48,
  0x19, 0x02, 0x20, 0x84, 0x10, 0xC4, 0x08, 0x06, 0x0C, 0x18, 0x20, 0x60,
  0x81, 0x84, 0x06, 0x10, 0x08, 0x80, 0x22, 0x00, 0x90, 0x02, 0x40, 0x0B,
  0x00, 0x28, 0x00, 0xA0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x0E, 0x00, 0x30,
  0x00, 0x0F, 0x80, 0x40, 0x40, 0x60, 0x20, 0x30, 0x10, 0x10, 0x08, 0x08,
  0x04, 0x04, 0x02, 0x02, 0x03, 0x01, 0xF8, 0x01, 0xE0, 0x60, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x03,
  0x01, 0x80, 0x08, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x00, 0x10, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x18, 0x01, 0xC0, 0x40, 0x10, 0x02,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x06,
  0x03, 0x80, 0x00, 0x7C, 0x30, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 22, 6, 0, -22 },
  { 21, 7, 8, 8, 3, -22 },
  { 28, 12, 22, 12, 0, -22 },
  { 61, 12, 26, 11, 0, -24 },
  { 100, 14, 22, 17, 1, -22 },
  { 139, 10, 22, 11, 0, -22 },
  { 167, 3, 8, 5, 3, -22 },
  { 170, 8, 27, 8, 1, -22 },
  { 197, 8, 27, 8, -2, -22 },
  { 224, 8, 9, 10, 4, -24 },
  { 233, 11, 14, 13, 1, -18 },
  { 253, 4, 7, 5, -1, -3 },
  { 257, 6, 1, 8, 1, -9 },
  { 258, 2, 2, 5, 0, -2 },
  { 259, 12, 22, 9, -1, -22 },
  { 292, 10, 22, 11, 1, -22 },
  { 320, 6, 22, 11, 3, -22 },
  { 337, 12, 22, 11, -1, -22 },
  { 370, 12, 22, 11, -1, -22 },
  { 403, 12, 22, 11, -1, -22 },
  { 436, 12, 22, 11, -1, -22 },
  { 469, 11, 22, 11, 1, -22 },
  { 500, 11, 22, 11, 1, -22 },
  { 531, 11, 22, 11, 0, -22 },
  { 562, 11, 22, 11, 0, -22 },
  { 593, 5, 16, 5, 0, -16 },
  { 603, 6, 20, 5, -1, -16 },
  { 618, 11, 13, 13, 1, -17 },
  { 636, 11, 8, 13, 1, -15 },
  { 647, 11, 13, 13, 1, -17 },
  { 665, 9, 22, 8, 0, -22 },
  { 690, 15, 25, 16, 1, -22 },
  { 737, 11, 22, 11, -2, -22 },
  { 768, 12, 22, 12, 0, -22 },
  { 801, 12, 22, 11, 1, -22 },
  { 834, 13, 22, 13, 0, -22 },
  { 870, 12, 22, 11, 0, -22 },
  { 903, 12, 22, 10, 0, -22 },
  { 936, 14, 22, 14, 1, -22 },
  { 975, 14, 22, 14, 0, -22 },
  { 1014, 10, 22, 6, -2, -22 },
  { 1042, 10, 27, 5, -4, -22 },
  { 1076, 13, 22, 11, 0, -22 },
  { 1112, 7, 22, 10, 0, -22 },
  { 1132, 19, 22, 19, 0, -22 },
  { 1185, 15, 22, 15, 0, -22 },
  { 1227, 13, 22, 14, 1, -22 },
  { 1263, 12, 22, 11, 0, -22 },
  { 1296, 13, 27, 14, 1, -22 },
  { 1340, 12, 22, 11, 0, -22 },
  { 1373, 13, 22, 11, -1, -22 },
  { 1409, 10, 22, 9, 2, -22 },
  { 1437, 13, 22, 13, 1, -22 },
  { 1473, 11, 22, 11, 3, -22 },
  { 1504, 19, 22, 19, 2, -22 },
  { 1557, 14, 22, 10, -2, -22 },
  { 1596, 10, 22, 9, 2, -22 },
  { 1624, 13, 22, 10, -1, -22 },
  { 1660, 11, 27, 9, -1, -22 },
  { 1698, 4, 22, 10, 3, -22 },
  { 1709, 11, 27, 9, -2, -22 },
  { 1747, 11, 11, 12, 1, -22 },
  { 1763, 8, 1, 8, -2, 3 },
  { 1764, 3, 5, 7, 5, -24 },
  { 1766, 11, 17, 12, 1, -17 },
  { 1790, 11, 24, 12, 0, -24 },
  { 1823, 9, 17, 9, 1, -17 },
  { 1843, 12, 24, 12, 1, -24 },
  { 1879, 9, 17, 10, 1, -17 },
  { 1899, 14, 31, 6, -4, -24 },
  { 1954, 13, 24, 12, -1, -17 },
  { 1993, 11, 24, 11, 0, -24 },
  { 2026, 6, 22, 5, 0, -22 },
  { 2043, 10, 29, 5, -4, -22 },
  { 2080, 11, 24, 10, 0, -24 },
  { 2113, 6, 24, 5, 0, -24 },
  { 2131, 16, 17, 17, 0, -17 },
  { 2165, 10, 17, 11, 0, -17 },
  { 2187, 10, 17, 11, 1, -17 },
  { 2209, 12, 24, 12, -1, -17 },
  { 2245, 11, 24, 12, 1, -17 },
  { 2278, 9, 17, 8, 0, -17 },
  { 2298, 9, 17, 9, 0, -17 },
  { 2318, 6, 20, 6, 1, -20 },
  { 2333, 10, 16, 11, 1, -16 },
  { 2353, 8, 16, 9, 2, -16 },
  { 2369, 14, 16, 15, 2, -16 },
  { 2397, 11, 16, 9, -1, -16 },
  { 2419, 14, 24, 9, -3, -16 },
  { 2461, 9, 16, 7, -1, -16 },
  { 2479, 11, 27, 10, 1, -22 },
  { 2517, 1, 32, 11, 5, -24 },
  { 2521, 11, 27, 10, -2, -22 },
  { 2559, 11, 2, 13, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC31PT7B_H_
