#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC27PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x20, 0x82, 0x08, 0x61, 0x04, 0x10, 0x42, 0x08, 0x20, 0x80,
  0x00, 0x01, 0x0C, 0x00, 0x4A, 0x63, 0x29, 0x4A, 0x40, 0x02, 0x60, 0x88,
  0x11, 0x02, 0x40, 0x88, 0x7F, 0xC2, 0x20, 0x48, 0x11, 0x02, 0x20, 0x48,
  0x11, 0x0F, 0xF8, 0x48, 0x11, 0x02, 0x20, 0x48, 0x11, 0x02, 0x20, 0x00,
  0x01, 0x00, 0x40, 0x20, 0x3F, 0x12, 0x08, 0x82, 0x20, 0x90, 0x24, 0x05,
  0x00, 0xC0, 0x10, 0x0A, 0x02, 0x80, 0x90, 0x24, 0x11, 0x04, 0x89, 0x61,
  0xE0, 0x10, 0x08, 0x02, 0x00, 0x08, 0x11, 0x42, 0x24, 0x24, 0x44, 0x44,
  0x44, 0x48, 0x44, 0x88, 0x50, 0x89, 0x38, 0xA5, 0x8A, 0x95, 0x49, 0x25,
  0x10, 0x91, 0x09, 0x11, 0x11, 0x12, 0x12, 0x22, 0x21, 0x24, 0x1C, 0x02,
  0x07, 0x82, 0x42, 0x21, 0x10, 0x88, 0x48, 0x24, 0x14, 0x04, 0x06, 0x05,
  0x04, 0x4E, 0x2A, 0x15, 0x0A, 0x82, 0x43, 0x22, 0x8F, 0x60, 0x5A, 0xA8,
  0x02, 0x08, 0x20, 0x81, 0x04, 0x08, 0x20, 0x41, 0x82, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x08, 0x10, 0x00, 0x04, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0xC0, 0x19, 0x21, 0xC8, 0xE2,
  0x99, 0x01, 0x00, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x24, 0xA5, 0x00, 0xF8, 0x70, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x00, 0x06, 0x0B, 0x11, 0x21, 0x21, 0x61, 0x41, 0x41, 0x41, 0x81,
  0x81, 0x81, 0x82, 0x82, 0x82, 0x84, 0x84, 0x8C, 0x88, 0xF0, 0x19, 0x55,
  0x21, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x84, 0x20, 0x03, 0x01,
  0x98, 0x01, 0x00, 0x20, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x04, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00,
  0x7F, 0x80, 0x01, 0x01, 0xD8, 0x21, 0x00, 0x10, 0x02, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0x80, 0xE0, 0x38, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x08, 0x7E, 0x00, 0x00, 0x60, 0x08, 0x03, 0x00, 0xA0,
  0x14, 0x04, 0x80, 0xA0, 0x24, 0x08, 0x81, 0x10, 0x42, 0x08, 0x82, 0x10,
  0x82, 0x10, 0x57, 0xFC, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x07, 0xE1,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x1F, 0x00, 0x30,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x43, 0xF0,
  0x00, 0x01, 0x07, 0x46, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x5C, 0x51,
  0x30, 0x90, 0x68, 0x14, 0x12, 0x09, 0x04, 0x82, 0x42, 0x21, 0x0F, 0x00,
  0x3F, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x00,
  0x02, 0x03, 0x61, 0x0C, 0x41, 0x30, 0x48, 0x13, 0x08, 0x42, 0x13, 0x03,
  0x81, 0xC0, 0x88, 0x42, 0x20, 0x48, 0x12, 0x04, 0x81, 0x20, 0xCC, 0x21,
  0xF0, 0x02, 0x06, 0xC4, 0x22, 0x12, 0x09, 0x04, 0x82, 0x81, 0x40, 0xB0,
  0xC8, 0x66, 0xD0, 0x90, 0x08, 0x04, 0x04, 0x02, 0x02, 0x02, 0x1E, 0x00,
  0x11, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC8, 0x08, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x42, 0x11, 0x08, 0x80, 0x00, 0x81, 0x83, 0x06, 0x0C, 0x06,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x20, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x04, 0x0C, 0x18,
  0x30, 0x30, 0x20, 0x00, 0x0C, 0x32, 0x01, 0x01, 0x01, 0x03, 0x02, 0x04,
  0x04, 0x08, 0x10, 0x20, 0x20, 0x20, 0x40, 0x00, 0x00, 0x00, 0x40, 0xC0,
  0x07, 0xE0, 0x40, 0x84, 0x04, 0x20, 0x12, 0x00, 0x91, 0xE5, 0x12, 0x28,
  0x91, 0x48, 0x8C, 0x44, 0xA4, 0x45, 0x22, 0x29, 0x12, 0x49, 0x92, 0x4D,
  0x11, 0xB8, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x07, 0xE0, 0x00, 0x00,
  0x80, 0xC0, 0x60, 0x30, 0x28, 0x14, 0x12, 0x09, 0x0C, 0x84, 0x42, 0x23,
  0xF1, 0x09, 0x84, 0x82, 0x41, 0x40, 0xA0, 0x60, 0x20, 0x0F, 0x81, 0x08,
  0x21, 0x08, 0x31, 0x04, 0x20, 0x84, 0x11, 0x84, 0x3F, 0x04, 0x60, 0x86,
  0x10, 0x44, 0x08, 0x81, 0x10, 0x22, 0x08, 0x41, 0x10, 0x43, 0xF0, 0x00,
  0x00, 0x81, 0x90, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x30, 0x04, 0x00,
  0xF0, 0x0F, 0x81, 0x08, 0x21, 0x88, 0x11, 0x02, 0x20, 0x44, 0x09, 0x81,
  0x20, 0x24, 0x08, 0x81, 0x10, 0x24, 0x04, 0x81, 0x10, 0x22, 0x08, 0x43,
  0x10, 0xC3, 0xE0, 0x00, 0x0F, 0xC2, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x3F, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x0F, 0xE0, 0x0F, 0xC2, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x20, 0x0F, 0xC2, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x00, 0x00, 0xC0, 0x77, 0x08, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x81, 0xC8, 0x24, 0x80, 0x48,
  0x04, 0x80, 0x88, 0x08, 0x80, 0x8C, 0x08, 0x40, 0x83, 0xF0, 0x08, 0x18,
  0x40, 0x82, 0x04, 0x20, 0x21, 0x03, 0x08, 0x10, 0x40, 0x84, 0x04, 0x3F,
  0xE1, 0x02, 0x08, 0x10, 0x40, 0x84, 0x04, 0x20, 0x21, 0x02, 0x08, 0x10,
  0x40, 0x84, 0x04, 0x20, 0x60, 0x0F, 0x81, 0x00, 0x80, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x10, 0x3E, 0x00, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x80, 0x41, 0xC0, 0x08, 0x30, 0x84, 0x08, 0xC1, 0x08,
  0x11, 0x01, 0x20, 0x12, 0x02, 0x40, 0x28, 0x03, 0x40, 0x24, 0x02, 0x40,
  0x44, 0x04, 0x20, 0x42, 0x04, 0x20, 0x42, 0x08, 0x30, 0x81, 0x00, 0x08,
  0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42,
  0x0F, 0xC0, 0x0C, 0x01, 0x86, 0x01, 0x83, 0x00, 0xC2, 0x80, 0xA1, 0x40,
  0x50, 0xA0, 0x50, 0x50, 0x28, 0x48, 0x24, 0x24, 0x12, 0x12, 0x11, 0x09,
  0x09, 0x04, 0x88, 0x84, 0x44, 0x42, 0x26, 0x21, 0x12, 0x20, 0x89, 0x10,
  0x45, 0x08, 0x42, 0x84, 0x20, 0x86, 0x00, 0x0C, 0x08, 0x60, 0x43, 0x02,
  0x28, 0x21, 0x41, 0x0A, 0x08, 0x48, 0x44, 0x46, 0x22, 0x21, 0x11, 0x08,
  0x88, 0x42, 0x44, 0x14, 0x20, 0xA1, 0x05, 0x08, 0x28, 0x41, 0x44, 0x04,
  0x20, 0x20, 0x01, 0x01, 0xD8, 0x61, 0x08, 0x12, 0x02, 0x40, 0x50, 0x0A,
  0x01, 0x40, 0x68, 0x0A, 0x01, 0x40, 0x28, 0x05, 0x01, 0xA0, 0x24, 0x04,
  0x81, 0x10, 0x21, 0x08, 0x3E, 0x00, 0x0F, 0x82, 0x30, 0x84, 0x41, 0x10,
  0x44, 0x11, 0x04, 0xC2, 0x20, 0x88, 0xC3, 0xC0, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x00, 0x01, 0x01, 0xD8, 0x61, 0x08, 0x12,
  0x02, 0x40, 0x50, 0x0A, 0x01, 0x40, 0x68, 0x0A, 0x01, 0x40, 0x28, 0x05,
  0x01, 0xA0, 0x24, 0x04, 0x81, 0x10, 0x21, 0x08, 0x3E, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x0F, 0x82, 0x30, 0x84, 0x41, 0x10, 0x44,
  0x11, 0x04, 0xC2, 0x21, 0x8F, 0xC2, 0x40, 0x90, 0x44, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x20, 0x88, 0x30, 0x01, 0x00, 0xCC, 0x20, 0x0C, 0x01, 0x00,
  0x20, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x22, 0x0C, 0x7F, 0x00, 0xFF, 0x18, 0x10,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0xC0, 0x80, 0x80, 0x80, 0x10, 0x22, 0x04, 0x80, 0x90, 0x22, 0x04, 0x40,
  0x88, 0x12, 0x02, 0x40, 0x88, 0x11, 0x02, 0x20, 0x48, 0x11, 0x02, 0x20,
  0x44, 0x08, 0x82, 0x10, 0x41, 0xF0, 0x00, 0x80, 0xE0, 0x28, 0x1A, 0x04,
  0x81, 0x20, 0x88, 0x22, 0x10, 0x84, 0x21, 0x08, 0x82, 0x20, 0x90, 0x24,
  0x0A, 0x02, 0x80, 0xA0, 0x30, 0x0C, 0x00, 0x80, 0x81, 0x81, 0x81, 0x81,
  0x82, 0x82, 0x82, 0x82, 0x86, 0x82, 0x84, 0x84, 0x84, 0x84, 0x88, 0x88,
  0x88, 0x88, 0x98, 0x88, 0x90, 0x90, 0x90, 0x90, 0xA0, 0xA1, 0x20, 0xA1,
  0x60, 0xA1, 0x40, 0xC1, 0x40, 0xC1, 0x80, 0xC1, 0x80, 0x04, 0x10, 0x43,
  0x04, 0x20, 0x24, 0x02, 0x40, 0x28, 0x02, 0x80, 0x30, 0x03, 0x00, 0x20,
  0x05, 0x00, 0x50, 0x09, 0x00, 0x90, 0x11, 0x02, 0x10, 0x21, 0x04, 0x10,
  0xC1, 0x00, 0x81, 0x83, 0x82, 0x46, 0x44, 0x48, 0x48, 0x50, 0x50, 0x60,
  0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x0F, 0xE0, 0x08,
  0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x18, 0x03, 0xF8, 0x00,
  0x07, 0xC1, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x0F, 0x80, 0x92, 0x48, 0x92, 0x49, 0x22, 0x49, 0x24,
  0x80, 0x07, 0xC0, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x02, 0x0F, 0x80, 0x0C, 0x06, 0x04, 0x82, 0x42, 0x21,
  0x09, 0x05, 0x81, 0x80, 0x80, 0xFE, 0x91, 0x22, 0x04, 0x0D, 0x48, 0x64,
  0x34, 0x12, 0x0A, 0x05, 0x02, 0x81, 0x41, 0x20, 0x90, 0x48, 0x64, 0x51,
  0xD0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x20, 0x56, 0x18,
  0x84, 0x13, 0x04, 0x81, 0x20, 0x88, 0x24, 0x09, 0x02, 0x41, 0x90, 0x44,
  0x12, 0x88, 0xBC, 0x00, 0x04, 0x34, 0x81, 0x04, 0x08, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x1E, 0x00, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x81, 0x20, 0xD4, 0x21, 0x84, 0x31, 0x04, 0x20, 0x88, 0x11,
  0x02, 0x20, 0x44, 0x10, 0x82, 0x10, 0x42, 0x18, 0x45, 0x07, 0x40, 0x04,
  0x1A, 0x21, 0x61, 0x42, 0x42, 0x84, 0xF8, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x78, 0x00, 0x60, 0x14, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80,
  0x3C, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20,
  0x04, 0x03, 0x80, 0x00, 0x01, 0x00, 0xD4, 0x21, 0x84, 0x31, 0x04, 0x20,
  0x88, 0x11, 0x02, 0x20, 0x44, 0x10, 0x82, 0x10, 0x42, 0x18, 0x45, 0x07,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x0F, 0xC0, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x80, 0x48, 0x2B, 0x18, 0x88, 0x4C, 0x24, 0x12, 0x09,
  0x08, 0x84, 0x82, 0x41, 0x21, 0x90, 0x90, 0x48, 0x20, 0x08, 0x40, 0x00,
  0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x08, 0x44, 0x20, 0x00, 0x80, 0x40,
  0x00, 0x00, 0x00, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20,
  0xF0, 0x00, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x21, 0x11,
  0x09, 0x09, 0x84, 0x82, 0x81, 0xC1, 0x90, 0x88, 0x44, 0x22, 0x11, 0x10,
  0x88, 0x20, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x88, 0x42, 0x11, 0x08,
  0x42, 0x11, 0x08, 0x00, 0x02, 0x10, 0x76, 0xB1, 0x0C, 0x44, 0x21, 0x20,
  0x84, 0x82, 0x12, 0x10, 0x48, 0x42, 0x61, 0x09, 0x04, 0x24, 0x20, 0x90,
  0x82, 0x42, 0x12, 0x08, 0x48, 0x21, 0x00, 0x02, 0x0A, 0xC6, 0x22, 0x13,
  0x09, 0x04, 0x82, 0x42, 0x61, 0x20, 0x90, 0x48, 0x44, 0x24, 0x12, 0x08,
  0x04, 0x1A, 0x21, 0x61, 0x41, 0x41, 0x81, 0x81, 0x81, 0x83, 0x82, 0x82,
  0x84, 0x84, 0x78, 0x01, 0x01, 0x58, 0x31, 0x04, 0x11, 0x82, 0x20, 0x44,
  0x18, 0x82, 0x10, 0x44, 0x08, 0x81, 0x10, 0x42, 0x08, 0xA2, 0x17, 0x82,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x00, 0x04, 0x0D, 0x48, 0x64,
  0x34, 0x12, 0x0A, 0x05, 0x02, 0x81, 0x41, 0x20, 0x90, 0x48, 0x64, 0x51,
  0xD0, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x02, 0x15, 0x18, 0x10,
  0x30, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x0C,
  0x13, 0x20, 0x20, 0x20, 0x20, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x04, 0x04,
  0x08, 0xF8, 0x08, 0x21, 0x04, 0x3C, 0x42, 0x08, 0x20, 0x82, 0x10, 0x41,
  0x04, 0x10, 0x81, 0x80, 0x20, 0x90, 0x88, 0x48, 0x24, 0x12, 0x11, 0x09,
  0x04, 0x82, 0x41, 0x21, 0x10, 0x88, 0xC7, 0xA0, 0x83, 0x0A, 0x14, 0x48,
  0x93, 0x24, 0x48, 0xA1, 0x43, 0x06, 0x08, 0x10, 0x00, 0x86, 0x18, 0x62,
  0x8A, 0x28, 0xA2, 0x8A, 0x49, 0x24, 0x92, 0x8A, 0x48, 0xA4, 0x8A, 0x50,
  0xC5, 0x0C, 0x50, 0x86, 0x08, 0x60, 0x10, 0xC4, 0x20, 0x90, 0x24, 0x0A,
  0x03, 0x00, 0xC0, 0x30, 0x14, 0x05, 0x02, 0x41, 0x08, 0x42, 0x20, 0x80,
  0x04, 0x18, 0x20, 0x81, 0x08, 0x08, 0x40, 0x44, 0x02, 0x20, 0x11, 0x00,
  0x90, 0x04, 0x80, 0x28, 0x01, 0x40, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x04, 0x01, 0x40, 0x0C, 0x00, 0x00, 0x1F,
  0x01, 0x02, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40,
  0xFC, 0x03, 0x82, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08,
  0x08, 0x18, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x40, 0x08, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x30, 0x07, 0x02, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x0E, 0x00,
  0x70, 0xC6, 0x60, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 19, 6, 0, -19 },
  { 16, 5, 7, 7, 3, -19 },
  { 21, 11, 19, 10, 0, -19 },
  { 48, 10, 23, 9, 0, -21 },
  { 77, 12, 20, 15, 1, -20 },
  { 107, 9, 20, 9, 0, -20 },
  { 130, 2, 7, 4, 3, -19 },
  { 132, 7, 23, 7, 1, -19 },
  { 153, 8, 23, 7, -2, -19 },
  { 176, 7, 7, 9, 3, -20 },
  { 183, 9, 13, 11, 1, -16 },
  { 198, 3, 6, 4, -1, -3 },
  { 201, 5, 1, 7, 1, -8 },
  { 202, 2, 2, 4, 0, -2 },
  { 203, 11, 19, 8, -1, -19 },
  { 230, 8, 20, 10, 1, -20 },
  { 250, 5, 19, 10, 3, -19 },
  { 262, 11, 20, 10, -1, -20 },
  { 290, 11, 20, 10, -1, -20 },
  { 318, 11, 20, 10, -1, -20 },
  { 346, 11, 19, 10, -1, -19 },
  { 373, 9, 20, 10, 1, -20 },
  { 396, 10, 19, 10, 1, -19 },
  { 420, 10, 20, 10, 0, -20 },
  { 445, 9, 20, 10, 0, -20 },
  { 468, 4, 14, 4, 0, -14 },
  { 475, 5, 17, 4, -1, -14 },
  { 486, 9, 11, 11, 1, -15 },
  { 499, 9, 7, 11, 1, -13 },
  { 507, 9, 11, 11, 1, -15 },
  { 520, 8, 20, 7, 0, -20 },
  { 540, 13, 21, 14, 1, -19 },
  { 575, 9, 19, 9, -2, -19 },
  { 597, 11, 19, 10, 0, -19 },
  { 624, 10, 20, 9, 1, -20 },
  { 649, 11, 19, 11, 0, -19 },
  { 676, 10, 19, 9, 0, -19 },
  { 700, 10, 19, 9, 0, -19 },
  { 724, 12, 20, 12, 1, -20 },
  { 754, 13, 19, 12, 0, -19 },
  { 785, 9, 19, 5, -2, -19 },
  { 807, 9, 24, 4, -4, -19 },
  { 834, 12, 19, 10, 0, -19 },
  { 863, 6, 19, 8, 0, -19 },
  { 878, 17, 19, 16, 0, -19 },
  { 919, 13, 19, 13, 0, -19 },
  { 950, 11, 20, 12, 1, -20 },
  { 978, 10, 19, 10, 0, -19 },
  { 1002, 11, 25, 12, 1, -20 },
  { 1037, 10, 19, 10, 0, -19 },
  { 1061, 11, 20, 9, -1, -20 },
  { 1089, 8, 19, 8, 2, -19 },
  { 1108, 11, 19, 12, 1, -19 },
  { 1135, 10, 19, 10, 2, -19 },
  { 1159, 16, 19, 16, 2, -19 },
  { 1197, 12, 19, 9, -2, -19 },
  { 1226, 8, 19, 8, 2, -19 },
  { 1245, 11, 19, 8, -1, -19 },
  { 1272, 10, 23, 7, -1, -19 },
  { 1301, 3, 19, 9, 3, -19 },
  { 1309, 10, 23, 7, -2, -19 },
  { 1338, 9, 9, 11, 1, -19 },
  { 1349, 7, 1, 7, -2, 2 },
  { 1350, 3, 5, 6, 4, -21 },
  { 1352, 9, 15, 10, 1, -15 },
  { 1369, 10, 21, 10, 0, -21 },
  { 1396, 7, 15, 8, 1, -15 },
  { 1410, 11, 21, 10, 1, -21 },
  { 1439, 8, 15, 9, 1, -15 },
  { 1454, 11, 27, 5, -3, -21 },
  { 1492, 11, 21, 10, -1, -15 },
  { 1521, 9, 21, 10, 0, -21 },
  { 1545, 5, 19, 4, 0, -19 },
  { 1557, 9, 25, 5, -4, -19 },
  { 1586, 9, 21, 8, 0, -21 },
  { 1610, 5, 21, 4, 0, -21 },
  { 1624, 14, 15, 15, 0, -15 },
  { 1651, 9, 15, 10, 0, -15 },
  { 1668, 8, 15, 10, 1, -15 },
  { 1683, 11, 21, 10, -1, -15 },
  { 1712, 9, 21, 11, 1, -15 },
  { 1736, 8, 15, 7, 0, -15 },
  { 1751, 8, 15, 8, 0, -15 },
  { 1766, 6, 18, 5, 0, -18 },
  { 1780, 9, 14, 10, 1, -14 },
  { 1796, 7, 14, 8, 2, -14 },
  { 1809, 12, 14, 13, 2, -14 },
  { 1830, 10, 14, 8, -1, -14 },
  { 1848, 13, 21, 8, -3, -14 },
  { 1883, 8, 14, 7, -1, -14 },
  { 1897, 9, 23, 8, 1, -19 },
  { 1923, 1, 28, 9, 4, -21 },
  { 1927, 10, 23, 8, -2, -19 },
  { 1956, 9, 3, 11, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC27PT7B_H_
