#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC56PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0x18, 0x31, 0x83, 0x18,
  0x73, 0x86, 0x30, 0x63, 0x06, 0x30, 0x63, 0x04, 0x60, 0xC6, 0x0C, 0x60,
  0xC6, 0x08, 0x40, 0x8C, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00,
  0xC1, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x03,
  0x00, 0x0C, 0x0C, 0x00, 0x30, 0x60, 0x00, 0x81, 0x80, 0x06, 0x06, 0x00,
  0x18, 0x10, 0x0F, 0xFF, 0xFC, 0x03, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x30,
  0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC0, 0xC0,
  0x03, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x20, 0x60, 0x01, 0x81, 0x80, 0x06,
  0x0C, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x03, 0x02, 0x00, 0x0C, 0x18,
  0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x30, 0x00,
  0xC0, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83,
  0x00, 0x04, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xE0, 0x03,
  0xFF, 0xC0, 0x38, 0x87, 0x03, 0x84, 0x10, 0x18, 0x60, 0x01, 0x83, 0x00,
  0x0C, 0x18, 0x00, 0x60, 0x80, 0x03, 0x04, 0x00, 0x18, 0x60, 0x00, 0xC3,
  0x00, 0x06, 0x18, 0x00, 0x30, 0x80, 0x00, 0xC4, 0x00, 0x07, 0x60, 0x00,
  0x1B, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x60, 0x00, 0x13, 0x80, 0x00, 0x8C, 0x00, 0x0C, 0x30, 0x00,
  0x61, 0x80, 0x03, 0x0C, 0x00, 0x10, 0x60, 0x00, 0x83, 0x00, 0x0C, 0x18,
  0x00, 0x60, 0xC0, 0x03, 0x0E, 0x00, 0x10, 0x60, 0x40, 0x86, 0x03, 0x8C,
  0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03,
  0xF0, 0x03, 0x03, 0x98, 0x01, 0x01, 0x86, 0x01, 0x81, 0x83, 0x00, 0x80,
  0xC1, 0x80, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x60, 0x60, 0x30, 0x30,
  0x30, 0x18, 0x30, 0x18, 0x0C, 0x18, 0x0C, 0x06, 0x18, 0x0C, 0x06, 0x0C,
  0x06, 0x03, 0x0C, 0x03, 0x01, 0x86, 0x01, 0x80, 0xC6, 0x00, 0xC0, 0xC3,
  0x00, 0x60, 0x63, 0x0F, 0xB0, 0x31, 0x9C, 0xD0, 0x31, 0x8C, 0x3C, 0x18,
  0xCC, 0x1E, 0x18, 0xC6, 0x0F, 0x0C, 0x66, 0x07, 0xDC, 0x63, 0x03, 0x7C,
  0x33, 0x01, 0x88, 0x31, 0x80, 0xC0, 0x18, 0xC0, 0x60, 0x18, 0x60, 0x20,
  0x0C, 0x60, 0x30, 0x0C, 0x30, 0x18, 0x06, 0x18, 0x0C, 0x06, 0x0C, 0x06,
  0x03, 0x06, 0x06, 0x03, 0x03, 0x03, 0x01, 0x81, 0x01, 0x81, 0x80, 0x81,
  0x80, 0xC0, 0x40, 0xC0, 0xC0, 0x30, 0xC0, 0x60, 0x18, 0x60, 0x60, 0x0C,
  0x60, 0x70, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x03,
  0xF0, 0x00, 0xE6, 0x00, 0x30, 0xE0, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x30,
  0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60,
  0xC0, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xCC,
  0x00, 0x1B, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x01, 0xCC, 0x00, 0x31, 0x80, 0x0C, 0x30, 0x63, 0x07, 0x0C, 0xE0, 0x63,
  0x98, 0x0C, 0x63, 0x01, 0x8C, 0xC0, 0x1B, 0x18, 0x03, 0x63, 0x00, 0x6C,
  0x60, 0x0F, 0x1C, 0x00, 0xE3, 0x80, 0x18, 0x70, 0x07, 0x06, 0x01, 0xF0,
  0xC0, 0x36, 0x1C, 0x0C, 0xC1, 0xC7, 0x18, 0x1F, 0xC1, 0x80, 0x40, 0x00,
  0x18, 0xC6, 0x73, 0x18, 0xC6, 0x23, 0x18, 0xC4, 0x60, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x02, 0x0C, 0x0E, 0x18, 0x07, 0x30,
  0x43, 0xCF, 0x81, 0xF8, 0x03, 0x80, 0x0D, 0x00, 0x73, 0x01, 0x82, 0x06,
  0x06, 0x04, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x06, 0x1C, 0x30, 0x61,
  0x83, 0x0C, 0x18, 0x20, 0xC1, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x07, 0xE0, 0x01, 0xEE, 0x00, 0x70, 0xE0, 0x1C, 0x0C,
  0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x07, 0x06, 0x00, 0x60, 0xC0, 0x0C,
  0x30, 0x03, 0x86, 0x00, 0x70, 0xC0, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x30,
  0xC0, 0x06, 0x38, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xE7,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x03, 0x8C,
  0x00, 0x63, 0x80, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x71, 0x80, 0x0C, 0x30,
  0x01, 0x86, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x60, 0x60,
  0x0C, 0x0E, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x38, 0x01, 0xDE, 0x00, 0x1F,
  0x80, 0x00, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x1F, 0x07, 0x61, 0xCC, 0x73,
  0x3C, 0x62, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xDF, 0x00, 0x18, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFE, 0x00, 0x3C, 0x78,
  0x03, 0x80, 0xE0, 0x10, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x02, 0x00, 0xE0, 0x1E, 0x1E,
  0x00, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x34, 0x00, 0x01, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00,
  0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x02, 0x18,
  0x00, 0x31, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0x83, 0x00, 0x18,
  0x18, 0x00, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x03,
  0x01, 0x80, 0x38, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x40, 0x1C, 0x03, 0xC7, 0xC0, 0x1F, 0xF8,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0x00, 0x3E, 0x30,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x20, 0x03, 0x1F,
  0xC0, 0x33, 0x9E, 0x03, 0x60, 0x70, 0x3C, 0x03, 0x07, 0x80, 0x30, 0x70,
  0x03, 0x87, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x8E,
  0x00, 0x38, 0xE0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x07, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x06, 0x00, 0xC0, 0x60, 0x1C,
  0x06, 0x01, 0x80, 0x70, 0x38, 0x03, 0xDF, 0x00, 0x1F, 0xC0, 0x00, 0x70,
  0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x01, 0xFE, 0x00, 0x1E,
  0x78, 0x01, 0xC0, 0x60, 0x1C, 0x03, 0x80, 0xC0, 0x0C, 0x0E, 0x00, 0x60,
  0x60, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00,
  0x30, 0x30, 0x03, 0x01, 0x80, 0x18, 0x06, 0x01, 0x80, 0x30, 0x1C, 0x01,
  0xC1, 0xC0, 0x06, 0x1C, 0x00, 0x1B, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xEE, 0x00, 0x0E, 0x38, 0x01, 0xC0, 0xC0, 0x1C, 0x03, 0x00, 0xC0,
  0x18, 0x0C, 0x00, 0x60, 0xE0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xE1,
  0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x01, 0xC6, 0x00, 0x0C, 0x38, 0x00,
  0x60, 0xC0, 0x03, 0x06, 0x00, 0x30, 0x38, 0x03, 0x80, 0xE0, 0x38, 0x03,
  0xCF, 0x80, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F,
  0xF0, 0x03, 0xCF, 0x00, 0xE0, 0x60, 0x38, 0x0E, 0x06, 0x00, 0xC1, 0xC0,
  0x18, 0x30, 0x03, 0x06, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00,
  0x31, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00,
  0x63, 0x00, 0x1C, 0x60, 0x03, 0x8C, 0x00, 0xF1, 0xC0, 0x1C, 0x18, 0x07,
  0x83, 0x81, 0xB0, 0x3D, 0xE6, 0x03, 0xF9, 0x80, 0x08, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x06, 0x3E, 0x00, 0xFF, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x01, 0xC0, 0xE0, 0x60, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x1C, 0x0E, 0x07, 0x00, 0x00, 0x20,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0x80, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x0F, 0xF0, 0x3C, 0xF0,
  0x40, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80,
  0x1C, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60,
  0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x20, 0x60, 0x1F, 0x03, 0x0C, 0x03, 0xF8, 0x20, 0xC0, 0x61, 0x82,
  0x18, 0x0C, 0x30, 0x21, 0x81, 0x83, 0x06, 0x18, 0x30, 0x30, 0x63, 0x03,
  0x03, 0x06, 0x30, 0x20, 0x60, 0x63, 0x06, 0x06, 0x06, 0x30, 0x60, 0x60,
  0x42, 0x0C, 0x06, 0x0C, 0x60, 0xC0, 0xC0, 0xC6, 0x0C, 0x0C, 0x0C, 0x60,
  0xC0, 0xC0, 0x86, 0x0C, 0x1C, 0x18, 0x60, 0xC1, 0x81, 0x84, 0x08, 0x18,
  0x10, 0x40, 0x83, 0x83, 0x0C, 0x08, 0x28, 0x20, 0xC0, 0xC6, 0x86, 0x0C,
  0x0C, 0xCC, 0xC0, 0xC0, 0xF8, 0xF8, 0x0C, 0x03, 0x02, 0x00, 0xC0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x06, 0x60, 0x00,
  0xCC, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x30, 0xC0, 0x06,
  0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x0E, 0x0C, 0x01, 0x81, 0x80, 0x30,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x60, 0x0C, 0x0C, 0x01, 0x83, 0x80, 0x30, 0x60, 0x06, 0x0C, 0x00,
  0xC3, 0x00, 0x18, 0x60, 0x03, 0x1C, 0x00, 0x63, 0x00, 0x0C, 0xE0, 0x01,
  0x98, 0x00, 0x33, 0x00, 0x06, 0xE0, 0x00, 0xD8, 0x00, 0x1F, 0x00, 0x03,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0C, 0x07, 0x00, 0x30, 0x0E, 0x00,
  0xC0, 0x18, 0x07, 0x00, 0x70, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80,
  0x0C, 0x06, 0x00, 0x70, 0x30, 0x01, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x18,
  0x0C, 0x00, 0xE0, 0x30, 0x03, 0x01, 0x80, 0x18, 0x06, 0x00, 0xE0, 0x18,
  0x0E, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0C, 0x07, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0x60, 0x03, 0x81,
  0x80, 0x06, 0x06, 0x00, 0x38, 0x18, 0x00, 0xE0, 0xC0, 0x03, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x30, 0x30, 0x01, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x38,
  0x18, 0x01, 0xC0, 0x60, 0x0E, 0x01, 0x80, 0xF0, 0x0F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xE0, 0x03, 0xF3, 0xC0, 0x1C,
  0x02, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0xDE, 0x00, 0x0F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x03, 0x03, 0xC0, 0x06, 0x01, 0xC0, 0x0C, 0x01,
  0x80, 0x38, 0x03, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C,
  0x03, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x70, 0x30, 0x00, 0xE0,
  0x60, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C,
  0x00, 0x18, 0x18, 0x00, 0x30, 0x70, 0x00, 0x60, 0xC0, 0x01, 0xC1, 0x80,
  0x03, 0x83, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x60, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x81, 0x80, 0x06, 0x06, 0x00, 0x0C,
  0x0C, 0x00, 0x30, 0x18, 0x00, 0xE0, 0x30, 0x01, 0x80, 0xE0, 0x07, 0x01,
  0x80, 0x1C, 0x03, 0x00, 0x70, 0x06, 0x01, 0xC0, 0x0C, 0x0F, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xC7, 0xE0, 0x0F, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x1F, 0xC3, 0x80, 0x1F, 0xE1, 0x80, 0x00, 0x30,
  0xC0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0x81, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x30, 0x18, 0x00, 0x30, 0x0C, 0x00,
  0x18, 0x07, 0x00, 0x0C, 0x01, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x1F,
  0xBF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0xC0,
  0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x01,
  0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x1C,
  0x03, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x70, 0x00, 0x60, 0x18, 0x00,
  0x18, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80,
  0x30, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x0E, 0x01, 0x80, 0x03,
  0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00,
  0x07, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x60, 0x1C, 0x00, 0x18, 0x06,
  0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30,
  0x0E, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0x80,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x04,
  0x38, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0xC0,
  0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x38, 0x01, 0x80,
  0x30, 0x01, 0x80, 0x60, 0x01, 0x80, 0xE0, 0x01, 0x80, 0xC0, 0x01, 0x81,
  0x80, 0x03, 0x03, 0x80, 0x03, 0x07, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C,
  0x00, 0x07, 0x1C, 0x00, 0x06, 0x38, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60,
  0x00, 0x06, 0xE0, 0x00, 0x0E, 0xB0, 0x00, 0x0D, 0xB0, 0x00, 0x0F, 0x30,
  0x00, 0x0E, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x0C,
  0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x60, 0x07,
  0x00, 0xE0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x6C, 0x00,
  0x01, 0xE0, 0x1B, 0x00, 0x00, 0xD8, 0x06, 0xC0, 0x00, 0x36, 0x01, 0xB0,
  0x00, 0x19, 0x80, 0x6C, 0x00, 0x06, 0xC0, 0x33, 0x00, 0x03, 0x30, 0x0C,
  0xC0, 0x00, 0xCC, 0x03, 0x30, 0x00, 0x63, 0x00, 0xCC, 0x00, 0x19, 0xC0,
  0x73, 0x00, 0x0C, 0x60, 0x18, 0xC0, 0x03, 0x18, 0x06, 0x30, 0x01, 0x86,
  0x01, 0x8C, 0x00, 0x61, 0x80, 0x61, 0x00, 0x38, 0xE0, 0x30, 0x60, 0x0C,
  0x30, 0x0C, 0x18, 0x07, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x80,
  0x60, 0xC0, 0x30, 0x60, 0x30, 0x60, 0x18, 0x18, 0x0C, 0x18, 0x06, 0x06,
  0x06, 0x06, 0x01, 0x81, 0x81, 0x81, 0x80, 0x60, 0x60, 0xC0, 0x60, 0x18,
  0x18, 0x30, 0x30, 0x0C, 0x06, 0x18, 0x0C, 0x03, 0x01, 0x86, 0x03, 0x00,
  0xC0, 0x63, 0x00, 0xC0, 0x30, 0x18, 0xC0, 0x70, 0x1C, 0x06, 0x60, 0x18,
  0x06, 0x01, 0x98, 0x06, 0x01, 0x80, 0x6C, 0x01, 0x80, 0x60, 0x1B, 0x00,
  0x60, 0x18, 0x07, 0xC0, 0x30, 0x0C, 0x00, 0xE0, 0x0C, 0x03, 0x00, 0x38,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x1C, 0x00, 0x0C, 0x03, 0xC0, 0x01,
  0x80, 0x78, 0x00, 0x70, 0x0F, 0x00, 0x0C, 0x03, 0x60, 0x01, 0x80, 0x6C,
  0x00, 0x30, 0x0C, 0x80, 0x06, 0x01, 0x98, 0x01, 0x80, 0x33, 0x00, 0x30,
  0x0C, 0x60, 0x06, 0x01, 0x8C, 0x00, 0xC0, 0x31, 0x80, 0x18, 0x06, 0x18,
  0x06, 0x01, 0xC3, 0x00, 0xC0, 0x30, 0x60, 0x18, 0x06, 0x0C, 0x03, 0x00,
  0xC1, 0x80, 0xE0, 0x18, 0x30, 0x18, 0x07, 0x03, 0x03, 0x00, 0xC0, 0x60,
  0x60, 0x18, 0x0C, 0x0C, 0x03, 0x01, 0x83, 0x00, 0x60, 0x30, 0x60, 0x18,
  0x03, 0x0C, 0x03, 0x00, 0x61, 0x80, 0x60, 0x0C, 0x30, 0x0C, 0x01, 0x8C,
  0x01, 0x80, 0x31, 0x80, 0x60, 0x06, 0x30, 0x0C, 0x00, 0x66, 0x01, 0x80,
  0x0C, 0xC0, 0x30, 0x01, 0xB0, 0x0E, 0x00, 0x36, 0x01, 0x80, 0x06, 0xC0,
  0x30, 0x00, 0xF8, 0x06, 0x00, 0x0F, 0x00, 0xC0, 0x01, 0xC0, 0x38, 0x00,
  0x38, 0x06, 0x00, 0x07, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0x80, 0x03,
  0xCF, 0x00, 0x38, 0x0E, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x70, 0x30, 0x00,
  0xC1, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xC0, 0x00, 0xC3,
  0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x80, 0x00, 0xCC, 0x00,
  0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x37, 0x00, 0x00, 0xD8, 0x00, 0x07,
  0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0,
  0x00, 0x3B, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x73, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3,
  0x00, 0x06, 0x0C, 0x00, 0x18, 0x38, 0x00, 0xC0, 0x60, 0x07, 0x01, 0xC0,
  0x38, 0x03, 0x01, 0xC0, 0x0F, 0xBE, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x30, 0x38, 0x01, 0x80, 0xE0,
  0x0C, 0x03, 0x00, 0xE0, 0x1C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80,
  0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x03, 0x81,
  0x80, 0x18, 0x1C, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x60, 0x30, 0x07,
  0x01, 0x80, 0x30, 0x1C, 0x07, 0x00, 0xC0, 0x70, 0x07, 0xFF, 0x00, 0x3F,
  0xE0, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x7F, 0x80, 0x03, 0xCF, 0x00, 0x38, 0x0E, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0x70, 0x30, 0x00, 0xC1, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x38,
  0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00,
  0x33, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x37,
  0x00, 0x00, 0xD8, 0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x66, 0x00,
  0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x3B, 0x00, 0x00, 0xCC, 0x00, 0x03,
  0x30, 0x00, 0x0C, 0xC0, 0x00, 0x73, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x38, 0x00,
  0xC0, 0x60, 0x07, 0x01, 0xC0, 0x38, 0x03, 0x01, 0xC0, 0x0F, 0xBE, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x30, 0x38, 0x01, 0x80, 0xE0, 0x0C, 0x03, 0x00, 0xE0, 0x1C, 0x06,
  0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x06,
  0x06, 0x00, 0x30, 0x30, 0x03, 0x81, 0x80, 0x18, 0x1C, 0x00, 0xC0, 0xC0,
  0x0E, 0x06, 0x00, 0x60, 0x30, 0x07, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x00,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x30, 0xE0, 0x01, 0x83, 0x00, 0x18, 0x18,
  0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0xC0, 0x18,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x80, 0x70,
  0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x03, 0x80,
  0x18, 0x18, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xF9,
  0xF8, 0x03, 0x80, 0x20, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x10, 0x03, 0x80, 0x7E, 0x3E, 0x00, 0x7F,
  0xF0, 0x00, 0x0A, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81,
  0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x06, 0x06, 0x00,
  0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x01,
  0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x38,
  0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x07,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60,
  0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x30, 0x0E, 0x00, 0xC0, 0x0E, 0x03, 0x80, 0x0F, 0x3E, 0x00, 0x0F, 0xF0,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0x60,
  0x00, 0x6C, 0x00, 0x1D, 0x80, 0x03, 0x30, 0x00, 0xE6, 0x00, 0x18, 0xC0,
  0x03, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x07, 0x0C, 0x00, 0xC1, 0x80,
  0x38, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01,
  0xC0, 0x60, 0x30, 0x0C, 0x0E, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06, 0x0C,
  0x00, 0xC1, 0x80, 0x18, 0x70, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x60,
  0x01, 0x8C, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xDC, 0x00, 0x1B, 0x00,
  0x03, 0x60, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xD8, 0x00, 0x38, 0x00, 0x76,
  0x00, 0x0C, 0x00, 0x19, 0x80, 0x07, 0x00, 0x06, 0x60, 0x01, 0xC0, 0x03,
  0x18, 0x00, 0xD0, 0x00, 0xC6, 0x00, 0x34, 0x00, 0x71, 0x80, 0x0D, 0x00,
  0x18, 0x60, 0x06, 0xC0, 0x06, 0x18, 0x01, 0xB0, 0x03, 0x06, 0x00, 0xCC,
  0x00, 0xC1, 0x80, 0x33, 0x00, 0x70, 0x60, 0x0C, 0xC0, 0x18, 0x18, 0x06,
  0x30, 0x06, 0x06, 0x01, 0x8C, 0x03, 0x03, 0x80, 0xC3, 0x00, 0xC0, 0xC0,
  0x30, 0xC0, 0x70, 0x30, 0x0C, 0x30, 0x18, 0x0C, 0x06, 0x0C, 0x06, 0x03,
  0x01, 0x83, 0x03, 0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0x30, 0x30, 0x30, 0x70,
  0x0C, 0x0C, 0x0C, 0x18, 0x03, 0x06, 0x03, 0x06, 0x00, 0xC1, 0x80, 0xC3,
  0x00, 0x30, 0x60, 0x30, 0xC0, 0x0C, 0x30, 0x0C, 0x70, 0x03, 0x0C, 0x03,
  0x18, 0x00, 0xC6, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x33, 0x00, 0x0C, 0x60,
  0x0C, 0xC0, 0x03, 0x30, 0x03, 0x70, 0x00, 0xCC, 0x00, 0x98, 0x00, 0x36,
  0x00, 0x26, 0x00, 0x0D, 0x80, 0x0B, 0x00, 0x03, 0x60, 0x02, 0xC0, 0x00,
  0xF0, 0x01, 0xB0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x00, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0x80,
  0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x70, 0x00, 0x10, 0x30, 0x00, 0x0C, 0x38,
  0x00, 0x06, 0x18, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x71, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x18, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x07, 0x00,
  0x0E, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x60, 0x01,
  0xD8, 0x00, 0x66, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x06, 0x18, 0x01, 0x86,
  0x00, 0xC1, 0x80, 0x30, 0x60, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x00, 0xC0,
  0xC0, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x31, 0x80,
  0x0C, 0x60, 0x03, 0x30, 0x00, 0xDC, 0x00, 0x16, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0xC1, 0x83, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x02, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x81, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x20, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0x67, 0x00, 0x06, 0x18, 0x00, 0x30,
  0xE0, 0x03, 0x03, 0x00, 0x18, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0xC0, 0x1C, 0x0E, 0x00, 0x60, 0x60, 0x03, 0x07, 0x00, 0x0C, 0x30, 0x00,
  0x63, 0x80, 0x01, 0x98, 0x00, 0x0D, 0xC0, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFC, 0xC3, 0x86, 0x1C, 0x30, 0x41, 0x82, 0x0C, 0x00, 0x7C, 0x20, 0x3F,
  0xCC, 0x0E, 0x0D, 0x83, 0x81, 0xB0, 0xE0, 0x14, 0x18, 0x03, 0x86, 0x00,
  0x70, 0xC0, 0x0E, 0x30, 0x01, 0xC6, 0x00, 0x31, 0xC0, 0x06, 0x30, 0x00,
  0xC6, 0x00, 0x18, 0xC0, 0x07, 0x38, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03,
  0x18, 0x00, 0x63, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x1C,
  0x30, 0x03, 0x86, 0x00, 0xE0, 0xC0, 0x1C, 0x18, 0x07, 0x83, 0x00, 0xB0,
  0x70, 0x36, 0x07, 0xBC, 0x80, 0x7F, 0x30, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0xF8, 0x03, 0x3F, 0xC0,
  0x37, 0x0E, 0x03, 0x40, 0x60, 0x38, 0x07, 0x07, 0x80, 0x30, 0x70, 0x03,
  0x07, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0xE0, 0x03, 0x0C, 0x00,
  0x30, 0xC0, 0x07, 0x0C, 0x00, 0x60, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80,
  0x06, 0x18, 0x00, 0x61, 0x80, 0x0C, 0x38, 0x00, 0xC3, 0x00, 0x0C, 0x30,
  0x01, 0x83, 0x00, 0x18, 0x30, 0x03, 0x87, 0x00, 0x30, 0x78, 0x07, 0x07,
  0x80, 0xE0, 0x6C, 0x1C, 0x04, 0xF7, 0x80, 0xC7, 0xF0, 0x00, 0x08, 0x00,
  0x00, 0x7E, 0x03, 0xFC, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x9C, 0x07, 0xF8, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x03,
  0xF1, 0x80, 0x1F, 0xE6, 0x00, 0xE0, 0xD8, 0x07, 0x03, 0x60, 0x38, 0x07,
  0x00, 0xC0, 0x1C, 0x06, 0x00, 0x70, 0x18, 0x01, 0xC0, 0xC0, 0x07, 0x03,
  0x00, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00,
  0x30, 0x38, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30,
  0x30, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0xE0, 0x30,
  0x03, 0x80, 0xC0, 0x1C, 0x03, 0x00, 0x70, 0x0C, 0x03, 0xC0, 0x30, 0x0B,
  0x00, 0xE0, 0x6C, 0x01, 0xEF, 0x20, 0x03, 0xF9, 0x80, 0x01, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0x80, 0x70, 0xE0, 0x60, 0x30, 0x60, 0x18, 0x70,
  0x0C, 0x30, 0x06, 0x38, 0x03, 0x18, 0x03, 0x0C, 0x01, 0x8C, 0x01, 0x86,
  0x01, 0xC3, 0x01, 0xC3, 0x83, 0xC1, 0xFF, 0x80, 0xFE, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x01, 0x03,
  0xC7, 0x00, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x71, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xBC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x84, 0x00, 0xFF, 0x30,
  0x07, 0x06, 0xC0, 0x38, 0x1B, 0x01, 0xC0, 0x28, 0x06, 0x00, 0xE0, 0x30,
  0x03, 0x80, 0xC0, 0x0E, 0x06, 0x00, 0x38, 0x18, 0x00, 0xC0, 0x60, 0x03,
  0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x01, 0x81, 0xC0, 0x06, 0x06,
  0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x03, 0x81, 0x80, 0x0C, 0x06, 0x00,
  0x30, 0x18, 0x00, 0xC0, 0x60, 0x07, 0x01, 0x80, 0x1C, 0x06, 0x00, 0xE0,
  0x18, 0x03, 0x80, 0x60, 0x1E, 0x01, 0x80, 0xD8, 0x07, 0x07, 0x60, 0x0F,
  0x7B, 0x00, 0x1F, 0x8C, 0x00, 0x08, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x80, 0x70, 0x03, 0xEF,
  0x80, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x3F, 0x00, 0xCF, 0xF0, 0x1B, 0x07, 0x03, 0xC0, 0x60, 0x70, 0x0C,
  0x0E, 0x01, 0x83, 0x80, 0x30, 0x70, 0x06, 0x0C, 0x01, 0xC1, 0x80, 0x30,
  0x70, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x07, 0x06, 0x00, 0xC1,
  0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x18, 0x18, 0x03, 0x06,
  0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x60, 0xE0, 0x0C, 0x18,
  0x01, 0x83, 0x00, 0x30, 0x60, 0x0E, 0x0C, 0x01, 0x83, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x02, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0xC0, 0xC0, 0x38, 0x18, 0x06, 0x03, 0x01, 0x80,
  0x60, 0x60, 0x18, 0x1C, 0x03, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x01,
  0x8E, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x01, 0x9C, 0x00, 0x37, 0x80, 0x07,
  0xF0, 0x01, 0xB6, 0x00, 0x3C, 0xE0, 0x07, 0x0C, 0x00, 0xC1, 0x80, 0x30,
  0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x03, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x00, 0x00, 0x03, 0x1F, 0x83, 0xE0, 0x0C, 0xFF, 0x3F, 0xE0, 0x36, 0x0D,
  0xC3, 0x80, 0xF0, 0x34, 0x07, 0x03, 0x80, 0xF0, 0x0C, 0x1C, 0x01, 0x80,
  0x30, 0x70, 0x0E, 0x01, 0xC1, 0x80, 0x30, 0x06, 0x06, 0x00, 0xC0, 0x18,
  0x18, 0x03, 0x00, 0x60, 0xE0, 0x0C, 0x01, 0x83, 0x00, 0x70, 0x0E, 0x0C,
  0x01, 0x80, 0x30, 0x30, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x03, 0x06, 0x00,
  0x60, 0x0C, 0x18, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x01, 0x81, 0x80, 0x30,
  0x06, 0x0E, 0x00, 0xC0, 0x18, 0x30, 0x07, 0x00, 0x60, 0xC0, 0x18, 0x03,
  0x03, 0x00, 0x60, 0x0C, 0x0C, 0x01, 0x80, 0x30, 0x60, 0x06, 0x00, 0xC1,
  0x80, 0x30, 0x07, 0x06, 0x00, 0xC0, 0x18, 0x18, 0x03, 0x00, 0x60, 0x60,
  0x0C, 0x01, 0x83, 0x00, 0x70, 0x06, 0x00, 0x03, 0x1F, 0x80, 0x67, 0xF8,
  0x0D, 0x83, 0x81, 0xE0, 0x30, 0x38, 0x06, 0x0E, 0x00, 0xC1, 0xC0, 0x18,
  0x38, 0x03, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x38, 0x03, 0x06, 0x00, 0x60,
  0xC0, 0x0C, 0x18, 0x03, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83,
  0x00, 0x30, 0x60, 0x0C, 0x1C, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x0C,
  0x01, 0xC1, 0x80, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30,
  0x06, 0x06, 0x00, 0xC1, 0x80, 0x18, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0xC1, 0xC0, 0xC0, 0x60, 0xC0, 0x18, 0xE0, 0x0C, 0x60, 0x06, 0x70, 0x03,
  0x30, 0x01, 0x98, 0x00, 0xDC, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8,
  0x00, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x18,
  0x60, 0x0C, 0x30, 0x0C, 0x1C, 0x0E, 0x07, 0x9E, 0x01, 0xFC, 0x00, 0x10,
  0x00, 0x00, 0x43, 0xE0, 0x03, 0x3F, 0xC0, 0x0D, 0xC3, 0x80, 0x34, 0x06,
  0x00, 0xF0, 0x1C, 0x07, 0x80, 0x30, 0x1C, 0x00, 0xC0, 0x70, 0x03, 0x01,
  0x80, 0x0C, 0x06, 0x00, 0x30, 0x38, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x70, 0x30, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18,
  0x18, 0x00, 0x60, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x0E, 0x00, 0x30, 0x30,
  0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x38, 0x1C, 0x00, 0xC0, 0x78, 0x07,
  0x01, 0xE0, 0x38, 0x06, 0xC1, 0xC0, 0x1B, 0x9E, 0x00, 0xC7, 0xF0, 0x03,
  0x02, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x20, 0x3F, 0xCC, 0x0E, 0x1D, 0x83, 0x01, 0xB0, 0xE0, 0x14,
  0x18, 0x03, 0x86, 0x00, 0x70, 0xC0, 0x0E, 0x30, 0x01, 0xC6, 0x00, 0x30,
  0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x02, 0x38, 0x00, 0xC6,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x18, 0x60, 0x03, 0x0C,
  0x00, 0x61, 0x80, 0x1C, 0x30, 0x03, 0x86, 0x00, 0xE0, 0xC0, 0x1C, 0x18,
  0x07, 0x83, 0x00, 0xB0, 0x70, 0x36, 0x07, 0xBD, 0x80, 0x7F, 0x30, 0x01,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x03, 0x1F, 0x03, 0x3F, 0x03,
  0x60, 0x03, 0xC0, 0x02, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0,
  0xE0, 0x60, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x10, 0x0E, 0x0F, 0x1E, 0x03, 0xFE, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x7F,
  0x3F, 0xE0, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x72, 0x07, 0xC0, 0x30, 0x00, 0x07, 0x00, 0x60, 0xC0, 0x0C, 0x18,
  0x01, 0x83, 0x00, 0x60, 0x60, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60,
  0x06, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80,
  0x18, 0x30, 0x06, 0x0E, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00,
  0xE0, 0xC0, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x1C, 0x18, 0x03,
  0x03, 0x00, 0x60, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0xB0, 0x30, 0x34,
  0x07, 0xBD, 0x80, 0x7F, 0x30, 0x01, 0x00, 0x00, 0xC0, 0x03, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38,
  0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC1, 0xC0, 0xC1, 0x80, 0xC1, 0x80, 0xC3, 0x00, 0xC3, 0x00, 0xC6, 0x00,
  0xC6, 0x00, 0xCC, 0x00, 0xCC, 0x00, 0xCC, 0x00, 0xD8, 0x00, 0xD8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x40, 0x06, 0x00, 0xD0,
  0x03, 0x80, 0x3C, 0x00, 0xE0, 0x1B, 0x00, 0x78, 0x06, 0xC0, 0x1E, 0x01,
  0xB0, 0x05, 0x80, 0xCC, 0x03, 0x60, 0x33, 0x00, 0xD8, 0x18, 0xC0, 0x66,
  0x06, 0x30, 0x19, 0x81, 0x8C, 0x0C, 0x60, 0xC3, 0x03, 0x18, 0x30, 0xC0,
  0xC6, 0x08, 0x30, 0x61, 0x86, 0x0C, 0x18, 0x61, 0x83, 0x0C, 0x18, 0xC0,
  0xC3, 0x06, 0x30, 0x30, 0xC1, 0x0C, 0x0C, 0x60, 0x46, 0x03, 0x18, 0x11,
  0x80, 0xCC, 0x04, 0xC0, 0x33, 0x01, 0x30, 0x0C, 0xC0, 0x4C, 0x03, 0x60,
  0x16, 0x00, 0xD8, 0x05, 0x80, 0x3C, 0x03, 0x40, 0x0F, 0x00, 0xF0, 0x03,
  0xC0, 0x3C, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x30, 0x18, 0x03, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x01, 0x80, 0xC0, 0x18,
  0x18, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x00, 0xC7, 0x00, 0x0C, 0x60, 0x00,
  0xCC, 0x00, 0x04, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x1B, 0x00, 0x01, 0xB0, 0x00, 0x33, 0x00,
  0x07, 0x18, 0x00, 0x61, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x18, 0x18,
  0x03, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0xE0, 0x0C, 0x0C, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0x60,
  0x00, 0xC0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x01,
  0x80, 0x00, 0x40, 0x60, 0x00, 0x10, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x30, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x27, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0F,
  0xFF, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0x78, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0xE0,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x07,
  0x03, 0xC3, 0xC0, 0x1F, 0xE8, 0x00, 0x70,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 40, 12, 1, -40 },
  { 56, 12, 14, 15, 5, -40 },
  { 77, 22, 40, 21, 0, -40 },
  { 187, 21, 46, 20, 0, -43 },
  { 308, 25, 42, 30, 3, -41 },
  { 440, 19, 42, 19, -1, -41 },
  { 540, 5, 14, 9, 5, -40 },
  { 549, 16, 49, 14, 1, -40 },
  { 647, 16, 49, 14, -4, -40 },
  { 745, 15, 15, 18, 6, -42 },
  { 774, 19, 26, 23, 2, -33 },
  { 836, 7, 12, 9, -2, -5 },
  { 847, 12, 2, 15, 1, -16 },
  { 850, 3, 4, 9, 1, -4 },
  { 852, 24, 40, 17, -3, -40 },
  { 972, 19, 42, 20, 1, -41 },
  { 1072, 11, 40, 20, 6, -40 },
  { 1127, 22, 41, 20, -2, -41 },
  { 1240, 21, 42, 20, -1, -41 },
  { 1351, 21, 40, 20, -1, -40 },
  { 1456, 21, 41, 20, -1, -40 },
  { 1564, 20, 42, 20, 1, -41 },
  { 1669, 20, 40, 20, 2, -40 },
  { 1769, 21, 42, 20, -1, -41 },
  { 1880, 19, 42, 20, 0, -41 },
  { 1980, 9, 30, 9, 0, -30 },
  { 2014, 12, 37, 9, -3, -30 },
  { 2070, 19, 23, 23, 2, -31 },
  { 2125, 19, 14, 23, 2, -27 },
  { 2159, 19, 23, 23, 2, -31 },
  { 2214, 15, 41, 14, 1, -41 },
  { 2291, 28, 45, 29, 1, -40 },
  { 2449, 19, 40, 19, -4, -40 },
  { 2544, 22, 40, 22, 0, -40 },
  { 2654, 22, 42, 19, 2, -41 },
  { 2770, 23, 40, 24, 0, -40 },
  { 2885, 22, 40, 19, 0, -40 },
  { 2995, 22, 40, 18, 0, -40 },
  { 3105, 25, 42, 26, 2, -41 },
  { 3237, 26, 40, 25, 0, -40 },
  { 3367, 17, 40, 10, -3, -40 },
  { 3452, 19, 50, 9, -8, -40 },
  { 3571, 24, 40, 20, 0, -40 },
  { 3691, 13, 40, 17, 0, -40 },
  { 3756, 34, 40, 34, 0, -40 },
  { 3926, 27, 40, 26, 0, -40 },
  { 4061, 22, 42, 25, 2, -41 },
  { 4177, 21, 40, 20, 0, -40 },
  { 4282, 22, 51, 25, 2, -41 },
  { 4423, 21, 40, 21, 0, -40 },
  { 4528, 23, 42, 19, -2, -41 },
  { 4649, 17, 40, 17, 4, -40 },
  { 4734, 23, 41, 24, 2, -40 },
  { 4852, 19, 40, 20, 5, -40 },
  { 4947, 34, 40, 34, 4, -40 },
  { 5117, 25, 40, 18, -3, -40 },
  { 5242, 18, 40, 17, 4, -40 },
  { 5332, 23, 40, 17, -2, -40 },
  { 5447, 20, 49, 15, -1, -40 },
  { 5570, 7, 40, 18, 6, -40 },
  { 5605, 20, 49, 15, -3, -40 },
  { 5728, 21, 20, 22, 1, -40 },
  { 5781, 15, 2, 15, -4, 5 },
  { 5785, 6, 9, 12, 8, -43 },
  { 5792, 19, 31, 22, 2, -30 },
  { 5866, 20, 44, 21, 0, -43 },
  { 5976, 15, 31, 16, 2, -30 },
  { 6035, 22, 44, 22, 2, -43 },
  { 6156, 17, 31, 19, 1, -30 },
  { 6222, 24, 56, 11, -7, -43 },
  { 6390, 22, 43, 22, -1, -30 },
  { 6509, 19, 43, 21, 0, -43 },
  { 6612, 11, 40, 9, 0, -40 },
  { 6667, 18, 53, 9, -7, -40 },
  { 6787, 19, 43, 17, 0, -43 },
  { 6890, 11, 43, 9, 0, -43 },
  { 6950, 30, 30, 31, 0, -30 },
  { 7063, 19, 30, 21, 0, -30 },
  { 7135, 17, 31, 21, 2, -30 },
  { 7201, 22, 43, 21, -2, -30 },
  { 7320, 19, 43, 22, 2, -30 },
  { 7423, 16, 30, 14, 0, -30 },
  { 7483, 17, 31, 16, -1, -30 },
  { 7549, 11, 38, 11, 1, -37 },
  { 7602, 19, 31, 21, 1, -30 },
  { 7676, 16, 30, 16, 3, -30 },
  { 7736, 26, 30, 27, 3, -30 },
  { 7834, 20, 30, 17, -2, -30 },
  { 7909, 26, 44, 17, -6, -30 },
  { 8052, 17, 30, 14, -2, -30 },
  { 8116, 19, 49, 18, 2, -40 },
  { 8233, 2, 57, 19, 9, -43 },
  { 8248, 20, 49, 17, -4, -40 },
  { 8371, 19, 5, 23, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC56PT7B_H_
