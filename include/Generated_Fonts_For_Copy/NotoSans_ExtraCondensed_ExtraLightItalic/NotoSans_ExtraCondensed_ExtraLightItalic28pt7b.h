#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC28PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x82, 0x08, 0x21, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82,
  0x00, 0x00, 0x04, 0x30, 0x4D, 0x24, 0xA2, 0x8A, 0x49, 0x00, 0x02, 0x20,
  0x44, 0x11, 0x02, 0x20, 0x44, 0x09, 0x0F, 0xF8, 0x44, 0x09, 0x02, 0x20,
  0x44, 0x09, 0x02, 0x21, 0xFF, 0x08, 0x82, 0x20, 0x44, 0x08, 0x82, 0x20,
  0x44, 0x00, 0x01, 0x00, 0x40, 0x7C, 0x69, 0x12, 0x08, 0x82, 0x20, 0x90,
  0x14, 0x07, 0x00, 0xC0, 0x10, 0x0A, 0x02, 0x40, 0x90, 0x24, 0x09, 0x04,
  0x49, 0x61, 0xE0, 0x10, 0x08, 0x02, 0x00, 0x1C, 0x11, 0x21, 0x08, 0x88,
  0x88, 0x84, 0x44, 0x22, 0x41, 0x12, 0x10, 0xA0, 0x89, 0x7C, 0x52, 0x62,
  0xA2, 0xE9, 0x10, 0x50, 0x84, 0x84, 0x24, 0x62, 0x22, 0x11, 0x11, 0x08,
  0x88, 0x48, 0x83, 0x80, 0x07, 0x04, 0x82, 0x42, 0x21, 0x10, 0x88, 0x48,
  0x24, 0x0C, 0x0C, 0x0E, 0x04, 0x94, 0x4C, 0x2E, 0x15, 0x06, 0x82, 0x43,
  0x21, 0x8F, 0x20, 0x56, 0xA8, 0x02, 0x08, 0x30, 0x41, 0x02, 0x08, 0x30,
  0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x10, 0x20, 0x04, 0x02, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x03, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x20, 0xC0, 0x08, 0x13, 0x41, 0xF1, 0x0D, 0x31, 0x02, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x0F, 0xFC, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x00, 0x32, 0x24, 0x48, 0x80, 0xFC, 0x70, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x03, 0x00, 0x40, 0x00,
  0x0F, 0x0C, 0x84, 0x24, 0x12, 0x0A, 0x05, 0x02, 0x83, 0x41, 0x40, 0xA0,
  0x50, 0x28, 0x34, 0x12, 0x09, 0x04, 0x84, 0x42, 0x22, 0x0E, 0x00, 0x09,
  0xDB, 0x11, 0x08, 0x42, 0x31, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x00,
  0x07, 0xC1, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x80, 0x10, 0x04, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0C,
  0x01, 0x00, 0x7F, 0x80, 0x07, 0xC1, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x10, 0x02, 0x01, 0x81, 0xC0, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x80, 0x22, 0x08, 0x7E, 0x00, 0x00, 0x60, 0x14, 0x03,
  0x00, 0xA0, 0x14, 0x04, 0x81, 0x90, 0x24, 0x08, 0x81, 0x10, 0x42, 0x18,
  0xC2, 0x10, 0x82, 0x1F, 0xF4, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x07, 0xE0, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x1E,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x22, 0x08, 0x7E, 0x00, 0x07, 0xC2, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x5E, 0x28, 0x8C, 0x12, 0x04, 0x81, 0x20, 0x48, 0x32, 0x08,
  0x82, 0x21, 0x88, 0x41, 0xE0, 0x3F, 0xC0, 0x10, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x0F, 0x86, 0x11, 0x04, 0x41, 0x30,
  0x44, 0x11, 0x08, 0x46, 0x0B, 0x03, 0x01, 0x61, 0x88, 0x41, 0x20, 0x48,
  0x12, 0x04, 0x81, 0x20, 0x4C, 0x21, 0xF0, 0x0F, 0x86, 0x21, 0x0C, 0x81,
  0x20, 0x48, 0x12, 0x05, 0x83, 0x60, 0x88, 0x22, 0x18, 0x7A, 0x01, 0x80,
  0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0xC3, 0xC0, 0x11, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x80, 0x0C, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x82, 0x10, 0x42, 0x08, 0x00, 0x00, 0x40, 0x60, 0x60, 0x60,
  0x30, 0x30, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x02, 0x00, 0x3E, 0x01,
  0x01, 0x01, 0x01, 0x03, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x20, 0x20, 0x20,
  0x40, 0x00, 0x00, 0x00, 0x40, 0xC0, 0x03, 0xE0, 0x20, 0x82, 0x02, 0x20,
  0x12, 0x00, 0x90, 0x05, 0x8F, 0x28, 0x89, 0x44, 0x8A, 0x44, 0x62, 0x23,
  0x11, 0x29, 0x11, 0x48, 0x8A, 0x44, 0x92, 0x64, 0x8C, 0xC4, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x3F, 0x00, 0x00, 0xC0, 0x30, 0x14, 0x05, 0x03,
  0x40, 0x90, 0x24, 0x11, 0x04, 0x43, 0x10, 0x84, 0x3F, 0x10, 0x44, 0x13,
  0x04, 0x81, 0x20, 0x50, 0x14, 0x06, 0x01, 0x0F, 0x81, 0x08, 0x20, 0x84,
  0x11, 0x02, 0x20, 0x44, 0x10, 0x82, 0x31, 0x87, 0xC0, 0x84, 0x10, 0x42,
  0x08, 0xC1, 0x10, 0x22, 0x04, 0x40, 0x88, 0x22, 0x08, 0x7E, 0x00, 0x03,
  0xE1, 0x80, 0x60, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x18,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x1F, 0x00, 0x0F, 0x81, 0x08, 0x20, 0x84, 0x11, 0x02, 0x20, 0x44,
  0x08, 0x81, 0x30, 0x24, 0x04, 0x80, 0x90, 0x32, 0x04, 0x80, 0x90, 0x32,
  0x04, 0x41, 0x88, 0x62, 0x18, 0x7C, 0x00, 0x0F, 0xE1, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x07, 0xF0, 0x80, 0x10, 0x02,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x7F, 0x00, 0x0F,
  0xE1, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04,
  0x00, 0xFC, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x00, 0x03, 0xF8, 0x60, 0x86, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x79, 0x00, 0x88, 0x04,
  0x40, 0x22, 0x01, 0x10, 0x18, 0x80, 0x82, 0x04, 0x18, 0x20, 0x7F, 0x00,
  0x08, 0x08, 0x40, 0x42, 0x04, 0x10, 0x21, 0x01, 0x08, 0x08, 0x40, 0x42,
  0x04, 0x30, 0x21, 0xFF, 0x08, 0x08, 0x40, 0xC2, 0x04, 0x20, 0x21, 0x01,
  0x08, 0x08, 0x40, 0x82, 0x04, 0x20, 0x21, 0x01, 0x00, 0x07, 0x81, 0x00,
  0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x1F, 0x00, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0xE0,
  0x00, 0x08, 0x10, 0x82, 0x08, 0x40, 0x8C, 0x10, 0x81, 0x10, 0x12, 0x01,
  0x60, 0x34, 0x02, 0xC0, 0x34, 0x02, 0x40, 0x24, 0x04, 0x20, 0x42, 0x04,
  0x20, 0x42, 0x04, 0x30, 0x81, 0x08, 0x10, 0x08, 0x20, 0x82, 0x10, 0x41,
  0x04, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x3F, 0x0C, 0x01,
  0x86, 0x00, 0xC3, 0x00, 0xA1, 0x80, 0x61, 0x40, 0x70, 0xA0, 0x28, 0x50,
  0x34, 0x28, 0x12, 0x24, 0x0A, 0x12, 0x09, 0x09, 0x04, 0x84, 0x84, 0x42,
  0x42, 0x22, 0x22, 0x21, 0x09, 0x10, 0x85, 0x08, 0x42, 0x84, 0x21, 0x86,
  0x20, 0xC2, 0x10, 0x41, 0x00, 0x0C, 0x0C, 0x30, 0x20, 0xC0, 0x83, 0x02,
  0x14, 0x08, 0x48, 0x41, 0x21, 0x04, 0x84, 0x22, 0x10, 0x88, 0x42, 0x22,
  0x08, 0x48, 0x21, 0x21, 0x04, 0x84, 0x12, 0x10, 0x50, 0x40, 0xC1, 0x03,
  0x08, 0x0C, 0x20, 0x20, 0x07, 0xC1, 0x0C, 0x40, 0x88, 0x12, 0x02, 0x40,
  0x50, 0x0A, 0x01, 0x40, 0x28, 0x06, 0x01, 0xC0, 0x28, 0x05, 0x00, 0xA0,
  0x34, 0x04, 0x81, 0x90, 0x21, 0x08, 0x3E, 0x00, 0x0F, 0x81, 0x18, 0x21,
  0x04, 0x31, 0x06, 0x20, 0x84, 0x10, 0x82, 0x30, 0xC4, 0x30, 0x9C, 0x1C,
  0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x00,
  0x07, 0xC1, 0x0C, 0x40, 0x88, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x40,
  0x28, 0x06, 0x01, 0xC0, 0x28, 0x05, 0x00, 0xA0, 0x24, 0x04, 0x81, 0x90,
  0x21, 0x08, 0x3E, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0x0F,
  0x81, 0x18, 0x21, 0x04, 0x21, 0x06, 0x20, 0x84, 0x10, 0x82, 0x30, 0x84,
  0x30, 0xFC, 0x12, 0x02, 0x40, 0x84, 0x10, 0x82, 0x10, 0x42, 0x08, 0x42,
  0x0C, 0x40, 0x80, 0x07, 0xF0, 0xC2, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x83, 0x0F, 0xE0, 0xFF, 0x84, 0x02,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x00, 0x10, 0x11, 0x02, 0x10,
  0x22, 0x02, 0x20, 0x22, 0x06, 0x20, 0x42, 0x04, 0x40, 0x44, 0x04, 0x40,
  0x84, 0x08, 0xC0, 0x88, 0x08, 0x81, 0x88, 0x10, 0x81, 0x08, 0x30, 0xC2,
  0x07, 0xC0, 0x80, 0x60, 0x38, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x22, 0x08,
  0x86, 0x21, 0x08, 0x42, 0x20, 0x88, 0x24, 0x09, 0x02, 0x40, 0xA0, 0x28,
  0x0C, 0x03, 0x00, 0x80, 0x80, 0xC0, 0x40, 0xE0, 0x60, 0x50, 0x30, 0x28,
  0x28, 0x24, 0x14, 0x12, 0x0A, 0x19, 0x09, 0x08, 0x84, 0x84, 0x42, 0x44,
  0x22, 0x22, 0x11, 0x13, 0x09, 0x09, 0x04, 0x84, 0x82, 0x42, 0x81, 0x41,
  0x40, 0xA0, 0xE0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x10, 0x00, 0x04, 0x18,
  0x20, 0x80, 0x8C, 0x04, 0x40, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x50, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x64, 0x02, 0x20,
  0x21, 0x01, 0x08, 0x10, 0x41, 0x81, 0x00, 0x81, 0xC0, 0x90, 0xC8, 0x44,
  0x62, 0x21, 0x20, 0x90, 0x50, 0x28, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x40, 0x20, 0x10, 0x00, 0x0F, 0xE0, 0x04, 0x01, 0x00, 0x20,
  0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x7F, 0x80, 0x03, 0xC1,
  0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x03, 0xE0, 0x88, 0x88, 0x44, 0x44, 0x44, 0x44, 0x22, 0x22,
  0x22, 0x31, 0x07, 0xC0, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x83, 0xE0, 0x04, 0x03, 0x00, 0xA0,
  0x48, 0x33, 0x08, 0x44, 0x11, 0x02, 0x80, 0xA0, 0x10, 0xFE, 0x89, 0x10,
  0x0E, 0x44, 0x62, 0x09, 0x82, 0x40, 0x90, 0x68, 0x12, 0x04, 0x81, 0x20,
  0x48, 0x22, 0x08, 0x86, 0x21, 0x87, 0xA0, 0x0C, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x78, 0x63, 0x18, 0x44, 0x13, 0x04, 0x81, 0x20, 0x48,
  0x14, 0x09, 0x02, 0x40, 0x90, 0x44, 0x12, 0x88, 0xBC, 0x00, 0x0F, 0x10,
  0x20, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x78, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x83, 0x90, 0x8C,
  0x21, 0x8C, 0x11, 0x02, 0x20, 0xC8, 0x11, 0x02, 0x20, 0x44, 0x08, 0x82,
  0x10, 0x42, 0x18, 0x45, 0x07, 0xA0, 0x0E, 0x11, 0x21, 0x41, 0x41, 0x42,
  0x8C, 0xF0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x7C, 0x00, 0x78, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x0F, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x01, 0xC0, 0x00, 0x03, 0x90, 0x46, 0x08, 0x61,
  0x82, 0x10, 0x61, 0x06, 0x20, 0x42, 0x04, 0x20, 0x42, 0x04, 0x20, 0x82,
  0x08, 0x21, 0x82, 0x28, 0x1E, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x20, 0xC4, 0x03, 0x80, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x5E,
  0x31, 0x10, 0x88, 0x4C, 0x24, 0x12, 0x09, 0x04, 0x84, 0x82, 0x41, 0x20,
  0x90, 0xD8, 0x48, 0x20, 0x08, 0x40, 0x00, 0x08, 0x42, 0x11, 0x08, 0x42,
  0x11, 0x08, 0x42, 0x21, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x0C, 0x0C, 0x00, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x0C,
  0x42, 0x11, 0x04, 0x82, 0x60, 0x90, 0x28, 0x0D, 0x06, 0x41, 0x10, 0x44,
  0x11, 0x04, 0x42, 0x08, 0x82, 0x00, 0x0C, 0x20, 0x82, 0x08, 0x41, 0x04,
  0x10, 0x42, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x80, 0x17, 0xBC,
  0x31, 0x4C, 0x43, 0x08, 0x84, 0x12, 0x08, 0x44, 0x10, 0x88, 0x21, 0x10,
  0x82, 0x61, 0x04, 0x82, 0x11, 0x04, 0x22, 0x18, 0x44, 0x20, 0x90, 0x41,
  0x20, 0x84, 0x00, 0x17, 0x8C, 0x44, 0x22, 0x13, 0x09, 0x04, 0x82, 0x41,
  0x61, 0x20, 0x90, 0x48, 0x24, 0x34, 0x12, 0x08, 0x0E, 0x08, 0x88, 0x48,
  0x34, 0x1A, 0x0E, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x90, 0x48, 0x64, 0x21,
  0xE0, 0x0B, 0xC1, 0x8C, 0x30, 0x84, 0x11, 0x82, 0x20, 0x44, 0x08, 0x81,
  0x10, 0x44, 0x08, 0x81, 0x10, 0x42, 0x08, 0xA2, 0x17, 0x82, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x08, 0x00, 0x0E, 0x44, 0x62, 0x19, 0x82, 0x40,
  0x90, 0x6C, 0x12, 0x04, 0x81, 0x20, 0x48, 0x22, 0x08, 0x86, 0x22, 0x87,
  0xA0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x17, 0x18,
  0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x80, 0x1F, 0x31, 0x20, 0x20, 0x20, 0x20, 0x30, 0x18, 0x08, 0x04, 0x04,
  0x04, 0x04, 0x0C, 0xF8, 0x08, 0x21, 0x0F, 0x10, 0x42, 0x08, 0x20, 0x82,
  0x10, 0x41, 0x04, 0x10, 0xC1, 0xC0, 0x20, 0x90, 0x48, 0x24, 0x24, 0x12,
  0x09, 0x04, 0x86, 0x82, 0x41, 0x20, 0x90, 0xC8, 0x44, 0x63, 0xD0, 0x83,
  0x06, 0x14, 0x28, 0x91, 0x22, 0x48, 0x91, 0x42, 0x86, 0x0C, 0x18, 0x20,
  0x00, 0x82, 0x1C, 0x30, 0xA1, 0x85, 0x14, 0x48, 0xA2, 0x45, 0x12, 0x49,
  0x12, 0x48, 0xA2, 0x85, 0x14, 0x28, 0xA1, 0x86, 0x0C, 0x30, 0x41, 0x02,
  0x08, 0x00, 0x10, 0x44, 0x20, 0x88, 0x24, 0x09, 0x02, 0x80, 0xC0, 0x30,
  0x0C, 0x05, 0x01, 0x40, 0x88, 0x42, 0x10, 0x88, 0x20, 0x04, 0x08, 0x20,
  0x81, 0x04, 0x08, 0x40, 0x42, 0x02, 0x10, 0x11, 0x00, 0x88, 0x04, 0x80,
  0x24, 0x01, 0x40, 0x0A, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x80,
  0x40, 0x40, 0x20, 0x20, 0x30, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02,
  0x03, 0xF0, 0x01, 0xC1, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x80, 0xC0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0x00, 0x60, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0xC0, 0x30, 0x04, 0x01, 0xC0, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x02, 0x01, 0x83, 0xC0, 0x78, 0x61, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 20, 6, 0, -20 },
  { 16, 6, 7, 8, 3, -20 },
  { 22, 11, 20, 11, 0, -20 },
  { 50, 10, 23, 10, 0, -21 },
  { 79, 13, 20, 15, 1, -20 },
  { 112, 9, 20, 10, 0, -20 },
  { 135, 2, 7, 4, 3, -20 },
  { 137, 7, 24, 7, 1, -20 },
  { 158, 8, 24, 7, -2, -20 },
  { 182, 7, 8, 9, 3, -21 },
  { 189, 10, 13, 11, 1, -16 },
  { 206, 4, 7, 5, -1, -3 },
  { 210, 6, 1, 7, 1, -8 },
  { 211, 2, 2, 5, 0, -2 },
  { 212, 11, 20, 8, -1, -20 },
  { 240, 9, 20, 10, 1, -20 },
  { 263, 5, 20, 10, 3, -20 },
  { 276, 11, 20, 10, -1, -20 },
  { 304, 11, 20, 10, -1, -20 },
  { 332, 11, 20, 10, -1, -20 },
  { 360, 11, 20, 10, -1, -20 },
  { 388, 10, 20, 10, 1, -20 },
  { 413, 10, 20, 10, 1, -20 },
  { 438, 10, 20, 10, 0, -20 },
  { 463, 10, 20, 10, 0, -20 },
  { 488, 4, 15, 5, 0, -15 },
  { 496, 6, 19, 5, -1, -15 },
  { 511, 10, 12, 11, 1, -16 },
  { 526, 10, 7, 11, 1, -13 },
  { 535, 10, 12, 11, 1, -16 },
  { 550, 8, 20, 7, 0, -20 },
  { 570, 13, 22, 15, 1, -20 },
  { 606, 10, 20, 10, -2, -20 },
  { 631, 11, 20, 11, 0, -20 },
  { 659, 11, 20, 10, 1, -20 },
  { 687, 11, 20, 12, 0, -20 },
  { 715, 11, 20, 10, 0, -20 },
  { 743, 11, 20, 9, 0, -20 },
  { 771, 13, 20, 13, 1, -20 },
  { 804, 13, 20, 13, 0, -20 },
  { 837, 9, 20, 5, -2, -20 },
  { 860, 9, 25, 5, -4, -20 },
  { 889, 12, 20, 10, 0, -20 },
  { 919, 6, 20, 9, 0, -20 },
  { 934, 17, 20, 17, 0, -20 },
  { 977, 14, 20, 13, 0, -20 },
  { 1012, 11, 20, 13, 1, -20 },
  { 1040, 11, 20, 10, 0, -20 },
  { 1068, 11, 25, 13, 1, -20 },
  { 1103, 11, 20, 10, 0, -20 },
  { 1131, 12, 20, 10, -1, -20 },
  { 1161, 9, 20, 9, 2, -20 },
  { 1184, 12, 20, 12, 1, -20 },
  { 1214, 10, 20, 10, 2, -20 },
  { 1239, 17, 20, 17, 2, -20 },
  { 1282, 13, 20, 9, -2, -20 },
  { 1315, 9, 20, 8, 2, -20 },
  { 1338, 11, 20, 9, -1, -20 },
  { 1366, 10, 24, 8, -1, -20 },
  { 1396, 4, 20, 9, 3, -20 },
  { 1406, 10, 24, 8, -2, -20 },
  { 1436, 10, 10, 11, 1, -20 },
  { 1449, 7, 1, 8, -2, 2 },
  { 1450, 3, 4, 6, 4, -21 },
  { 1452, 10, 15, 11, 1, -15 },
  { 1471, 10, 21, 11, 0, -21 },
  { 1498, 8, 15, 8, 1, -15 },
  { 1513, 11, 21, 11, 1, -21 },
  { 1542, 8, 15, 9, 1, -15 },
  { 1557, 13, 28, 5, -4, -21 },
  { 1603, 12, 22, 11, -1, -15 },
  { 1636, 9, 21, 10, 0, -21 },
  { 1660, 5, 20, 5, 0, -20 },
  { 1673, 10, 27, 5, -4, -20 },
  { 1707, 10, 21, 9, 0, -21 },
  { 1734, 6, 21, 4, 0, -21 },
  { 1750, 15, 15, 16, 0, -15 },
  { 1779, 9, 15, 10, 0, -15 },
  { 1796, 9, 15, 10, 1, -15 },
  { 1813, 11, 21, 11, -1, -15 },
  { 1842, 10, 22, 11, 1, -15 },
  { 1870, 8, 15, 7, 0, -15 },
  { 1885, 8, 15, 8, 0, -15 },
  { 1900, 6, 18, 5, 0, -18 },
  { 1914, 9, 15, 10, 1, -15 },
  { 1931, 7, 15, 8, 2, -15 },
  { 1945, 13, 15, 13, 2, -15 },
  { 1970, 10, 15, 8, -1, -15 },
  { 1989, 13, 22, 8, -3, -15 },
  { 2025, 9, 15, 7, -1, -15 },
  { 2042, 10, 24, 9, 1, -20 },
  { 2072, 1, 28, 10, 4, -21 },
  { 2076, 10, 24, 9, -2, -20 },
  { 2106, 10, 2, 11, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC28PT7B_H_
