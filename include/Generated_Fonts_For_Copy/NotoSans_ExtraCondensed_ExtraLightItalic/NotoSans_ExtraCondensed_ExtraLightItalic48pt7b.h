#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC48PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01,
  0x80, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01,
  0xC0, 0xC0, 0x60, 0x00, 0x30, 0xC8, 0x66, 0x19, 0x86, 0x61, 0x90, 0x44,
  0x13, 0x0C, 0xC3, 0x30, 0x88, 0x22, 0x18, 0x00, 0x30, 0x60, 0x06, 0x08,
  0x00, 0x83, 0x00, 0x10, 0x60, 0x06, 0x08, 0x00, 0xC3, 0x00, 0x10, 0x60,
  0x06, 0x08, 0x00, 0xC3, 0x00, 0x10, 0x60, 0x3F, 0xFF, 0x88, 0xC1, 0x00,
  0x10, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x00, 0x10, 0x60, 0x02, 0x0C, 0x00,
  0xC1, 0x00, 0x10, 0x60, 0x02, 0x0C, 0x00, 0xC1, 0x01, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC0, 0xC1, 0x00, 0x18, 0x20, 0x02, 0x0C, 0x00, 0xC1, 0x80, 0x18,
  0x20, 0x02, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x20, 0x03, 0x0C, 0x00, 0x41,
  0x80, 0x18, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0xFF, 0x80, 0xE4, 0x70, 0x61, 0x04, 0x18, 0x40, 0x0C, 0x30,
  0x03, 0x0C, 0x00, 0xC2, 0x00, 0x30, 0x80, 0x0C, 0x20, 0x03, 0x18, 0x00,
  0x46, 0x00, 0x19, 0x00, 0x03, 0x40, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x19, 0x80, 0x06, 0x30, 0x01, 0x0C,
  0x00, 0x43, 0x00, 0x10, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0x82, 0x00,
  0x21, 0x82, 0x08, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x1F,
  0x00, 0xC0, 0xC6, 0x03, 0x06, 0x18, 0x18, 0x18, 0x60, 0x60, 0xC1, 0x83,
  0x03, 0x06, 0x0C, 0x08, 0x18, 0x60, 0x60, 0x61, 0x81, 0x81, 0x0C, 0x06,
  0x04, 0x30, 0x10, 0x31, 0x80, 0x40, 0xC6, 0x03, 0x03, 0x30, 0x0C, 0x08,
  0xC7, 0x30, 0x66, 0x3E, 0xC1, 0x99, 0x8F, 0x04, 0xCC, 0x3C, 0x33, 0x30,
  0xD1, 0x99, 0x83, 0x7C, 0x66, 0x0C, 0xE3, 0x10, 0x30, 0x0C, 0xC0, 0xC0,
  0x63, 0x03, 0x01, 0x8C, 0x08, 0x0C, 0x20, 0x60, 0x30, 0x81, 0x81, 0x82,
  0x06, 0x06, 0x18, 0x10, 0x30, 0x60, 0xC0, 0xC1, 0x83, 0x06, 0x06, 0x18,
  0x18, 0x18, 0x60, 0xC0, 0x33, 0x03, 0x00, 0xF8, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x3F, 0x00, 0x31, 0x80, 0x18, 0x40, 0x18, 0x30, 0x0C, 0x18,
  0x06, 0x08, 0x02, 0x0C, 0x01, 0x06, 0x00, 0x83, 0x00, 0x43, 0x00, 0x21,
  0x80, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x01, 0xB0, 0x01, 0xC8, 0x00, 0xC6, 0x18, 0xC3, 0x08, 0xC1, 0x8C,
  0x60, 0x46, 0x60, 0x32, 0x30, 0x1B, 0x18, 0x0D, 0x88, 0x03, 0x8C, 0x01,
  0xC6, 0x00, 0xC3, 0x00, 0xE0, 0xC0, 0x58, 0x60, 0x6C, 0x38, 0xE6, 0x0F,
  0xE1, 0x00, 0x32, 0x66, 0x66, 0x4C, 0xCC, 0x88, 0x00, 0x18, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x20, 0x02, 0x08, 0x60, 0xE6, 0x03, 0xCF, 0x0F,
  0x80, 0xE0, 0x12, 0x06, 0x30, 0xC1, 0x08, 0x18, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x30, 0xC6,
  0x18, 0x43, 0x08, 0x61, 0x0C, 0x00, 0xFF, 0xFF, 0xF0, 0x5F, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0xFC, 0x01, 0x86, 0x03, 0x06, 0x03, 0x03, 0x06, 0x03,
  0x04, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10, 0x03,
  0x30, 0x03, 0x30, 0x02, 0x30, 0x06, 0x20, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x0C, 0x40, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x08,
  0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x10, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x60,
  0xC0, 0x60, 0xC0, 0xC0, 0x61, 0x80, 0x73, 0x80, 0x3E, 0x00, 0x03, 0x83,
  0xC3, 0x63, 0x23, 0x37, 0x19, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40,
  0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60,
  0x00, 0x00, 0x1E, 0x00, 0x1F, 0xF0, 0x07, 0x07, 0x00, 0x40, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x38, 0x38, 0x04, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x80, 0x70, 0x30, 0x38, 0x0F, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0B, 0x00, 0x06, 0x80, 0x01, 0x60,
  0x00, 0xD8, 0x00, 0x66, 0x00, 0x11, 0x00, 0x0C, 0x40, 0x02, 0x30, 0x01,
  0x8C, 0x00, 0xC3, 0x00, 0x20, 0x80, 0x18, 0x60, 0x0C, 0x18, 0x03, 0x06,
  0x01, 0x81, 0x80, 0x40, 0x40, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x00, 0x80, 0x80, 0x60, 0x60, 0x18, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xC0, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x82, 0x01, 0xC0, 0xE1, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x3F, 0xC0, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xCF, 0x80, 0x4F, 0xF0, 0x6C, 0x18, 0x3C, 0x06,
  0x1C, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xC7, 0x00, 0x63, 0x00, 0x31, 0x80,
  0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x02, 0x18, 0x03, 0x0C, 0x01, 0x86,
  0x00, 0xC3, 0x00, 0xC0, 0x80, 0xE0, 0x60, 0x60, 0x18, 0xE0, 0x0F, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xC0, 0x1C, 0x18, 0x06, 0x03, 0x03,
  0x00, 0xC0, 0x80, 0x10, 0x60, 0x04, 0x18, 0x01, 0x06, 0x00, 0xC1, 0x80,
  0x30, 0x60, 0x0C, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x18, 0x60,
  0x07, 0x70, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3B, 0x00, 0x18, 0x60, 0x1C,
  0x0C, 0x06, 0x03, 0x03, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01,
  0x84, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x86, 0x00, 0x41,
  0x80, 0x30, 0x30, 0x18, 0x0F, 0x1C, 0x00, 0xFE, 0x00, 0x00, 0x38, 0x00,
  0x7F, 0x00, 0xE1, 0x80, 0x60, 0x60, 0x60, 0x30, 0x20, 0x08, 0x30, 0x06,
  0x18, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80,
  0x10, 0x80, 0x18, 0x40, 0x0C, 0x20, 0x06, 0x18, 0x07, 0x0C, 0x03, 0x86,
  0x02, 0xC1, 0x87, 0x40, 0xFE, 0x60, 0x1C, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x43, 0xC0, 0x3F, 0x80, 0x00,
  0x07, 0x06, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0,
  0xC0, 0x01, 0xC0, 0x70, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0x80,
  0x60, 0x10, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x10, 0x00, 0x00, 0x03, 0x80, 0x7F, 0x86,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x70, 0x70, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x20, 0x18, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x80,
  0x00, 0x83, 0x00, 0x01, 0x0C, 0x00, 0x02, 0x18, 0x0F, 0x04, 0x60, 0x7F,
  0x08, 0xC1, 0x84, 0x11, 0x02, 0x08, 0x26, 0x0C, 0x30, 0x4C, 0x10, 0x61,
  0x90, 0x60, 0x83, 0x20, 0x81, 0x06, 0xC3, 0x06, 0x0D, 0x86, 0x0C, 0x12,
  0x08, 0x10, 0x64, 0x10, 0x60, 0xC8, 0x60, 0xC1, 0x30, 0xC1, 0x86, 0x61,
  0x87, 0x0C, 0xC3, 0x0C, 0x11, 0x86, 0x3C, 0x63, 0x04, 0x59, 0x86, 0x0F,
  0x1E, 0x0C, 0x04, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC3, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x05, 0x00, 0x0D, 0x00, 0x0D, 0x00, 0x1B, 0x00, 0x1B, 0x00, 0x13, 0x00,
  0x33, 0x00, 0x33, 0x00, 0x63, 0x00, 0x63, 0x00, 0x43, 0x00, 0xC3, 0x00,
  0xC3, 0x01, 0x83, 0x01, 0x83, 0x01, 0x03, 0x03, 0x03, 0x03, 0xFF, 0x07,
  0xFF, 0x06, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x18, 0x03, 0x18,
  0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x60, 0x03, 0x60, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x01, 0xFF, 0x00, 0x30, 0xF0, 0x06, 0x03, 0x00, 0x80,
  0x60, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x06, 0x00,
  0x40, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0x40, 0x18, 0x18, 0x06,
  0x03, 0x03, 0x80, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0x01, 0x80, 0x60, 0x18,
  0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06, 0x04, 0x00, 0xC1, 0x80, 0x18,
  0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x08, 0x30, 0x03, 0x06, 0x00, 0x60,
  0xC0, 0x18, 0x18, 0x07, 0x02, 0x01, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x1F, 0xF0, 0x0E, 0x04, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x18, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x31, 0xF0,
  0x06, 0x07, 0x00, 0x80, 0x60, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18,
  0x18, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30,
  0x40, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x61,
  0x00, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x84,
  0x00, 0x61, 0x80, 0x0C, 0x30, 0x03, 0x86, 0x00, 0x60, 0x80, 0x18, 0x30,
  0x03, 0x06, 0x00, 0xC0, 0xC0, 0x38, 0x18, 0x0E, 0x02, 0x07, 0x80, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0xFF, 0x80, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0x80,
  0x38, 0x0E, 0x03, 0x80, 0x10, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x07, 0xF1, 0x80, 0x3F, 0x8C, 0x00,
  0x08, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86,
  0x00, 0x08, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01,
  0x81, 0x80, 0x08, 0x0C, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xE0, 0xF0, 0x03,
  0xFF, 0x00, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x40,
  0x02, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x06,
  0x06, 0x00, 0x10, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x04,
  0x00, 0x30, 0x30, 0x00, 0x80, 0xC0, 0x06, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x20, 0x01, 0x81, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0,
  0x60, 0x03, 0x01, 0x00, 0x08, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0,
  0x06, 0x02, 0x00, 0x18, 0x18, 0x00, 0x40, 0x60, 0x03, 0x01, 0x80, 0x0C,
  0x06, 0x00, 0x30, 0x10, 0x00, 0xC0, 0xC0, 0x02, 0x03, 0x00, 0x18, 0x00,
  0x01, 0xFE, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x01, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x8E, 0x00, 0xFC, 0x00, 0x01, 0x80, 0x38, 0x0C, 0x03, 0x00, 0x60, 0x18,
  0x02, 0x01, 0x80, 0x30, 0x18, 0x01, 0x81, 0xC0, 0x0C, 0x0C, 0x00, 0x60,
  0xC0, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x86, 0x00, 0x0C, 0x60, 0x00,
  0x46, 0x00, 0x06, 0x30, 0x00, 0x33, 0x00, 0x01, 0xB8, 0x00, 0x0F, 0xC0,
  0x00, 0x56, 0x00, 0x07, 0x10, 0x00, 0x38, 0xC0, 0x01, 0x86, 0x00, 0x0C,
  0x30, 0x00, 0x41, 0x80, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80,
  0x08, 0x0C, 0x00, 0xC0, 0x20, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x60, 0x08, 0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0xD8, 0x0D, 0x00, 0x03, 0x40, 0x34, 0x00, 0x0B, 0x00,
  0x90, 0x00, 0x6C, 0x06, 0x40, 0x01, 0x30, 0x19, 0x00, 0x0C, 0x80, 0x64,
  0x00, 0x26, 0x01, 0x98, 0x01, 0x98, 0x04, 0x60, 0x04, 0x60, 0x31, 0x80,
  0x31, 0x80, 0xC6, 0x00, 0xC4, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x18,
  0xC0, 0x21, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x18, 0x20,
  0x18, 0x60, 0x61, 0x80, 0x41, 0x83, 0x06, 0x01, 0x06, 0x0C, 0x18, 0x0C,
  0x18, 0x60, 0x40, 0x30, 0x61, 0x83, 0x00, 0xC0, 0x8C, 0x0C, 0x02, 0x02,
  0x30, 0x30, 0x18, 0x08, 0x80, 0xC0, 0x60, 0x26, 0x02, 0x01, 0x80, 0x90,
  0x18, 0x06, 0x02, 0xC0, 0x60, 0x10, 0x0E, 0x01, 0x80, 0xC0, 0x38, 0x06,
  0x03, 0x00, 0xE0, 0x30, 0x00, 0x01, 0xC0, 0x06, 0x03, 0x80, 0x0C, 0x07,
  0x00, 0x18, 0x0A, 0x00, 0x30, 0x34, 0x00, 0x40, 0x6C, 0x01, 0x80, 0xD8,
  0x03, 0x01, 0x30, 0x06, 0x06, 0x60, 0x0C, 0x0C, 0x40, 0x10, 0x18, 0x80,
  0x60, 0x31, 0x80, 0xC0, 0x43, 0x01, 0x81, 0x86, 0x02, 0x03, 0x0C, 0x0C,
  0x06, 0x08, 0x18, 0x0C, 0x18, 0x30, 0x10, 0x30, 0x60, 0x60, 0x60, 0x80,
  0xC0, 0xC3, 0x01, 0x80, 0x86, 0x03, 0x01, 0x0C, 0x04, 0x03, 0x18, 0x18,
  0x06, 0x20, 0x30, 0x0C, 0xC0, 0x60, 0x19, 0x80, 0x80, 0x13, 0x03, 0x00,
  0x34, 0x06, 0x00, 0x68, 0x0C, 0x00, 0xF0, 0x18, 0x01, 0xE0, 0x20, 0x01,
  0xC0, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xF0,
  0x07, 0x06, 0x01, 0xC0, 0x60, 0x30, 0x0C, 0x0C, 0x00, 0xC3, 0x00, 0x18,
  0x60, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x33,
  0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x02, 0x60, 0x00, 0xC8,
  0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x09, 0x80, 0x03, 0x30,
  0x00, 0x66, 0x00, 0x0C, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60,
  0x03, 0x0C, 0x00, 0x61, 0x80, 0x18, 0x30, 0x07, 0x06, 0x00, 0xC0, 0x60,
  0x30, 0x0F, 0x1C, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x67, 0xC0,
  0x18, 0x18, 0x04, 0x07, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C,
  0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x04, 0x01,
  0x83, 0x00, 0x60, 0xC0, 0x30, 0x30, 0x1C, 0x0C, 0x0E, 0x02, 0x0F, 0x01,
  0xFF, 0x00, 0x7E, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x07, 0x06, 0x01, 0xC0, 0x60, 0x30, 0x0C,
  0x0C, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C,
  0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B,
  0x00, 0x02, 0x60, 0x00, 0xC8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C,
  0x00, 0x09, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x03, 0x18,
  0x00, 0x63, 0x00, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x18, 0x30,
  0x07, 0x06, 0x00, 0xC0, 0x60, 0x30, 0x0F, 0x1C, 0x00, 0x7F, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x63, 0xC0,
  0x18, 0x18, 0x04, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C,
  0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x06, 0x04, 0x01,
  0x83, 0x00, 0x60, 0xC0, 0x30, 0x30, 0x18, 0x0C, 0x0E, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x02, 0x00, 0xC0,
  0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10,
  0x18, 0x06, 0x06, 0x01, 0x81, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x00,
  0x00, 0x1E, 0x00, 0x1F, 0xFC, 0x07, 0x03, 0x81, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x80, 0x38, 0x1C, 0x1E, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x03, 0x00, 0x18, 0x18, 0x00, 0x80, 0x80, 0x0C,
  0x0C, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0x81, 0x80,
  0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x10, 0x10, 0x01, 0x81,
  0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x10, 0x10, 0x01,
  0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x02, 0x03, 0x00, 0x30, 0x30,
  0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x02, 0x03, 0x00, 0x30,
  0x10, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0xC0, 0x20, 0x06, 0x01, 0x80,
  0x60, 0x0C, 0x07, 0x00, 0x38, 0x70, 0x00, 0xFF, 0x00, 0x00, 0xC0, 0x01,
  0xE0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x23, 0x00,
  0x31, 0x80, 0x18, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x0C, 0x18, 0x06, 0x0C,
  0x03, 0x06, 0x03, 0x03, 0x01, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0xC0,
  0x30, 0x60, 0x18, 0x30, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x18, 0x01, 0x8C,
  0x00, 0xC4, 0x00, 0x66, 0x00, 0x33, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x0D, 0x80, 0x0C, 0x00, 0x66, 0x00, 0x30, 0x01, 0x98, 0x01,
  0xC0, 0x0C, 0x60, 0x05, 0x00, 0x31, 0x80, 0x34, 0x00, 0x86, 0x00, 0xD0,
  0x06, 0x18, 0x02, 0x40, 0x18, 0x60, 0x1B, 0x00, 0xC1, 0x80, 0x4C, 0x03,
  0x06, 0x03, 0x30, 0x08, 0x18, 0x0C, 0xC0, 0x60, 0x60, 0x23, 0x01, 0x81,
  0x81, 0x8C, 0x0C, 0x06, 0x04, 0x30, 0x30, 0x18, 0x30, 0xC0, 0x80, 0x60,
  0xC3, 0x06, 0x01, 0x02, 0x0C, 0x18, 0x04, 0x18, 0x30, 0xC0, 0x10, 0x60,
  0xC3, 0x00, 0x43, 0x03, 0x08, 0x01, 0x0C, 0x0C, 0x60, 0x04, 0x20, 0x31,
  0x80, 0x11, 0x80, 0xCC, 0x00, 0x46, 0x03, 0x30, 0x01, 0x30, 0x0C, 0x80,
  0x04, 0xC0, 0x26, 0x00, 0x12, 0x00, 0x98, 0x00, 0x58, 0x02, 0xC0, 0x01,
  0x60, 0x0B, 0x00, 0x05, 0x00, 0x28, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70,
  0x03, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x1C, 0x01, 0x80,
  0x60, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x81, 0x00,
  0x06, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x21, 0x80, 0x00, 0x8C, 0x00, 0x03,
  0x30, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x36, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x60, 0x00, 0x18, 0x80, 0x00, 0xC2,
  0x00, 0x02, 0x08, 0x00, 0x18, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00,
  0x18, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x30, 0x00, 0x60, 0x07, 0x60, 0x06, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x18, 0x20, 0x18, 0x20, 0x30, 0x20, 0x30, 0x20, 0x60, 0x30,
  0x60, 0x30, 0xC0, 0x30, 0xC0, 0x31, 0x80, 0x31, 0x00, 0x33, 0x00, 0x32,
  0x00, 0x16, 0x00, 0x14, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x10, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xC1, 0x83, 0x06, 0x04,
  0x08, 0x18, 0x30, 0x60, 0xC1, 0x81, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0x40, 0x81, 0x83, 0x06, 0x0C, 0x18, 0x10, 0x20, 0x60, 0xC1, 0x83, 0x06,
  0x04, 0x0C, 0x00, 0x7F, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0B, 0x00, 0x06, 0xC0, 0x03, 0x10, 0x00, 0xC6, 0x00, 0x61, 0x80,
  0x18, 0x30, 0x0C, 0x0C, 0x03, 0x01, 0x81, 0x80, 0x60, 0x60, 0x08, 0x30,
  0x03, 0x0C, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC6, 0x18, 0xC2, 0x18, 0x41, 0x00, 0x70, 0x00, 0xFE,
  0x40, 0xC3, 0x60, 0xC0, 0xB0, 0xC0, 0x30, 0x60, 0x18, 0x60, 0x0C, 0x30,
  0x06, 0x30, 0x03, 0x18, 0x01, 0x08, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63,
  0x00, 0x31, 0x80, 0x10, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x06,
  0x18, 0x03, 0x0C, 0x03, 0x86, 0x01, 0xC1, 0x81, 0xE0, 0xC0, 0xA0, 0x71,
  0x90, 0x1F, 0x98, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x87, 0x00, 0xCF, 0xE0, 0x6C, 0x30, 0x3C, 0x0C, 0x14, 0x06,
  0x0C, 0x03, 0x0E, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x31, 0x80,
  0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x02, 0x10, 0x03, 0x18, 0x01, 0x8C,
  0x00, 0xC6, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x31, 0xC0, 0x30, 0xE0, 0x18,
  0x70, 0x18, 0x2C, 0x18, 0x17, 0x18, 0x19, 0xF8, 0x00, 0x00, 0x78, 0x07,
  0xF0, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x80, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x71, 0x80, 0x1F,
  0x98, 0x03, 0x0D, 0x80, 0x60, 0x58, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18,
  0x03, 0x01, 0x80, 0x30, 0x30, 0x03, 0x03, 0x00, 0x60, 0x20, 0x06, 0x06,
  0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x04, 0x04, 0x00, 0xC0,
  0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x38,
  0x0C, 0x03, 0x80, 0x60, 0x78, 0x06, 0x0D, 0x00, 0x71, 0x90, 0x03, 0xF3,
  0x00, 0x00, 0x70, 0x07, 0xF0, 0x30, 0xC1, 0x83, 0x0C, 0x04, 0x60, 0x11,
  0x80, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x66, 0x03, 0x18, 0x38, 0x7F, 0xC1,
  0xF8, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x60, 0x7F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x07, 0xF8, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x1F, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0F,
  0xE4, 0x03, 0x0D, 0x80, 0xC0, 0xB0, 0x30, 0x0C, 0x06, 0x01, 0x81, 0x80,
  0x30, 0x30, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x30, 0x20, 0x06, 0x0C, 0x00,
  0xC1, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0xC0, 0x80, 0x18, 0x30, 0x03,
  0x06, 0x00, 0x60, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0xE0, 0x60, 0x1C,
  0x06, 0x07, 0x80, 0xC1, 0xA0, 0x1C, 0x6C, 0x01, 0xF9, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x02, 0x01, 0x80, 0x60, 0xE0, 0x0F, 0xF8, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x1C, 0x06, 0x7E, 0x06, 0x83, 0x07, 0x03, 0x07, 0x03, 0x06, 0x03, 0x0E,
  0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x08, 0x02, 0x18, 0x06, 0x18,
  0x06, 0x18, 0x06, 0x10, 0x04, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30,
  0x0C, 0x20, 0x08, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0x40,
  0x10, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02,
  0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0x60, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xF8, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x20, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x18, 0x30, 0x08, 0x30,
  0x0C, 0x30, 0x06, 0x18, 0x03, 0x18, 0x01, 0x18, 0x01, 0x98, 0x00, 0xDC,
  0x00, 0x6B, 0x00, 0x3D, 0x80, 0x1C, 0xC0, 0x1C, 0x60, 0x0C, 0x30, 0x06,
  0x08, 0x03, 0x06, 0x01, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60,
  0x20, 0x10, 0x30, 0x0C, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x20, 0x18, 0x06,
  0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60,
  0x10, 0x0C, 0x03, 0x00, 0x00, 0x3C, 0x1E, 0x03, 0x7F, 0x1F, 0x81, 0xE1,
  0xD0, 0x60, 0xE0, 0x70, 0x30, 0x60, 0x38, 0x08, 0x30, 0x18, 0x04, 0x30,
  0x0C, 0x06, 0x18, 0x06, 0x03, 0x0C, 0x02, 0x01, 0x86, 0x03, 0x00, 0xC6,
  0x01, 0x80, 0x43, 0x00, 0xC0, 0x61, 0x80, 0x60, 0x30, 0xC0, 0x60, 0x18,
  0x40, 0x30, 0x0C, 0x60, 0x18, 0x04, 0x30, 0x0C, 0x06, 0x18, 0x04, 0x03,
  0x0C, 0x06, 0x01, 0x84, 0x03, 0x00, 0x86, 0x01, 0x80, 0xC3, 0x00, 0xC0,
  0x61, 0x80, 0x40, 0x30, 0xC0, 0x60, 0x18, 0x40, 0x30, 0x08, 0x60, 0x18,
  0x0C, 0x00, 0x00, 0x3C, 0x06, 0x7E, 0x06, 0x83, 0x07, 0x03, 0x07, 0x03,
  0x06, 0x03, 0x0E, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x02, 0x18, 0x06,
  0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x10, 0x04, 0x30, 0x0C, 0x30, 0x0C,
  0x30, 0x0C, 0x30, 0x0C, 0x20, 0x08, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18,
  0x60, 0x18, 0x40, 0x10, 0xC0, 0x30, 0x00, 0xF0, 0x07, 0xF8, 0x1C, 0x30,
  0x30, 0x30, 0xC0, 0x63, 0x00, 0xC6, 0x00, 0x98, 0x01, 0x30, 0x02, 0x60,
  0x0C, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xA0, 0x02,
  0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x26, 0x00, 0xCC, 0x01, 0x98, 0x06, 0x18,
  0x0C, 0x30, 0x30, 0x71, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0x00, 0x33, 0xF0,
  0x06, 0xC3, 0x00, 0xF0, 0x30, 0x14, 0x06, 0x03, 0x00, 0xC0, 0xE0, 0x18,
  0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x08, 0x01, 0x83, 0x00, 0x30,
  0x60, 0x06, 0x0C, 0x00, 0x81, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC1,
  0x80, 0x10, 0x30, 0x06, 0x06, 0x00, 0xC1, 0xC0, 0x30, 0x38, 0x06, 0x07,
  0x01, 0x80, 0xE0, 0x60, 0x13, 0x18, 0x06, 0x7E, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0xFE, 0x40, 0xC3, 0x60, 0xC0, 0xF0, 0xC0, 0x70, 0x40, 0x18,
  0x60, 0x0C, 0x30, 0x06, 0x30, 0x03, 0x18, 0x01, 0x0C, 0x01, 0x8C, 0x00,
  0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x10, 0x80, 0x18, 0xC0, 0x0C, 0x60,
  0x06, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x03, 0x86, 0x01, 0xC1, 0x81, 0xE0,
  0xC1, 0xA0, 0x71, 0xB0, 0x1F, 0x98, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x19, 0xE0, 0x6C, 0x01,
  0x40, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xFC, 0x18, 0x10, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x40,
  0x70, 0xE1, 0xC1, 0xFF, 0x00, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60,
  0xFE, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0xE0, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x08, 0x02,
  0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x10, 0x04, 0x30, 0x0C,
  0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x20, 0x08, 0x60, 0x18, 0x60, 0x18,
  0x60, 0x18, 0x60, 0x18, 0x40, 0x30, 0xC0, 0x30, 0xC0, 0x70, 0xC0, 0x70,
  0xC0, 0xA0, 0x63, 0xA0, 0x7E, 0x20, 0x80, 0x1C, 0x01, 0xA0, 0x0D, 0x00,
  0x48, 0x06, 0x40, 0x22, 0x03, 0x10, 0x18, 0x81, 0x84, 0x0C, 0x20, 0xC1,
  0x06, 0x0C, 0x20, 0x63, 0x03, 0x18, 0x19, 0x80, 0xCC, 0x06, 0xC0, 0x36,
  0x01, 0xA0, 0x0F, 0x00, 0x50, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x00, 0xC0,
  0x30, 0x0F, 0x00, 0xC0, 0x2C, 0x07, 0x01, 0xB0, 0x14, 0x06, 0xC0, 0xD0,
  0x33, 0x03, 0x40, 0xCC, 0x09, 0x02, 0x30, 0x64, 0x18, 0xC1, 0x10, 0x63,
  0x0C, 0x41, 0x0C, 0x33, 0x0C, 0x30, 0x8C, 0x20, 0xC6, 0x31, 0x83, 0x10,
  0xC6, 0x0C, 0xC3, 0x10, 0x23, 0x0C, 0xC0, 0x98, 0x32, 0x02, 0x60, 0xD8,
  0x09, 0x03, 0x60, 0x2C, 0x0D, 0x00, 0xB0, 0x3C, 0x02, 0x80, 0xE0, 0x0E,
  0x03, 0x80, 0x30, 0x0E, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x01, 0xC0, 0xC0,
  0x60, 0x30, 0x30, 0x04, 0x08, 0x01, 0x06, 0x00, 0x63, 0x00, 0x18, 0xC0,
  0x06, 0x60, 0x00, 0x90, 0x00, 0x2C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x06, 0x60, 0x01, 0x08,
  0x00, 0xC2, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x0C, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x40, 0xC0, 0x18, 0x00, 0x00, 0x40, 0x0C, 0x01, 0x00, 0x60, 0x04,
  0x01, 0x80, 0x10, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0x80, 0x06, 0x06,
  0x00, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x60, 0x00, 0x61, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x20, 0x00, 0x19,
  0x80, 0x00, 0x66, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x0F,
  0x80, 0x0F, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0xBC, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x1F, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0xF8, 0x00, 0x80, 0x00, 0x7E, 0x01, 0xFF, 0x81, 0x81, 0xEF, 0x80,
  0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 34, 10, 1, -34 },
  { 40, 10, 12, 13, 5, -34 },
  { 55, 19, 34, 18, 0, -34 },
  { 136, 18, 39, 17, 0, -36 },
  { 224, 22, 36, 26, 2, -35 },
  { 323, 17, 35, 17, -1, -35 },
  { 398, 4, 12, 7, 5, -34 },
  { 404, 13, 42, 12, 1, -34 },
  { 473, 13, 42, 12, -3, -34 },
  { 542, 12, 13, 16, 6, -36 },
  { 562, 17, 22, 19, 1, -28 },
  { 609, 6, 11, 8, -2, -5 },
  { 618, 10, 2, 13, 1, -14 },
  { 621, 3, 4, 8, 1, -4 },
  { 623, 20, 34, 14, -2, -34 },
  { 708, 16, 35, 17, 1, -35 },
  { 778, 9, 34, 17, 5, -34 },
  { 817, 19, 35, 17, -2, -35 },
  { 901, 18, 36, 17, -1, -35 },
  { 982, 18, 35, 17, -1, -35 },
  { 1061, 18, 34, 17, -1, -34 },
  { 1138, 17, 35, 17, 1, -35 },
  { 1213, 17, 34, 17, 2, -34 },
  { 1286, 18, 35, 17, -1, -35 },
  { 1365, 17, 35, 17, 0, -35 },
  { 1440, 8, 25, 8, 0, -25 },
  { 1465, 10, 31, 8, -2, -25 },
  { 1504, 17, 20, 19, 1, -27 },
  { 1547, 17, 12, 19, 1, -23 },
  { 1573, 17, 20, 19, 1, -27 },
  { 1616, 13, 35, 12, 1, -35 },
  { 1673, 23, 38, 25, 1, -34 },
  { 1783, 16, 34, 16, -3, -34 },
  { 1851, 19, 34, 18, 0, -34 },
  { 1932, 18, 35, 17, 2, -35 },
  { 2011, 19, 34, 20, 0, -34 },
  { 2092, 18, 34, 17, 0, -34 },
  { 2169, 19, 34, 15, 0, -34 },
  { 2250, 21, 35, 22, 2, -35 },
  { 2342, 22, 34, 22, 0, -34 },
  { 2436, 15, 34, 9, -3, -34 },
  { 2500, 16, 42, 8, -7, -34 },
  { 2584, 21, 34, 17, 0, -34 },
  { 2674, 11, 34, 15, 0, -34 },
  { 2721, 30, 34, 29, 0, -34 },
  { 2849, 23, 34, 23, 0, -34 },
  { 2947, 19, 35, 22, 2, -35 },
  { 3031, 18, 34, 17, 0, -34 },
  { 3108, 19, 43, 22, 2, -35 },
  { 3211, 18, 34, 18, 0, -34 },
  { 3288, 19, 35, 17, -1, -35 },
  { 3372, 15, 34, 15, 3, -34 },
  { 3436, 21, 34, 21, 1, -34 },
  { 3526, 17, 34, 17, 4, -34 },
  { 3599, 30, 34, 29, 3, -34 },
  { 3727, 22, 34, 15, -3, -34 },
  { 3821, 16, 34, 15, 3, -34 },
  { 3889, 20, 34, 15, -2, -34 },
  { 3974, 17, 42, 13, -1, -34 },
  { 4064, 7, 34, 16, 5, -34 },
  { 4094, 17, 42, 13, -3, -34 },
  { 4184, 18, 17, 19, 1, -34 },
  { 4223, 13, 2, 13, -4, 4 },
  { 4227, 5, 8, 10, 7, -37 },
  { 4232, 17, 26, 19, 1, -26 },
  { 4288, 17, 36, 18, 0, -36 },
  { 4365, 14, 26, 13, 1, -26 },
  { 4411, 20, 36, 19, 1, -36 },
  { 4501, 14, 26, 16, 1, -26 },
  { 4547, 21, 49, 9, -6, -37 },
  { 4676, 19, 38, 19, -1, -26 },
  { 4767, 16, 36, 18, 0, -36 },
  { 4839, 9, 34, 8, 0, -34 },
  { 4878, 16, 46, 8, -6, -34 },
  { 4970, 17, 36, 15, 0, -36 },
  { 5047, 10, 36, 8, 0, -36 },
  { 5092, 25, 26, 27, 0, -26 },
  { 5174, 16, 26, 18, 0, -26 },
  { 5226, 15, 26, 18, 1, -26 },
  { 5275, 19, 37, 18, -2, -26 },
  { 5363, 17, 37, 19, 1, -26 },
  { 5442, 14, 26, 12, 0, -26 },
  { 5488, 15, 26, 14, -1, -26 },
  { 5537, 9, 31, 9, 1, -31 },
  { 5572, 16, 25, 18, 1, -25 },
  { 5622, 13, 25, 14, 3, -25 },
  { 5663, 22, 25, 23, 3, -25 },
  { 5732, 18, 25, 14, -2, -25 },
  { 5789, 22, 37, 15, -5, -25 },
  { 5891, 15, 25, 12, -2, -25 },
  { 5938, 17, 42, 15, 1, -34 },
  { 6028, 2, 49, 17, 7, -37 },
  { 6041, 16, 42, 15, -3, -34 },
  { 6125, 16, 4, 19, 2, -19 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC48PT7B_H_
