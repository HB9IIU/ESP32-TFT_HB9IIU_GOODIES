#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC15PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x94, 0x92, 0x02, 0x00, 0x55, 0xAA, 0x14, 0x52, 0x9F, 0x29,
  0x25, 0x3E, 0x52, 0x8A, 0x00, 0x10, 0xF5, 0x14, 0x50, 0x83, 0x0A, 0x2B,
  0x46, 0x10, 0x66, 0x9A, 0xAA, 0xB7, 0x7F, 0x4D, 0x55, 0x59, 0x80, 0x11,
  0x4A, 0x62, 0x11, 0xB5, 0x94, 0xBC, 0x5A, 0x08, 0x88, 0x44, 0x22, 0x10,
  0x84, 0x21, 0x04, 0x00, 0x11, 0x11, 0x11, 0x11, 0x12, 0x24, 0x80, 0x4F,
  0xC2, 0x10, 0x41, 0x3F, 0x10, 0x41, 0x00, 0x58, 0xF0, 0x80, 0x02, 0x08,
  0x10, 0x40, 0x82, 0x08, 0x10, 0x40, 0x82, 0x00, 0x19, 0x52, 0x94, 0xC6,
  0x31, 0x94, 0x98, 0x7D, 0x5A, 0xA8, 0x1C, 0x10, 0x41, 0x04, 0x20, 0x84,
  0x21, 0x0F, 0x80, 0x38, 0x42, 0x10, 0x98, 0x42, 0x10, 0xB8, 0x08, 0x46,
  0x52, 0xA9, 0x52, 0xF8, 0x88, 0x39, 0x10, 0x86, 0x08, 0x21, 0x08, 0xB8,
  0x1C, 0x84, 0x10, 0x71, 0x28, 0xA2, 0x8A, 0x47, 0x00, 0xF8, 0x44, 0x22,
  0x11, 0x08, 0x84, 0x20, 0x3A, 0x52, 0x93, 0x91, 0x51, 0x8C, 0xBC, 0x3A,
  0x52, 0x94, 0xA5, 0xE1, 0x10, 0xB8, 0x40, 0x02, 0x20, 0x00, 0x02, 0x50,
  0x0C, 0xCC, 0x18, 0x18, 0x10, 0xFC, 0x00, 0x3F, 0xE0, 0x60, 0x46, 0x62,
  0x00, 0x71, 0x11, 0x22, 0x44, 0x00, 0x80, 0x0E, 0x11, 0x21, 0x4D, 0x55,
  0x65, 0xAA, 0xAA, 0xAA, 0x94, 0x80, 0x70, 0x08, 0x46, 0x32, 0x94, 0xE9,
  0x4C, 0x62, 0x38, 0x92, 0x51, 0x49, 0xC4, 0x92, 0x8A, 0x2F, 0x00, 0x3A,
  0x11, 0x08, 0x42, 0x10, 0x84, 0x38, 0x38, 0x92, 0x51, 0x45, 0x14, 0x51,
  0x8A, 0x4E, 0x00, 0x3C, 0x82, 0x10, 0x41, 0xE4, 0x10, 0x82, 0x0F, 0x00,
  0x3C, 0x82, 0x10, 0x41, 0xC4, 0x10, 0x82, 0x08, 0x00, 0x3D, 0x04, 0x20,
  0x82, 0x48, 0xA2, 0x8A, 0x2F, 0x00, 0x22, 0x44, 0x8A, 0x24, 0x4F, 0x91,
  0x22, 0x89, 0x12, 0x20, 0x38, 0x84, 0x42, 0x10, 0x84, 0x42, 0x38, 0x08,
  0x42, 0x21, 0x08, 0x42, 0x21, 0x08, 0x44, 0x40, 0x24, 0x92, 0x94, 0x51,
  0x85, 0x14, 0x92, 0x49, 0x00, 0x24, 0xA4, 0x92, 0x93, 0x80, 0x20, 0x90,
  0x48, 0x6C, 0x35, 0x2A, 0x99, 0x54, 0xAA, 0x99, 0x4D, 0x24, 0x80, 0x22,
  0x44, 0x8A, 0x95, 0x2A, 0x95, 0x26, 0x8D, 0x12, 0x20, 0x39, 0x14, 0x61,
  0x86, 0x28, 0xA2, 0x8A, 0x4E, 0x00, 0x38, 0x92, 0x51, 0x49, 0x27, 0x10,
  0x82, 0x08, 0x00, 0x39, 0x14, 0x61, 0x86, 0x18, 0xA2, 0x8A, 0x4E, 0x08,
  0x20, 0x80, 0x38, 0x92, 0x51, 0x49, 0x27, 0x14, 0x92, 0x49, 0x00, 0x3D,
  0x04, 0x10, 0x40, 0x81, 0x04, 0x10, 0x4E, 0x00, 0xF9, 0x08, 0x84, 0x21,
  0x10, 0x84, 0x20, 0x22, 0x44, 0x8A, 0x24, 0x48, 0x91, 0x44, 0x89, 0x11,
  0xC0, 0x86, 0x28, 0xA4, 0x92, 0x4A, 0x28, 0xC3, 0x08, 0x00, 0x88, 0xC4,
  0x62, 0x33, 0x29, 0x95, 0x52, 0xA9, 0x94, 0xCC, 0x46, 0x22, 0x00, 0x12,
  0x28, 0x50, 0xC1, 0x82, 0x0C, 0x18, 0x48, 0x92, 0x20, 0x8C, 0xA5, 0x4A,
  0x61, 0x10, 0x84, 0x20, 0x1E, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0x40,
  0x83, 0xE0, 0x39, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x0C, 0x00, 0xAA,
  0xAA, 0x94, 0x18, 0x42, 0x10, 0x84, 0x42, 0x10, 0x88, 0x4E, 0x00, 0x10,
  0x42, 0x92, 0x46, 0x10, 0xF0, 0x90, 0x3D, 0x24, 0x92, 0x8A, 0x29, 0x1C,
  0x21, 0x08, 0xF4, 0xA5, 0x29, 0x8C, 0x7C, 0x3A, 0x11, 0x08, 0x42, 0x0E,
  0x04, 0x10, 0x4F, 0x49, 0x24, 0xA2, 0x8A, 0x47, 0x00, 0x3A, 0x53, 0x6C,
  0x42, 0x0E, 0x0E, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81,
  0x02, 0x08, 0x20, 0x00, 0x3D, 0x24, 0x92, 0x8A, 0x29, 0x1C, 0x10, 0x42,
  0x30, 0x21, 0x08, 0xF4, 0xA5, 0x29, 0x94, 0xA4, 0x20, 0x24, 0x92, 0x92,
  0x00, 0x08, 0x00, 0x11, 0x08, 0x42, 0x21, 0x08, 0x42, 0x22, 0x00, 0x21,
  0x08, 0x95, 0x29, 0x8C, 0xA4, 0xA4, 0x24, 0xA4, 0x92, 0x92, 0x00, 0x3F,
  0x49, 0x49, 0x49, 0x49, 0x92, 0x92, 0x92, 0x7A, 0x52, 0x94, 0xCA, 0x52,
  0x3A, 0x53, 0x18, 0xC6, 0x4E, 0x3C, 0x92, 0x49, 0x25, 0x14, 0x5E, 0x41,
  0x08, 0x00, 0x3D, 0x24, 0x92, 0x8A, 0x29, 0x1C, 0x10, 0x41, 0x04, 0x74,
  0x44, 0x48, 0x88, 0x74, 0x44, 0x22, 0x2E, 0x25, 0xA4, 0xA4, 0x98, 0x4A,
  0x52, 0x94, 0xCA, 0x5E, 0x99, 0xAA, 0xCC, 0x88, 0x93, 0x2A, 0xD5, 0xAD,
  0x93, 0x24, 0x48, 0x24, 0xA2, 0x84, 0x10, 0xC5, 0x24, 0x12, 0x24, 0x50,
  0xA1, 0x43, 0x04, 0x08, 0x10, 0x40, 0x86, 0x00, 0x38, 0x44, 0x22, 0x21,
  0x1E, 0x0C, 0x41, 0x08, 0x20, 0x84, 0x30, 0x41, 0x04, 0x10, 0x60, 0xFF,
  0xFE, 0x10, 0x42, 0x11, 0x08, 0x22, 0x21, 0x08, 0x4C, 0x00, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 11, 3, 0, -11 },
  { 6, 4, 4, 4, 1, -11 },
  { 8, 6, 11, 6, 0, -11 },
  { 17, 6, 12, 5, 0, -11 },
  { 26, 6, 11, 8, 1, -11 },
  { 35, 5, 11, 5, 0, -11 },
  { 42, 2, 4, 2, 1, -11 },
  { 43, 5, 13, 4, 0, -11 },
  { 52, 4, 13, 4, -1, -11 },
  { 59, 4, 4, 5, 2, -11 },
  { 61, 6, 7, 6, 0, -9 },
  { 67, 2, 3, 2, -1, -1 },
  { 68, 4, 1, 4, 0, -5 },
  { 69, 1, 1, 2, 0, -1 },
  { 70, 7, 11, 5, -1, -11 },
  { 80, 5, 11, 5, 0, -11 },
  { 87, 2, 11, 5, 2, -11 },
  { 90, 6, 11, 5, -1, -11 },
  { 99, 5, 11, 5, 0, -11 },
  { 106, 5, 11, 5, 0, -11 },
  { 113, 5, 11, 5, 0, -11 },
  { 120, 6, 11, 5, 0, -11 },
  { 129, 5, 11, 5, 1, -11 },
  { 136, 5, 11, 5, 0, -11 },
  { 143, 5, 11, 5, 0, -11 },
  { 150, 2, 8, 2, 0, -8 },
  { 152, 3, 10, 2, -1, -8 },
  { 156, 6, 6, 6, 0, -8 },
  { 161, 6, 4, 6, 0, -7 },
  { 164, 6, 6, 6, 0, -8 },
  { 169, 4, 11, 4, 0, -11 },
  { 175, 8, 12, 8, 0, -11 },
  { 187, 5, 11, 5, -1, -11 },
  { 194, 6, 11, 6, 0, -11 },
  { 203, 5, 11, 5, 1, -11 },
  { 210, 6, 11, 6, 0, -11 },
  { 219, 6, 11, 5, 0, -11 },
  { 228, 6, 11, 5, 0, -11 },
  { 237, 6, 11, 7, 1, -11 },
  { 246, 7, 11, 7, 0, -11 },
  { 256, 5, 11, 3, -1, -11 },
  { 263, 5, 14, 2, -2, -11 },
  { 272, 6, 11, 5, 0, -11 },
  { 281, 3, 11, 5, 0, -11 },
  { 286, 9, 11, 9, 0, -11 },
  { 299, 7, 11, 7, 0, -11 },
  { 309, 6, 11, 7, 1, -11 },
  { 318, 6, 11, 5, 0, -11 },
  { 327, 6, 14, 7, 1, -11 },
  { 338, 6, 11, 6, 0, -11 },
  { 347, 6, 11, 5, 0, -11 },
  { 356, 5, 11, 5, 1, -11 },
  { 363, 7, 11, 7, 0, -11 },
  { 373, 6, 11, 5, 1, -11 },
  { 382, 9, 11, 9, 1, -11 },
  { 395, 7, 11, 5, -1, -11 },
  { 405, 5, 11, 5, 1, -11 },
  { 412, 7, 11, 5, -1, -11 },
  { 422, 5, 13, 4, 0, -11 },
  { 431, 2, 11, 5, 2, -11 },
  { 434, 5, 13, 4, -1, -11 },
  { 443, 6, 6, 6, 0, -11 },
  { 448, 4, 1, 4, -1, 1 },
  { 449, 2, 2, 3, 2, -11 },
  { 450, 6, 8, 6, 0, -8 },
  { 456, 5, 11, 6, 0, -11 },
  { 463, 5, 8, 4, 0, -8 },
  { 468, 6, 11, 6, 0, -11 },
  { 477, 5, 8, 5, 0, -8 },
  { 482, 7, 15, 3, -2, -11 },
  { 496, 6, 12, 6, 0, -8 },
  { 505, 5, 11, 6, 0, -11 },
  { 512, 3, 11, 2, 0, -11 },
  { 517, 5, 15, 3, -2, -11 },
  { 527, 5, 11, 5, 0, -11 },
  { 534, 3, 11, 2, 0, -11 },
  { 539, 8, 8, 8, 0, -8 },
  { 547, 5, 8, 6, 0, -8 },
  { 552, 5, 8, 6, 0, -8 },
  { 557, 6, 11, 6, -1, -8 },
  { 566, 6, 12, 6, 0, -8 },
  { 575, 4, 8, 4, 0, -8 },
  { 579, 4, 8, 4, 0, -8 },
  { 583, 3, 10, 3, 0, -10 },
  { 587, 5, 8, 6, 0, -8 },
  { 592, 4, 8, 4, 1, -8 },
  { 596, 7, 8, 7, 1, -8 },
  { 603, 6, 8, 4, -1, -8 },
  { 609, 7, 12, 5, -2, -8 },
  { 620, 5, 8, 4, -1, -8 },
  { 625, 6, 13, 5, 0, -11 },
  { 635, 1, 15, 5, 2, -11 },
  { 637, 5, 13, 5, -1, -11 },
  { 646, 6, 1, 6, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC15PT7B_H_
