#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC10PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x88, 0xF0, 0x35, 0x66, 0xEC, 0xC0, 0x27, 0x44, 0x46, 0x6C,
  0x80, 0x6D, 0xA9, 0xB2, 0xB5, 0xE0, 0x6D, 0x2F, 0x78, 0xC0, 0x29, 0x49,
  0x24, 0x80, 0x24, 0x92, 0x52, 0x80, 0x5F, 0x00, 0x22, 0xF2, 0x20, 0xC0,
  0xC0, 0x80, 0x12, 0x24, 0x48, 0x80, 0x75, 0x99, 0xAA, 0xC0, 0xD5, 0xA8,
  0x71, 0x12, 0x48, 0xC0, 0x71, 0x26, 0x22, 0xC0, 0x32, 0x6A, 0xA6, 0x40,
  0x74, 0xC2, 0x22, 0xC0, 0x74, 0xCA, 0xAA, 0xE0, 0x71, 0x22, 0x44, 0x80,
  0x75, 0x64, 0xAA, 0xE0, 0x76, 0xD6, 0x70, 0x40, 0x80, 0x40, 0xA0, 0x16,
  0x86, 0x10, 0xF0, 0xF0, 0x86, 0x16, 0x80, 0x64, 0xA8, 0x20, 0x3A, 0x6F,
  0xBD, 0xDA, 0x0C, 0x11, 0x35, 0x75, 0x90, 0x75, 0x5A, 0x9A, 0xE0, 0x34,
  0x88, 0x88, 0xE0, 0x75, 0x59, 0x9A, 0xE0, 0x74, 0x4A, 0x88, 0xC0, 0x74,
  0x46, 0x88, 0x80, 0x3A, 0x21, 0x29, 0x49, 0xC0, 0x4A, 0x55, 0x69, 0x4A,
  0x40, 0x32, 0x24, 0x44, 0xC0, 0x24, 0xA4, 0x92, 0x80, 0x56, 0x44, 0xAA,
  0xA0, 0x56, 0xAC, 0x45, 0x14, 0xEA, 0xBA, 0xAA, 0x80, 0x4A, 0x53, 0x6B,
  0x4A, 0x40, 0x75, 0x99, 0x99, 0xE0, 0x75, 0x5E, 0x88, 0x80, 0x75, 0x99,
  0x99, 0xE2, 0x20, 0x75, 0x5E, 0xAA, 0xA0, 0x78, 0x44, 0x22, 0xE0, 0xF2,
  0x49, 0x20, 0x4A, 0x95, 0x29, 0x4B, 0x80, 0xB6, 0xE9, 0x20, 0xA6, 0xAE,
  0xBA, 0xB2, 0x4A, 0x00, 0x29, 0x88, 0x42, 0x2A, 0x40, 0xBB, 0x49, 0x20,
  0x72, 0x24, 0x48, 0xC0, 0x69, 0x29, 0x24, 0xC0, 0xFE, 0x31, 0x12, 0x22,
  0x22, 0xC0, 0x26, 0x90, 0xE0, 0xC0, 0x79, 0x9A, 0xE0, 0x44, 0x65, 0x99,
  0xAE, 0x72, 0x4C, 0x11, 0x35, 0x99, 0xAE, 0x77, 0x4E, 0x12, 0x22, 0x24,
  0x44, 0x48, 0x79, 0x9A, 0xE2, 0xE0, 0x49, 0x3B, 0x6D, 0x46, 0xA8, 0x20,
  0x94, 0x92, 0x80, 0x49, 0x3D, 0xAD, 0x55, 0xAA, 0x7D, 0x6B, 0x5A, 0x80,
  0x76, 0xDA, 0x76, 0xDE, 0x79, 0x9A, 0xE8, 0x80, 0x79, 0x9A, 0xE2, 0x20,
  0x72, 0x48, 0xF1, 0x2C, 0x56, 0xA8, 0x59, 0xAA, 0xE0, 0xFA, 0x80, 0xDD,
  0xEA, 0xA0, 0x69, 0x6C, 0x5A, 0x94, 0xC2, 0x23, 0x00, 0x69, 0x4C, 0x32,
  0x44, 0xC4, 0x48, 0x40, 0xFF, 0xC0, 0x31, 0x22, 0x32, 0x24, 0x80, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 2, 2, 3, 1, -7 },
  { 4, 4, 7, 4, 0, -7 },
  { 8, 4, 9, 4, 0, -8 },
  { 13, 5, 7, 5, 0, -7 },
  { 18, 3, 7, 3, 0, -7 },
  { 21, 1, 2, 2, 1, -7 },
  { 22, 3, 9, 2, 0, -7 },
  { 26, 3, 9, 2, -1, -7 },
  { 30, 3, 3, 3, 1, -8 },
  { 32, 4, 5, 4, 0, -6 },
  { 35, 1, 2, 2, 0, -1 },
  { 36, 2, 1, 3, 0, -3 },
  { 37, 1, 1, 2, 0, -1 },
  { 38, 4, 7, 3, 0, -7 },
  { 42, 4, 7, 4, 0, -7 },
  { 46, 2, 7, 4, 1, -7 },
  { 48, 4, 7, 4, 0, -7 },
  { 52, 4, 7, 4, 0, -7 },
  { 56, 4, 7, 4, 0, -7 },
  { 60, 4, 7, 4, 0, -7 },
  { 64, 4, 7, 4, 0, -7 },
  { 68, 4, 7, 4, 0, -7 },
  { 72, 4, 7, 4, 0, -7 },
  { 76, 3, 7, 4, 0, -7 },
  { 79, 2, 5, 2, 0, -5 },
  { 81, 2, 6, 2, 0, -5 },
  { 83, 4, 5, 4, 0, -6 },
  { 86, 4, 3, 4, 0, -5 },
  { 88, 4, 5, 4, 0, -6 },
  { 91, 3, 7, 3, 0, -7 },
  { 94, 5, 8, 5, 0, -7 },
  { 99, 4, 7, 3, -1, -7 },
  { 103, 4, 7, 4, 0, -7 },
  { 107, 4, 7, 3, 0, -7 },
  { 111, 4, 7, 4, 0, -7 },
  { 115, 4, 7, 3, 0, -7 },
  { 119, 4, 7, 3, 0, -7 },
  { 123, 5, 7, 5, 0, -7 },
  { 128, 5, 7, 4, 0, -7 },
  { 133, 4, 7, 2, -1, -7 },
  { 137, 3, 9, 2, -1, -7 },
  { 141, 4, 7, 4, 0, -7 },
  { 145, 2, 7, 3, 0, -7 },
  { 147, 6, 7, 6, 0, -7 },
  { 153, 5, 7, 5, 0, -7 },
  { 158, 4, 7, 5, 0, -7 },
  { 162, 4, 7, 4, 0, -7 },
  { 166, 4, 9, 5, 0, -7 },
  { 171, 4, 7, 4, 0, -7 },
  { 175, 4, 7, 3, 0, -7 },
  { 179, 3, 7, 3, 1, -7 },
  { 182, 5, 7, 4, 0, -7 },
  { 187, 3, 7, 4, 1, -7 },
  { 190, 6, 7, 6, 1, -7 },
  { 196, 5, 7, 3, -1, -7 },
  { 201, 3, 7, 3, 1, -7 },
  { 204, 4, 7, 3, 0, -7 },
  { 208, 3, 9, 3, 0, -7 },
  { 212, 1, 7, 3, 1, -7 },
  { 213, 4, 9, 3, -1, -7 },
  { 218, 4, 3, 4, 0, -7 },
  { 220, 3, 1, 3, -1, 1 },
  { 221, 1, 2, 2, 1, -8 },
  { 222, 4, 5, 4, 0, -5 },
  { 225, 4, 8, 4, 0, -8 },
  { 229, 3, 5, 3, 0, -5 },
  { 231, 4, 8, 4, 0, -8 },
  { 235, 3, 5, 3, 0, -5 },
  { 237, 4, 10, 2, -1, -8 },
  { 242, 4, 7, 4, 0, -5 },
  { 246, 3, 8, 4, 0, -8 },
  { 249, 2, 7, 2, 0, -7 },
  { 251, 3, 9, 2, -1, -7 },
  { 255, 3, 8, 3, 0, -8 },
  { 258, 2, 8, 2, 0, -8 },
  { 260, 5, 5, 6, 0, -5 },
  { 264, 3, 5, 4, 0, -5 },
  { 266, 3, 5, 4, 0, -5 },
  { 268, 4, 7, 4, 0, -5 },
  { 272, 4, 7, 4, 0, -5 },
  { 276, 3, 5, 2, 0, -5 },
  { 278, 3, 5, 3, 0, -5 },
  { 280, 2, 7, 2, 0, -7 },
  { 282, 4, 5, 4, 0, -5 },
  { 285, 2, 5, 3, 1, -5 },
  { 287, 4, 5, 5, 1, -5 },
  { 290, 3, 5, 3, 0, -5 },
  { 292, 5, 7, 3, -1, -5 },
  { 297, 3, 5, 2, 0, -5 },
  { 299, 4, 9, 3, 0, -7 },
  { 304, 1, 10, 3, 1, -8 },
  { 306, 4, 9, 3, -1, -7 },
  { 311, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC10PT7B_H_
