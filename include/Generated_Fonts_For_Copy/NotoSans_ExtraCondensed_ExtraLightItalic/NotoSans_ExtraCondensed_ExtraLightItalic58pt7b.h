#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC58PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x73,
  0x06, 0x30, 0x63, 0x06, 0x70, 0x66, 0x0C, 0x60, 0xC6, 0x0C, 0x60, 0xCC,
  0x08, 0xC1, 0x8C, 0x18, 0xC1, 0x88, 0x10, 0x81, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80,
  0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00,
  0x60, 0x60, 0x00, 0x81, 0x80, 0x03, 0x03, 0x00, 0xFF, 0xFF, 0xE0, 0x0C,
  0x08, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x80, 0x03, 0x03,
  0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60,
  0x00, 0xC0, 0xC0, 0x01, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x03,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x00, 0x06,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x00, 0xC0,
  0xC0, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x71, 0x86, 0x03, 0x86, 0x00, 0x0C, 0x10, 0x00, 0x60,
  0x40, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0x80,
  0x01, 0x82, 0x00, 0x06, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x31, 0x80, 0x00,
  0xE4, 0x00, 0x01, 0xD0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xB0, 0x00, 0x06, 0x60, 0x00, 0x19, 0xC0,
  0x00, 0x43, 0x00, 0x01, 0x0E, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00,
  0xC1, 0x80, 0x02, 0x06, 0x00, 0x08, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x83,
  0x00, 0x06, 0x1C, 0x08, 0x10, 0xE0, 0x3C, 0x5F, 0x00, 0xFF, 0xF0, 0x00,
  0x3E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xC0,
  0xE3, 0x00, 0x60, 0x30, 0xC0, 0x18, 0x18, 0x10, 0x0C, 0x06, 0x06, 0x03,
  0x03, 0x01, 0x81, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x30, 0x30, 0x18, 0x0C,
  0x0C, 0x06, 0x03, 0x06, 0x01, 0x80, 0xC1, 0x80, 0xE0, 0x30, 0xC0, 0x30,
  0x0C, 0x30, 0x0C, 0x06, 0x18, 0x03, 0x01, 0x86, 0x00, 0xC0, 0x63, 0x00,
  0x30, 0x18, 0xC3, 0xCC, 0x0C, 0x63, 0xFB, 0x03, 0x18, 0xC3, 0xC1, 0xCC,
  0x60, 0xF0, 0x63, 0x30, 0x3C, 0x31, 0x8C, 0x0F, 0x1C, 0x63, 0x03, 0x7E,
  0x31, 0x80, 0xCF, 0x0C, 0x60, 0x30, 0x06, 0x18, 0x0C, 0x01, 0x8C, 0x03,
  0x00, 0xC3, 0x01, 0x80, 0x30, 0xC0, 0x60, 0x18, 0x30, 0x18, 0x06, 0x08,
  0x06, 0x03, 0x06, 0x03, 0x80, 0xC1, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18,
  0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x81, 0x81, 0x80, 0x60, 0xC0,
  0x60, 0x18, 0x70, 0x30, 0x03, 0x38, 0x0C, 0x00, 0xFC, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x38, 0xC0, 0x07, 0x0C, 0x00,
  0x60, 0xE0, 0x0E, 0x0E, 0x00, 0xC0, 0xE0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0,
  0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x30,
  0x00, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0xCE, 0x00, 0x0F, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1B, 0x00, 0x03, 0x30, 0x00, 0x73,
  0x00, 0x0E, 0x38, 0x31, 0xC1, 0x87, 0x18, 0x18, 0x63, 0x81, 0x86, 0x30,
  0x1C, 0x67, 0x00, 0xCC, 0x60, 0x0C, 0xC6, 0x00, 0xD8, 0x60, 0x07, 0x8E,
  0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0F, 0x06, 0x00, 0xF0,
  0x60, 0x1B, 0x07, 0x03, 0x18, 0x3D, 0xE1, 0x81, 0xFC, 0x18, 0x03, 0x00,
  0x00, 0x39, 0x8C, 0x67, 0x31, 0x8C, 0x62, 0x31, 0x8C, 0x42, 0x00, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x0C, 0x10, 0x1C, 0x20, 0x0E, 0x43, 0x07, 0xFF, 0x03, 0xC0,
  0x0E, 0x00, 0x36, 0x00, 0xC4, 0x07, 0x0C, 0x1C, 0x0C, 0x10, 0x18, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x0C, 0x38,
  0x60, 0xC3, 0x06, 0x1C, 0x30, 0x61, 0x82, 0x0C, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x5F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x01,
  0xC7, 0x00, 0x70, 0x70, 0x1C, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x18,
  0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x38, 0x01, 0x86, 0x00, 0x30, 0xC0,
  0x06, 0x38, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xE7, 0x00,
  0x1C, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0xE0, 0x01, 0x98, 0x00,
  0x73, 0x00, 0x0E, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x70, 0x01,
  0xCE, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01, 0xC6, 0x00, 0x30, 0xC0, 0x06,
  0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x0E, 0x0E, 0x01, 0x80, 0xC0, 0x70,
  0x18, 0x1C, 0x03, 0x87, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x10, 0x00,
  0x00, 0x00, 0xE0, 0x3C, 0x1D, 0x87, 0x61, 0xCC, 0x71, 0xBC, 0x32, 0x0E,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xC1, 0xE0, 0x02, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0x80, 0x1E, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x80,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x20, 0x0F,
  0x00, 0xF1, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xD8,
  0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00,
  0x18, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61,
  0x80, 0x03, 0x06, 0x00, 0x18, 0x38, 0x00, 0x60, 0xC0, 0x03, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x60,
  0x18, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x0C, 0x00, 0xC0, 0x70, 0x03, 0x01, 0x80, 0x1C, 0x0F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x60, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x08, 0x03, 0xC0, 0x3C, 0x7E, 0x00, 0xFF, 0xE0, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0x04, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xCF,
  0xE0, 0x0C, 0xFF, 0x80, 0x6C, 0x0E, 0x03, 0xC0, 0x38, 0x3C, 0x00, 0xC1,
  0xE0, 0x06, 0x0E, 0x00, 0x30, 0x70, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00,
  0x60, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x80, 0x06, 0x1C,
  0x00, 0x70, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x38, 0x01, 0xC1, 0xC0, 0x0C,
  0x06, 0x00, 0xE0, 0x30, 0x06, 0x01, 0x80, 0x70, 0x06, 0x07, 0x00, 0x3D,
  0xF0, 0x00, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xC0, 0x07, 0x07, 0x00, 0x38, 0x06, 0x01, 0xC0, 0x1C, 0x06, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x0E, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x18, 0x00, 0xC0, 0xE0, 0x03, 0x87, 0x00, 0x06, 0x70, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x38, 0xE0, 0x01, 0xC1,
  0xC0, 0x0E, 0x03, 0x00, 0x70, 0x0E, 0x03, 0x80, 0x18, 0x0C, 0x00, 0x70,
  0x70, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xE0,
  0x00, 0xC3, 0x80, 0x03, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x70, 0x60, 0x01,
  0x81, 0x80, 0x0E, 0x07, 0x00, 0x30, 0x0E, 0x01, 0xC0, 0x1F, 0x7E, 0x00,
  0x3F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x00,
  0xE0, 0xC0, 0x1C, 0x06, 0x03, 0x80, 0x60, 0x30, 0x07, 0x07, 0x00, 0x30,
  0x60, 0x03, 0x06, 0x00, 0x30, 0xE0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x31, 0xC0, 0x03, 0x18, 0x00, 0x31, 0x80, 0x07, 0x18, 0x00,
  0x71, 0x80, 0x07, 0x18, 0x00, 0xE1, 0x80, 0x0E, 0x1C, 0x01, 0xE0, 0xC0,
  0x1E, 0x0E, 0x03, 0x60, 0x70, 0xEC, 0x07, 0xFC, 0xC0, 0x1F, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xEF, 0xC0,
  0x0F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x0C, 0x0F, 0x07, 0x03, 0x80, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x0E, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x07, 0xFC, 0x0E, 0x0E, 0x08, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x38, 0x01,
  0x80, 0x03, 0x80, 0x06, 0x00, 0x38, 0x00, 0x30, 0x03, 0x80, 0x00, 0xC0,
  0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x20, 0x60, 0x0F, 0x81, 0x86, 0x01, 0xFE,
  0x0C, 0x30, 0x1C, 0x60, 0x41, 0x81, 0x83, 0x06, 0x18, 0x0C, 0x18, 0x30,
  0xC0, 0xC0, 0xC1, 0x86, 0x0C, 0x0C, 0x0C, 0x60, 0x60, 0x60, 0x63, 0x03,
  0x03, 0x03, 0x18, 0x30, 0x18, 0x18, 0xC1, 0x81, 0x81, 0x8C, 0x0C, 0x0C,
  0x0C, 0x60, 0xC0, 0x60, 0x63, 0x06, 0x07, 0x03, 0x18, 0x30, 0x30, 0x30,
  0xC1, 0x81, 0x81, 0x86, 0x0C, 0x1C, 0x0C, 0x30, 0x60, 0xE0, 0xC1, 0x03,
  0x07, 0x06, 0x18, 0x18, 0x78, 0x60, 0xC0, 0xC6, 0xC6, 0x06, 0x07, 0x73,
  0xF0, 0x30, 0x1F, 0x1F, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x20, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xB0, 0x00, 0x1B, 0x00, 0x01, 0xB0, 0x00, 0x33, 0x00, 0x03, 0x30,
  0x00, 0x73, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0C, 0x30, 0x00, 0xC3,
  0x00, 0x1C, 0x30, 0x01, 0x83, 0x00, 0x18, 0x30, 0x03, 0x03, 0x00, 0x30,
  0x30, 0x07, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0x80, 0x30, 0x30, 0x03, 0x03,
  0x00, 0x30, 0x70, 0x03, 0x06, 0x00, 0x30, 0xE0, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x1C, 0x00, 0x31, 0x80, 0x03, 0x38, 0x00, 0x33, 0x00, 0x03,
  0x30, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x3E, 0x00, 0x03, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xE0, 0x03, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x70, 0x03, 0x80, 0xC0, 0x07, 0x01, 0x80, 0x0E,
  0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x30, 0x01, 0xC0,
  0x60, 0x03, 0x00, 0xC0, 0x0E, 0x01, 0x80, 0x18, 0x07, 0x00, 0x60, 0x0C,
  0x03, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xE0, 0xF8, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x06, 0x00, 0x70, 0x0C, 0x00, 0x60, 0x38, 0x00,
  0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C,
  0x0E, 0x00, 0x18, 0x18, 0x00, 0x70, 0x30, 0x00, 0xE0, 0x60, 0x01, 0x80,
  0xC0, 0x07, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x38, 0x0C, 0x00, 0xE0, 0x18,
  0x07, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0xF0, 0x30, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0x01, 0xE0, 0x06, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xC0, 0x03, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x07, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x70, 0xE0, 0x00,
  0xE1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x1C,
  0x38, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x01, 0xC1, 0x80, 0x03, 0x03,
  0x00, 0x0E, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x70, 0x30, 0x00, 0xC0, 0x60,
  0x03, 0x81, 0xC0, 0x0E, 0x03, 0x00, 0x38, 0x06, 0x00, 0xE0, 0x0C, 0x03,
  0x80, 0x18, 0x1E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x02, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0xFF, 0x06, 0x00, 0x3F, 0xC3, 0x80,
  0x00, 0x30, 0xE0, 0x00, 0x1C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03,
  0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x1C, 0x06, 0x00,
  0x06, 0x01, 0x80, 0x01, 0x80, 0x70, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x60, 0x1C, 0x00, 0x1C, 0x03,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x03,
  0x80, 0x70, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x30,
  0x00, 0x30, 0x06, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x30,
  0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x38, 0x06, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0xE0, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x60, 0x0C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x00, 0x60, 0x00, 0x60, 0x0C,
  0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x70, 0x0C, 0x00, 0x0C,
  0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x30, 0x06, 0x00, 0x06, 0x01, 0xC0,
  0x01, 0x80, 0x30, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0,
  0x18, 0x00, 0x38, 0x07, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x60,
  0x03, 0x80, 0x70, 0x03, 0x80, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x0C,
  0x01, 0xC0, 0x06, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0xE0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0x60, 0x00, 0x70, 0x60, 0x00,
  0x30, 0x70, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x30, 0x00,
  0x06, 0x38, 0x00, 0x03, 0x38, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xDE, 0x00,
  0x00, 0xFB, 0x00, 0x00, 0x69, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x06, 0x07, 0x00, 0x03, 0x01,
  0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x38, 0x00, 0x60,
  0x1C, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03, 0x00, 0x1C, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x01,
  0xC0, 0x07, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x03,
  0x60, 0x0F, 0x00, 0x00, 0x7C, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x1B, 0x00,
  0x00, 0x6C, 0x01, 0xB0, 0x00, 0x0C, 0xC0, 0x1B, 0x00, 0x00, 0xDC, 0x01,
  0xB8, 0x00, 0x19, 0x80, 0x31, 0x80, 0x01, 0x98, 0x03, 0x18, 0x00, 0x31,
  0x80, 0x31, 0x80, 0x03, 0x18, 0x03, 0x18, 0x00, 0x63, 0x80, 0x71, 0x80,
  0x06, 0x30, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x06,
  0x18, 0x01, 0xC7, 0x00, 0x61, 0x80, 0x18, 0x60, 0x0E, 0x18, 0x03, 0x86,
  0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x07, 0x06, 0x00, 0xC1, 0x80,
  0x60, 0xE0, 0x0C, 0x18, 0x0E, 0x0C, 0x01, 0xC1, 0x80, 0xC0, 0xC0, 0x18,
  0x18, 0x0C, 0x0C, 0x01, 0x81, 0x81, 0x80, 0xC0, 0x18, 0x18, 0x18, 0x1C,
  0x01, 0x81, 0x83, 0x01, 0x80, 0x30, 0x1C, 0x30, 0x18, 0x03, 0x00, 0xC6,
  0x01, 0x80, 0x30, 0x0C, 0x60, 0x38, 0x03, 0x00, 0xCC, 0x03, 0x00, 0x70,
  0x0C, 0xC0, 0x30, 0x06, 0x00, 0xD8, 0x03, 0x00, 0x60, 0x0D, 0x80, 0x30,
  0x06, 0x00, 0xF8, 0x07, 0x00, 0x60, 0x0F, 0x00, 0x60, 0x0E, 0x00, 0xF0,
  0x06, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x30, 0x0F,
  0x00, 0x03, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x06, 0x00, 0xF0, 0x00,
  0x60, 0x0D, 0x80, 0x06, 0x01, 0xD8, 0x00, 0x60, 0x19, 0x80, 0x0E, 0x01,
  0x98, 0x00, 0xC0, 0x19, 0x80, 0x0C, 0x01, 0x9C, 0x00, 0xC0, 0x38, 0xC0,
  0x0C, 0x03, 0x0C, 0x01, 0xC0, 0x30, 0xC0, 0x18, 0x03, 0x0C, 0x01, 0x80,
  0x70, 0xC0, 0x18, 0x06, 0x06, 0x01, 0x80, 0x60, 0x60, 0x30, 0x06, 0x06,
  0x03, 0x00, 0x60, 0x60, 0x30, 0x0E, 0x06, 0x03, 0x00, 0xC0, 0x70, 0x70,
  0x0C, 0x03, 0x06, 0x00, 0xC0, 0x30, 0x60, 0x0C, 0x03, 0x06, 0x01, 0xC0,
  0x30, 0x60, 0x18, 0x03, 0x0E, 0x01, 0x80, 0x38, 0xC0, 0x18, 0x01, 0x8C,
  0x01, 0x80, 0x18, 0xC0, 0x38, 0x01, 0x8C, 0x03, 0x00, 0x19, 0x80, 0x30,
  0x01, 0x98, 0x03, 0x00, 0x0D, 0x80, 0x70, 0x00, 0xD8, 0x06, 0x00, 0x0D,
  0x80, 0x60, 0x00, 0xF0, 0x06, 0x00, 0x0F, 0x00, 0x60, 0x00, 0xF0, 0x0E,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x30, 0x01,
  0xC0, 0xE0, 0x01, 0x81, 0x80, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x18, 0x60, 0x00, 0x31, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xC6,
  0x00, 0x01, 0x9C, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00,
  0x03, 0x30, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x33, 0x00, 0x00,
  0x66, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x1C,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x07,
  0x00, 0x0C, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x60, 0x1C, 0x01, 0x80, 0x1C,
  0x0E, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x0C, 0x07, 0x00, 0x30, 0x0E, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C,
  0x06, 0x00, 0x30, 0x18, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x00, 0x18, 0x0C,
  0x00, 0x60, 0x30, 0x01, 0x81, 0xC0, 0x0E, 0x06, 0x00, 0x30, 0x18, 0x01,
  0xC0, 0x60, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x31, 0xFC, 0x00,
  0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xE0,
  0xE0, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0xE0, 0x01,
  0x81, 0x80, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x31, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x9C,
  0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x3B, 0x80,
  0x00, 0x76, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00,
  0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x01,
  0xCC, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x30,
  0xC0, 0x00, 0x61, 0x80, 0x01, 0x83, 0x00, 0x03, 0x07, 0x00, 0x0C, 0x06,
  0x00, 0x38, 0x0C, 0x00, 0x60, 0x1C, 0x01, 0x80, 0x1C, 0x0F, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x80, 0x0C, 0x07, 0x00, 0x30, 0x0E, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x06,
  0x00, 0x70, 0x18, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x00, 0x18, 0x0C, 0x00,
  0x60, 0x30, 0x03, 0x81, 0xC0, 0x0C, 0x07, 0x00, 0x30, 0x18, 0x01, 0x80,
  0x60, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x0F, 0x80, 0x3F, 0xF8, 0x00, 0xFF,
  0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x60, 0x01, 0x81, 0xC0,
  0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x00, 0xC0, 0x0C,
  0x03, 0x80, 0x30, 0x0E, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x60, 0x18, 0x01,
  0x80, 0x60, 0x06, 0x01, 0x80, 0x1C, 0x06, 0x00, 0x30, 0x38, 0x00, 0xC0,
  0xC0, 0x03, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x3C, 0x0F,
  0x00, 0x70, 0x02, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0xC0, 0x0F, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x05, 0x00, 0x00,
  0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x03,
  0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06,
  0x07, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x0C,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x1C,
  0x0C, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x38,
  0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x38, 0x00, 0x30, 0x30, 0x00, 0x30,
  0x30, 0x00, 0x70, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x70, 0x00, 0x60,
  0x60, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xE0, 0x00, 0xC0,
  0xC0, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80,
  0xC0, 0x03, 0x80, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00,
  0x0E, 0xC0, 0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0,
  0x03, 0x8C, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00, 0x60, 0xC0, 0x0E, 0x0C,
  0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x01, 0xC0, 0xC0, 0x18, 0x0C, 0x03, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0xE0,
  0x0C, 0x0C, 0x00, 0xC1, 0xC0, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x30,
  0x00, 0xC3, 0x00, 0x0C, 0x70, 0x00, 0xC6, 0x00, 0x0C, 0xE0, 0x00, 0xCC,
  0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x0D, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x76, 0x00, 0x06, 0x00, 0x06, 0x60, 0x00, 0xE0, 0x00, 0xC6,
  0x00, 0x0E, 0x00, 0x0C, 0x60, 0x01, 0xE0, 0x01, 0xC6, 0x00, 0x1E, 0x00,
  0x18, 0x60, 0x01, 0xE0, 0x01, 0x86, 0x00, 0x36, 0x00, 0x30, 0x60, 0x03,
  0x60, 0x03, 0x06, 0x00, 0x66, 0x00, 0x70, 0x60, 0x06, 0x60, 0x06, 0x06,
  0x00, 0x66, 0x00, 0x60, 0x60, 0x0C, 0x60, 0x0C, 0x06, 0x00, 0xC6, 0x00,
  0xC0, 0x60, 0x18, 0x60, 0x1C, 0x06, 0x01, 0x86, 0x01, 0x80, 0x60, 0x18,
  0x60, 0x18, 0x06, 0x03, 0x06, 0x03, 0x00, 0x60, 0x30, 0x60, 0x30, 0x06,
  0x07, 0x06, 0x07, 0x00, 0x60, 0x60, 0x60, 0x60, 0x06, 0x06, 0x06, 0x06,
  0x00, 0x60, 0xC0, 0x60, 0xC0, 0x06, 0x0C, 0x06, 0x0C, 0x00, 0x61, 0xC0,
  0x61, 0xC0, 0x0E, 0x18, 0x06, 0x18, 0x00, 0xE1, 0x80, 0x61, 0x80, 0x0E,
  0x30, 0x04, 0x30, 0x00, 0xE3, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x0C, 0x70,
  0x00, 0xC6, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x0C, 0x60, 0x00, 0xCC, 0x00,
  0xCC, 0x00, 0x0C, 0xC0, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0xDC, 0x00, 0x0D,
  0x80, 0x0D, 0x80, 0x00, 0xD8, 0x00, 0xD8, 0x00, 0x0F, 0x80, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x03, 0x00,
  0x30, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x38, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x98, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x07, 0x18, 0x00, 0x01, 0x86,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0E,
  0x03, 0x00, 0x03, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x0C, 0x00,
  0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x0E,
  0x00, 0xC0, 0x03, 0x80, 0x00, 0x60, 0x00, 0xD8, 0x00, 0x66, 0x00, 0x19,
  0x80, 0x0C, 0x60, 0x03, 0x18, 0x01, 0x87, 0x00, 0x60, 0xC0, 0x30, 0x30,
  0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x18,
  0x03, 0x0E, 0x00, 0xC3, 0x00, 0x31, 0xC0, 0x0C, 0x60, 0x01, 0xB8, 0x00,
  0x6C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x60,
  0x60, 0x60, 0x60, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0E, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x07, 0x03, 0x03, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x60, 0x00,
  0x63, 0x00, 0x07, 0x1C, 0x00, 0x30, 0x60, 0x03, 0x83, 0x80, 0x18, 0x0C,
  0x01, 0xC0, 0x60, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x70, 0x60,
  0x01, 0x83, 0x00, 0x0E, 0x30, 0x00, 0x31, 0x80, 0x01, 0x98, 0x00, 0x07,
  0xC0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0xE1, 0x87, 0x0C, 0x18, 0x60,
  0x83, 0x04, 0x00, 0x7E, 0x30, 0x1F, 0xF3, 0x03, 0x83, 0x30, 0x70, 0x1E,
  0x06, 0x01, 0xE0, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0x80, 0x0E, 0x38, 0x00,
  0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC7, 0x00, 0x1C, 0x60, 0x01, 0x86, 0x00,
  0x18, 0x60, 0x01, 0x8E, 0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00, 0x30, 0xC0,
  0x03, 0x0C, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x06, 0x0C,
  0x00, 0xE0, 0xC0, 0x0E, 0x0C, 0x01, 0xE0, 0xC0, 0x16, 0x0E, 0x03, 0xC0,
  0x60, 0x6C, 0x07, 0xBC, 0xC0, 0x3F, 0x8C, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC7, 0xE0, 0x0E,
  0x7F, 0x80, 0x66, 0x0E, 0x03, 0x60, 0x70, 0x1E, 0x01, 0x80, 0xE0, 0x0C,
  0x0F, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x18, 0x00, 0xE0, 0xC0,
  0x07, 0x0E, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60,
  0xC0, 0x03, 0x0C, 0x00, 0x38, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00,
  0x61, 0xC0, 0x07, 0x0E, 0x00, 0x30, 0x70, 0x01, 0x83, 0x00, 0x1C, 0x18,
  0x00, 0xC1, 0xE0, 0x0E, 0x0F, 0x00, 0x60, 0x68, 0x06, 0x03, 0x60, 0x70,
  0x13, 0xDF, 0x01, 0x8F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0x01,
  0xFE, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x7D, 0xC0, 0x3F, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x0F, 0xC6, 0x00, 0x7F, 0xCC, 0x01, 0xC1, 0xB8, 0x07,
  0x01, 0xE0, 0x0C, 0x03, 0xC0, 0x30, 0x03, 0x80, 0xE0, 0x07, 0x01, 0x80,
  0x0E, 0x07, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x70, 0x01,
  0xC0, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x0E, 0x00, 0x18,
  0x18, 0x00, 0x70, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01,
  0x80, 0x0E, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xE0, 0x18,
  0x01, 0xC0, 0x30, 0x07, 0x80, 0x60, 0x0F, 0x00, 0xE0, 0x3C, 0x00, 0xC0,
  0xD8, 0x01, 0xEF, 0x30, 0x01, 0xFC, 0x60, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0xFF, 0x80, 0xE0, 0xC0, 0xE0, 0x60, 0xE0, 0x38, 0x60, 0x1C,
  0x70, 0x0C, 0x30, 0x06, 0x30, 0x03, 0x18, 0x03, 0x9C, 0x01, 0x8C, 0x01,
  0xC6, 0x01, 0xC3, 0x03, 0xC3, 0x9F, 0x81, 0xFF, 0x00, 0xE8, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x01,
  0x03, 0xE7, 0x80, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC6,
  0x00, 0x7F, 0xCC, 0x01, 0xC1, 0x98, 0x07, 0x01, 0xE0, 0x0C, 0x03, 0xC0,
  0x30, 0x03, 0x80, 0xE0, 0x07, 0x01, 0x80, 0x0C, 0x07, 0x00, 0x18, 0x0C,
  0x00, 0x30, 0x18, 0x00, 0x60, 0x70, 0x01, 0xC0, 0xC0, 0x03, 0x01, 0x80,
  0x06, 0x03, 0x00, 0x0C, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x70, 0x30, 0x00,
  0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x1C,
  0x06, 0x00, 0x30, 0x0C, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x30, 0x07, 0x80,
  0x60, 0x0E, 0x00, 0xE0, 0x3C, 0x00, 0xC0, 0xD8, 0x01, 0xEF, 0x30, 0x01,
  0xFC, 0x60, 0x00, 0x41, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x01, 0x00, 0x70, 0x03, 0x83, 0xC0,
  0x07, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0xFC, 0x01, 0xBF, 0xE0, 0x37, 0x06, 0x03,
  0x40, 0x70, 0x3C, 0x07, 0x03, 0x80, 0x70, 0x30, 0x07, 0x07, 0x00, 0x60,
  0x70, 0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x0E, 0x00, 0x60, 0xC0, 0x0C,
  0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xC1, 0xC0, 0x1C, 0x18, 0x01,
  0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x18, 0x30, 0x03, 0x83, 0x00,
  0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x70, 0x03, 0x06, 0x00, 0x60, 0x60,
  0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x0E, 0x00, 0xE0, 0x00, 0x20, 0x0C,
  0x03, 0x80, 0x70, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0E, 0x03, 0x01, 0xC0, 0x30, 0x18,
  0x03, 0x03, 0x00, 0x70, 0x70, 0x06, 0x0E, 0x00, 0x60, 0xC0, 0x06, 0x18,
  0x00, 0x63, 0x80, 0x0E, 0x70, 0x00, 0xC6, 0x00, 0x0C, 0xE0, 0x00, 0xDE,
  0x00, 0x0F, 0x30, 0x01, 0xB3, 0x00, 0x1E, 0x30, 0x01, 0xC3, 0x00, 0x18,
  0x30, 0x03, 0x83, 0x00, 0x30, 0x18, 0x03, 0x01, 0x80, 0x30, 0x18, 0x03,
  0x01, 0x80, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x06, 0x00, 0xC0,
  0x60, 0x0C, 0x0C, 0x00, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x01,
  0x9F, 0x81, 0xF0, 0x06, 0x7F, 0x8F, 0xF8, 0x0D, 0x83, 0xB0, 0x70, 0x1E,
  0x03, 0xC0, 0x70, 0x38, 0x07, 0x80, 0xE0, 0x70, 0x0E, 0x00, 0xC1, 0xC0,
  0x1C, 0x03, 0x83, 0x80, 0x30, 0x06, 0x06, 0x00, 0x60, 0x0C, 0x0C, 0x01,
  0xC0, 0x18, 0x18, 0x03, 0x00, 0x30, 0x70, 0x06, 0x00, 0xE0, 0xC0, 0x0C,
  0x01, 0x81, 0x80, 0x18, 0x03, 0x03, 0x00, 0x70, 0x06, 0x06, 0x00, 0xC0,
  0x0C, 0x18, 0x01, 0x80, 0x38, 0x30, 0x03, 0x00, 0x60, 0x60, 0x06, 0x00,
  0xC0, 0xC0, 0x18, 0x01, 0x83, 0x80, 0x30, 0x03, 0x06, 0x00, 0x60, 0x0C,
  0x0C, 0x00, 0xC0, 0x18, 0x18, 0x03, 0x80, 0x30, 0x30, 0x06, 0x00, 0x60,
  0xE0, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x03, 0x03, 0x00, 0x30, 0x06, 0x06,
  0x00, 0xE0, 0x0C, 0x0C, 0x01, 0x80, 0x18, 0x30, 0x03, 0x00, 0x70, 0x00,
  0x01, 0x0F, 0xC0, 0x33, 0xFE, 0x03, 0x70, 0xE0, 0x34, 0x07, 0x03, 0x80,
  0x70, 0x38, 0x07, 0x07, 0x00, 0x60, 0x70, 0x06, 0x07, 0x00, 0x60, 0x60,
  0x06, 0x06, 0x00, 0x60, 0xE0, 0x0E, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C,
  0x00, 0xC0, 0xC0, 0x0C, 0x18, 0x01, 0xC1, 0x80, 0x18, 0x18, 0x01, 0x81,
  0x80, 0x18, 0x38, 0x01, 0x83, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x30,
  0x30, 0x03, 0x07, 0x00, 0x30, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x06,
  0x06, 0x00, 0x60, 0xC0, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x38,
  0x38, 0x1C, 0x06, 0x0E, 0x01, 0x83, 0x00, 0x71, 0xC0, 0x0C, 0x60, 0x03,
  0x38, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0D, 0xC0, 0x07, 0x60, 0x01, 0xD8,
  0x00, 0x66, 0x00, 0x1B, 0x80, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00,
  0x3B, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x01, 0xCC, 0x00, 0x63, 0x00, 0x18,
  0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x01, 0x83, 0x80, 0xE0, 0x60, 0x70, 0x1F,
  0x78, 0x03, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x63, 0xF0, 0x00, 0x8F, 0xF0,
  0x03, 0x30, 0x70, 0x06, 0xC0, 0x60, 0x0F, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x78, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x00, 0x1C, 0x06,
  0x00, 0x38, 0x1C, 0x00, 0x70, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0,
  0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x18, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0x60, 0x03, 0x81, 0xC0, 0x06, 0x03, 0x80, 0x0C,
  0x07, 0x00, 0x38, 0x0E, 0x00, 0x60, 0x3C, 0x01, 0xC0, 0x78, 0x03, 0x00,
  0xD0, 0x0C, 0x01, 0xB0, 0x38, 0x03, 0x7B, 0xE0, 0x0E, 0x7F, 0x00, 0x18,
  0x18, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x30, 0x1F, 0xF3, 0x03, 0x83, 0x30, 0x70, 0x1E, 0x0E,
  0x01, 0xE0, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0x80, 0x0E, 0x38, 0x00, 0xC3,
  0x00, 0x0C, 0x30, 0x00, 0xC7, 0x00, 0x1C, 0x60, 0x01, 0x86, 0x00, 0x18,
  0x60, 0x01, 0x8E, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x06, 0x0C, 0x00,
  0xE0, 0xC0, 0x0E, 0x0C, 0x01, 0xE0, 0xC0, 0x1E, 0x0E, 0x03, 0xC0, 0x60,
  0x6C, 0x07, 0xBC, 0xC0, 0x3F, 0x8C, 0x00, 0x61, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x01, 0x0F, 0x81, 0x9F, 0x80, 0xDC,
  0x00, 0x6C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x38, 0x18, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x80, 0x70, 0x3C, 0x78, 0x07, 0xFC, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x7F, 0x3F,
  0xE0, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0E, 0x40, 0xF8, 0x04, 0x00, 0x06, 0x00, 0x61, 0xC0, 0x1C, 0x30,
  0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x87, 0x00, 0x70, 0xC0,
  0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0xE0, 0x06, 0x18, 0x01, 0xC3, 0x00,
  0x30, 0x60, 0x06, 0x0C, 0x00, 0xC3, 0x80, 0x18, 0x60, 0x06, 0x0C, 0x00,
  0xC1, 0x80, 0x18, 0x30, 0x03, 0x0E, 0x00, 0xE1, 0x80, 0x18, 0x30, 0x03,
  0x06, 0x00, 0xE0, 0xC0, 0x1C, 0x18, 0x07, 0x83, 0x00, 0xE0, 0x60, 0x3C,
  0x0C, 0x0D, 0x81, 0xEF, 0x30, 0x1F, 0xC6, 0x00, 0x40, 0x00, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x1C,
  0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0x60,
  0xC0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC1, 0x80, 0xC1, 0x80, 0xC3, 0x00,
  0xC3, 0x00, 0xC7, 0x00, 0xC6, 0x00, 0xCE, 0x00, 0xCC, 0x00, 0xCC, 0x00,
  0xD8, 0x00, 0x58, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x06, 0x00, 0x6C, 0x00, 0xC0, 0x0D, 0x80, 0x38, 0x03, 0x30, 0x07,
  0x00, 0x66, 0x01, 0xA0, 0x0C, 0xC0, 0x3C, 0x03, 0x18, 0x07, 0x80, 0x63,
  0x01, 0xB0, 0x18, 0x60, 0x36, 0x03, 0x0C, 0x0C, 0xC0, 0x61, 0x81, 0x98,
  0x18, 0x30, 0x33, 0x03, 0x06, 0x0C, 0x60, 0x60, 0x81, 0x8C, 0x18, 0x30,
  0x61, 0x83, 0x06, 0x0C, 0x30, 0xC0, 0xC1, 0x86, 0x18, 0x18, 0x60, 0xC3,
  0x03, 0x0C, 0x18, 0xC0, 0x63, 0x03, 0x18, 0x0C, 0x60, 0x66, 0x01, 0x8C,
  0x0C, 0xC0, 0x33, 0x01, 0x98, 0x06, 0x60, 0x36, 0x00, 0xD8, 0x06, 0xC0,
  0x1B, 0x00, 0xD0, 0x03, 0x60, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x0C,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x70, 0x01,
  0x81, 0x80, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x61, 0x80, 0x01, 0x8E,
  0x00, 0x03, 0x30, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0D,
  0x80, 0x00, 0x33, 0x00, 0x01, 0x8C, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xC0,
  0x01, 0x83, 0x00, 0x0E, 0x06, 0x00, 0x30, 0x18, 0x01, 0xC0, 0x60, 0x06,
  0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x0C, 0x0E, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x07, 0x00, 0x0C, 0x00,
  0xC0, 0x01, 0x80, 0x38, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30,
  0x00, 0x0C, 0x0E, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1E,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x17, 0xFC, 0x01, 0xE0,
  0xF0, 0x78, 0x03, 0xFE, 0x80, 0x0F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 41, 12, 1, -41 },
  { 58, 12, 15, 16, 6, -41 },
  { 81, 23, 41, 22, 0, -41 },
  { 199, 22, 47, 20, 0, -44 },
  { 329, 26, 43, 31, 3, -42 },
  { 469, 20, 43, 20, -1, -42 },
  { 577, 5, 15, 9, 6, -41 },
  { 587, 16, 50, 14, 1, -41 },
  { 687, 16, 50, 14, -4, -41 },
  { 787, 15, 16, 19, 7, -44 },
  { 817, 20, 27, 23, 2, -34 },
  { 885, 7, 13, 10, -2, -6 },
  { 897, 13, 2, 15, 1, -17 },
  { 901, 3, 5, 10, 1, -5 },
  { 903, 24, 41, 17, -3, -41 },
  { 1026, 19, 43, 20, 1, -42 },
  { 1129, 11, 41, 20, 6, -41 },
  { 1186, 23, 42, 20, -2, -42 },
  { 1307, 22, 43, 20, -1, -42 },
  { 1426, 22, 42, 20, -1, -42 },
  { 1542, 22, 42, 20, -1, -41 },
  { 1658, 21, 43, 20, 1, -42 },
  { 1771, 21, 41, 20, 2, -41 },
  { 1879, 22, 43, 20, -1, -42 },
  { 1998, 20, 43, 20, 0, -42 },
  { 2106, 9, 31, 9, 0, -31 },
  { 2141, 12, 38, 10, -3, -31 },
  { 2198, 20, 25, 23, 2, -33 },
  { 2261, 20, 15, 23, 2, -28 },
  { 2299, 20, 25, 23, 2, -33 },
  { 2362, 16, 42, 15, 1, -42 },
  { 2446, 29, 47, 30, 1, -42 },
  { 2617, 20, 42, 20, -4, -42 },
  { 2722, 23, 41, 22, 0, -41 },
  { 2840, 23, 43, 20, 2, -42 },
  { 2964, 23, 41, 24, 0, -41 },
  { 3082, 22, 41, 20, 0, -41 },
  { 3195, 22, 41, 19, 0, -41 },
  { 3308, 26, 43, 27, 2, -42 },
  { 3448, 27, 41, 26, 0, -41 },
  { 3587, 18, 41, 11, -3, -41 },
  { 3680, 19, 51, 10, -8, -41 },
  { 3802, 25, 41, 21, 0, -41 },
  { 3931, 13, 41, 18, 0, -41 },
  { 3998, 36, 41, 35, 0, -41 },
  { 4183, 28, 41, 27, 0, -41 },
  { 4327, 23, 43, 26, 2, -42 },
  { 4451, 22, 41, 21, 0, -41 },
  { 4564, 23, 52, 26, 2, -42 },
  { 4714, 22, 41, 21, 0, -41 },
  { 4827, 24, 43, 20, -2, -42 },
  { 4956, 18, 41, 18, 4, -41 },
  { 5049, 24, 42, 25, 2, -41 },
  { 5175, 20, 41, 21, 5, -41 },
  { 5278, 36, 41, 35, 4, -41 },
  { 5463, 26, 41, 18, -3, -41 },
  { 5597, 18, 41, 18, 4, -41 },
  { 5690, 24, 41, 18, -2, -41 },
  { 5813, 21, 50, 16, -1, -41 },
  { 5945, 8, 41, 19, 6, -41 },
  { 5986, 21, 50, 16, -4, -41 },
  { 6118, 21, 20, 23, 1, -41 },
  { 6171, 15, 2, 16, -4, 5 },
  { 6175, 6, 9, 12, 8, -44 },
  { 6182, 20, 32, 23, 2, -31 },
  { 6262, 21, 45, 22, 0, -44 },
  { 6381, 16, 32, 16, 2, -31 },
  { 6445, 23, 45, 23, 2, -44 },
  { 6575, 17, 32, 20, 2, -31 },
  { 6643, 25, 58, 11, -7, -44 },
  { 6825, 23, 45, 22, -1, -31 },
  { 6955, 20, 44, 21, 0, -44 },
  { 7065, 11, 42, 9, 0, -42 },
  { 7123, 20, 56, 10, -8, -42 },
  { 7263, 20, 44, 18, 0, -44 },
  { 7373, 12, 44, 9, 0, -44 },
  { 7439, 31, 31, 32, 0, -31 },
  { 7560, 20, 31, 21, 0, -31 },
  { 7638, 18, 32, 21, 2, -31 },
  { 7710, 23, 44, 22, -2, -31 },
  { 7837, 20, 45, 23, 2, -31 },
  { 7950, 17, 31, 14, 0, -31 },
  { 8016, 18, 32, 16, -1, -31 },
  { 8088, 11, 39, 11, 1, -38 },
  { 8142, 19, 32, 21, 2, -31 },
  { 8218, 16, 31, 16, 3, -31 },
  { 8280, 27, 31, 28, 3, -31 },
  { 8385, 22, 31, 17, -3, -31 },
  { 8471, 27, 45, 18, -6, -31 },
  { 8623, 18, 31, 14, -2, -31 },
  { 8693, 20, 50, 18, 2, -41 },
  { 8818, 2, 58, 20, 9, -44 },
  { 8833, 20, 50, 18, -4, -41 },
  { 8958, 20, 5, 23, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC58PT7B_H_
