#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC51PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x02,
  0x00, 0x00, 0x3E, 0x3F, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C,
  0x7C, 0x3C, 0x78, 0x7C, 0x78, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF0, 0x78,
  0xF0, 0x78, 0xF0, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00,
  0x3C, 0x1C, 0x00, 0x07, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1C,
  0x00, 0x07, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x07,
  0x07, 0x80, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x80, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0xF0, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x10, 0xF0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0xF0, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0,
  0x78, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0x38, 0xE0, 0xF8, 0xE0,
  0x03, 0xE3, 0x00, 0x0F, 0x0C, 0x00, 0x3C, 0x70, 0x00, 0xF9, 0xC0, 0x03,
  0xE6, 0x00, 0x0F, 0xD8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x77, 0xE0, 0x01, 0x8F, 0x80, 0x06, 0x3E, 0x00, 0x38, 0xF8, 0x00,
  0xE3, 0xE0, 0x03, 0x8F, 0x88, 0x0C, 0x7C, 0x38, 0x33, 0xF0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x10, 0x1F, 0xC0, 0x07, 0x80, 0xFF, 0x80,
  0x1E, 0x07, 0xFF, 0x00, 0xF0, 0x1E, 0x3C, 0x03, 0x80, 0xF0, 0xF0, 0x1E,
  0x03, 0xC3, 0xC0, 0xF0, 0x1E, 0x0F, 0x03, 0xC0, 0x78, 0x3C, 0x1E, 0x01,
  0xE0, 0xF0, 0x78, 0x07, 0x03, 0xC3, 0xC0, 0x3C, 0x0E, 0x1E, 0x00, 0xF0,
  0x78, 0x78, 0x03, 0xC1, 0xE3, 0xC0, 0x0F, 0x07, 0x8F, 0x00, 0x3C, 0x3C,
  0x78, 0xFC, 0xF0, 0xF3, 0xC7, 0xFB, 0xC3, 0xCF, 0x3F, 0xFF, 0x1E, 0x78,
  0xF3, 0xFF, 0xF1, 0xE7, 0x8F, 0x7F, 0xCF, 0x3C, 0x1D, 0xFE, 0x78, 0xF0,
  0x71, 0xE1, 0xE3, 0xC3, 0xC0, 0x0F, 0x1E, 0x0F, 0x00, 0x3C, 0x78, 0x3C,
  0x01, 0xE1, 0xE0, 0xF0, 0x07, 0x87, 0x83, 0xC0, 0x3C, 0x1C, 0x0F, 0x01,
  0xE0, 0xF0, 0x78, 0x07, 0x83, 0xC1, 0xE0, 0x3C, 0x0F, 0x07, 0x80, 0xF0,
  0x3C, 0x3C, 0x07, 0x80, 0xF0, 0xF0, 0x3C, 0x01, 0xE7, 0x80, 0xF0, 0x07,
  0xFE, 0x07, 0x80, 0x1F, 0xF0, 0x3E, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x07, 0xC0,
  0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xC3, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x1F, 0x0F, 0xFF, 0x07, 0xC7, 0xE7, 0xC3,
  0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x3E, 0x7C, 0x7C, 0x0F, 0x9F, 0x1F, 0x01,
  0xFF, 0x87, 0xC0, 0x7F, 0xE3, 0xE0, 0x1F, 0xF0, 0xF8, 0x03, 0xF8, 0x3E,
  0x00, 0xFE, 0x0F, 0x80, 0x3F, 0x03, 0xF0, 0x1F, 0xE0, 0x7E, 0x0F, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xE7, 0xC0, 0xFF, 0xF1, 0xF8, 0x0F, 0xF0,
  0x3F, 0x00, 0x60, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xE7, 0xCF, 0x9F, 0x3C,
  0x78, 0xF1, 0xC7, 0x8F, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x40, 0xF0, 0x1C, 0x3C, 0x07, 0xCE, 0x03, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xDE,
  0x03, 0xE7, 0x81, 0xF8, 0xF0, 0x3C, 0x3C, 0x06, 0x0F, 0x80, 0x81, 0xC0,
  0x00, 0x40, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F,
  0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFB, 0xE2, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03,
  0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xF0, 0xF8,
  0x1F, 0x07, 0xC1, 0xF0, 0x1E, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xCF,
  0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03,
  0xEF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8,
  0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x1F, 0x0F, 0x00, 0xF8,
  0x78, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xFC, 0x7E, 0x07, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0xFF, 0xE7, 0xFF,
  0xBF, 0x3E, 0xF8, 0xF1, 0xC7, 0xC6, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xE0, 0x7E, 0x00, 0xC0, 0x3F,
  0x00, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xBF, 0xC0, 0x38, 0x0F, 0xC0,
  0x40, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x21, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x40,
  0x07, 0xE0, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0xBC, 0x00,
  0x0F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF8, 0x00,
  0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xE0, 0xF0, 0x01,
  0xE1, 0xF0, 0x03, 0xC1, 0xF0, 0x07, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xE2, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF3, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x10, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x20, 0x03, 0xF0, 0x70, 0x1F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0x18,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE3, 0xF0, 0x0F, 0x3F, 0xE0, 0x7D, 0xFF, 0xC1, 0xFF, 0xFF, 0x07,
  0xF8, 0xFE, 0x1F, 0x81, 0xF8, 0xFC, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80,
  0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xF8, 0x3E,
  0x07, 0xE0, 0xFC, 0x3F, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x1F, 0x8F, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x81,
  0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0xFC, 0x7C, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0xFE, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xF8,
  0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x7E,
  0x07, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xBF, 0x03, 0xE0, 0xFC, 0x3F, 0x03, 0xE1,
  0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01,
  0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0x3E,
  0x01, 0xF9, 0xF8, 0x1F, 0xCF, 0xC1, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x07, 0xFE, 0xF8, 0x1F, 0xE7, 0x80, 0x38, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x80, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x7C,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x03, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x3C, 0x02,
  0x00, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x01, 0xF8,
  0x07, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xF3, 0xF8, 0xC0, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0F, 0x0F,
  0x00, 0xF8, 0x0F, 0x0F, 0x03, 0xFF, 0x0F, 0x1E, 0x07, 0xFF, 0x0F, 0x1C,
  0x0F, 0xDF, 0x0F, 0x3C, 0x1E, 0x0F, 0x0F, 0x3C, 0x1E, 0x1E, 0x0F, 0x78,
  0x3C, 0x1E, 0x0F, 0x78, 0x38, 0x1E, 0x0F, 0x78, 0x78, 0x1E, 0x0E, 0x70,
  0x78, 0x3C, 0x0E, 0xF0, 0xF0, 0x3C, 0x1E, 0xF0, 0xF0, 0x3C, 0x1E, 0xF0,
  0xF0, 0x3C, 0x1C, 0xF0, 0xF0, 0x78, 0x3C, 0xE0, 0xF0, 0x78, 0x3C, 0xE0,
  0xF0, 0xF8, 0x78, 0xE0, 0xF0, 0xF8, 0x78, 0xE0, 0xF1, 0xF8, 0xF0, 0xE0,
  0xFF, 0xBF, 0xE0, 0xE0, 0x7F, 0x1F, 0xC0, 0xF0, 0x3E, 0x1F, 0x80, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x08, 0x00, 0x1F,
  0x80, 0x78, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x3E,
  0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x1E,
  0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x1E,
  0x00, 0xF8, 0x1E, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x1E, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xC0, 0x1E,
  0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F,
  0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x7F, 0x03, 0xE0, 0x3F,
  0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7C,
  0x0F, 0x81, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x1F, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0,
  0x7C, 0x07, 0xF0, 0xF8, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xE0,
  0x30, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x81,
  0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3E, 0x0F, 0xF0, 0x1F, 0x01, 0xF8,
  0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07,
  0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x7C, 0x00,
  0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0,
  0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x1F,
  0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x83,
  0xE0, 0x3F, 0x81, 0xF0, 0x3F, 0x81, 0xF9, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xF8, 0x03, 0x00, 0xFE,
  0x00, 0x20, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x7F, 0xE1, 0xF0, 0x0F, 0xFC, 0x3E, 0x01, 0xFF, 0x87, 0xC0, 0x3F,
  0xF1, 0xF8, 0x0F, 0xFE, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xFC,
  0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3E,
  0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xF8,
  0x07, 0xC0, 0x3F, 0x80, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00,
  0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0,
  0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0,
  0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x00, 0xF8,
  0x0F, 0x80, 0x0F, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F,
  0x01, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E,
  0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x07,
  0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07,
  0xC0, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00,
  0xF8, 0x0F, 0x80, 0x1F, 0x80, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x03, 0x3F, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xC0,
  0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x00,
  0xF8, 0x7E, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x78, 0xF8,
  0x00, 0x1F, 0x3F, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xF9, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0,
  0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00,
  0x3E, 0x07, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01,
  0xF0, 0x03, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x03, 0xDF, 0x01, 0xFF, 0x80, 0x3E, 0xF0, 0x0F, 0x7C,
  0x01, 0xEF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0x00, 0xF3, 0xE0,
  0x3E, 0x78, 0x0F, 0x9E, 0x01, 0xF3, 0xC0, 0x79, 0xF0, 0x0F, 0x1E, 0x07,
  0xCF, 0x80, 0xF8, 0xF0, 0x3C, 0x7C, 0x07, 0xC7, 0x83, 0xE3, 0xE0, 0x3E,
  0x3C, 0x1E, 0x1E, 0x01, 0xE1, 0xE1, 0xF1, 0xF0, 0x0F, 0x0F, 0x0F, 0x0F,
  0x80, 0xF8, 0x78, 0xF8, 0x7C, 0x07, 0xC3, 0xC7, 0x83, 0xE0, 0x3E, 0x1E,
  0x3C, 0x3E, 0x01, 0xE0, 0xF3, 0xC1, 0xF0, 0x0F, 0x07, 0xDE, 0x0F, 0x80,
  0xF8, 0x3F, 0xE0, 0x7C, 0x07, 0xC1, 0xFF, 0x03, 0xC0, 0x3E, 0x0F, 0xF8,
  0x3E, 0x01, 0xE0, 0x3F, 0x81, 0xF0, 0x1F, 0x01, 0xFC, 0x0F, 0x80, 0xF8,
  0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E,
  0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x7C, 0x07, 0xE0,
  0x01, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0xFF, 0x00, 0x3E, 0x03, 0xFC, 0x00,
  0xF8, 0x0F, 0xF0, 0x03, 0xE0, 0x3F, 0xC0, 0x0F, 0x00, 0xFF, 0x80, 0x7C,
  0x07, 0xFE, 0x01, 0xF0, 0x1F, 0x78, 0x07, 0xC0, 0x79, 0xE0, 0x1F, 0x01,
  0xE7, 0xC0, 0x78, 0x0F, 0x9F, 0x03, 0xE0, 0x3E, 0x7C, 0x0F, 0x80, 0xF8,
  0xF0, 0x3E, 0x03, 0xE3, 0xE0, 0xF0, 0x0F, 0x0F, 0x87, 0xC0, 0x7C, 0x3E,
  0x1F, 0x01, 0xF0, 0x78, 0x7C, 0x07, 0xC1, 0xE1, 0xF0, 0x1F, 0x07, 0xC7,
  0x80, 0x78, 0x1F, 0x3E, 0x03, 0xE0, 0x3C, 0xF8, 0x0F, 0x80, 0xF3, 0xE0,
  0x3E, 0x03, 0xEF, 0x80, 0xF0, 0x0F, 0xBC, 0x03, 0xC0, 0x3E, 0xF0, 0x1F,
  0x00, 0x7F, 0xC0, 0x7C, 0x01, 0xFF, 0x01, 0xF0, 0x07, 0xFC, 0x07, 0x80,
  0x1F, 0xE0, 0x3E, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0xFE, 0x03, 0xE0, 0x03,
  0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x3C, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F,
  0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F,
  0x1F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x1F, 0x7E, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFD, 0xF0,
  0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03,
  0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x07, 0xC0,
  0x1F, 0x81, 0xF8, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x03, 0xE0, 0xFE, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xE0,
  0x3F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3F, 0x07, 0xC0,
  0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7E, 0x0F, 0x80,
  0xFC, 0x0F, 0x81, 0xFC, 0x1F, 0x07, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF1, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xF7,
  0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03,
  0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x3F, 0x00,
  0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F,
  0x00, 0x3F, 0x07, 0xC0, 0x1F, 0x81, 0xF8, 0x0F, 0xE0, 0x3F, 0x07, 0xF0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3E, 0x0F, 0xE0, 0x7C, 0x0F,
  0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C,
  0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x78, 0x03, 0xE1, 0xF0, 0x0F, 0xC3,
  0xE0, 0x3F, 0x07, 0xC0, 0xFE, 0x0F, 0x83, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x87,
  0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E,
  0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0,
  0x3C, 0x03, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87,
  0xC0, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x0E, 0x03, 0xF0, 0x02,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x60, 0x07, 0xE0, 0x78, 0x1F, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00,
  0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F,
  0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x0F,
  0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8,
  0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8,
  0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00,
  0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x03,
  0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x07,
  0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x0F,
  0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x3D, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xC0, 0x0F, 0xDF, 0x00,
  0x3E, 0x00, 0x7C, 0xF0, 0x03, 0xF0, 0x03, 0xE7, 0x80, 0x1F, 0x80, 0x3E,
  0x3C, 0x01, 0xFC, 0x01, 0xF1, 0xE0, 0x0F, 0xE0, 0x1F, 0x0F, 0x00, 0xFF,
  0x00, 0xF8, 0x78, 0x07, 0xF8, 0x07, 0xC3, 0xC0, 0x3F, 0xC0, 0x7C, 0x1E,
  0x03, 0xDE, 0x03, 0xE0, 0xF0, 0x1E, 0xF0, 0x3E, 0x07, 0x81, 0xF7, 0x81,
  0xF0, 0x3C, 0x0F, 0x3C, 0x0F, 0x81, 0xE0, 0x79, 0xE0, 0xF8, 0x0F, 0x07,
  0x8F, 0x07, 0xC0, 0x78, 0x3C, 0x78, 0x7C, 0x03, 0xC3, 0xE3, 0xC3, 0xE0,
  0x1E, 0x1E, 0x1E, 0x1F, 0x00, 0xF1, 0xF0, 0xF1, 0xF0, 0x07, 0x8F, 0x07,
  0x8F, 0x80, 0x3C, 0x78, 0x3C, 0xF8, 0x01, 0xE7, 0xC1, 0xE7, 0xC0, 0x0F,
  0x3C, 0x0F, 0x3E, 0x00, 0xF9, 0xE0, 0x7B, 0xE0, 0x07, 0xDE, 0x03, 0xDF,
  0x00, 0x3E, 0xF0, 0x1E, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x00,
  0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF1, 0xF0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0x3C, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8,
  0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0x7C, 0x03,
  0xE1, 0xF0, 0x1F, 0x83, 0xC0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80,
  0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0x79,
  0xF0, 0x01, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xF8, 0x3E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0,
  0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x7D, 0xE0,
  0x01, 0xE7, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0xF8, 0x0F,
  0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x1F, 0x07, 0x80, 0x3C, 0x3E, 0x00,
  0xF0, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0xBE, 0x00, 0x1E, 0xF0, 0x00, 0x7C,
  0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x1F,
  0x87, 0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0x00, 0x7C, 0x00, 0x07, 0xF8, 0xF0,
  0x3F, 0xF7, 0xC1, 0xFF, 0xDE, 0x0F, 0xE7, 0xF8, 0x7E, 0x0F, 0xE1, 0xF0,
  0x1F, 0x8F, 0xC0, 0x7E, 0x3E, 0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E,
  0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x7F, 0x0F, 0x81, 0xF8, 0x3F, 0x0F, 0xE0,
  0xFF, 0xF7, 0x81, 0xFF, 0xBE, 0x07, 0xFC, 0xF8, 0x0F, 0xE3, 0xC0, 0x04,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x1F,
  0x00, 0x3E, 0x7F, 0x80, 0x79, 0xFF, 0x01, 0xF7, 0xFF, 0x03, 0xFE, 0x7E,
  0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x7E, 0x01, 0xF0,
  0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0x80, 0x3F, 0x1F,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE3, 0xE0,
  0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0x03,
  0xF0, 0xFE, 0x07, 0xC1, 0xFC, 0x1F, 0x83, 0xDF, 0xFE, 0x07, 0xBF, 0xF8,
  0x0F, 0x3F, 0xE0, 0x3C, 0x3F, 0x80, 0x00, 0x18, 0x00, 0x00, 0x7F, 0x00,
  0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xE3, 0x87, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x30, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xC0,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x7C, 0x7C, 0x01, 0xFE, 0x7C, 0x03, 0xFF, 0x7C, 0x07, 0xFF, 0x78,
  0x0F, 0xE7, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0x01, 0xF8, 0x3F, 0x01, 0xF8,
  0x3E, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0xFC, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0,
  0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0,
  0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x1F, 0x80, 0xF8, 0x3F, 0x80,
  0xFF, 0xF7, 0x80, 0x7F, 0xE7, 0x80, 0x7F, 0xCF, 0x80, 0x3F, 0x8F, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF,
  0xF0, 0xFC, 0x3E, 0x3F, 0x07, 0xC7, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x03,
  0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x0F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x30,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xF1, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0x8F, 0x00, 0xFF, 0xDF, 0x01, 0xFF, 0xDE, 0x03, 0xF9,
  0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0x80,
  0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03,
  0xF0, 0x3E, 0x07, 0xF0, 0x3E, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFB, 0xE0, 0x1F, 0xF3, 0xE0, 0x0F, 0xE7, 0xC0, 0x01, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x80, 0x1F, 0x00, 0xE0, 0x7F, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x03, 0xEF, 0xF8, 0x0F, 0x7F,
  0xF0, 0x7D, 0xFF, 0xC1, 0xFF, 0x3F, 0x07, 0xF0, 0x7C, 0x1F, 0x81, 0xF0,
  0x7C, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8,
  0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F,
  0x87, 0xC0, 0x3E, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F,
  0x80, 0x7C, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00,
  0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x70,
  0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x01, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x7C, 0x03,
  0xC0, 0xF8, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xC7, 0xE0, 0x07,
  0x87, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x9F, 0x00, 0x0F, 0xBE, 0x00, 0x0F,
  0x7E, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C,
  0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0xC0, 0xF8,
  0x07, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0xF3,
  0xFE, 0x1F, 0xE0, 0x3D, 0xFF, 0x9F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07,
  0xF8, 0xFF, 0xCF, 0xC1, 0xFC, 0x1F, 0xC1, 0xF0, 0x7E, 0x07, 0xE0, 0x7C,
  0x1F, 0x01, 0xF8, 0x1F, 0x0F, 0xC0, 0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x01,
  0xF0, 0xF8, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xE0, 0x1E, 0x0F, 0x00, 0xF8,
  0x0F, 0x87, 0xC0, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x80, 0xF8, 0x7C, 0x07,
  0xC0, 0x3E, 0x1F, 0x01, 0xF0, 0x0F, 0x07, 0x80, 0x7C, 0x07, 0xC3, 0xE0,
  0x1F, 0x01, 0xF0, 0xF8, 0x07, 0x80, 0x7C, 0x3E, 0x03, 0xE0, 0x1F, 0x0F,
  0x80, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x80, 0xF8,
  0x7C, 0x03, 0xC0, 0x3E, 0x1F, 0x01, 0xF0, 0x0F, 0x07, 0x80, 0x7C, 0x07,
  0xC3, 0xE0, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x3F, 0xE0, 0x3D,
  0xFF, 0xC1, 0xF7, 0xFF, 0x07, 0xFC, 0xFC, 0x1F, 0xC1, 0xF0, 0x7E, 0x07,
  0xC1, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xF8, 0x07, 0xC3,
  0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C,
  0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xC7, 0xE1, 0xF8,
  0x3F, 0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x1F, 0x7C,
  0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x00, 0x7C,
  0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0xC3, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x78, 0xFF, 0x00, 0x3C, 0xFF, 0xC0, 0x1E, 0xFF, 0xE0,
  0x1F, 0xE3, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F,
  0x03, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01,
  0xF0, 0x3C, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80,
  0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0,
  0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x3F,
  0x83, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0x9F, 0xF0, 0x07,
  0xC7, 0xF0, 0x03, 0xE0, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF8, 0xF0, 0x3F, 0xF7,
  0xC1, 0xFF, 0xDE, 0x0F, 0xE7, 0xF8, 0x7E, 0x0F, 0xE1, 0xF0, 0x1F, 0x8F,
  0xC0, 0x7E, 0x3E, 0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00,
  0x7C, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8,
  0x0F, 0xC3, 0xE0, 0x3F, 0x0F, 0x81, 0xF8, 0x3F, 0x0F, 0xE0, 0xFF, 0xFF,
  0x81, 0xFF, 0xBE, 0x07, 0xFC, 0xF8, 0x0F, 0xE7, 0xC0, 0x04, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x79, 0xF8, 0x0F,
  0x7F, 0x03, 0xEF, 0xE0, 0x7F, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFC,
  0x38, 0x3F, 0x01, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x20, 0x0F, 0x86, 0x03, 0xF0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x20, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x0F, 0xFF,
  0x7F, 0xFD, 0xFF, 0xE1, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x00, 0x80, 0x00,
  0x0F, 0x80, 0x7C, 0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F,
  0x00, 0xF8, 0x7C, 0x03, 0xC1, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1,
  0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x1F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x7E,
  0x0F, 0x87, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xEF, 0x01, 0xFF, 0x3C, 0x03,
  0xF8, 0xF0, 0x03, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x07,
  0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x87, 0xC0, 0xF8,
  0x7C, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x07, 0x9F, 0x00, 0x79, 0xF0, 0x07,
  0x9E, 0x00, 0x7B, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x0F, 0xC0, 0x3F, 0xF0, 0x1F, 0x80, 0xFB, 0xE0, 0x7F, 0x01,
  0xF7, 0xC0, 0xFE, 0x07, 0xCF, 0x81, 0xFC, 0x0F, 0x9F, 0x07, 0xF8, 0x1E,
  0x3E, 0x0F, 0xF0, 0x7C, 0x7C, 0x3D, 0xE0, 0xF8, 0xF8, 0x7B, 0xC3, 0xE1,
  0xF0, 0xF7, 0x87, 0xC3, 0xE3, 0xCF, 0x0F, 0x07, 0xC7, 0x9E, 0x3E, 0x0F,
  0x9E, 0x3C, 0x78, 0x1F, 0x3C, 0x79, 0xF0, 0x3E, 0x78, 0xF3, 0xE0, 0x7D,
  0xE1, 0xE7, 0x80, 0xFB, 0xC3, 0xDF, 0x01, 0xEF, 0x07, 0xBC, 0x03, 0xDE,
  0x0F, 0x78, 0x07, 0xBC, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x7F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03,
  0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x3F, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xFC, 0x01, 0xF0,
  0xF8, 0x01, 0xF1, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xEF, 0x00, 0x03, 0xEF, 0x80, 0x07, 0xCF, 0x80, 0x0F, 0x8F,
  0x80, 0x1F, 0x87, 0x80, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7E, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xE0, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x01, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0x81, 0xF0, 0x00, 0xF0,
  0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x7C, 0x00,
  0x0F, 0x0F, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xDF, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7C,
  0x00, 0x00, 0x06, 0x00, 0x09, 0xFE, 0x00, 0x5F, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0xD0, 0x00, 0x30,
};

const GFXglyph NotoSans_Condensed_MediumItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 37, 13, 1, -36 },
  { 62, 16, 13, 19, 5, -36 },
  { 88, 27, 36, 26, 0, -36 },
  { 210, 22, 42, 23, 1, -39 },
  { 326, 30, 38, 35, 3, -37 },
  { 469, 26, 38, 27, 0, -37 },
  { 593, 7, 13, 11, 5, -36 },
  { 605, 17, 45, 14, 1, -37 },
  { 701, 17, 45, 14, -4, -37 },
  { 797, 18, 20, 22, 5, -39 },
  { 842, 21, 24, 24, 2, -30 },
  { 905, 10, 13, 12, -2, -6 },
  { 922, 12, 5, 14, 1, -16 },
  { 930, 6, 7, 12, 1, -6 },
  { 936, 25, 37, 18, -3, -37 },
  { 1052, 21, 38, 23, 2, -37 },
  { 1152, 14, 36, 23, 6, -36 },
  { 1215, 24, 37, 23, -1, -37 },
  { 1326, 23, 38, 23, 0, -37 },
  { 1436, 24, 37, 23, -1, -37 },
  { 1547, 23, 37, 23, 0, -36 },
  { 1654, 22, 38, 23, 2, -37 },
  { 1759, 23, 36, 23, 2, -36 },
  { 1863, 23, 38, 23, 0, -37 },
  { 1973, 21, 38, 23, 1, -37 },
  { 2073, 11, 29, 12, 0, -28 },
  { 2113, 14, 35, 12, -3, -28 },
  { 2175, 21, 24, 24, 2, -30 },
  { 2238, 21, 14, 24, 2, -25 },
  { 2275, 21, 24, 24, 2, -30 },
  { 2338, 17, 38, 18, 2, -37 },
  { 2419, 32, 41, 35, 2, -37 },
  { 2583, 24, 37, 24, -3, -37 },
  { 2694, 24, 36, 25, 1, -36 },
  { 2802, 25, 38, 23, 2, -37 },
  { 2921, 25, 36, 27, 1, -36 },
  { 3034, 23, 36, 21, 1, -36 },
  { 3138, 23, 36, 20, 1, -36 },
  { 3242, 27, 38, 28, 2, -37 },
  { 3371, 28, 36, 28, 1, -36 },
  { 3497, 21, 36, 15, -2, -36 },
  { 3592, 21, 46, 12, -8, -36 },
  { 3713, 27, 36, 24, 1, -36 },
  { 3835, 16, 36, 20, 1, -36 },
  { 3907, 37, 36, 37, 1, -36 },
  { 4074, 30, 36, 30, 1, -36 },
  { 4209, 26, 38, 29, 2, -37 },
  { 4333, 24, 36, 24, 1, -36 },
  { 4441, 26, 46, 29, 2, -37 },
  { 4591, 23, 36, 24, 1, -36 },
  { 4695, 24, 38, 22, -1, -37 },
  { 4809, 21, 36, 21, 4, -36 },
  { 4904, 27, 37, 28, 2, -36 },
  { 5029, 24, 36, 24, 4, -36 },
  { 5137, 37, 36, 37, 4, -36 },
  { 5304, 29, 36, 22, -3, -36 },
  { 5435, 22, 36, 21, 4, -36 },
  { 5534, 26, 36, 21, -2, -36 },
  { 5651, 19, 45, 15, -1, -37 },
  { 5758, 10, 37, 18, 5, -37 },
  { 5805, 20, 45, 15, -4, -37 },
  { 5918, 22, 21, 23, 1, -36 },
  { 5976, 18, 4, 17, -5, 4 },
  { 5985, 9, 8, 14, 7, -39 },
  { 5994, 22, 29, 24, 2, -28 },
  { 6074, 23, 40, 24, 0, -39 },
  { 6189, 18, 29, 19, 2, -28 },
  { 6255, 24, 40, 24, 2, -39 },
  { 6375, 19, 29, 22, 2, -28 },
  { 6444, 26, 51, 14, -6, -39 },
  { 6610, 24, 40, 24, 0, -28 },
  { 6730, 22, 39, 24, 0, -39 },
  { 6838, 13, 38, 11, 0, -38 },
  { 6900, 20, 50, 11, -7, -38 },
  { 7025, 24, 39, 21, 0, -39 },
  { 7142, 13, 39, 11, 0, -39 },
  { 7206, 34, 28, 36, 0, -28 },
  { 7325, 22, 28, 24, 0, -28 },
  { 7402, 20, 29, 24, 2, -28 },
  { 7475, 25, 40, 24, -2, -28 },
  { 7600, 22, 40, 24, 2, -28 },
  { 7710, 19, 28, 17, 0, -28 },
  { 7777, 19, 29, 19, 0, -28 },
  { 7846, 14, 35, 14, 2, -34 },
  { 7908, 22, 28, 24, 2, -27 },
  { 7985, 20, 27, 20, 3, -27 },
  { 8053, 31, 27, 31, 3, -27 },
  { 8158, 24, 27, 21, -2, -27 },
  { 8239, 27, 39, 20, -4, -27 },
  { 8371, 21, 27, 18, -2, -27 },
  { 8442, 19, 44, 17, 1, -36 },
  { 8547, 4, 51, 22, 9, -39 },
  { 8573, 19, 44, 17, -3, -36 },
  { 8678, 21, 8, 24, 2, -22 },
};

const GFXfont NotoSans_Condensed_MediumItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC51PT7B_H_
