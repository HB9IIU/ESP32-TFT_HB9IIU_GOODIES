#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC52PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x10, 0x00, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x78,
  0x78, 0xF0, 0x78, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x3C,
  0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x83, 0xC0, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0x1C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x1E, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0x1E, 0x0F, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x0F, 0xCC, 0xF0, 0x1F, 0x38, 0x20, 0x7C, 0x70, 0x00, 0xF8, 0xC0, 0x01,
  0xF1, 0x80, 0x03, 0xE3, 0x00, 0x07, 0xCE, 0x00, 0x0F, 0xDC, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xEF,
  0xC0, 0x01, 0xCF, 0x80, 0x03, 0x1F, 0x00, 0x06, 0x3E, 0x00, 0x1C, 0x7C,
  0x00, 0x38, 0xF8, 0x40, 0x63, 0xF0, 0xE0, 0xCF, 0xC1, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xE0, 0x1F, 0xE0,
  0x07, 0x80, 0x7F, 0xE0, 0x0F, 0x01, 0xE3, 0xC0, 0x3C, 0x03, 0xC7, 0x80,
  0x78, 0x0F, 0x0F, 0x01, 0xE0, 0x1E, 0x1E, 0x07, 0xC0, 0x78, 0x3C, 0x0F,
  0x00, 0xF0, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x78, 0x03, 0x81, 0xE1, 0xE0,
  0x0F, 0x03, 0xC3, 0xC0, 0x1E, 0x0F, 0x0F, 0x00, 0x3C, 0x1E, 0x3C, 0x00,
  0x78, 0x3C, 0x78, 0x70, 0xF0, 0xF1, 0xE3, 0xF9, 0xE1, 0xE3, 0xCF, 0xFB,
  0xC3, 0xCF, 0x3F, 0xFF, 0x8F, 0x3C, 0x78, 0xFF, 0xFC, 0x79, 0xE1, 0xEF,
  0xF9, 0xE3, 0xC3, 0xCF, 0xE3, 0xCF, 0x07, 0x86, 0x0F, 0x1E, 0x0F, 0x00,
  0x3C, 0x3C, 0x1E, 0x00, 0x78, 0xF0, 0x3C, 0x01, 0xE1, 0xE0, 0x78, 0x03,
  0xC3, 0xC1, 0xE0, 0x0F, 0x07, 0x83, 0xC0, 0x3E, 0x0F, 0x07, 0x80, 0x78,
  0x1E, 0x0F, 0x01, 0xE0, 0x3C, 0x3C, 0x03, 0xC0, 0x78, 0x78, 0x0F, 0x00,
  0xF1, 0xE0, 0x3E, 0x01, 0xE7, 0xC0, 0x78, 0x03, 0xFF, 0x01, 0xE0, 0x03,
  0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x7C, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xC0, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC3,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x07, 0xC3, 0xF7, 0xC1, 0xF1, 0xF9, 0xF0,
  0x78, 0xFC, 0x3E, 0x3E, 0x3E, 0x0F, 0x8F, 0x9F, 0x03, 0xF7, 0xC7, 0xC0,
  0x7D, 0xF1, 0xF0, 0x1F, 0xF8, 0xF8, 0x03, 0xFC, 0x3E, 0x00, 0xFF, 0x0F,
  0x80, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xF8, 0x1F, 0x83, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFD, 0xF8, 0x3F, 0xFC, 0x3E, 0x03, 0xFE,
  0x0F, 0xC0, 0x18, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C,
  0x7C, 0x78, 0x78, 0x78, 0x70, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0xC1, 0xE0, 0x1E, 0x3C, 0x07, 0xF7,
  0x83, 0xFF, 0xFF, 0xE7, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F,
  0x00, 0x1F, 0xF0, 0x07, 0xDE, 0x01, 0xF1, 0xE0, 0x7E, 0x3C, 0x07, 0x87,
  0xC0, 0x60, 0x7C, 0x04, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F,
  0xC3, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFD, 0xFF, 0xE0, 0x11, 0xFF, 0xFF, 0xFF, 0xFF, 0x88, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xF8, 0xF8, 0x1F, 0x83, 0xE1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8,
  0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0x7C, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0x9F,
  0x00, 0x7D, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x0F,
  0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0x3E, 0x01, 0xF1, 0xE0,
  0x0F, 0x8F, 0x00, 0xFC, 0x78, 0x07, 0xC3, 0xE0, 0x7E, 0x1F, 0x03, 0xE0,
  0xF8, 0x3F, 0x07, 0xE3, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x07,
  0xF0, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x3F, 0x7C, 0xFC, 0xF8,
  0xF1, 0xF1, 0x87, 0xC1, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x7F, 0x00,
  0xE0, 0x3F, 0x00, 0x80, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x3C, 0x0F, 0xC0, 0x60, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x03, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x80, 0x0F, 0xC1, 0xC0, 0x3F,
  0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xBE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x7C, 0x00, 0x1E,
  0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF8, 0x00, 0x78,
  0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0xF0, 0x03, 0xC1,
  0xF0, 0x07, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x07, 0x1F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x80, 0x0F, 0xC0, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0xC0, 0x0F, 0x9F, 0xE0, 0x3C, 0xFF, 0xC1,
  0xF7, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xC1, 0xF8, 0x7E, 0x03, 0xE3, 0xF0,
  0x0F, 0x8F, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x0F,
  0x80, 0x7C, 0x3E, 0x03, 0xF0, 0xFC, 0x1F, 0x81, 0xF0, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x18, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x1F,
  0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0xF8, 0x01, 0xFB, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x1F, 0x87, 0xE0, 0x3F, 0x03, 0xF0,
  0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x00, 0xF8,
  0xFC, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0x7C, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F,
  0x87, 0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x3F, 0x0F, 0x80, 0x7C, 0x7C, 0x01,
  0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x03, 0xF3,
  0xE0, 0x0F, 0xCF, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xF0,
  0x3F, 0x87, 0xE1, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xDF,
  0x01, 0xFC, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x02, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x0F, 0x03, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x3E, 0x02,
  0x00, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x01, 0xFF, 0x81,
  0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0x03, 0xF1, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x03, 0x83, 0xC0, 0x7F, 0xC1, 0xC3, 0xC0, 0x7F, 0xF0,
  0xF1, 0xE0, 0x7F, 0xF0, 0x78, 0xE0, 0x7C, 0x78, 0x3C, 0xF0, 0x78, 0x3C,
  0x1E, 0x78, 0x3C, 0x1E, 0x0E, 0x78, 0x3C, 0x1E, 0x07, 0x3C, 0x1C, 0x0F,
  0x03, 0x9E, 0x1E, 0x07, 0x83, 0xCE, 0x0F, 0x03, 0xC1, 0xEF, 0x07, 0x03,
  0xC0, 0xF7, 0x87, 0x81, 0xE0, 0x73, 0xC3, 0xC0, 0xF0, 0x79, 0xE1, 0xE0,
  0x78, 0x3C, 0xF0, 0xF0, 0x78, 0x3C, 0x70, 0x78, 0x3C, 0x1E, 0x38, 0x3C,
  0x3E, 0x1E, 0x1C, 0x1F, 0x3F, 0x9E, 0x0E, 0x07, 0xF9, 0xFF, 0x07, 0x83,
  0xF8, 0xFF, 0x03, 0xC0, 0xF8, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x80, 0x00, 0xFC, 0x03, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xDE, 0x00, 0x07,
  0xDE, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x9E, 0x00, 0x0F, 0x1E, 0x00, 0x1F,
  0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xC0, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3E, 0x07, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x7E, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0xC1,
  0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x7E, 0x01, 0xF0,
  0x3E, 0x03, 0xF0, 0x1F, 0x0F, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x7C, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0,
  0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xFC, 0x3F, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xF0, 0x30, 0x0F, 0xE0, 0x08, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x40, 0x1F, 0xC0, 0xE0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x03, 0xF3, 0xFF, 0x00, 0xF8, 0x0F, 0xE0, 0x3E, 0x01,
  0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7C,
  0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0,
  0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x03,
  0xF1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xC0,
  0x07, 0xE1, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F,
  0x80, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xFC,
  0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x3C, 0x03, 0xF8,
  0x00, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xFF, 0x87, 0xC0, 0x3F, 0xF8, 0x7C,
  0x03, 0xFF, 0x07, 0xC0, 0x3F, 0xF0, 0x7C, 0x03, 0xFF, 0x0F, 0xC0, 0x01,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00,
  0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x7F, 0x00, 0x7C, 0x03, 0xFC, 0x0F, 0xC0,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x80,
  0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x1F,
  0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x03,
  0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80,
  0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x1F,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80,
  0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3F,
  0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x07,
  0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80,
  0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x3E,
  0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x04, 0x7F, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x03,
  0xF0, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x03,
  0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x0F,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x00,
  0x7C, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F,
  0x80, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0x00, 0x01, 0xF9,
  0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x7C,
  0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x7E,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0x80, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFE, 0x03, 0xFE,
  0x00, 0x3D, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xF7, 0x80, 0x1E, 0xF8,
  0x0F, 0xBC, 0x01, 0xF7, 0xC0, 0x79, 0xE0, 0x0F, 0x3E, 0x07, 0xCF, 0x00,
  0xF9, 0xE0, 0x3E, 0x78, 0x07, 0xDF, 0x01, 0xF3, 0xC0, 0x3C, 0xF8, 0x0F,
  0x9E, 0x03, 0xE7, 0xC0, 0x78, 0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0x81, 0xF3,
  0xE0, 0x3E, 0x3C, 0x0F, 0x1F, 0x01, 0xF1, 0xE0, 0xF8, 0xF8, 0x0F, 0x8F,
  0x87, 0x87, 0xC0, 0x78, 0x7C, 0x7C, 0x3E, 0x07, 0xC3, 0xE3, 0xC3, 0xE0,
  0x3E, 0x1F, 0x3E, 0x1F, 0x01, 0xF0, 0xF9, 0xE0, 0xF8, 0x0F, 0x87, 0xDF,
  0x07, 0xC0, 0x78, 0x1E, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0x83, 0xE0, 0x3E,
  0x07, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0xC0, 0xF8, 0x0F, 0x01, 0xFC, 0x07,
  0xC0, 0xF8, 0x0F, 0xE0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x03,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x7C, 0x07, 0xF0, 0x01, 0xF0, 0x1F, 0xC0, 0x07,
  0xC0, 0x7F, 0x00, 0x1F, 0x03, 0xFC, 0x00, 0x78, 0x0F, 0xF0, 0x03, 0xE0,
  0x3F, 0xE0, 0x0F, 0x80, 0xFF, 0x80, 0x3E, 0x03, 0xFE, 0x00, 0xF8, 0x1F,
  0x78, 0x03, 0xC0, 0x7D, 0xF0, 0x1F, 0x01, 0xF7, 0xC0, 0x7C, 0x07, 0x9F,
  0x01, 0xF0, 0x3E, 0x3C, 0x07, 0xC0, 0xF8, 0xF0, 0x3E, 0x03, 0xE3, 0xE0,
  0xF8, 0x0F, 0x8F, 0x83, 0xE0, 0x3C, 0x1E, 0x0F, 0x81, 0xF0, 0x78, 0x3E,
  0x07, 0xC1, 0xF1, 0xF0, 0x1F, 0x07, 0xC7, 0xC0, 0x7C, 0x1F, 0x1F, 0x01,
  0xE0, 0x3C, 0x7C, 0x0F, 0x80, 0xF9, 0xE0, 0x3E, 0x03, 0xEF, 0x80, 0xF8,
  0x0F, 0xBE, 0x03, 0xE0, 0x1E, 0xF8, 0x0F, 0x00, 0x7B, 0xE0, 0x7C, 0x01,
  0xFF, 0x01, 0xF0, 0x07, 0xFC, 0x07, 0xC0, 0x1F, 0xF0, 0x1E, 0x00, 0x3F,
  0xC0, 0xF8, 0x00, 0xFF, 0x03, 0xE0, 0x03, 0xF8, 0x0F, 0x80, 0x0F, 0xE0,
  0x3E, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x3E, 0x07,
  0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xF1, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF9, 0xF0,
  0x00, 0x3F, 0x3E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F,
  0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x9F, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3,
  0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0xFC, 0x1F, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x07,
  0xF0, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xF1, 0xFE, 0x03,
  0xE0, 0x3F, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x07,
  0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F,
  0xC0, 0x3F, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0xFC, 0x0F,
  0x81, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x3F,
  0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F,
  0x8F, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xCF, 0xC0,
  0x01, 0xF9, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00,
  0x1F, 0x9F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x9F,
  0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E,
  0x01, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x03, 0xE0, 0xFE, 0x03, 0xE0, 0x7F, 0x03, 0xE0, 0x3F, 0x03,
  0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07,
  0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7E, 0x0F,
  0x80, 0xFC, 0x0F, 0x81, 0xFC, 0x0F, 0x8F, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0x1F, 0x00, 0x3F,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x3E,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7C,
  0x07, 0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0xF8,
  0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xE0, 0xF0,
  0x0F, 0xE0, 0x08, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x80, 0x07, 0xE0, 0x60, 0x07, 0xE0,
  0x3E, 0x1F, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0,
  0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xC0,
  0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x00,
  0xFC, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x1F,
  0x80, 0x1F, 0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0x81, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF8,
  0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x7F, 0x0F, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8,
  0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xE0,
  0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x3F, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0x79, 0xF0, 0x00,
  0x79, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xBE, 0x00, 0x7E, 0x00, 0x7D, 0xF0,
  0x03, 0xF0, 0x07, 0xEF, 0x80, 0x3F, 0x80, 0x3E, 0x7C, 0x01, 0xFC, 0x01,
  0xF3, 0xE0, 0x1F, 0xE0, 0x1F, 0x1F, 0x00, 0xFF, 0x00, 0xF8, 0xF8, 0x07,
  0xF8, 0x0F, 0xC7, 0xC0, 0x7B, 0xC0, 0x7C, 0x3E, 0x03, 0xDE, 0x03, 0xE1,
  0xF0, 0x3F, 0xF0, 0x3E, 0x0F, 0x81, 0xEF, 0x81, 0xF0, 0x7C, 0x1F, 0x7C,
  0x1F, 0x83, 0xE0, 0xF3, 0xE0, 0xF8, 0x1F, 0x07, 0x9F, 0x07, 0xC0, 0xF0,
  0x7C, 0xF8, 0x7C, 0x07, 0x83, 0xC7, 0xC3, 0xE0, 0x3C, 0x3E, 0x3E, 0x3F,
  0x01, 0xE1, 0xE1, 0xF1, 0xF0, 0x0F, 0x0F, 0x0F, 0x8F, 0x80, 0x78, 0xF8,
  0x78, 0xF8, 0x03, 0xC7, 0x83, 0xC7, 0xC0, 0x1E, 0x7C, 0x1E, 0x3C, 0x00,
  0xF3, 0xC0, 0xF3, 0xE0, 0x07, 0x9E, 0x07, 0x9F, 0x00, 0x3D, 0xF0, 0x3D,
  0xF0, 0x01, 0xEF, 0x01, 0xEF, 0x80, 0x0F, 0xF8, 0x0F, 0x78, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x3E,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFF, 0xE0,
  0x07, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F,
  0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x81, 0xF0, 0x7C, 0x07,
  0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x3C, 0x7C, 0x00, 0xF1, 0xF0, 0x03, 0xEF,
  0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x10, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xF0, 0x01, 0xF3,
  0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x3E, 0x01, 0xF0, 0x78, 0x07, 0x81, 0xE0,
  0x3E, 0x07, 0xC0, 0xF0, 0x0F, 0x07, 0xC0, 0x3C, 0x1E, 0x00, 0xF8, 0xF0,
  0x01, 0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x7F, 0xFF,
  0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xF8, 0xFC, 0xFC, 0x7C,
  0x3E, 0x3E, 0x1E, 0x0F, 0x00, 0x10, 0x00, 0x01, 0xFC, 0x7C, 0x0F, 0xFC,
  0xF0, 0x3F, 0xFB, 0xE0, 0xFF, 0xFF, 0xC1, 0xF8, 0x7F, 0x87, 0xE0, 0x7E,
  0x0F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7C, 0x03, 0xF1, 0xF8, 0x07, 0xE3,
  0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7C,
  0x00, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0,
  0x3F, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x0F,
  0xE0, 0xFC, 0x3F, 0xC1, 0xFF, 0xEF, 0x01, 0xFF, 0xDE, 0x03, 0xFF, 0x3C,
  0x03, 0xF8, 0x78, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x06, 0x00, 0x3E, 0x3F, 0x00, 0x7D, 0xFF, 0x80,
  0xFF, 0xFF, 0x03, 0xEF, 0xFF, 0x07, 0xF8, 0x7E, 0x0F, 0xE0, 0x7C, 0x1F,
  0x80, 0xF8, 0x3E, 0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0,
  0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01,
  0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0x80, 0x3E,
  0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7E, 0x03, 0xE1, 0xFC, 0x0F, 0xC3,
  0xFC, 0x3F, 0x07, 0xFF, 0xFC, 0x0F, 0x7F, 0xF8, 0x1E, 0x7F, 0xC0, 0x78,
  0x7F, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xF0, 0x1F, 0xFC,
  0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xF0, 0x21, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x0C, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x02, 0x07, 0xC0, 0x0F, 0xE7, 0xC0, 0x1F, 0xFB, 0xE0, 0x1F, 0xFD, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xC3, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E,
  0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF0, 0x07,
  0xC0, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00,
  0x78, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0,
  0x1F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E,
  0x07, 0xF0, 0x1F, 0x87, 0xF8, 0x0F, 0xFF, 0x78, 0x03, 0xFF, 0xBC, 0x01,
  0xFF, 0x9E, 0x00, 0x7F, 0x0F, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x87,
  0xC7, 0xE0, 0x78, 0xF8, 0x0F, 0x3E, 0x01, 0xE7, 0xC0, 0x7D, 0xF0, 0x0F,
  0xBE, 0x07, 0xE7, 0xC3, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC0,
  0xFF, 0x80, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x02, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x8F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x1F, 0xC7, 0xC0, 0x3F, 0xF3, 0xC0, 0x3F, 0xFD, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0x87, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xFC,
  0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F,
  0x81, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7E, 0x07, 0xC0,
  0x3F, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C,
  0x0F, 0xE0, 0x3F, 0x0F, 0xF0, 0x1F, 0xFE, 0xF0, 0x07, 0xFE, 0xF8, 0x03,
  0xFF, 0x7C, 0x00, 0xFE, 0x3E, 0x00, 0x08, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x10, 0x03, 0xF0, 0x0C, 0x03, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x06, 0x00, 0x3E, 0x7F, 0x80, 0x7D, 0xFF,
  0x80, 0xF7, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xF8, 0x7E, 0x0F, 0xE0, 0x7C,
  0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0x83,
  0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x80,
  0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF0, 0x07,
  0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8,
  0x7C, 0x03, 0xF0, 0x00, 0x30, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80,
  0x78, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x7C,
  0x03, 0xC0, 0xF8, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xC7, 0xE0,
  0x07, 0xCF, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x9F, 0x00, 0x0F, 0xBE, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0x9F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x3E, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x0F, 0x80,
  0x7C, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x00, 0x80, 0x04, 0x00, 0x78, 0xFE, 0x07, 0xF0, 0x0F, 0x3F,
  0xE3, 0xFF, 0x01, 0xEF, 0xFE, 0xFF, 0xE0, 0x7F, 0xFF, 0xDF, 0xFE, 0x0F,
  0xF0, 0xFF, 0x0F, 0xC1, 0xFC, 0x1F, 0xC0, 0xF8, 0x3F, 0x03, 0xF0, 0x1F,
  0x07, 0xC0, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0,
  0x0F, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0x80, 0x7C, 0x1F, 0x01,
  0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC0, 0x7C, 0x1F,
  0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x01, 0xF0, 0x78, 0x07, 0xC0, 0x3E,
  0x1F, 0x00, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0x3E, 0x0F, 0x80, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x00, 0xF8, 0x7C, 0x03,
  0xE0, 0x1E, 0x0F, 0x80, 0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0x00, 0xF8, 0x3E,
  0x03, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x40, 0x07,
  0x8F, 0xF0, 0x0F, 0x3F, 0xF0, 0x1E, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF,
  0x0F, 0xC1, 0xFC, 0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x1F, 0x80,
  0xFC, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F,
  0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0xFC, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F,
  0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0,
  0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x08, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xE1, 0xF8,
  0x7E, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xDF, 0x00,
  0x7E, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF,
  0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x03, 0xF0, 0xFC,
  0x3F, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x78, 0x7F, 0x00, 0x3C, 0xFF,
  0xC0, 0x1E, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x0F, 0xF0, 0xFC, 0x07, 0xF0,
  0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x81, 0xF8, 0x07, 0xC0, 0xFC,
  0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81,
  0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xF0,
  0x3F, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0xE1, 0xF8, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x03, 0xEF, 0xF8, 0x03, 0xE3, 0xF8, 0x01, 0xF0, 0x20,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x03, 0xF8, 0xF0, 0x3F, 0xF3, 0xC1, 0xFF, 0xEF, 0x0F,
  0xFF, 0xFC, 0x3F, 0x0F, 0xF1, 0xF8, 0x1F, 0x87, 0xC0, 0x7E, 0x3F, 0x01,
  0xF8, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF3,
  0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xE0,
  0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x3F,
  0x0F, 0x80, 0xFC, 0x3E, 0x07, 0xF0, 0xFC, 0x3F, 0xC3, 0xFF, 0xDE, 0x07,
  0xFE, 0xF8, 0x1F, 0xFB, 0xE0, 0x3F, 0x8F, 0x80, 0x10, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xC0, 0x78, 0xFC, 0x0F, 0x3F,
  0x81, 0xEF, 0xE0, 0x7D, 0xFC, 0x0F, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xF0,
  0xFF, 0xFC, 0x1F, 0x01, 0x87, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC4, 0x01, 0xF0, 0xC0,
  0x7E, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x04,
  0x00, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E,
  0x01, 0xFF, 0xDF, 0xFF, 0x7F, 0xFD, 0xFF, 0xF0, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x81,
  0xFE, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07,
  0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87,
  0x80, 0x3E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80,
  0x7C, 0x7C, 0x01, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8,
  0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8,
  0x0F, 0xC3, 0xE0, 0x7F, 0x0F, 0x81, 0xF8, 0x3E, 0x0F, 0xE0, 0xFF, 0xF7,
  0x83, 0xFF, 0x9E, 0x07, 0xFC, 0xF8, 0x0F, 0xE3, 0xC0, 0x04, 0x00, 0x00,
  0xF8, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x07,
  0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x7C, 0x07, 0x87, 0xC0, 0x78,
  0xF8, 0x07, 0x8F, 0x80, 0x79, 0xF0, 0x07, 0x9F, 0x00, 0x79, 0xE0, 0x07,
  0xBE, 0x00, 0x7B, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x07,
  0xE0, 0x3F, 0xF8, 0x0F, 0xE0, 0x3E, 0xF8, 0x0F, 0xE0, 0x3C, 0xF8, 0x0F,
  0xC0, 0x7C, 0xF8, 0x1F, 0xC0, 0x7C, 0xF8, 0x1F, 0xC0, 0xF8, 0xF8, 0x3D,
  0xC0, 0xF8, 0xF8, 0x3D, 0xC0, 0xF0, 0xF8, 0x3F, 0xC1, 0xF0, 0xF8, 0x7B,
  0xC1, 0xF0, 0xF8, 0x7B, 0xC3, 0xE0, 0xF8, 0xF3, 0xC3, 0xE0, 0xF8, 0xF3,
  0xC3, 0xC0, 0xF8, 0xF3, 0xC7, 0xC0, 0xF9, 0xE3, 0xC7, 0x80, 0xF9, 0xE3,
  0xCF, 0x80, 0xFB, 0xC3, 0xCF, 0x80, 0xFB, 0xC3, 0xCF, 0x00, 0xFF, 0xC3,
  0xDF, 0x00, 0xFF, 0x83, 0xDE, 0x00, 0xF7, 0x83, 0xDE, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x1F, 0x80, 0x7C, 0x0F, 0x80,
  0x3E, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x03, 0xE7, 0xC0,
  0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x7E,
  0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x07, 0xC0,
  0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0x80, 0xF8, 0x00, 0x78,
  0x1F, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x78, 0x7C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xD0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x04, 0xFF, 0x80, 0x37, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0xFF, 0xE8, 0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_Condensed_MediumItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 38, 13, 1, -37 },
  { 63, 16, 13, 19, 5, -37 },
  { 89, 27, 37, 26, 0, -37 },
  { 214, 23, 43, 23, 1, -40 },
  { 338, 31, 39, 36, 3, -38 },
  { 490, 26, 39, 27, 0, -38 },
  { 617, 8, 13, 11, 5, -37 },
  { 630, 17, 45, 14, 1, -37 },
  { 726, 17, 45, 14, -4, -37 },
  { 822, 19, 21, 22, 5, -40 },
  { 872, 22, 25, 25, 2, -31 },
  { 941, 10, 13, 12, -2, -6 },
  { 958, 13, 4, 15, 1, -16 },
  { 965, 6, 8, 12, 1, -7 },
  { 971, 26, 37, 18, -3, -37 },
  { 1092, 21, 39, 23, 2, -38 },
  { 1195, 15, 37, 23, 6, -37 },
  { 1265, 24, 38, 23, -1, -38 },
  { 1379, 23, 39, 23, 0, -38 },
  { 1492, 24, 37, 23, -1, -37 },
  { 1603, 24, 38, 23, 0, -37 },
  { 1717, 22, 39, 23, 2, -38 },
  { 1825, 23, 37, 23, 2, -37 },
  { 1932, 24, 39, 23, 0, -38 },
  { 2049, 22, 39, 23, 1, -38 },
  { 2157, 11, 29, 12, 0, -28 },
  { 2197, 15, 35, 12, -3, -28 },
  { 2263, 22, 25, 25, 2, -31 },
  { 2332, 22, 15, 25, 2, -26 },
  { 2374, 22, 25, 25, 2, -31 },
  { 2443, 18, 39, 18, 2, -38 },
  { 2531, 33, 41, 35, 2, -37 },
  { 2701, 24, 37, 24, -3, -37 },
  { 2812, 25, 37, 26, 1, -37 },
  { 2928, 25, 39, 24, 2, -38 },
  { 3050, 26, 37, 28, 1, -37 },
  { 3171, 23, 37, 22, 1, -37 },
  { 3278, 23, 37, 21, 1, -37 },
  { 3385, 28, 39, 29, 2, -38 },
  { 3522, 29, 37, 29, 1, -37 },
  { 3657, 21, 37, 15, -2, -37 },
  { 3755, 22, 47, 12, -8, -37 },
  { 3885, 28, 37, 24, 1, -37 },
  { 4015, 16, 37, 20, 1, -37 },
  { 4089, 37, 37, 37, 1, -37 },
  { 4261, 30, 37, 30, 1, -37 },
  { 4400, 27, 39, 30, 2, -38 },
  { 4532, 24, 37, 24, 1, -37 },
  { 4643, 27, 47, 30, 2, -38 },
  { 4802, 24, 37, 25, 1, -37 },
  { 4913, 25, 39, 22, -1, -38 },
  { 5035, 21, 37, 21, 4, -37 },
  { 5133, 27, 38, 28, 2, -37 },
  { 5262, 24, 37, 24, 5, -37 },
  { 5373, 37, 37, 38, 5, -37 },
  { 5545, 30, 37, 23, -3, -37 },
  { 5684, 22, 37, 22, 5, -37 },
  { 5786, 26, 37, 21, -2, -37 },
  { 5907, 20, 45, 15, -1, -37 },
  { 6020, 10, 37, 19, 5, -37 },
  { 6067, 20, 45, 15, -4, -37 },
  { 6180, 22, 21, 24, 1, -37 },
  { 6238, 19, 4, 17, -5, 4 },
  { 6248, 8, 8, 14, 8, -40 },
  { 6256, 23, 30, 25, 2, -29 },
  { 6343, 23, 41, 25, 0, -40 },
  { 6461, 18, 30, 19, 2, -29 },
  { 6529, 25, 41, 25, 2, -40 },
  { 6658, 19, 30, 22, 2, -29 },
  { 6730, 26, 52, 14, -6, -40 },
  { 6899, 25, 41, 25, 0, -29 },
  { 7028, 23, 40, 25, 0, -40 },
  { 7143, 13, 39, 12, 0, -39 },
  { 7207, 20, 51, 12, -7, -39 },
  { 7335, 24, 40, 22, 0, -40 },
  { 7455, 14, 40, 12, 0, -40 },
  { 7525, 35, 29, 37, 0, -29 },
  { 7652, 23, 29, 25, 0, -29 },
  { 7736, 21, 30, 24, 2, -29 },
  { 7815, 25, 41, 25, -2, -29 },
  { 7944, 22, 41, 25, 2, -29 },
  { 8057, 19, 29, 17, 0, -29 },
  { 8126, 19, 30, 19, 0, -29 },
  { 8198, 14, 35, 15, 2, -34 },
  { 8260, 22, 29, 25, 2, -28 },
  { 8340, 20, 28, 20, 3, -28 },
  { 8410, 32, 28, 32, 3, -28 },
  { 8522, 25, 28, 21, -2, -28 },
  { 8610, 28, 40, 21, -5, -28 },
  { 8750, 21, 28, 18, -2, -28 },
  { 8824, 20, 45, 18, 1, -37 },
  { 8937, 4, 52, 22, 9, -40 },
  { 8963, 20, 45, 18, -3, -37 },
  { 9076, 22, 7, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_MediumItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC52PT7B_H_
