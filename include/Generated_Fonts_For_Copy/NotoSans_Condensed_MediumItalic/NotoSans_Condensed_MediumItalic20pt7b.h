#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC20PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x63, 0x18, 0xC4, 0x23, 0x00, 0x8E, 0x60, 0x6D, 0x3C,
  0xB2, 0xD8, 0x04, 0xC3, 0x20, 0xC8, 0x26, 0x3F, 0xD6, 0x41, 0x30, 0x48,
  0xFF, 0xBF, 0xE2, 0x61, 0x90, 0x64, 0x13, 0x00, 0x02, 0x03, 0x07, 0xE6,
  0x93, 0x41, 0xA0, 0xF0, 0x38, 0x0E, 0x05, 0x82, 0xD2, 0x6F, 0xE7, 0xE0,
  0x40, 0x20, 0x38, 0x66, 0xCC, 0x4C, 0x8C, 0xD8, 0xC9, 0x0C, 0xB6, 0xDA,
  0xFF, 0x59, 0x0D, 0x90, 0x93, 0x19, 0x31, 0x12, 0x31, 0x66, 0x1C, 0x0F,
  0x06, 0x61, 0x98, 0x6C, 0x1B, 0x07, 0x81, 0xC0, 0xF3, 0x6E, 0xF1, 0xEC,
  0x7B, 0x1C, 0xEF, 0x1E, 0x60, 0x6B, 0x6C, 0x0E, 0x18, 0x60, 0x83, 0x04,
  0x18, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x08, 0x10, 0x30, 0x60, 0x0C, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x61, 0x83, 0x0C, 0x18,
  0xE0, 0x19, 0x33, 0xCB, 0xF3, 0x9D, 0x13, 0x04, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x36, 0x64, 0xC0, 0x7F, 0xC0, 0x5F,
  0x00, 0x01, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x20, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x00, 0x1E, 0x33, 0x63, 0x63, 0x63,
  0xC3, 0xC3, 0xC6, 0xC6, 0xC6, 0x8C, 0xCC, 0xF8, 0x70, 0x1C, 0xF6, 0xB6,
  0x18, 0x61, 0x8C, 0x30, 0xC3, 0x08, 0x61, 0x80, 0x0F, 0x86, 0x70, 0x0C,
  0x03, 0x00, 0x80, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x7F,
  0x3F, 0xC0, 0x3F, 0x09, 0xC0, 0x60, 0x30, 0x30, 0x38, 0x70, 0x1C, 0x07,
  0x01, 0x80, 0xC0, 0xCF, 0xE7, 0xE0, 0x03, 0x81, 0xC1, 0x41, 0xE1, 0xB0,
  0x98, 0xC8, 0xCC, 0x46, 0x7F, 0xBF, 0xC0, 0x80, 0xC0, 0x60, 0x1F, 0x8F,
  0xC4, 0x06, 0x03, 0x01, 0xE1, 0xF8, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0xCF,
  0xE7, 0xE0, 0x0F, 0x18, 0x30, 0x60, 0x60, 0xDC, 0xFE, 0xC6, 0xC6, 0xC6,
  0xC6, 0xCE, 0xFC, 0x78, 0x7F, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30,
  0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x00, 0x1F, 0x0C, 0xCC, 0x66,
  0x33, 0x38, 0xF8, 0x70, 0x6C, 0x63, 0x61, 0xB0, 0xD8, 0x6E, 0x63, 0xE0,
  0x1F, 0x1D, 0xCC, 0x64, 0x36, 0x1B, 0x1D, 0x8C, 0x7E, 0x1B, 0x01, 0x81,
  0x81, 0xCF, 0xC7, 0xC0, 0x33, 0x30, 0x00, 0x00, 0x4E, 0xC0, 0x18, 0xC6,
  0x00, 0x00, 0x00, 0x01, 0x98, 0xCC, 0x60, 0x01, 0x03, 0x0E, 0x38, 0xE0,
  0xE0, 0x3C, 0x0F, 0x03, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0xE0, 0x78, 0x1C, 0x07, 0x07, 0x1C, 0xF0, 0xC0, 0x80, 0x7C, 0x9C, 0x18,
  0x20, 0xC3, 0x0C, 0x30, 0x60, 0x80, 0x02, 0x0C, 0x18, 0x00, 0x0F, 0xE1,
  0x82, 0x30, 0x32, 0x11, 0x47, 0x94, 0xD9, 0xD9, 0x99, 0x91, 0x91, 0x39,
  0x32, 0x9F, 0x68, 0xD8, 0x80, 0x0C, 0x00, 0x7F, 0x01, 0xC0, 0x03, 0x83,
  0xC1, 0xE0, 0xB0, 0xD8, 0x4C, 0x66, 0x33, 0x3F, 0x9F, 0xD8, 0x6C, 0x3E,
  0x1E, 0x0C, 0x1F, 0x86, 0x71, 0x8C, 0xC3, 0x31, 0xCC, 0xE3, 0xE0, 0xCC,
  0x61, 0x98, 0x66, 0x19, 0x8C, 0x7F, 0x3F, 0x00, 0x02, 0x07, 0xC6, 0x26,
  0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x03, 0xF1,
  0xF8, 0x1F, 0x86, 0xF1, 0x8C, 0xC3, 0x30, 0xCC, 0x33, 0x0C, 0xC3, 0x60,
  0xD8, 0x66, 0x19, 0x8C, 0x7E, 0x3F, 0x00, 0x1F, 0x8C, 0x06, 0x06, 0x03,
  0x01, 0x80, 0xFC, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xE7, 0xE0, 0x1F,
  0x8C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xFC, 0x7C, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x06, 0x00, 0x02, 0x03, 0xF1, 0xCC, 0xC0, 0x60, 0x18, 0x0E, 0x03,
  0x1E, 0xC7, 0xB0, 0x6C, 0x1B, 0x04, 0xC3, 0x1F, 0xC3, 0xF0, 0x18, 0x63,
  0x0C, 0x61, 0x98, 0x33, 0x0C, 0x61, 0x8F, 0xF1, 0x86, 0x60, 0xCC, 0x31,
  0x86, 0x30, 0xC6, 0x19, 0x87, 0x00, 0x1F, 0x0C, 0x0C, 0x0C, 0x0C, 0x08,
  0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0xF8, 0x03, 0x03, 0x03, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18,
  0xF0, 0xE0, 0x18, 0xE3, 0x18, 0x66, 0x19, 0x83, 0x60, 0x6C, 0x0F, 0x01,
  0xE0, 0x66, 0x0C, 0xC1, 0x98, 0x33, 0x84, 0x31, 0x86, 0x00, 0x18, 0x30,
  0x61, 0x83, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x07, 0xFF, 0x80, 0x1C,
  0x0E, 0x38, 0x38, 0x70, 0x71, 0xE1, 0xE3, 0xC2, 0xC6, 0x8D, 0x8D, 0x16,
  0x12, 0x6C, 0x64, 0x98, 0xCB, 0x31, 0x94, 0x43, 0x39, 0x84, 0x73, 0x18,
  0xC6, 0x00, 0x1C, 0x31, 0xC3, 0x1C, 0x33, 0x46, 0x36, 0x63, 0x66, 0x36,
  0x62, 0x64, 0x62, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x41, 0x8C, 0x18, 0x1F,
  0x8E, 0x73, 0x0D, 0x83, 0x60, 0xF8, 0x3C, 0x0F, 0x03, 0xC1, 0xB0, 0x6C,
  0x1B, 0x0C, 0x7E, 0x1F, 0x00, 0x1F, 0x86, 0xE1, 0x8C, 0xC3, 0x30, 0xCC,
  0x63, 0x38, 0xFC, 0x78, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x00, 0x1F,
  0x8E, 0x73, 0x0D, 0x83, 0x60, 0xF8, 0x3C, 0x0F, 0x03, 0xC1, 0xB0, 0x6C,
  0x1B, 0x0C, 0x7E, 0x1F, 0x00, 0xC0, 0x38, 0x06, 0x00, 0x1F, 0x86, 0xE1,
  0x9C, 0xC3, 0x31, 0x8C, 0x63, 0x70, 0xF8, 0x66, 0x19, 0x86, 0x61, 0x9C,
  0x43, 0x30, 0xC0, 0x1F, 0x9C, 0xCC, 0x06, 0x03, 0x01, 0xC0, 0x70, 0x1C,
  0x06, 0x03, 0x01, 0x90, 0xCF, 0xE7, 0xE0, 0xFF, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0x30, 0xCC, 0x33,
  0x0D, 0x83, 0x61, 0x98, 0x66, 0x1B, 0x06, 0xC3, 0x30, 0xCC, 0x33, 0x1C,
  0xFE, 0x1F, 0x00, 0xC1, 0xE1, 0xB0, 0xD8, 0xCC, 0x66, 0x63, 0x31, 0xB0,
  0xD8, 0x6C, 0x3C, 0x1E, 0x0E, 0x07, 0x00, 0xC3, 0x0F, 0x1C, 0x6C, 0x71,
  0xB1, 0xC6, 0xCF, 0x33, 0x2C, 0xCD, 0xB6, 0x36, 0xD8, 0xD3, 0x63, 0xCF,
  0x0E, 0x3C, 0x38, 0xE0, 0xE3, 0x83, 0x0E, 0x00, 0x18, 0x61, 0x98, 0x33,
  0x06, 0xC0, 0xF0, 0x1E, 0x01, 0x80, 0x70, 0x1E, 0x03, 0x60, 0xCC, 0x39,
  0x86, 0x31, 0x86, 0x00, 0xC3, 0xC6, 0xC6, 0xCC, 0x58, 0x58, 0x70, 0x70,
  0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0x1F, 0xC0, 0x30, 0x18, 0x0C, 0x03,
  0x01, 0x80, 0xE0, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0x7F, 0x3F, 0xC0,
  0x0F, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x20,
  0x20, 0x60, 0x60, 0x60, 0xF8, 0xCC, 0xC4, 0x46, 0x66, 0x66, 0x62, 0x23,
  0x1E, 0x0C, 0x18, 0x20, 0x41, 0x83, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x82,
  0x0C, 0x18, 0xF0, 0x04, 0x07, 0x07, 0x83, 0x43, 0x31, 0x19, 0x85, 0x83,
  0xFE, 0xCC, 0x80, 0x1D, 0x3F, 0x63, 0xE3, 0xC3, 0xC6, 0xC6, 0xC6, 0xCE,
  0xDC, 0xF4, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x71, 0xFC, 0xC6, 0x63, 0x61,
  0xB0, 0xD8, 0x4C, 0x66, 0x37, 0xB3, 0x70, 0x1E, 0x79, 0x86, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0xD1, 0xE0, 0x01, 0x80, 0xC0, 0x60, 0x31, 0xF1, 0xF9,
  0x8D, 0x86, 0xC3, 0x63, 0x31, 0x98, 0xCC, 0xE6, 0xE3, 0xD0, 0x1C, 0x7D,
  0x9E, 0x3C, 0xFF, 0x30, 0x60, 0xC1, 0x99, 0xF0, 0x03, 0xC1, 0xD0, 0x60,
  0x18, 0x0F, 0x07, 0xC0, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x0E, 0x03, 0x00, 0x0E, 0x8F, 0xCC,
  0x6E, 0x36, 0x1B, 0x19, 0x8C, 0xC6, 0x67, 0x37, 0x1F, 0x80, 0xC0, 0x64,
  0x63, 0xF0, 0xE0, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x71, 0xFC, 0xC6, 0x63,
  0x21, 0x31, 0x98, 0xCC, 0x66, 0x36, 0x13, 0x18, 0x18, 0xC4, 0x03, 0x18,
  0xC6, 0x63, 0x18, 0xC6, 0x63, 0x00, 0x03, 0x03, 0x02, 0x00, 0x06, 0x06,
  0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x30,
  0xF0, 0xE0, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x19, 0x98, 0xD8, 0x6C, 0x2C,
  0x3E, 0x1F, 0x0D, 0x86, 0x66, 0x33, 0x18, 0x18, 0xC6, 0x23, 0x18, 0xC6,
  0x23, 0x18, 0xC6, 0x63, 0x00, 0x37, 0x39, 0xFB, 0xCC, 0x66, 0x63, 0x32,
  0x31, 0xB1, 0x8D, 0x8C, 0x6C, 0x62, 0x62, 0x36, 0x31, 0xB1, 0x8C, 0x37,
  0x1F, 0xCC, 0x66, 0x36, 0x13, 0x19, 0x8C, 0xC6, 0x63, 0x63, 0x31, 0x80,
  0x1C, 0x3E, 0x63, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6, 0xCE, 0xFC, 0x78, 0x1B,
  0x87, 0xF1, 0x8C, 0x63, 0x10, 0xCC, 0x33, 0x0C, 0xC6, 0x31, 0x9E, 0xC6,
  0xE1, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0x1D, 0x3F, 0x63, 0xC3, 0xC3,
  0xC6, 0xC6, 0xC6, 0xCE, 0xDC, 0xFC, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x36,
  0x7C, 0xE1, 0x82, 0x0C, 0x18, 0x30, 0x61, 0x83, 0x00, 0x1E, 0x7D, 0x83,
  0x07, 0x07, 0x07, 0x06, 0x0D, 0xBB, 0xE0, 0x31, 0x9F, 0xF6, 0x31, 0x18,
  0xC6, 0x31, 0xAE, 0x00, 0x63, 0x63, 0x63, 0x63, 0xC2, 0xC6, 0xC6, 0xC6,
  0xCE, 0xDC, 0xFC, 0xC3, 0xC6, 0xC6, 0xCC, 0xCC, 0xC8, 0xD8, 0xD0, 0x70,
  0x60, 0x60, 0xC6, 0x3C, 0x63, 0xCE, 0x6C, 0xA6, 0xDA, 0x4D, 0xAC, 0xD2,
  0xCF, 0x38, 0xE3, 0x8E, 0x30, 0xE3, 0x00, 0x38, 0xC6, 0x61, 0xB0, 0x6C,
  0x0E, 0x03, 0x01, 0xC0, 0xD8, 0x36, 0x19, 0x8E, 0x30, 0x18, 0x63, 0x18,
  0x63, 0x0C, 0xC1, 0x98, 0x12, 0x02, 0xC0, 0x50, 0x0E, 0x01, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x3C, 0x07, 0x00, 0x1F, 0x1F, 0x06, 0x06, 0x0C,
  0x18, 0x18, 0x30, 0x70, 0x7E, 0xFC, 0x07, 0x0E, 0x0C, 0x08, 0x18, 0x18,
  0x18, 0x70, 0xE0, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x70, 0x38, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x18, 0x10, 0x60, 0xC1, 0x83, 0x06, 0x06,
  0x38, 0x60, 0xC3, 0x06, 0x0C, 0x38, 0xE0, 0xF9, 0x9F,
};

const GFXglyph NotoSans_Condensed_MediumItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 6, 5, 7, 2, -14 },
  { 14, 10, 14, 10, 0, -14 },
  { 32, 9, 16, 9, 0, -15 },
  { 50, 12, 14, 14, 1, -14 },
  { 71, 10, 14, 10, 0, -14 },
  { 89, 3, 5, 4, 2, -14 },
  { 91, 7, 17, 5, 0, -14 },
  { 106, 7, 17, 6, -2, -14 },
  { 121, 7, 8, 9, 2, -15 },
  { 128, 8, 10, 10, 1, -12 },
  { 138, 4, 5, 5, -1, -2 },
  { 141, 5, 2, 6, 0, -6 },
  { 143, 3, 3, 5, 0, -3 },
  { 145, 10, 14, 7, -1, -14 },
  { 163, 8, 14, 9, 1, -14 },
  { 177, 6, 14, 9, 2, -14 },
  { 188, 10, 14, 9, -1, -14 },
  { 206, 9, 14, 9, 0, -14 },
  { 222, 9, 14, 9, 0, -14 },
  { 238, 9, 14, 9, 0, -14 },
  { 254, 8, 14, 9, 1, -14 },
  { 268, 9, 14, 9, 1, -14 },
  { 284, 9, 14, 9, 0, -14 },
  { 300, 9, 14, 9, 0, -14 },
  { 316, 4, 11, 5, 0, -11 },
  { 322, 5, 14, 5, -1, -11 },
  { 331, 8, 10, 10, 1, -12 },
  { 341, 8, 6, 10, 1, -10 },
  { 347, 8, 10, 10, 1, -12 },
  { 357, 7, 14, 7, 1, -14 },
  { 370, 12, 16, 14, 1, -14 },
  { 394, 9, 14, 9, -1, -14 },
  { 410, 10, 14, 10, 0, -14 },
  { 428, 9, 15, 9, 1, -15 },
  { 445, 10, 14, 11, 0, -14 },
  { 463, 9, 14, 8, 0, -14 },
  { 479, 9, 14, 8, 0, -14 },
  { 495, 10, 15, 11, 1, -15 },
  { 514, 11, 14, 11, 0, -14 },
  { 534, 8, 14, 6, -1, -14 },
  { 548, 8, 18, 5, -3, -14 },
  { 566, 11, 14, 9, 0, -14 },
  { 586, 7, 14, 8, 0, -14 },
  { 599, 15, 14, 14, 0, -14 },
  { 626, 12, 14, 12, 0, -14 },
  { 647, 10, 14, 11, 1, -14 },
  { 665, 10, 14, 9, 0, -14 },
  { 683, 10, 17, 11, 1, -14 },
  { 705, 10, 14, 10, 0, -14 },
  { 723, 9, 14, 8, 0, -14 },
  { 739, 8, 14, 8, 2, -14 },
  { 753, 10, 14, 11, 1, -14 },
  { 771, 9, 14, 9, 2, -14 },
  { 787, 14, 14, 15, 2, -14 },
  { 812, 11, 14, 9, -1, -14 },
  { 832, 8, 14, 8, 2, -14 },
  { 846, 10, 14, 8, -1, -14 },
  { 864, 8, 17, 6, -1, -14 },
  { 881, 4, 14, 7, 2, -14 },
  { 888, 7, 17, 6, -1, -14 },
  { 903, 9, 8, 9, 0, -14 },
  { 912, 7, 1, 7, -2, 2 },
  { 913, 3, 3, 5, 3, -15 },
  { 915, 8, 11, 10, 1, -11 },
  { 926, 9, 15, 10, 0, -15 },
  { 943, 7, 11, 7, 1, -11 },
  { 953, 9, 15, 10, 1, -15 },
  { 970, 7, 11, 9, 1, -11 },
  { 980, 10, 20, 5, -2, -15 },
  { 1005, 9, 16, 10, 0, -11 },
  { 1023, 9, 15, 9, 0, -15 },
  { 1040, 5, 15, 4, 0, -15 },
  { 1050, 8, 20, 4, -3, -15 },
  { 1070, 9, 15, 8, 0, -15 },
  { 1087, 5, 15, 4, 0, -15 },
  { 1097, 13, 11, 14, 0, -11 },
  { 1115, 9, 11, 9, 0, -11 },
  { 1128, 8, 11, 9, 1, -11 },
  { 1139, 10, 16, 10, -1, -11 },
  { 1159, 8, 16, 10, 1, -11 },
  { 1175, 7, 11, 6, 0, -11 },
  { 1185, 7, 11, 7, 0, -11 },
  { 1195, 5, 13, 6, 1, -13 },
  { 1204, 8, 11, 9, 1, -11 },
  { 1215, 8, 11, 8, 1, -11 },
  { 1226, 12, 11, 12, 1, -11 },
  { 1243, 10, 11, 8, -1, -11 },
  { 1257, 11, 16, 8, -2, -11 },
  { 1279, 8, 11, 7, -1, -11 },
  { 1290, 8, 17, 7, 0, -14 },
  { 1307, 2, 20, 8, 3, -15 },
  { 1312, 7, 17, 7, -1, -14 },
  { 1327, 8, 2, 10, 1, -8 },
};

const GFXfont NotoSans_Condensed_MediumItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC20PT7B_H_
