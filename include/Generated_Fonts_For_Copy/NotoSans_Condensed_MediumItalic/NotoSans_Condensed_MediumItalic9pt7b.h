#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC9PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x20, 0xF8, 0x33, 0xD5, 0xE6, 0x50, 0x27, 0x66, 0x7E, 0x44,
  0x21, 0xAB, 0x2F, 0x74, 0xD5, 0x80, 0x22, 0x94, 0xDB, 0x5B, 0xC0, 0xC0,
  0x69, 0x49, 0x20, 0x24, 0x92, 0xB0, 0x5F, 0x30, 0x2F, 0x22, 0xC0, 0xC0,
  0x80, 0x32, 0x44, 0x88, 0x25, 0x59, 0x9A, 0xE0, 0x79, 0x25, 0x00, 0x25,
  0x12, 0x24, 0xE0, 0x25, 0x16, 0x22, 0xE0, 0x33, 0x6A, 0xF2, 0x74, 0x61,
  0x2E, 0x12, 0x47, 0x99, 0x60, 0x71, 0x22, 0x4C, 0x25, 0x56, 0xA9, 0xE0,
  0x25, 0x55, 0x72, 0xC0, 0x40, 0x80, 0x40, 0xA0, 0x3C, 0x61, 0xFF, 0xC3,
  0x68, 0x2C, 0xA4, 0x20, 0x3D, 0x7A, 0xED, 0xAA, 0x07, 0x00, 0x11, 0x4A,
  0x74, 0xE4, 0x75, 0x75, 0x9E, 0x13, 0x50, 0x88, 0x41, 0x80, 0x72, 0x52,
  0xA9, 0x70, 0x74, 0x64, 0x8E, 0x74, 0x64, 0x88, 0x11, 0x50, 0xA8, 0xC9,
  0xC0, 0x4A, 0x5E, 0xA9, 0x48, 0x69, 0x25, 0x80, 0x24, 0x94, 0x94, 0x5A,
  0x98, 0xCA, 0x48, 0x49, 0x29, 0xC0, 0x66, 0xD9, 0xB3, 0xAB, 0x55, 0x00,
  0x6B, 0x5A, 0xD9, 0x48, 0x13, 0x52, 0x98, 0xC9, 0xC0, 0x75, 0x56, 0x88,
  0x13, 0x52, 0x98, 0xC9, 0xC4, 0x10, 0x75, 0x56, 0xA9, 0x25, 0x46, 0x22,
  0xE0, 0xEA, 0x49, 0x00, 0x4A, 0x52, 0xA9, 0x30, 0x9A, 0xAC, 0xC8, 0xA6,
  0x9D, 0xB6, 0x92, 0x40, 0x2C, 0xC1, 0x0C, 0x53, 0x40, 0xBA, 0xC8, 0x88,
  0x72, 0x24, 0x8E, 0x69, 0x29, 0x30, 0xAA, 0x90, 0x31, 0x22, 0x22, 0xC0,
  0x25, 0x90, 0xE0, 0x90, 0x75, 0x99, 0xE0, 0x44, 0x75, 0x99, 0xE0, 0x74,
  0x88, 0x60, 0x08, 0x9C, 0xA9, 0x4B, 0x80, 0x75, 0xE8, 0x60, 0x19, 0x1C,
  0x42, 0x21, 0x08, 0xC0, 0x75, 0x99, 0xE2, 0xE0, 0x44, 0x75, 0x59, 0xA0,
  0x45, 0x68, 0x20, 0x92, 0x92, 0x80, 0x44, 0x56, 0x6A, 0xA0, 0x55, 0x68,
  0x7D, 0x55, 0x69, 0xA8, 0x75, 0x59, 0xA0, 0x75, 0x99, 0x60, 0x75, 0x59,
  0xE8, 0x80, 0x75, 0x99, 0xE2, 0x20, 0x69, 0x48, 0x71, 0x1C, 0x5D, 0x29,
  0x80, 0x55, 0x9A, 0xE0, 0x9A, 0xA4, 0x40, 0xAF, 0xBD, 0x6A, 0x00, 0x56,
  0x46, 0xA0, 0x49, 0x8C, 0x42, 0x13, 0x00, 0x65, 0x4E, 0x34, 0x48, 0x44,
  0x40, 0xFF, 0x80, 0x49, 0x14, 0xA0, 0xF0,
};

const GFXglyph NotoSans_Condensed_MediumItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 3, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 8, 4, 0, -7 },
  { 12, 6, 7, 6, 0, -7 },
  { 18, 5, 7, 5, 0, -7 },
  { 23, 1, 2, 2, 1, -6 },
  { 24, 3, 7, 2, 0, -6 },
  { 27, 3, 7, 2, -1, -6 },
  { 30, 3, 4, 4, 1, -7 },
  { 32, 4, 4, 4, 0, -5 },
  { 34, 1, 2, 2, 0, -1 },
  { 35, 2, 1, 3, 0, -3 },
  { 36, 1, 1, 2, 0, -1 },
  { 37, 4, 6, 3, 0, -6 },
  { 40, 4, 7, 4, 0, -7 },
  { 44, 3, 6, 4, 1, -6 },
  { 47, 4, 7, 4, 0, -7 },
  { 51, 4, 7, 4, 0, -7 },
  { 55, 4, 6, 4, 0, -6 },
  { 58, 4, 6, 4, 0, -6 },
  { 61, 4, 7, 4, 0, -7 },
  { 65, 4, 6, 4, 0, -6 },
  { 68, 4, 7, 4, 0, -7 },
  { 72, 4, 7, 4, 0, -7 },
  { 76, 2, 5, 2, 0, -5 },
  { 78, 2, 6, 2, 0, -5 },
  { 80, 4, 4, 4, 0, -5 },
  { 82, 4, 2, 4, 0, -4 },
  { 83, 4, 4, 4, 0, -5 },
  { 85, 3, 7, 3, 0, -7 },
  { 88, 6, 7, 6, 0, -6 },
  { 94, 5, 6, 4, -1, -6 },
  { 98, 4, 6, 4, 0, -6 },
  { 101, 5, 7, 4, 0, -7 },
  { 106, 5, 6, 5, 0, -6 },
  { 110, 4, 6, 4, 0, -6 },
  { 113, 4, 6, 4, 0, -6 },
  { 116, 5, 7, 5, 0, -7 },
  { 121, 5, 6, 5, 0, -6 },
  { 125, 3, 6, 3, 0, -6 },
  { 128, 3, 8, 2, -1, -6 },
  { 131, 5, 6, 4, 0, -6 },
  { 135, 3, 6, 4, 0, -6 },
  { 138, 7, 6, 6, 0, -6 },
  { 144, 5, 6, 5, 0, -6 },
  { 148, 5, 7, 5, 0, -7 },
  { 153, 4, 6, 4, 0, -6 },
  { 156, 5, 9, 5, 0, -7 },
  { 162, 4, 6, 4, 0, -6 },
  { 165, 4, 7, 4, 0, -7 },
  { 169, 3, 6, 4, 1, -6 },
  { 172, 5, 6, 5, 0, -6 },
  { 176, 4, 6, 4, 1, -6 },
  { 179, 6, 6, 7, 1, -6 },
  { 184, 6, 6, 4, -1, -6 },
  { 189, 4, 6, 4, 1, -6 },
  { 192, 4, 6, 4, 0, -6 },
  { 195, 3, 7, 3, 0, -6 },
  { 198, 2, 6, 3, 1, -6 },
  { 200, 4, 7, 3, -1, -6 },
  { 204, 4, 3, 4, 0, -6 },
  { 206, 3, 1, 3, -1, 1 },
  { 207, 2, 2, 2, 1, -7 },
  { 208, 4, 5, 4, 0, -5 },
  { 211, 4, 7, 4, 0, -7 },
  { 215, 4, 5, 3, 0, -5 },
  { 218, 5, 7, 4, 0, -7 },
  { 223, 4, 5, 4, 0, -5 },
  { 226, 5, 9, 2, -1, -7 },
  { 232, 4, 7, 4, 0, -5 },
  { 236, 4, 7, 4, 0, -7 },
  { 240, 2, 7, 2, 0, -7 },
  { 242, 3, 9, 2, -1, -7 },
  { 246, 4, 7, 4, 0, -7 },
  { 250, 2, 7, 2, 0, -7 },
  { 252, 6, 5, 6, 0, -5 },
  { 256, 4, 5, 4, 0, -5 },
  { 259, 4, 5, 4, 0, -5 },
  { 262, 4, 7, 4, 0, -5 },
  { 266, 4, 7, 4, 0, -5 },
  { 270, 3, 5, 3, 0, -5 },
  { 272, 3, 5, 3, 0, -5 },
  { 274, 3, 6, 3, 0, -6 },
  { 277, 4, 5, 4, 0, -5 },
  { 280, 4, 5, 4, 0, -5 },
  { 283, 5, 5, 6, 1, -5 },
  { 287, 4, 5, 4, 0, -5 },
  { 290, 5, 7, 4, -1, -5 },
  { 295, 3, 5, 3, 0, -5 },
  { 297, 4, 7, 3, 0, -6 },
  { 301, 1, 9, 4, 1, -7 },
  { 303, 3, 7, 3, 0, -6 },
  { 306, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_Condensed_MediumItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC9PT7B_H_
