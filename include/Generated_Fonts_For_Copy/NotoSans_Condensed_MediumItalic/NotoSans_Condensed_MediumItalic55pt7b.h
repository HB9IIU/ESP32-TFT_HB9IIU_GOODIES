#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC55PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x08, 0x00, 0x1F,
  0x0F, 0x9F, 0x8F, 0xCF, 0x87, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8,
  0xF0, 0x7C, 0xF8, 0x3C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1E, 0x0F, 0x0F, 0x07,
  0x87, 0x83, 0xC7, 0x81, 0xE0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x0F,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C,
  0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0x83, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1, 0x0F, 0x03, 0xC0, 0x00, 0x78,
  0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0x3E, 0x07, 0xE7, 0x0C,
  0x07, 0xC7, 0x00, 0x0F, 0x86, 0x00, 0x0F, 0x86, 0x00, 0x0F, 0x8E, 0x00,
  0x0F, 0x8E, 0x00, 0x0F, 0xCE, 0x00, 0x07, 0xEC, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x33, 0xF0,
  0x00, 0x31, 0xF0, 0x00, 0x71, 0xF0, 0x00, 0x71, 0xF0, 0x00, 0x71, 0xF0,
  0x00, 0x61, 0xF0, 0x80, 0x61, 0xF0, 0xC0, 0xE3, 0xE0, 0xF8, 0xEF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x1E, 0x01, 0xFF, 0x00, 0x1E, 0x01, 0xFF, 0xC0, 0x1F, 0x01, 0xF1,
  0xE0, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0x80, 0x78,
  0x3C, 0x07, 0x80, 0x3C, 0x1E, 0x07, 0xC0, 0x3E, 0x0F, 0x03, 0xC0, 0x1E,
  0x07, 0x83, 0xC0, 0x0F, 0x03, 0xC1, 0xE0, 0x07, 0x81, 0xE1, 0xE0, 0x07,
  0xC1, 0xF1, 0xF0, 0x03, 0xC0, 0xF0, 0xF0, 0x01, 0xE0, 0x78, 0xF8, 0x00,
  0xF0, 0x7C, 0x78, 0x7C, 0x78, 0x3C, 0x78, 0xFF, 0xBC, 0x1E, 0x7C, 0xFF,
  0xDE, 0x1E, 0x3C, 0x7F, 0xFF, 0x9F, 0x3E, 0x7C, 0xFB, 0xFF, 0x1E, 0x7C,
  0x3D, 0xFF, 0x1E, 0x3C, 0x1E, 0x7F, 0x1F, 0x1E, 0x0F, 0x0E, 0x0F, 0x1E,
  0x07, 0x80, 0x0F, 0x8F, 0x03, 0xC0, 0x07, 0x87, 0x81, 0xE0, 0x07, 0x87,
  0xC1, 0xF0, 0x03, 0xC3, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x78, 0x03, 0xE0,
  0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x3E, 0x01, 0xE0, 0x3C, 0x1E, 0x00, 0xF0,
  0x1E, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x07, 0x87, 0x80, 0x78,
  0x03, 0xEF, 0x80, 0x7C, 0x01, 0xFF, 0xC0, 0x3C, 0x00, 0x7F, 0xC0, 0x3C,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E,
  0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF9, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x1F, 0x0F, 0xDF, 0x83, 0xE1, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0xC7, 0xE3,
  0xF0, 0x7C, 0x7C, 0x7E, 0x07, 0xEF, 0xC7, 0xC0, 0x7E, 0xF8, 0x7C, 0x03,
  0xFF, 0x87, 0xC0, 0x3F, 0xF0, 0xFC, 0x01, 0xFE, 0x0F, 0xC0, 0x1F, 0xE0,
  0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0x7C, 0x03, 0xFE, 0x07, 0xF0,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xF3, 0xF0, 0x1F, 0xFE, 0x1F,
  0x80, 0xFF, 0x81, 0xF8, 0x00, 0x80, 0x00, 0x00, 0x3E, 0xFD, 0xFB, 0xE7,
  0xCF, 0x9F, 0x3C, 0xF9, 0xF3, 0xC7, 0x8F, 0x1E, 0x00, 0x00, 0x0F, 0xC0,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x07, 0x07, 0x80, 0x7C, 0x78, 0x07, 0xF7, 0x81, 0xFF, 0xF7, 0xF7, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x0F,
  0xBC, 0x01, 0xF3, 0xE0, 0x3F, 0x1E, 0x07, 0xE1, 0xF0, 0x1C, 0x1F, 0x00,
  0xC0, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x1F,
  0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x3E,
  0x0F, 0x80, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38,
  0xFB, 0xFF, 0xEF, 0xDF, 0xBE, 0x10, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xE3, 0xF0, 0x7E,
  0x07, 0xC1, 0xF8, 0x1F, 0x0F, 0xC0, 0x7C, 0x3E, 0x01, 0xF1, 0xF8, 0x07,
  0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xE0, 0x07, 0xCF,
  0x80, 0x1F, 0x7E, 0x00, 0x7D, 0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x00,
  0x3F, 0x7C, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBE, 0x00, 0x7E,
  0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xFC, 0xF8,
  0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F,
  0xC3, 0xE0, 0x7E, 0x0F, 0xC3, 0xF0, 0x3F, 0x9F, 0xC0, 0x7F, 0xFE, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFC, 0x7F, 0x7C, 0xFE, 0x7C, 0x7C, 0x7C, 0x78, 0xFC, 0x20, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xC1, 0xFC,
  0x03, 0x80, 0x7E, 0x00, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x0F, 0x83, 0xF8, 0x03, 0x00, 0xFC, 0x02, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x20, 0x03, 0xF8, 0x1E,
  0x07, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xDF,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x1E,
  0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xE1, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x0F, 0xC0, 0x0F, 0x03, 0xE0,
  0x07, 0xC0, 0xF8, 0x01, 0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x07,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x88, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0xE1, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x80, 0x03, 0xF0, 0x60, 0x07, 0xF0,
  0x3E, 0x0F, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFD, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x7F, 0xC0, 0x3E, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0x83, 0xF0, 0x7F, 0x01,
  0xF0, 0xFE, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03,
  0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xFC, 0x07,
  0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x3F, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xC1, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0,
  0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C,
  0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x03,
  0xF1, 0xF8, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xDF, 0xC0,
  0x3F, 0x87, 0xE0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x3E,
  0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xE3, 0xF0, 0x03,
  0xF1, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x80,
  0x7C, 0x0F, 0xE0, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0xFE, 0x1F, 0x81, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x3E, 0x1F,
  0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0,
  0x07, 0xC7, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x01,
  0xFC, 0xFC, 0x03, 0xF0, 0xF8, 0x0F, 0xE1, 0xF8, 0x3F, 0xC3, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x07, 0xFF, 0x7C, 0x07, 0xF8, 0xF8, 0x01, 0xC3, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x04, 0x07, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0x16, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x03, 0xF0,
  0x7F, 0x07, 0xF0, 0x7E, 0x03, 0xE0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x07, 0xC0, 0x10, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1C, 0x0F,
  0xC2, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x78, 0x1E, 0x00, 0xFC, 0x0F,
  0x07, 0x80, 0x7F, 0xE0, 0xE0, 0xF0, 0x3F, 0xFC, 0x1E, 0x3C, 0x0F, 0xFF,
  0x83, 0xC7, 0x83, 0xE1, 0xF0, 0x79, 0xE0, 0x78, 0x3C, 0x0F, 0x3C, 0x1E,
  0x07, 0x81, 0xC7, 0x83, 0xC0, 0xF0, 0x79, 0xE0, 0xF0, 0x3E, 0x0F, 0x3C,
  0x1E, 0x07, 0x81, 0xE7, 0x87, 0xC0, 0xF0, 0x3D, 0xE0, 0xF0, 0x1E, 0x07,
  0xBC, 0x1E, 0x07, 0xC1, 0xE7, 0x83, 0xC0, 0xF0, 0x3C, 0xF0, 0x78, 0x1E,
  0x07, 0x9E, 0x0F, 0x07, 0xC1, 0xE3, 0xC1, 0xE0, 0xF8, 0x3C, 0x78, 0x3C,
  0x3F, 0x0F, 0x0F, 0x07, 0x87, 0xE3, 0xC1, 0xE0, 0xFF, 0xDF, 0xF8, 0x3C,
  0x1F, 0xF3, 0xFE, 0x07, 0x81, 0xFC, 0x7F, 0x80, 0xF0, 0x1F, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x80, 0x00, 0xFE, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3E, 0xF0,
  0x00, 0x0F, 0xBC, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x78,
  0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x83, 0xE0,
  0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03,
  0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x83,
  0xF0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x8F, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x7E, 0x00,
  0x0F, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xF0, 0x7F,
  0xC0, 0x7C, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xE0,
  0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07,
  0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x1F, 0x01, 0xFC,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x07, 0xE0, 0x7C,
  0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE0,
  0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x07,
  0xE1, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xFC, 0x1F, 0x00, 0xFE, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFE, 0x07, 0x00,
  0x7F, 0x00, 0x20, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x80, 0x1F, 0xF1, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F,
  0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x03,
  0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x07,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00,
  0x7E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1,
  0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x1F, 0x00,
  0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0,
  0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0,
  0x1F, 0xC0, 0x7C, 0x03, 0xF8, 0x07, 0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x3E, 0x03, 0xFC, 0x00, 0xC0, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x4F, 0xC0, 0x1F, 0xF8, 0xFC, 0x03, 0xFF, 0x8F, 0xC0,
  0x3F, 0xF8, 0xF8, 0x03, 0xFF, 0x8F, 0x80, 0x3F, 0xF8, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF0, 0xF8,
  0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xC0, 0x7F, 0x00, 0x7C, 0x07,
  0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07,
  0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xE0,
  0x0F, 0x80, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0,
  0x03, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x7E, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x01,
  0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0xC0, 0x3F, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8,
  0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x83, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC,
  0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0xF8, 0x7E, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x3E, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xF0, 0x01,
  0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xE0,
  0x1F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x1F,
  0x80, 0x7C, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x0F, 0x7C, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xDF,
  0x00, 0x1E, 0xF8, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x3C,
  0xF8, 0x07, 0xDF, 0x00, 0x7D, 0xF8, 0x07, 0xDF, 0x00, 0x7D, 0xF0, 0x07,
  0xDF, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x01,
  0xF1, 0xF0, 0x0F, 0x8F, 0x01, 0xF3, 0xF0, 0x0F, 0x8F, 0x03, 0xE3, 0xE0,
  0x1F, 0x8F, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x07, 0xC3, 0xE0, 0x1F, 0x0F,
  0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x8F, 0x87, 0xE0, 0x1F, 0x0F, 0x8F, 0x87,
  0xC0, 0x3E, 0x0F, 0x9F, 0x07, 0xC0, 0x3E, 0x0F, 0x9F, 0x07, 0xC0, 0x3E,
  0x0F, 0x9E, 0x0F, 0xC0, 0x3E, 0x0F, 0xBE, 0x0F, 0x80, 0x3E, 0x0F, 0xBC,
  0x0F, 0x80, 0x7C, 0x0F, 0xFC, 0x0F, 0x80, 0x7C, 0x0F, 0xF8, 0x0F, 0x80,
  0x7C, 0x0F, 0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xF0, 0x1F, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x1F, 0x01, 0xFE, 0x00, 0x1F, 0x01,
  0xFE, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x3E, 0x01, 0xFE, 0x00, 0x3E, 0x03,
  0xFF, 0x00, 0x3E, 0x03, 0xFF, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0x7C, 0x03,
  0xFF, 0x00, 0x7C, 0x03, 0xDF, 0x00, 0x7C, 0x07, 0xCF, 0x80, 0x7C, 0x07,
  0xCF, 0x80, 0xFC, 0x07, 0xCF, 0x80, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0x07,
  0xC7, 0xC0, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x0F, 0x87, 0xC1, 0xF8, 0x0F,
  0x87, 0xC1, 0xF0, 0x0F, 0x83, 0xC1, 0xF0, 0x1F, 0x83, 0xE1, 0xF0, 0x1F,
  0x03, 0xE1, 0xF0, 0x1F, 0x03, 0xE3, 0xE0, 0x1F, 0x03, 0xE3, 0xE0, 0x1F,
  0x01, 0xF3, 0xE0, 0x3E, 0x01, 0xF3, 0xE0, 0x3E, 0x01, 0xF3, 0xE0, 0x3E,
  0x01, 0xF7, 0xC0, 0x3E, 0x00, 0xF7, 0xC0, 0x3E, 0x00, 0xFF, 0xC0, 0x7C,
  0x00, 0xFF, 0xC0, 0x7C, 0x00, 0xFF, 0xC0, 0x7C, 0x00, 0xFF, 0x80, 0x7C,
  0x00, 0x7F, 0x80, 0xFC, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x7F, 0x80, 0xF8,
  0x00, 0x7F, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x1F,
  0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0xFC, 0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x03, 0xF0,
  0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xF1, 0xFF, 0x80, 0x7C, 0x0F, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03,
  0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0x81, 0xF0,
  0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x03,
  0xF0, 0x1F, 0xC0, 0xF8, 0x1F, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x1F,
  0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0xFC, 0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x03, 0xF0,
  0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0x0F,
  0xF8, 0x0F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x1F, 0x03, 0xE0,
  0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x7E,
  0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7E, 0x0F,
  0xC0, 0x7F, 0x07, 0xC0, 0x7F, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xC0, 0xF8,
  0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07,
  0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x80,
  0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xC3, 0xE0, 0x1F, 0xC0, 0x30, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x10, 0x00,
  0xFC, 0x07, 0x00, 0x7F, 0x01, 0xFD, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80,
  0x07, 0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC,
  0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x83, 0xF0,
  0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x0F,
  0x80, 0x0F, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFF, 0x9F, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x06,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xDF,
  0x00, 0x07, 0xEF, 0x80, 0x07, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xF1,
  0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x1F, 0x07,
  0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x1F,
  0x3E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7C,
  0x00, 0x7E, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0xF8, 0x01, 0xFC, 0x00, 0xF8, 0xF8, 0x01,
  0xFC, 0x01, 0xF8, 0xF8, 0x03, 0xFC, 0x01, 0xF0, 0xF8, 0x03, 0xFC, 0x01,
  0xF0, 0xF8, 0x07, 0xFC, 0x03, 0xF0, 0xF8, 0x07, 0xBC, 0x03, 0xE0, 0xF8,
  0x07, 0xBC, 0x07, 0xE0, 0xF8, 0x0F, 0xBC, 0x07, 0xC0, 0xF8, 0x0F, 0x3C,
  0x07, 0xC0, 0xF8, 0x1F, 0x3C, 0x0F, 0xC0, 0xF8, 0x1E, 0x3C, 0x0F, 0x80,
  0xF8, 0x3E, 0x3C, 0x1F, 0x80, 0xF8, 0x3E, 0x3C, 0x1F, 0x00, 0xF8, 0x3C,
  0x3C, 0x1F, 0x00, 0xF8, 0x7C, 0x3C, 0x3E, 0x00, 0xF8, 0x78, 0x3C, 0x3E,
  0x00, 0xF8, 0xF8, 0x3C, 0x7E, 0x00, 0xF8, 0xF8, 0x3C, 0x7C, 0x00, 0xF8,
  0xF0, 0x3C, 0x7C, 0x00, 0xF9, 0xF0, 0x3C, 0xF8, 0x00, 0xF9, 0xE0, 0x7C,
  0xF8, 0x00, 0xFB, 0xE0, 0x7D, 0xF8, 0x00, 0xFB, 0xE0, 0x7D, 0xF0, 0x00,
  0xFB, 0xC0, 0x7D, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x03,
  0xE0, 0x1F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x7E, 0x1F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x3F, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xE7,
  0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x3E,
  0x03, 0xF0, 0x7C, 0x0F, 0xC0, 0xFC, 0x1F, 0x00, 0xF8, 0x7E, 0x01, 0xF0,
  0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0x3E,
  0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xE0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07,
  0x81, 0xE0, 0x7C, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xF3, 0xE0, 0x03,
  0xE3, 0xC0, 0x07, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3C, 0x0F, 0x00, 0xF8,
  0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x3C, 0x1F, 0x00, 0x7C, 0x3C, 0x00,
  0xF8, 0xF8, 0x00, 0xF3, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x00, 0x03,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x3E, 0x1F,
  0x87, 0xC3, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x80, 0x00, 0x7E, 0x1F, 0x01,
  0xFF, 0x1F, 0x03, 0xFF, 0x9F, 0x07, 0xFF, 0xFE, 0x07, 0xF3, 0xFE, 0x0F,
  0xC1, 0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xF8,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8,
  0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xE0, 0xFC, 0x1F, 0xE0, 0xFC,
  0x3F, 0xE0, 0xFF, 0xFB, 0xC0, 0x7F, 0xF3, 0xC0, 0x3F, 0xE3, 0xC0, 0x1F,
  0xC7, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x9F,
  0xE0, 0x0F, 0xBF, 0xF8, 0x07, 0xDF, 0xFE, 0x03, 0xFE, 0x7F, 0x03, 0xFC,
  0x1F, 0x81, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3E,
  0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x07,
  0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE1, 0xF0, 0x03, 0xF0,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0x7C,
  0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x3F,
  0x83, 0xFC, 0x3F, 0x81, 0xFF, 0xFF, 0x80, 0xF3, 0xFF, 0x80, 0x79, 0xFF,
  0x80, 0x7C, 0x7F, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFB, 0xC0, 0xFC, 0x04, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x02, 0x0F, 0xE0,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x7F, 0xCF, 0xC0,
  0x3F, 0xFB, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xF3, 0xFE, 0x03, 0xF0, 0x3F,
  0x81, 0xF8, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0,
  0x3F, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x1F,
  0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF8,
  0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03,
  0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x3F, 0x80, 0xFC,
  0x0F, 0xE0, 0x3F, 0x0F, 0xF8, 0x0F, 0xFF, 0xBC, 0x01, 0xFF, 0xCF, 0x00,
  0x3F, 0xE3, 0xC0, 0x07, 0xF1, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0x7E, 0x1F, 0x07,
  0xE0, 0xFC, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x3F, 0x01, 0xF1, 0xF0, 0x0F,
  0x9F, 0x80, 0xFC, 0xF8, 0x0F, 0xC7, 0xC1, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x87, 0xF0, 0x18, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xCC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x02, 0x7F, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC1, 0xE0, 0x07, 0xFE, 0x7C, 0x01, 0xFF, 0xCF,
  0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xE7, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x3E, 0x07, 0xE0, 0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03,
  0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x07,
  0xE0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x0F, 0xE0, 0x1F,
  0x83, 0xFC, 0x03, 0xF8, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0x7C,
  0x00, 0xFF, 0xCF, 0x80, 0x07, 0xF1, 0xF0, 0x00, 0x10, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0x80, 0x1F, 0x80, 0x3F, 0x1F,
  0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF1, 0xF8, 0x03, 0xE7, 0xFC, 0x03, 0xEF,
  0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xF8, 0x3F, 0x07, 0xF0,
  0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0x00, 0x38,
  0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x06, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x0F, 0x81, 0xF8,
  0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F,
  0xC0, 0x07, 0xC7, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3E,
  0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xF7, 0xE0, 0x01, 0xF9, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x03, 0xE0,
  0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x01, 0xF8, 0x07,
  0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x3F, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x01, 0xE1, 0xF8, 0x0F,
  0xC0, 0x1F, 0x3F, 0xE1, 0xFF, 0x00, 0xFB, 0xFF, 0x9F, 0xFC, 0x07, 0xBF,
  0xFD, 0xFF, 0xF0, 0x3D, 0xE7, 0xFF, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFC,
  0x1F, 0xC0, 0xFE, 0x03, 0xE0, 0xFC, 0x07, 0xF0, 0x1F, 0x07, 0xE0, 0x3F,
  0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0x80, 0x7C, 0x1F,
  0x80, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x7E,
  0x01, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0xF8, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x7E, 0x01,
  0xF0, 0x0F, 0x80, 0x01, 0xE1, 0xF8, 0x03, 0xE7, 0xFE, 0x03, 0xEF, 0xFE,
  0x03, 0xDF, 0xFF, 0x03, 0xDF, 0xFF, 0x07, 0xF8, 0x3F, 0x07, 0xF0, 0x1F,
  0x07, 0xF0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7E,
  0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C,
  0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xF3, 0xF8, 0x3F,
  0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xF8, 0x01,
  0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7C, 0x00, 0xFD, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xEF, 0x80,
  0x1F, 0xBE, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x7E,
  0x3E, 0x01, 0xF8, 0xFC, 0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x78, 0x7E, 0x00, 0x1F, 0x1F, 0xE0, 0x03, 0xEF, 0xFE, 0x00, 0x7D, 0xFF,
  0xE0, 0x0F, 0x79, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x01, 0xF0, 0x0F,
  0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x1F,
  0x81, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8,
  0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0,
  0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0xFE, 0x03,
  0xFC, 0x3F, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xBF, 0xF8, 0x01, 0xF3, 0xFE,
  0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC1, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x0F, 0x01, 0xFF, 0x9F, 0x03, 0xFF, 0x9E, 0x07, 0xFF,
  0xDE, 0x07, 0xF3, 0xFE, 0x0F, 0xC1, 0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0x80,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00,
  0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03,
  0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F,
  0xE0, 0xFC, 0x1F, 0xE0, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xF7,
  0xC0, 0x7F, 0xE7, 0xC0, 0x1F, 0xC7, 0xC0, 0x02, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xE1,
  0xF0, 0x3E, 0x7F, 0x03, 0xEF, 0xF0, 0x3C, 0xFE, 0x03, 0xDF, 0xE0, 0x7F,
  0xE2, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xE1, 0xE0, 0xF8, 0x04, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x80, 0x3F, 0x0E, 0x07, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x07, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xFF, 0x9F, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x10, 0xFF, 0xC1, 0xFF, 0x81, 0xFF,
  0x01, 0xFE, 0x00, 0x40, 0x00, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x1F,
  0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x3F,
  0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7E,
  0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C,
  0x03, 0xF0, 0xFC, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xF8,
  0x07, 0xE0, 0xF8, 0x0F, 0xE0, 0xF8, 0x1F, 0xC0, 0xFC, 0x3F, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xF7, 0xC0, 0x7F, 0xE7, 0xC0, 0x3F, 0xC7, 0x80, 0x04,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7D, 0xF0, 0x07,
  0xEF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xF8, 0xF8,
  0x0F, 0xC3, 0xC0, 0x7C, 0x1E, 0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xC3, 0xF0,
  0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE7,
  0xC0, 0x1F, 0x3E, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0xFE, 0x01, 0xFC, 0x03, 0xEF, 0x80, 0x7F, 0x01, 0xFB, 0xE0, 0x1F,
  0xC0, 0x7C, 0xF8, 0x0F, 0xF0, 0x1F, 0x3E, 0x03, 0xFC, 0x0F, 0x8F, 0x81,
  0xFF, 0x03, 0xE3, 0xE0, 0x7B, 0xC1, 0xF8, 0xF8, 0x1E, 0xF0, 0x7C, 0x3E,
  0x0F, 0x7C, 0x1F, 0x0F, 0x83, 0xDF, 0x0F, 0x83, 0xE1, 0xF7, 0xC3, 0xE0,
  0xF8, 0x79, 0xF1, 0xF0, 0x3E, 0x1E, 0x7C, 0x7C, 0x0F, 0x8F, 0x1F, 0x1F,
  0x03, 0xE3, 0xC7, 0xCF, 0x80, 0xF9, 0xF1, 0xF3, 0xE0, 0x3E, 0x78, 0x7D,
  0xF0, 0x0F, 0x9E, 0x1E, 0x7C, 0x03, 0xEF, 0x07, 0x9E, 0x00, 0xFB, 0xC1,
  0xEF, 0x80, 0x3F, 0xF0, 0x7B, 0xE0, 0x0F, 0xF8, 0x1E, 0xF0, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F,
  0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x1F,
  0x80, 0x0F, 0x8F, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x1F,
  0x7C, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xE7,
  0xC0, 0x01, 0xF9, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x1F,
  0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0,
  0x7C, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x03,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x7C,
  0x03, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x04, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF4, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x3F,
  0x80, 0x05, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0x00, 0xFF, 0xE8, 0x00, 0xFF, 0x00,
};

const GFXglyph NotoSans_Condensed_MediumItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 14, 40, 14, 1, -39 },
  { 71, 17, 14, 20, 5, -39 },
  { 101, 29, 39, 28, 0, -39 },
  { 243, 24, 45, 25, 1, -42 },
  { 378, 33, 41, 38, 3, -40 },
  { 548, 28, 41, 29, 0, -40 },
  { 692, 7, 14, 12, 6, -39 },
  { 705, 18, 48, 15, 1, -39 },
  { 813, 18, 49, 15, -4, -40 },
  { 924, 20, 21, 24, 5, -42 },
  { 977, 22, 27, 26, 3, -33 },
  { 1052, 11, 13, 13, -3, -6 },
  { 1070, 13, 5, 16, 1, -17 },
  { 1079, 7, 8, 13, 1, -7 },
  { 1086, 27, 39, 20, -3, -39 },
  { 1218, 22, 41, 25, 2, -40 },
  { 1331, 16, 39, 25, 6, -39 },
  { 1409, 25, 40, 25, -1, -40 },
  { 1534, 25, 41, 25, 0, -40 },
  { 1663, 26, 39, 25, -1, -39 },
  { 1790, 25, 40, 25, 0, -39 },
  { 1915, 24, 41, 25, 2, -40 },
  { 2038, 25, 39, 25, 2, -39 },
  { 2160, 25, 41, 25, 0, -40 },
  { 2289, 23, 41, 25, 1, -40 },
  { 2407, 12, 31, 13, 0, -30 },
  { 2454, 15, 37, 13, -3, -30 },
  { 2524, 22, 26, 26, 3, -33 },
  { 2596, 22, 15, 26, 3, -27 },
  { 2638, 22, 26, 26, 3, -33 },
  { 2710, 19, 41, 19, 2, -40 },
  { 2808, 35, 44, 37, 2, -39 },
  { 3001, 26, 39, 26, -3, -39 },
  { 3128, 26, 39, 27, 1, -39 },
  { 3255, 27, 41, 25, 2, -40 },
  { 3394, 28, 39, 29, 1, -39 },
  { 3531, 24, 39, 23, 1, -39 },
  { 3648, 24, 39, 22, 1, -39 },
  { 3765, 28, 41, 31, 3, -40 },
  { 3909, 31, 39, 30, 1, -39 },
  { 4061, 22, 39, 16, -2, -39 },
  { 4169, 22, 50, 13, -8, -39 },
  { 4307, 29, 39, 26, 1, -39 },
  { 4449, 17, 39, 22, 1, -39 },
  { 4532, 40, 39, 40, 1, -39 },
  { 4727, 32, 39, 32, 1, -39 },
  { 4883, 29, 41, 32, 2, -40 },
  { 5032, 26, 39, 26, 1, -39 },
  { 5159, 29, 49, 32, 2, -40 },
  { 5337, 25, 39, 26, 1, -39 },
  { 5459, 26, 41, 23, -1, -40 },
  { 5593, 23, 39, 22, 4, -39 },
  { 5706, 28, 40, 30, 3, -39 },
  { 5846, 25, 39, 26, 5, -39 },
  { 5968, 40, 39, 40, 5, -39 },
  { 6163, 31, 39, 24, -3, -39 },
  { 6315, 23, 39, 23, 5, -39 },
  { 6428, 27, 39, 22, -2, -39 },
  { 6560, 21, 48, 16, -1, -39 },
  { 6686, 10, 39, 20, 6, -39 },
  { 6735, 21, 48, 16, -4, -39 },
  { 6861, 23, 22, 25, 1, -39 },
  { 6925, 19, 3, 18, -5, 5 },
  { 6933, 9, 9, 15, 8, -42 },
  { 6944, 24, 31, 26, 2, -30 },
  { 7037, 25, 43, 26, 0, -42 },
  { 7172, 20, 31, 20, 2, -30 },
  { 7250, 26, 43, 26, 2, -42 },
  { 7390, 21, 31, 24, 2, -30 },
  { 7472, 27, 55, 15, -6, -42 },
  { 7658, 27, 43, 26, -1, -30 },
  { 7804, 24, 42, 26, 0, -42 },
  { 7930, 14, 41, 12, 0, -41 },
  { 8002, 21, 54, 12, -7, -41 },
  { 8144, 26, 42, 23, 0, -42 },
  { 8281, 15, 42, 12, 0, -42 },
  { 8360, 37, 30, 39, 0, -30 },
  { 8499, 24, 30, 26, 0, -30 },
  { 8589, 22, 31, 26, 2, -30 },
  { 8675, 27, 43, 26, -2, -30 },
  { 8821, 24, 43, 26, 2, -30 },
  { 8950, 20, 30, 18, 0, -30 },
  { 9025, 20, 31, 20, 0, -30 },
  { 9103, 15, 37, 16, 2, -36 },
  { 9173, 24, 31, 26, 2, -30 },
  { 9266, 21, 30, 22, 3, -30 },
  { 9345, 34, 30, 34, 3, -30 },
  { 9473, 26, 30, 22, -2, -30 },
  { 9571, 30, 43, 22, -5, -30 },
  { 9733, 22, 30, 19, -2, -30 },
  { 9816, 21, 48, 19, 1, -39 },
  { 9942, 5, 55, 23, 9, -42 },
  { 9977, 21, 48, 19, -3, -39 },
  { 10103, 22, 7, 26, 3, -23 },
};

const GFXfont NotoSans_Condensed_MediumItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC55PT7B_H_
