#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC25PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x06, 0x0C, 0x38, 0x60, 0xC1, 0x83,
  0x00, 0x00, 0x30, 0xE1, 0xC0, 0x73, 0x77, 0x67, 0x66, 0x66, 0x66, 0xC4,
  0x03, 0x30, 0x19, 0x80, 0x8C, 0x0C, 0x40, 0x66, 0x1F, 0xFC, 0xFF, 0xE1,
  0x98, 0x0C, 0xC0, 0xC4, 0x06, 0x61, 0xFF, 0xCF, 0xFE, 0x19, 0x80, 0xCC,
  0x04, 0x60, 0x62, 0x03, 0x30, 0x00, 0x01, 0x80, 0x20, 0x1F, 0x07, 0xF1,
  0xD6, 0x76, 0x0E, 0x81, 0xD0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x5C,
  0x0B, 0x83, 0x77, 0x5C, 0xFF, 0x0F, 0x80, 0x20, 0x0C, 0x00, 0x1C, 0x0C,
  0x7C, 0x30, 0xD8, 0x63, 0x31, 0x86, 0x63, 0x0C, 0xCC, 0x31, 0xB0, 0x63,
  0x6E, 0xCD, 0xBE, 0xFB, 0x6D, 0xED, 0x98, 0x33, 0x30, 0x66, 0x61, 0x88,
  0xC3, 0x31, 0x8C, 0x66, 0x30, 0x7C, 0x60, 0xF0, 0x07, 0xC0, 0x7E, 0x03,
  0x38, 0x19, 0xC1, 0xCC, 0x0E, 0x60, 0x36, 0x01, 0xE0, 0x0E, 0x01, 0xF1,
  0xCD, 0xCC, 0xC6, 0xEE, 0x3E, 0x70, 0xF3, 0x87, 0x1C, 0x78, 0x7F, 0xE3,
  0xF3, 0x80, 0xFF, 0x6D, 0xA0, 0x07, 0x0E, 0x0C, 0x18, 0x38, 0x30, 0x70,
  0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x60, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x18, 0x38, 0x30, 0x60,
  0xE0, 0x0E, 0x06, 0x13, 0x1F, 0x93, 0xF8, 0xE0, 0xD8, 0xEC, 0x27, 0x02,
  0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x39, 0x9C, 0xC6, 0x60, 0x7F, 0xF8, 0x7F, 0x80,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30,
  0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0x0F, 0x87, 0xE1, 0x9C, 0xE3, 0x30, 0xDC, 0x36, 0x0D,
  0x87, 0xE1, 0xF8, 0x7C, 0x1B, 0x06, 0xC3, 0xB0, 0xCC, 0x73, 0x18, 0xFE,
  0x1F, 0x00, 0x0E, 0x3C, 0xF3, 0xEE, 0xD3, 0x87, 0x0C, 0x18, 0x30, 0xE1,
  0xC3, 0x06, 0x1C, 0x38, 0x60, 0xC0, 0x03, 0xC0, 0xFE, 0x0C, 0x70, 0x87,
  0x00, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x7F, 0xCF, 0xFC, 0x0F, 0xC3, 0xFC,
  0x63, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x1C, 0x1F, 0x03, 0xE0, 0x0E,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x64, 0x1C, 0xFF, 0x1F, 0xC0, 0x00, 0xE0,
  0x1C, 0x07, 0x81, 0xE0, 0x6C, 0x0D, 0x83, 0x70, 0xCE, 0x19, 0x86, 0x31,
  0x86, 0x31, 0xCF, 0xFF, 0xFF, 0x80, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x0F,
  0xE1, 0xFC, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xF8, 0x3F, 0x80,
  0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x64, 0x1C, 0xFF, 0x1F, 0xC0,
  0x03, 0xE1, 0xF8, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x78, 0xFF,
  0x9E, 0x33, 0x86, 0x60, 0xCC, 0x19, 0x87, 0x30, 0xE7, 0x38, 0x7E, 0x0F,
  0x80, 0x3F, 0xE7, 0xFD, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60,
  0x1C, 0x00, 0x07, 0xC1, 0xFC, 0x71, 0x8C, 0x31, 0x86, 0x30, 0xC6, 0x30,
  0xFC, 0x0F, 0x03, 0xE0, 0xEE, 0x30, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x0C,
  0x7F, 0x87, 0xE0, 0x07, 0x81, 0xF8, 0x73, 0x9C, 0x73, 0x06, 0x61, 0xCC,
  0x39, 0x87, 0x31, 0xE7, 0xF8, 0xFB, 0x04, 0xE0, 0x18, 0x03, 0x00, 0xC0,
  0x38, 0xFE, 0x1F, 0x80, 0x08, 0xCE, 0x30, 0x00, 0x00, 0x00, 0x00, 0xCE,
  0x70, 0x04, 0x1C, 0x70, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC3,
  0x0E, 0x18, 0x70, 0xC0, 0x00, 0x40, 0x30, 0x3C, 0x3C, 0x3C, 0x3C, 0x0F,
  0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0C, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x80, 0x38, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0,
  0x1C, 0x1E, 0x1E, 0x1E, 0x0E, 0x02, 0x00, 0x3E, 0x3F, 0x88, 0xC0, 0x70,
  0x30, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0xE0, 0x70, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0E, 0x0E, 0x18, 0x06,
  0x30, 0x02, 0x31, 0xF3, 0x63, 0x73, 0x66, 0x23, 0xC6, 0x62, 0xCC, 0x66,
  0xCC, 0x66, 0xCC, 0xC6, 0xCC, 0xCC, 0xCD, 0xFC, 0xCF, 0x78, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x00, 0xF0, 0x0F, 0x01,
  0xF0, 0x1B, 0x01, 0xB0, 0x33, 0x03, 0x30, 0x73, 0x06, 0x30, 0xE3, 0x0C,
  0x31, 0xFF, 0x1F, 0xF3, 0x83, 0x38, 0x33, 0x03, 0x70, 0x3E, 0x03, 0x0F,
  0xC0, 0xFF, 0x0C, 0x71, 0xC3, 0x1C, 0x31, 0x83, 0x18, 0x73, 0x9E, 0x3F,
  0x83, 0xFC, 0x30, 0xE3, 0x0E, 0x70, 0xE7, 0x0E, 0x60, 0xE6, 0x1C, 0x7F,
  0x8F, 0xF0, 0x03, 0xE0, 0xFF, 0x1E, 0x21, 0xC0, 0x38, 0x07, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x07, 0x08, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0x3C, 0x38, 0x71,
  0xC3, 0x8C, 0x1C, 0x60, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCC, 0x0C, 0x60,
  0xE7, 0x07, 0x38, 0x71, 0x87, 0x8C, 0x78, 0x7F, 0x87, 0xF0, 0x00, 0x0F,
  0xF0, 0xFE, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x84, 0x3F,
  0x83, 0xF8, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x7F,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18,
  0x03, 0x80, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0x03, 0xF0, 0x7F, 0xC7, 0x84, 0x38, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x61, 0xF7, 0x0F, 0xB8, 0x7D, 0xC0,
  0xCE, 0x06, 0x70, 0x73, 0x83, 0x8E, 0x18, 0x7F, 0xC0, 0xFE, 0x00, 0x0E,
  0x0C, 0x30, 0x30, 0xC1, 0xC7, 0x07, 0x1C, 0x18, 0x60, 0x61, 0x83, 0x8E,
  0x0E, 0x3F, 0xF8, 0xFF, 0xC3, 0x03, 0x0C, 0x1C, 0x70, 0x71, 0xC1, 0x86,
  0x06, 0x18, 0x18, 0x60, 0xE3, 0x83, 0x80, 0x0F, 0xC7, 0xF0, 0x70, 0x18,
  0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06,
  0x01, 0x80, 0xE0, 0x7E, 0x3F, 0x00, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x09, 0xC1, 0xF0,
  0x3C, 0x00, 0x0C, 0x1C, 0x30, 0xE0, 0xC7, 0x07, 0x18, 0x1C, 0xE0, 0x67,
  0x01, 0xB8, 0x0E, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xB0, 0x0C, 0xC0, 0x73,
  0x81, 0xCE, 0x06, 0x18, 0x18, 0x70, 0x61, 0xC3, 0x87, 0x00, 0x0E, 0x0C,
  0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70,
  0x60, 0x60, 0x7F, 0xFF, 0x0E, 0x01, 0xC3, 0x80, 0xF0, 0xF0, 0x3C, 0x7C,
  0x1F, 0x1B, 0x07, 0xC6, 0xC3, 0xE1, 0xB0, 0xD8, 0xEC, 0x7E, 0x3B, 0x1B,
  0x8C, 0xCE, 0xC3, 0x33, 0x30, 0xCD, 0xCC, 0x73, 0x67, 0x1C, 0xD9, 0xC6,
  0x3C, 0x61, 0x8F, 0x18, 0x63, 0x86, 0x38, 0xE3, 0x80, 0x0E, 0x06, 0x1C,
  0x1C, 0x38, 0x38, 0xF8, 0x61, 0xB0, 0xC3, 0x61, 0x86, 0xC7, 0x1D, 0x8E,
  0x3B, 0x98, 0x63, 0x30, 0xC6, 0x61, 0x8D, 0xC7, 0x1F, 0x8E, 0x1E, 0x18,
  0x3C, 0x30, 0x78, 0x60, 0xF1, 0xC1, 0xC0, 0x03, 0xE0, 0x7F, 0x87, 0x1C,
  0x70, 0x73, 0x83, 0xB8, 0x1D, 0xC0, 0xEC, 0x07, 0x60, 0x3F, 0x01, 0xF8,
  0x0D, 0xC0, 0xEE, 0x07, 0x70, 0x73, 0x83, 0x8E, 0x38, 0x7F, 0x81, 0xF8,
  0x00, 0x0F, 0xC0, 0xFE, 0x0C, 0xF1, 0xC7, 0x1C, 0x31, 0x83, 0x18, 0x73,
  0x87, 0x38, 0xE3, 0xFC, 0x3F, 0x83, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0x1C, 0x70, 0x73, 0x83,
  0xB8, 0x1D, 0xC0, 0xEC, 0x07, 0x60, 0x3F, 0x01, 0xF8, 0x0D, 0xC0, 0xEE,
  0x07, 0x70, 0x73, 0x83, 0x8E, 0x38, 0x7F, 0x81, 0xF8, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x01, 0xC0, 0x0F, 0xC0, 0xFE, 0x0C, 0xF1, 0xC7, 0x1C, 0x71,
  0x87, 0x18, 0x73, 0x8E, 0x39, 0xE3, 0xFC, 0x3F, 0x03, 0x38, 0x73, 0x87,
  0x18, 0x61, 0x86, 0x1C, 0x61, 0xCE, 0x1C, 0x07, 0xE3, 0xFC, 0x71, 0x9C,
  0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x18, 0x03, 0x00, 0xE4, 0x3C, 0xFF, 0x1F, 0xC0, 0xFF, 0xFF, 0xF0, 0xC0,
  0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x00, 0x18, 0x18, 0xC1, 0xCE, 0x0E,
  0x70, 0x63, 0x03, 0x18, 0x18, 0xC1, 0xCE, 0x0E, 0x70, 0x63, 0x03, 0x18,
  0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x63, 0x87, 0x1C, 0x70, 0x7F, 0x81, 0xF8,
  0x00, 0xE0, 0x7E, 0x06, 0xE0, 0xEE, 0x0C, 0xE1, 0xCE, 0x18, 0xE3, 0x8E,
  0x30, 0x67, 0x06, 0x60, 0x66, 0x06, 0xE0, 0x6C, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0x70, 0x07, 0x00, 0xE0, 0xC0, 0xF8, 0x30, 0x7E, 0x1C, 0x1B, 0x87,
  0x0E, 0xE3, 0xC3, 0x38, 0xF0, 0xCE, 0x3C, 0x73, 0x9B, 0x18, 0xE6, 0xCE,
  0x3B, 0x33, 0x0E, 0xCC, 0xC3, 0x73, 0x70, 0xD8, 0xD8, 0x36, 0x3E, 0x0F,
  0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x38, 0x38, 0x00, 0x0C, 0x1C, 0x30,
  0xE0, 0xE3, 0x03, 0x9C, 0x06, 0x60, 0x1B, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0x60, 0x1D, 0x80, 0xE6, 0x03, 0x1C, 0x1C,
  0x70, 0x61, 0xC3, 0x83, 0x00, 0xE0, 0xFC, 0x39, 0x86, 0x31, 0xC6, 0x30,
  0xCE, 0x19, 0x83, 0xF0, 0x3C, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0x60, 0x1C, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x07, 0xC1, 0xF0, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01,
  0x80, 0x7C, 0x3E, 0x00, 0xCC, 0xCC, 0xCC, 0xE6, 0x66, 0x66, 0x67, 0x73,
  0x33, 0x07, 0xC1, 0xF0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x7C, 0x3E, 0x00, 0x03, 0x00, 0x60, 0x1E, 0x06, 0xC0, 0xD8,
  0x33, 0x86, 0x31, 0x86, 0x70, 0xDC, 0x0C, 0xFF, 0xFF, 0x80, 0xCE, 0x63,
  0x0E, 0x03, 0xFC, 0xEF, 0x38, 0xE6, 0x1D, 0xC3, 0xB8, 0x77, 0x0C, 0xC1,
  0x98, 0x73, 0x0E, 0x63, 0x8F, 0xF0, 0xF6, 0x00, 0x0E, 0x01, 0x80, 0x30,
  0x0E, 0x01, 0xC0, 0x33, 0x06, 0xF0, 0xF7, 0x38, 0x67, 0x0C, 0xC1, 0x98,
  0x37, 0x0E, 0xE1, 0xDC, 0x33, 0x8E, 0x71, 0x9F, 0xF3, 0x7C, 0x00, 0x07,
  0x0F, 0xCE, 0x4E, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x1C,
  0x4F, 0xE3, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0xEE,
  0x1F, 0xE3, 0x9C, 0x71, 0xC6, 0x1C, 0xE1, 0xCE, 0x1C, 0xC1, 0x8C, 0x18,
  0xC3, 0x8C, 0x38, 0xC7, 0x0F, 0xF0, 0x7B, 0x00, 0x06, 0x0F, 0xCE, 0x6E,
  0x36, 0x1F, 0x1F, 0xFD, 0xF8, 0xC0, 0x60, 0x30, 0x1C, 0x2F, 0xE3, 0xF0,
  0x00, 0xF8, 0x07, 0x80, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x3F, 0x81,
  0xF8, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x1E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xFF, 0x1D, 0xE3, 0x8E, 0x30,
  0xE7, 0x0E, 0x70, 0xE6, 0x0C, 0x60, 0xC6, 0x1C, 0x61, 0xC6, 0x38, 0x7F,
  0x83, 0xD8, 0x03, 0x80, 0x38, 0x03, 0x08, 0x70, 0xFE, 0x0F, 0xC0, 0x0E,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x33, 0x06, 0xF8, 0xF7, 0x38, 0xE7,
  0x1C, 0xC3, 0x98, 0x63, 0x0C, 0xE1, 0x9C, 0x73, 0x0E, 0x61, 0x9C, 0x33,
  0x8E, 0x00, 0x04, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x38, 0xE3, 0x0C, 0x71,
  0xC7, 0x18, 0x63, 0x8E, 0x00, 0x00, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C,
  0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE1, 0xE0, 0xE0, 0x00, 0x0E, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x81, 0x18, 0xE1, 0x9C, 0x39, 0x83,
  0xB0, 0x37, 0x03, 0xE0, 0x3E, 0x07, 0x70, 0x67, 0x06, 0x30, 0x63, 0x0E,
  0x38, 0xE3, 0x80, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x06, 0x0C, 0x38, 0x70,
  0xC1, 0x83, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x80, 0x01, 0x86, 0x0D, 0xEF,
  0x87, 0xBE, 0xE7, 0x1C, 0x73, 0x8E, 0x39, 0x86, 0x18, 0xC3, 0x0C, 0x61,
  0x86, 0x71, 0xC7, 0x38, 0xE3, 0x98, 0x61, 0x8C, 0x30, 0xCE, 0x18, 0x67,
  0x1C, 0x70, 0x01, 0x83, 0x7C, 0x7B, 0x9C, 0x73, 0x8E, 0x61, 0xCC, 0x33,
  0x86, 0x70, 0xCE, 0x39, 0x87, 0x30, 0xCE, 0x19, 0xC7, 0x00, 0x0E, 0x07,
  0xE3, 0xB9, 0xC7, 0x61, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xB0, 0x6C, 0x3B,
  0x9C, 0xFE, 0x1F, 0x00, 0x00, 0xC0, 0xDF, 0x0F, 0x71, 0xC3, 0x1C, 0x31,
  0x83, 0x18, 0x31, 0x87, 0x38, 0x73, 0x86, 0x38, 0xE3, 0x8C, 0x7F, 0xC7,
  0x78, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x0E, 0x03,
  0xFC, 0xEF, 0x38, 0xE6, 0x1D, 0xC3, 0xB8, 0x76, 0x0C, 0xC1, 0x98, 0x73,
  0x0E, 0x63, 0x8F, 0xF0, 0xF6, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0x01, 0x8D, 0xC7, 0xE7, 0x83, 0x81, 0xC0, 0xC0, 0x60, 0x70,
  0x38, 0x18, 0x0C, 0x0E, 0x07, 0x00, 0x0E, 0x1F, 0xCE, 0x6E, 0x07, 0x01,
  0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xD0, 0xCF, 0xE7, 0xE0, 0x18, 0x30,
  0xC7, 0xF3, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x3E, 0x7C,
  0x30, 0xE6, 0x19, 0xC3, 0x30, 0xE6, 0x1C, 0xC3, 0x38, 0x67, 0x0C, 0xC3,
  0x98, 0x73, 0x1C, 0x7F, 0x87, 0xB0, 0xE1, 0xF8, 0x66, 0x39, 0x8C, 0x67,
  0x19, 0x86, 0xE1, 0xB0, 0x6C, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x00, 0xC7,
  0x0F, 0x8E, 0x3B, 0x3C, 0x66, 0x78, 0xCC, 0xF3, 0x9B, 0x66, 0x36, 0xDC,
  0x79, 0xB0, 0xF3, 0x61, 0xE7, 0x83, 0x8F, 0x07, 0x1E, 0x0C, 0x38, 0x00,
  0x1C, 0x71, 0xCE, 0x0D, 0xC0, 0xD8, 0x0F, 0x80, 0x70, 0x0F, 0x00, 0xF0,
  0x1B, 0x03, 0xB0, 0x33, 0x86, 0x38, 0xE1, 0x80, 0x1C, 0x38, 0x61, 0x83,
  0x1C, 0x18, 0xC0, 0xCE, 0x06, 0x60, 0x33, 0x01, 0xB0, 0x0D, 0x80, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x38, 0x00, 0x1F, 0xC0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x80, 0xC0,
  0x70, 0x38, 0x0C, 0x07, 0x01, 0xFC, 0xFF, 0x00, 0x01, 0xC0, 0xF0, 0x70,
  0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x07, 0x03, 0xC0, 0x38,
  0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3C, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x07, 0x01, 0xC0, 0xE0,
  0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xE0, 0xF0, 0xE0, 0xE0, 0x70,
  0x30, 0x18, 0x0C, 0x0E, 0x06, 0x0F, 0x07, 0x00, 0x20, 0x7F, 0x1F, 0xFE,
  0x0E,
};

const GFXglyph NotoSans_Condensed_MediumItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 18, 6, 0, -18 },
  { 17, 8, 7, 9, 2, -18 },
  { 24, 13, 18, 13, 0, -18 },
  { 54, 11, 20, 11, 0, -19 },
  { 82, 15, 18, 17, 1, -18 },
  { 116, 13, 18, 13, 0, -18 },
  { 146, 3, 7, 5, 3, -18 },
  { 149, 8, 22, 7, 1, -18 },
  { 171, 8, 22, 7, -2, -18 },
  { 193, 9, 10, 11, 2, -19 },
  { 205, 10, 12, 12, 1, -15 },
  { 220, 5, 6, 6, -1, -3 },
  { 224, 7, 2, 7, 0, -8 },
  { 226, 3, 3, 6, 0, -3 },
  { 228, 12, 18, 9, -1, -18 },
  { 255, 10, 18, 11, 1, -18 },
  { 278, 7, 18, 11, 3, -18 },
  { 294, 12, 18, 11, -1, -18 },
  { 321, 11, 18, 11, 0, -18 },
  { 346, 11, 18, 11, 0, -18 },
  { 371, 11, 18, 11, 0, -18 },
  { 396, 11, 18, 11, 1, -18 },
  { 421, 11, 18, 11, 1, -18 },
  { 446, 11, 18, 11, 0, -18 },
  { 471, 11, 18, 11, 0, -18 },
  { 496, 5, 14, 6, 0, -14 },
  { 505, 7, 17, 6, -1, -14 },
  { 520, 10, 12, 12, 1, -15 },
  { 535, 10, 7, 12, 1, -12 },
  { 544, 10, 12, 12, 1, -15 },
  { 559, 9, 18, 9, 1, -18 },
  { 580, 16, 20, 17, 1, -18 },
  { 620, 12, 18, 12, -2, -18 },
  { 647, 12, 18, 12, 0, -18 },
  { 674, 12, 18, 11, 1, -18 },
  { 701, 13, 18, 13, 0, -18 },
  { 731, 12, 18, 11, 0, -18 },
  { 758, 12, 18, 10, 0, -18 },
  { 785, 13, 18, 14, 1, -18 },
  { 815, 14, 18, 14, 0, -18 },
  { 847, 10, 18, 7, -1, -18 },
  { 870, 11, 23, 6, -4, -18 },
  { 902, 14, 18, 12, 0, -18 },
  { 934, 8, 18, 10, 0, -18 },
  { 952, 18, 18, 18, 0, -18 },
  { 993, 15, 18, 15, 0, -18 },
  { 1027, 13, 18, 14, 1, -18 },
  { 1057, 12, 18, 12, 0, -18 },
  { 1084, 13, 22, 14, 1, -18 },
  { 1120, 12, 18, 12, 0, -18 },
  { 1147, 11, 18, 11, 0, -18 },
  { 1172, 10, 18, 10, 2, -18 },
  { 1195, 13, 18, 14, 1, -18 },
  { 1225, 12, 18, 12, 2, -18 },
  { 1252, 18, 18, 18, 2, -18 },
  { 1293, 14, 18, 11, -1, -18 },
  { 1325, 11, 18, 11, 2, -18 },
  { 1350, 13, 18, 10, -1, -18 },
  { 1380, 10, 22, 7, -1, -18 },
  { 1408, 4, 18, 9, 3, -18 },
  { 1417, 10, 22, 7, -2, -18 },
  { 1445, 11, 10, 11, 0, -18 },
  { 1459, 9, 2, 8, -2, 2 },
  { 1462, 4, 4, 7, 4, -19 },
  { 1464, 11, 14, 12, 1, -14 },
  { 1484, 11, 19, 12, 0, -19 },
  { 1511, 9, 14, 9, 1, -14 },
  { 1527, 12, 19, 12, 1, -19 },
  { 1556, 9, 14, 11, 1, -14 },
  { 1572, 13, 25, 7, -3, -19 },
  { 1613, 12, 20, 12, 0, -14 },
  { 1643, 11, 19, 12, 0, -19 },
  { 1670, 6, 19, 6, 0, -19 },
  { 1685, 9, 25, 6, -3, -19 },
  { 1714, 12, 19, 11, 0, -19 },
  { 1743, 7, 19, 6, 0, -19 },
  { 1760, 17, 14, 18, 0, -14 },
  { 1790, 11, 14, 12, 0, -14 },
  { 1810, 10, 14, 12, 1, -14 },
  { 1828, 12, 20, 12, -1, -14 },
  { 1858, 11, 20, 12, 1, -14 },
  { 1886, 9, 14, 8, 0, -14 },
  { 1902, 9, 14, 9, 0, -14 },
  { 1918, 7, 16, 7, 1, -16 },
  { 1932, 11, 13, 12, 1, -13 },
  { 1950, 10, 13, 10, 1, -13 },
  { 1967, 15, 13, 15, 2, -13 },
  { 1992, 12, 13, 10, -1, -13 },
  { 2012, 13, 19, 10, -2, -13 },
  { 2043, 10, 13, 9, -1, -13 },
  { 2060, 10, 22, 8, 0, -18 },
  { 2088, 2, 25, 11, 4, -19 },
  { 2095, 9, 22, 8, -1, -18 },
  { 2120, 10, 4, 12, 1, -11 },
};

const GFXfont NotoSans_Condensed_MediumItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC25PT7B_H_
