#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC13PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x26, 0x44, 0x04, 0xC0, 0x55, 0xB0, 0x14, 0x29, 0xF9, 0x42,
  0x9F, 0x94, 0x28, 0xD0, 0x08, 0xF7, 0x54, 0x70, 0xE2, 0x8A, 0xF8, 0x84,
  0x00, 0x66, 0xA4, 0xA8, 0xAA, 0xD7, 0x2A, 0x2A, 0x4A, 0xCC, 0x38, 0x58,
  0xA1, 0x87, 0x6A, 0xA7, 0x4C, 0x7C, 0x58, 0x12, 0x64, 0x44, 0xC8, 0xCC,
  0x40, 0x31, 0x11, 0x11, 0x32, 0x24, 0xC0, 0x35, 0x1E, 0xAD, 0x00, 0x21,
  0x09, 0xF2, 0x10, 0x2D, 0x60, 0xE0, 0x70, 0x06, 0x18, 0x20, 0xC1, 0x04,
  0x08, 0x20, 0xC0, 0x38, 0xB4, 0x53, 0x4F, 0x2C, 0xB4, 0x70, 0x3D, 0x72,
  0x22, 0x66, 0x40, 0x3D, 0x30, 0xC2, 0x10, 0xC6, 0x30, 0xF8, 0x7C, 0x30,
  0xC6, 0x30, 0x20, 0xA6, 0xF0, 0x0C, 0x63, 0x8A, 0x4A, 0x6F, 0x84, 0x10,
  0x3C, 0x86, 0x1C, 0x58, 0x20, 0xA6, 0xF0, 0x1C, 0x86, 0x1E, 0x4B, 0x2C,
  0x96, 0x70, 0xF8, 0xC4, 0x62, 0x31, 0x18, 0x80, 0x3D, 0x96, 0xCE, 0x31,
  0x28, 0xA2, 0x70, 0x39, 0xB4, 0xD3, 0x78, 0xA0, 0x84, 0xE0, 0x68, 0x00,
  0xB0, 0x32, 0x00, 0x02, 0x44, 0x80, 0x08, 0xD9, 0x06, 0x0C, 0xF8, 0x3E,
  0x86, 0x0C, 0x36, 0x40, 0x78, 0x46, 0x22, 0x20, 0x08, 0xC0, 0x1F, 0x10,
  0x93, 0xAA, 0x95, 0x4C, 0xAA, 0xF5, 0x24, 0x40, 0x1E, 0x00, 0x0C, 0x31,
  0x45, 0x24, 0xF6, 0x51, 0xC4, 0x3C, 0x92, 0x5B, 0x79, 0x34, 0xF2, 0xF0,
  0x3D, 0x0C, 0x20, 0x82, 0x08, 0x20, 0xF0, 0x3C, 0x4C, 0x9B, 0x34, 0x68,
  0x93, 0x6C, 0xF0, 0x3C, 0x82, 0x18, 0x79, 0x04, 0x30, 0xF0, 0x3C, 0x82,
  0x18, 0x79, 0x04, 0x30, 0xC0, 0x3D, 0x0C, 0x20, 0x9E, 0x28, 0xA2, 0xF8,
  0x22, 0x44, 0x8B, 0x37, 0xC8, 0x91, 0x62, 0xCC, 0x3C, 0x41, 0x04, 0x30,
  0x82, 0x08, 0xF0, 0x08, 0x42, 0x31, 0x08, 0x46, 0x31, 0x39, 0x80, 0x26,
  0x58, 0xA3, 0x87, 0x0A, 0x16, 0x64, 0xC8, 0x22, 0x26, 0x44, 0x4C, 0xF0,
  0x31, 0xCC, 0x63, 0x39, 0x4A, 0x57, 0x95, 0x45, 0x53, 0x64, 0x9B, 0x00,
  0x33, 0x32, 0x32, 0x52, 0x5A, 0x4E, 0x4C, 0xCC, 0x8C, 0x3D, 0x1C, 0x61,
  0x86, 0x38, 0xA6, 0xF0, 0x3C, 0x92, 0x59, 0x79, 0x04, 0x30, 0xC0, 0x3D,
  0x1C, 0x61, 0x86, 0x38, 0xA6, 0xF0, 0xC1, 0x00, 0x3C, 0x92, 0x5B, 0x79,
  0x45, 0xB2, 0xC8, 0x3D, 0x84, 0x18, 0x30, 0x61, 0xA6, 0xF0, 0xF9, 0x08,
  0xC4, 0x21, 0x08, 0xC0, 0x45, 0x1C, 0xF3, 0x8A, 0x28, 0xA6, 0xF0, 0x8E,
  0x28, 0xA4, 0xD3, 0xCE, 0x38, 0xC0, 0x88, 0xE2, 0x29, 0x92, 0x64, 0xAB,
  0x2A, 0x8A, 0xA3, 0x30, 0xCC, 0x00, 0x33, 0x16, 0x14, 0x18, 0x18, 0x38,
  0x28, 0x6C, 0xCC, 0xCF, 0x65, 0x18, 0x61, 0x04, 0x10, 0xC0, 0x7C, 0x21,
  0x84, 0x21, 0x84, 0x30, 0xF0, 0x39, 0x08, 0x84, 0x21, 0x18, 0x84, 0x30,
  0xC9, 0x24, 0x92, 0x20, 0x38, 0x46, 0x21, 0x08, 0x44, 0x21, 0x38, 0x10,
  0xA2, 0x92, 0xCC, 0xF0, 0x90, 0x3D, 0xB4, 0xD2, 0xCB, 0x66, 0x80, 0x20,
  0x82, 0x1E, 0x6D, 0x14, 0xD2, 0xCA, 0xC0, 0x3B, 0x10, 0x8C, 0x61, 0xC0,
  0x06, 0x08, 0x11, 0xE6, 0xC9, 0x92, 0x64, 0xD8, 0xD0, 0x3B, 0x52, 0xEC,
  0x61, 0xC0, 0x06, 0x10, 0x20, 0xE1, 0x82, 0x04, 0x08, 0x10, 0x60, 0x81,
  0x0E, 0x00, 0x3D, 0xB4, 0xD2, 0xCB, 0x66, 0x86, 0x13, 0xC0, 0x20, 0x82,
  0x1E, 0x6D, 0x34, 0x92, 0xCA, 0x60, 0x24, 0x34, 0x92, 0xD0, 0x08, 0x40,
  0x31, 0x88, 0x42, 0x31, 0x08, 0x4E, 0x00, 0x20, 0x82, 0x1B, 0x59, 0x47,
  0x14, 0xD2, 0x60, 0x24, 0xB6, 0x92, 0xD0, 0x7B, 0xB6, 0xD2, 0x69, 0x24,
  0x96, 0x4A, 0x6C, 0x7D, 0xB4, 0xD2, 0x4B, 0x29, 0x80, 0x39, 0xB4, 0xD3,
  0xCB, 0x67, 0x00, 0x3C, 0x6C, 0x89, 0x32, 0x4C, 0x96, 0x20, 0x41, 0x80,
  0x3D, 0xB4, 0xD2, 0xCB, 0x66, 0x86, 0x10, 0x40, 0x7B, 0x10, 0x84, 0x62,
  0x00, 0x7A, 0x10, 0x41, 0x0B, 0x80, 0x22, 0x76, 0x44, 0x4C, 0x60, 0x65,
  0x34, 0xD2, 0x4B, 0x66, 0x80, 0x9C, 0xAD, 0x4E, 0x63, 0x00, 0x93, 0xB2,
  0xB6, 0xB4, 0xD4, 0xD8, 0x98, 0x26, 0x78, 0x60, 0x83, 0x8D, 0x32, 0x00,
  0x26, 0x48, 0xB1, 0x42, 0x86, 0x0C, 0x10, 0x61, 0x80, 0x78, 0x8C, 0x44,
  0x63, 0xC0, 0x19, 0x88, 0x42, 0x61, 0x88, 0x42, 0x18, 0xFF, 0xF8, 0x30,
  0xC4, 0x21, 0x0C, 0xC4, 0x21, 0x30, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Condensed_MediumItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 4, 3, 5, 1, -9 },
  { 8, 7, 9, 7, 0, -9 },
  { 16, 6, 11, 6, 0, -10 },
  { 25, 8, 9, 9, 1, -9 },
  { 34, 7, 9, 7, 0, -9 },
  { 42, 2, 3, 3, 1, -9 },
  { 43, 4, 11, 4, 0, -9 },
  { 49, 4, 11, 4, -1, -9 },
  { 55, 5, 5, 6, 1, -10 },
  { 59, 5, 6, 6, 1, -8 },
  { 63, 3, 4, 3, -1, -2 },
  { 65, 3, 1, 4, 0, -4 },
  { 66, 2, 2, 3, 0, -2 },
  { 67, 7, 9, 5, -1, -9 },
  { 75, 6, 9, 6, 0, -9 },
  { 82, 4, 9, 6, 1, -9 },
  { 87, 6, 9, 6, 0, -9 },
  { 94, 6, 9, 6, 0, -9 },
  { 101, 6, 9, 6, 0, -9 },
  { 108, 6, 9, 6, 0, -9 },
  { 115, 6, 9, 6, 0, -9 },
  { 122, 5, 9, 6, 1, -9 },
  { 128, 6, 9, 6, 0, -9 },
  { 135, 6, 9, 6, 0, -9 },
  { 142, 3, 7, 3, 0, -7 },
  { 145, 4, 9, 3, -1, -7 },
  { 150, 5, 6, 6, 1, -8 },
  { 154, 5, 3, 6, 1, -6 },
  { 156, 5, 6, 6, 1, -8 },
  { 160, 5, 9, 4, 0, -9 },
  { 166, 9, 10, 9, 0, -9 },
  { 178, 6, 9, 6, -1, -9 },
  { 185, 6, 9, 6, 0, -9 },
  { 192, 6, 9, 6, 1, -9 },
  { 199, 7, 9, 7, 0, -9 },
  { 207, 6, 9, 5, 0, -9 },
  { 214, 6, 9, 5, 0, -9 },
  { 221, 6, 9, 7, 1, -9 },
  { 228, 7, 9, 7, 0, -9 },
  { 236, 6, 9, 4, -1, -9 },
  { 243, 5, 12, 3, -2, -9 },
  { 251, 7, 9, 6, 0, -9 },
  { 259, 4, 9, 5, 0, -9 },
  { 264, 10, 9, 9, 0, -9 },
  { 276, 8, 9, 8, 0, -9 },
  { 285, 6, 9, 7, 1, -9 },
  { 292, 6, 9, 6, 0, -9 },
  { 299, 6, 11, 7, 1, -9 },
  { 308, 6, 9, 6, 0, -9 },
  { 315, 6, 9, 6, 0, -9 },
  { 322, 5, 9, 5, 1, -9 },
  { 328, 6, 9, 7, 1, -9 },
  { 335, 6, 9, 6, 1, -9 },
  { 342, 10, 9, 9, 1, -9 },
  { 354, 8, 9, 6, -1, -9 },
  { 363, 6, 9, 5, 1, -9 },
  { 370, 6, 9, 5, 0, -9 },
  { 377, 5, 11, 4, 0, -9 },
  { 384, 3, 9, 5, 1, -9 },
  { 388, 5, 11, 4, -1, -9 },
  { 395, 6, 5, 6, 0, -9 },
  { 399, 4, 1, 4, -1, 1 },
  { 400, 2, 2, 4, 2, -10 },
  { 401, 6, 7, 6, 0, -7 },
  { 407, 6, 10, 6, 0, -10 },
  { 415, 5, 7, 5, 0, -7 },
  { 420, 7, 10, 6, 0, -10 },
  { 429, 5, 7, 6, 0, -7 },
  { 434, 7, 13, 4, -2, -10 },
  { 446, 6, 10, 6, 0, -7 },
  { 454, 6, 10, 6, 0, -10 },
  { 462, 3, 10, 3, 0, -10 },
  { 466, 5, 13, 3, -2, -10 },
  { 475, 6, 10, 5, 0, -10 },
  { 483, 3, 10, 3, 0, -10 },
  { 487, 9, 7, 9, 0, -7 },
  { 495, 6, 7, 6, 0, -7 },
  { 501, 6, 7, 6, 0, -7 },
  { 507, 7, 10, 6, -1, -7 },
  { 516, 6, 10, 6, 0, -7 },
  { 524, 5, 7, 4, 0, -7 },
  { 529, 5, 7, 5, 0, -7 },
  { 534, 4, 9, 4, 0, -9 },
  { 539, 6, 7, 6, 0, -7 },
  { 545, 5, 7, 5, 1, -7 },
  { 550, 8, 7, 8, 1, -7 },
  { 557, 7, 7, 5, -1, -7 },
  { 564, 7, 10, 5, -1, -7 },
  { 573, 5, 7, 4, 0, -7 },
  { 578, 5, 11, 4, 0, -9 },
  { 585, 1, 13, 6, 2, -10 },
  { 587, 5, 11, 4, -1, -9 },
  { 594, 5, 2, 6, 1, -6 },
};

const GFXfont NotoSans_Condensed_MediumItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC13PT7B_H_
