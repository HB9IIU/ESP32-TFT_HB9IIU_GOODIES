#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC34PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x07,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x07, 0xC3, 0xC0, 0xE0, 0x39, 0xEF, 0x39, 0xC7, 0x38, 0xE7, 0x1C, 0xE7,
  0x18, 0xE3, 0x1C, 0xE3, 0x00, 0x00, 0xE3, 0x80, 0x30, 0xC0, 0x0C, 0x70,
  0x07, 0x1C, 0x01, 0xC6, 0x00, 0x61, 0x80, 0x38, 0xE0, 0x7F, 0xFF, 0x3F,
  0xFF, 0x80, 0xC7, 0x00, 0x71, 0xC0, 0x18, 0x60, 0x06, 0x38, 0x03, 0x8E,
  0x07, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x07, 0x18, 0x01, 0x86, 0x00,
  0xE3, 0x80, 0x38, 0xC0, 0x0C, 0x30, 0x03, 0x1C, 0x01, 0xC7, 0x00, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC3, 0x91,
  0x0F, 0x20, 0x1C, 0xC0, 0x39, 0x80, 0x7B, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0x78, 0x06, 0x70, 0x0C, 0xE0, 0x19,
  0xC4, 0x37, 0x8E, 0x7E, 0x3F, 0xF8, 0x3F, 0xE0, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x06, 0x00, 0x21, 0xF0, 0x1C, 0x3F, 0x81, 0xC3,
  0x18, 0x38, 0x71, 0x83, 0x07, 0x18, 0x70, 0x61, 0x8E, 0x0E, 0x38, 0xE0,
  0xE3, 0x9C, 0x0E, 0x39, 0x80, 0xC3, 0x39, 0xEC, 0x73, 0x3F, 0xE6, 0x77,
  0x7F, 0xEE, 0x63, 0x7C, 0xCE, 0x31, 0x1C, 0xC3, 0x01, 0x9C, 0x30, 0x39,
  0xC7, 0x07, 0x1C, 0x70, 0x61, 0xC6, 0x0E, 0x18, 0x60, 0xC1, 0xCE, 0x1C,
  0x1D, 0xC3, 0x81, 0xFC, 0x38, 0x0F, 0x80, 0x00, 0x30, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0xF3, 0xC0, 0x70, 0xE0, 0x38, 0xF0, 0x1C, 0x70, 0x0E, 0x38,
  0x07, 0x38, 0x03, 0xBC, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xFE,
  0x1C, 0xF7, 0x8E, 0x71, 0xCE, 0x70, 0xE7, 0x38, 0x7F, 0x3C, 0x1F, 0x9E,
  0x0F, 0x8F, 0x03, 0x87, 0x87, 0xE1, 0xFF, 0xF0, 0xFF, 0xBC, 0x3F, 0x8F,
  0x00, 0x39, 0xDE, 0xE7, 0x39, 0x8C, 0xE0, 0x01, 0xE0, 0x70, 0x0E, 0x03,
  0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0x70,
  0x1C, 0x0F, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0xC6, 0x07, 0x30, 0x7F,
  0xFC, 0x7F, 0xE1, 0xEF, 0x1F, 0x81, 0xDC, 0x1E, 0x70, 0x63, 0x81, 0x18,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x3F, 0xFF, 0xFF, 0xFC, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x1E, 0x3C, 0x71, 0xE3, 0x87, 0x1C, 0x78,
  0xFF, 0xFF, 0xFE, 0x73, 0xFE, 0xE0, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x40, 0x0F,
  0xC0, 0x7F, 0x83, 0xCF, 0x0E, 0x1C, 0x70, 0x73, 0xC1, 0xCE, 0x07, 0x38,
  0x1D, 0xE0, 0x77, 0x03, 0xDC, 0x0F, 0x70, 0x3F, 0xC0, 0xEF, 0x03, 0xBC,
  0x1E, 0xE0, 0x7B, 0x81, 0xCE, 0x07, 0x38, 0x38, 0xE0, 0xE3, 0xC7, 0x07,
  0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x03, 0xC3, 0xE1, 0xF8, 0xFE, 0x7F, 0xBD,
  0xC4, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0,
  0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x00,
  0x70, 0x01, 0xFC, 0x07, 0xFE, 0x07, 0x9F, 0x06, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF8, 0x00, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x79, 0xF0, 0x41, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x3F, 0x80,
  0x7C, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x10, 0x1E, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1B, 0x80,
  0x77, 0x01, 0xDE, 0x07, 0x38, 0x0E, 0x70, 0x38, 0xE0, 0xE3, 0xC1, 0x87,
  0x07, 0x0E, 0x1C, 0x1C, 0x30, 0x38, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x07, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC8, 0x0F,
  0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x1C, 0x01, 0xFC, 0x0F, 0xF0,
  0x3E, 0x20, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xEF, 0x83, 0xBF, 0x87, 0xEF, 0x8F, 0x0F, 0x3C, 0x0E, 0x78, 0x1C,
  0xF0, 0x39, 0xC0, 0xF3, 0x81, 0xE7, 0x03, 0x8F, 0x0F, 0x1E, 0x1C, 0x1F,
  0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x1F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x07, 0xF8, 0x1F, 0xF8, 0x78,
  0xF0, 0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x1E, 0x1E, 0x78,
  0x1D, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xFE, 0x0F, 0xBC, 0x1C, 0x3C, 0x70,
  0x38, 0xE0, 0x73, 0xC0, 0xE7, 0x81, 0xCF, 0x03, 0x9E, 0x0F, 0x1F, 0x7C,
  0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x60, 0x07, 0xF0, 0x1F, 0xF0, 0x79, 0xE0,
  0xE1, 0xE3, 0xC1, 0xC7, 0x03, 0x9E, 0x07, 0x3C, 0x1E, 0x70, 0x3C, 0xE0,
  0x79, 0xE1, 0xE3, 0xC3, 0xC3, 0xFF, 0x87, 0xF7, 0x07, 0xDE, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x3F, 0xF0, 0x7F,
  0xC0, 0xFE, 0x00, 0x04, 0x1C, 0x78, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0xF1, 0xE3, 0xC0, 0x01, 0x00, 0xE0, 0x7C,
  0x1E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07,
  0xC0, 0x3C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x03,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x03, 0xC0, 0x0C, 0x00,
  0x20, 0x00, 0x03, 0x01, 0xFE, 0x3F, 0xE3, 0x8F, 0x20, 0x70, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x3C, 0x07,
  0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x30, 0x00, 0x61, 0xC1, 0xE1, 0x8E,
  0x1F, 0xE7, 0x38, 0xE3, 0x1C, 0xC7, 0x1C, 0x77, 0x1C, 0x71, 0x98, 0xE1,
  0x86, 0x63, 0x86, 0x1B, 0x8C, 0x38, 0xEE, 0x30, 0xE3, 0xB8, 0xC3, 0x0C,
  0xE3, 0x1C, 0x73, 0x8C, 0xF3, 0x8E, 0x3F, 0xFC, 0x38, 0x79, 0xE0, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x80, 0x3E, 0x3C,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xEE, 0x00, 0xEE, 0x01, 0xCE, 0x01,
  0xCE, 0x03, 0xCE, 0x03, 0x8E, 0x03, 0x8E, 0x07, 0x0E, 0x07, 0x0F, 0x0F,
  0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x78,
  0x0F, 0x78, 0x07, 0x70, 0x07, 0xF0, 0x07, 0x07, 0xFC, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x38, 0x1E, 0x1C, 0x0E,
  0x0E, 0x0F, 0x0F, 0x0F, 0x07, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xE0,
  0xE0, 0xF0, 0x78, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x0F, 0x1E, 0x07, 0x8F,
  0x07, 0x87, 0x07, 0xC3, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x30,
  0x01, 0xFF, 0x07, 0xFE, 0x0F, 0xCE, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x20, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1C, 0x3E, 0x0F, 0x07, 0x83,
  0xC0, 0xE0, 0xE0, 0x3C, 0x38, 0x0F, 0x0E, 0x03, 0xC7, 0x80, 0xF1, 0xE0,
  0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1C,
  0x38, 0x0F, 0x0E, 0x03, 0x87, 0x81, 0xE1, 0xE0, 0xF0, 0x70, 0xF8, 0x1F,
  0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xC1, 0xFF,
  0xE1, 0xFD, 0xE1, 0xF0, 0x10, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x07, 0xF7, 0x03, 0xF3,
  0x83, 0xF9, 0xC0, 0x1C, 0xE0, 0x1E, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03,
  0x8F, 0x03, 0xC7, 0xC1, 0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x00,
  0x07, 0x80, 0xE0, 0xF0, 0x1C, 0x1C, 0x07, 0x83, 0x80, 0xF0, 0xF0, 0x1C,
  0x1E, 0x03, 0x83, 0x80, 0x70, 0x70, 0x1E, 0x0E, 0x03, 0xC3, 0xC0, 0x70,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x38, 0x0F, 0x0F, 0x01, 0xC1,
  0xE0, 0x38, 0x38, 0x07, 0x07, 0x01, 0xE0, 0xE0, 0x38, 0x3C, 0x07, 0x07,
  0x00, 0xE0, 0xE0, 0x3C, 0x1C, 0x07, 0x87, 0x80, 0xE0, 0x07, 0xF8, 0x7F,
  0xC0, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x03, 0xFE, 0x1F, 0xE0,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x27,
  0xC0, 0xFE, 0x03, 0xF0, 0x07, 0x00, 0x00, 0x07, 0x83, 0xE0, 0xE0, 0x78,
  0x1C, 0x1E, 0x03, 0x87, 0x80, 0xF1, 0xE0, 0x1E, 0x38, 0x03, 0x8F, 0x00,
  0x73, 0xC0, 0x0E, 0xF0, 0x03, 0xDC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3D, 0xC0, 0x0F, 0x38, 0x01, 0xC7, 0x80, 0x38, 0xF0, 0x07,
  0x0E, 0x00, 0xE1, 0xC0, 0x3C, 0x3C, 0x07, 0x07, 0x80, 0xE0, 0x70, 0x1C,
  0x0F, 0x07, 0x81, 0xE0, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xFF, 0xDF, 0xFF,
  0xFF, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xC0, 0xF8,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xB8, 0x3B, 0x01, 0xFC, 0x1D,
  0x80, 0xFC, 0x0E, 0xE0, 0xEE, 0x0F, 0x70, 0x77, 0x07, 0x38, 0x73, 0x83,
  0x9C, 0x3B, 0xC1, 0xCE, 0x39, 0xC0, 0xE7, 0x1C, 0xE0, 0xE3, 0x9C, 0x70,
  0x71, 0xCE, 0x78, 0x38, 0xEE, 0x3C, 0x1C, 0x77, 0x1C, 0x1E, 0x3F, 0x0E,
  0x0E, 0x1F, 0x87, 0x07, 0x0F, 0x87, 0x83, 0x87, 0xC3, 0x81, 0xC3, 0xC1,
  0xC1, 0xE0, 0xE0, 0xE0, 0x07, 0x80, 0x78, 0x3E, 0x03, 0x81, 0xF0, 0x1C,
  0x0F, 0x80, 0xE0, 0xFC, 0x0F, 0x07, 0x70, 0x70, 0x3B, 0x83, 0x81, 0xDC,
  0x1C, 0x0E, 0xE0, 0xE0, 0xF7, 0x0E, 0x07, 0x1C, 0x70, 0x38, 0xE3, 0x81,
  0xC7, 0x1C, 0x0E, 0x39, 0xE0, 0xE0, 0xEE, 0x07, 0x07, 0x70, 0x38, 0x3B,
  0x81, 0xC1, 0xDC, 0x1E, 0x0F, 0xE0, 0xE0, 0x3E, 0x07, 0x01, 0xF0, 0x38,
  0x0F, 0x81, 0xC0, 0x7C, 0x1E, 0x01, 0xE0, 0x00, 0x60, 0x01, 0xFE, 0x01,
  0xFF, 0x81, 0xF3, 0xE1, 0xE0, 0x70, 0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x0F,
  0x78, 0x07, 0xB8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x3B, 0x80, 0x1D, 0xC0, 0x1E, 0xE0, 0x0F, 0x70, 0x07, 0x38, 0x07, 0x9C,
  0x07, 0x8F, 0x03, 0xC7, 0x83, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xC0,
  0x00, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0x0F, 0x0F, 0x07, 0x0F,
  0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x1E, 0x0F, 0x1E, 0x1E, 0x1C,
  0x3E, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xC0, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0x00, 0x60, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xF3, 0xE1, 0xE0, 0x70,
  0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x0F, 0x78, 0x07, 0xB8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1E, 0xE0,
  0x0F, 0x70, 0x07, 0x38, 0x07, 0x9C, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xC1,
  0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x07,
  0xFF, 0x07, 0x0F, 0x0F, 0x07, 0x0F, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E,
  0x0F, 0x1E, 0x0E, 0x1E, 0x1E, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0x3C,
  0xE0, 0x38, 0xF0, 0x38, 0x70, 0x38, 0x70, 0x38, 0x70, 0x78, 0x78, 0x70,
  0x78, 0x70, 0x38, 0x70, 0x3C, 0xF0, 0x3C, 0x00, 0x60, 0x03, 0xFF, 0x07,
  0xFE, 0x0F, 0xFE, 0x1F, 0x04, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x81, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0x1E, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xE7, 0x80, 0xE3, 0xC0, 0x71, 0xC0,
  0x38, 0xE0, 0x3C, 0x70, 0x1E, 0x78, 0x0E, 0x3C, 0x07, 0x1C, 0x03, 0x8E,
  0x03, 0xC7, 0x01, 0xE7, 0x80, 0xE3, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x3C,
  0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x0F, 0x0F, 0x0F, 0x07, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0x00, 0xE0, 0x0F, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0,
  0x3C, 0xE0, 0x38, 0xE0, 0x78, 0xE0, 0x70, 0xF0, 0xF0, 0xF0, 0xE0, 0xF1,
  0xE0, 0xF1, 0xC0, 0xF1, 0xC0, 0xF3, 0x80, 0x73, 0x80, 0x77, 0x80, 0x77,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xE0, 0x3C, 0x07, 0xF0, 0x1E, 0x07, 0xB8, 0x0F, 0x03,
  0x9C, 0x0F, 0x81, 0xCE, 0x07, 0xC1, 0xE7, 0x07, 0xE0, 0xE3, 0x83, 0xF0,
  0xF1, 0xC1, 0xB8, 0x70, 0xE1, 0xDC, 0x38, 0x70, 0xEE, 0x3C, 0x38, 0xE7,
  0x1C, 0x1C, 0x73, 0x9E, 0x0E, 0x31, 0xCE, 0x07, 0x38, 0xE7, 0x03, 0x9C,
  0x77, 0x01, 0xDC, 0x3B, 0x80, 0xEE, 0x1F, 0xC0, 0x76, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03,
  0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x0F,
  0x0F, 0x01, 0xE1, 0xC0, 0x1C, 0x70, 0x03, 0x9E, 0x00, 0x73, 0x80, 0x0F,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x3D, 0xC0, 0x07, 0x38, 0x01, 0xE7,
  0x00, 0x38, 0xF0, 0x0E, 0x1E, 0x03, 0xC1, 0xC0, 0x70, 0x38, 0x1E, 0x07,
  0x07, 0x80, 0xF0, 0xE0, 0x3F, 0xC0, 0xEF, 0x07, 0x9C, 0x1C, 0x70, 0xF1,
  0xC3, 0x87, 0x1C, 0x1C, 0xF0, 0x73, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0x83,
  0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0x03, 0xF8, 0x1F, 0xC0, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xFC, 0x0F, 0xE0, 0x00,
  0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x83, 0x07, 0x03, 0xF8, 0x1F,
  0x81, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x81, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0xE6, 0x01, 0xCE, 0x07, 0x1C,
  0x0C, 0x18, 0x38, 0x38, 0xE0, 0x71, 0xC0, 0x67, 0x00, 0xFE, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF3, 0x9C, 0x73, 0x80, 0x01, 0x80, 0x0F, 0x9C, 0x3F,
  0xB8, 0xF3, 0xE3, 0xC3, 0xC7, 0x07, 0x9E, 0x0F, 0x38, 0x1E, 0x70, 0x39,
  0xE0, 0x73, 0xC0, 0xE7, 0x83, 0xCE, 0x07, 0x9C, 0x0E, 0x38, 0x3C, 0x78,
  0xF8, 0xFF, 0xF0, 0xFE, 0xE0, 0xF9, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x18, 0x0E, 0xFC,
  0x1F, 0xFC, 0x7E, 0x78, 0xF8, 0x71, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x9E,
  0x07, 0x38, 0x1E, 0x70, 0x3C, 0xE0, 0x71, 0xC0, 0xE7, 0x83, 0xCF, 0x07,
  0x1E, 0x1E, 0x3F, 0xF8, 0xEF, 0xE1, 0xCF, 0x80, 0x01, 0xC0, 0x7F, 0x0F,
  0xF1, 0xE2, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x04, 0x7F, 0x87, 0xF8, 0x3F,
  0x80, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x07, 0x1C, 0x07, 0xCE, 0x07, 0xFF, 0x07, 0x9F,
  0x07, 0x87, 0x83, 0x83, 0xC3, 0xC1, 0xE1, 0xC0, 0xF0, 0xE0, 0x70, 0xF0,
  0x38, 0x78, 0x1C, 0x3C, 0x1E, 0x1C, 0x0F, 0x0E, 0x07, 0x07, 0x07, 0x83,
  0xC7, 0xC1, 0xF7, 0xE0, 0x7F, 0x60, 0x1F, 0x30, 0x00, 0x01, 0xC0, 0x3F,
  0x83, 0xFE, 0x3C, 0x73, 0xC3, 0x9C, 0x1D, 0xE1, 0xEE, 0x1E, 0x7F, 0xE7,
  0xFE, 0x3F, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x04, 0x78,
  0xC3, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xF7, 0x07, 0xF7, 0x0F,
  0x3E, 0x1E, 0x1E, 0x1C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x78,
  0x1C, 0x78, 0x1C, 0x78, 0x3C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0x78, 0x78,
  0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xE0, 0x81, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x18, 0x0E, 0xFC, 0x1F, 0xFC, 0x7E, 0x78, 0xF8, 0x71, 0xE0, 0xE3,
  0x83, 0xC7, 0x07, 0x9E, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0xF1, 0xC1,
  0xC7, 0x83, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x70, 0x71, 0xE0, 0xE0,
  0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x0F, 0x07,
  0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03,
  0x81, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0E, 0x01, 0x0E, 0x1E, 0x0E, 0x1C, 0x1E, 0x38, 0x1C, 0x78, 0x1C,
  0xF0, 0x1D, 0xE0, 0x1D, 0xC0, 0x3B, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3D,
  0xC0, 0x39, 0xE0, 0x79, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xF0, 0x70,
  0xF0, 0xF0, 0x70, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1C,
  0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E,
  0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x00, 0x00, 0x30, 0x38,
  0x1D, 0xF9, 0xF8, 0x37, 0xF7, 0xF8, 0xFC, 0xFC, 0xF1, 0xE1, 0xF1, 0xE3,
  0xC3, 0xC3, 0xC7, 0x07, 0x87, 0x8E, 0x0E, 0x0E, 0x3C, 0x1C, 0x1C, 0x70,
  0x38, 0x38, 0xE0, 0xF0, 0x71, 0xC1, 0xC1, 0xE3, 0x83, 0x83, 0x8F, 0x07,
  0x07, 0x1C, 0x1E, 0x0E, 0x38, 0x3C, 0x3C, 0x70, 0x70, 0x78, 0xE0, 0xE0,
  0xE3, 0xC1, 0xC1, 0xC0, 0x00, 0x30, 0x1D, 0xF8, 0x37, 0xF8, 0xFC, 0xF1,
  0xF0, 0xE3, 0xC1, 0xC7, 0x07, 0x8E, 0x0F, 0x3C, 0x1C, 0x70, 0x38, 0xE0,
  0x71, 0xC1, 0xE3, 0x83, 0x8F, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x70, 0x79,
  0xE0, 0xE3, 0xC1, 0xC0, 0x01, 0xC0, 0x1F, 0xC0, 0xFF, 0x87, 0x9E, 0x3C,
  0x3C, 0xE0, 0xF7, 0x83, 0xDC, 0x0F, 0x70, 0x3F, 0xC0, 0xEF, 0x03, 0xB8,
  0x0E, 0xE0, 0x7B, 0x81, 0xCE, 0x0F, 0x3C, 0x38, 0x7F, 0xE1, 0xFF, 0x03,
  0xF8, 0x00, 0x00, 0x18, 0x07, 0x7E, 0x07, 0xFF, 0x0F, 0xCF, 0x0F, 0x87,
  0x0F, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x0F,
  0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1C, 0x3C, 0x3C, 0x3F, 0xF8,
  0x3F, 0xF0, 0x7B, 0xE0, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x0F, 0xDC,
  0x3F, 0xB8, 0xF3, 0xE3, 0xC3, 0xC7, 0x07, 0x9E, 0x0F, 0x38, 0x1E, 0x70,
  0x39, 0xE0, 0x73, 0xC0, 0xE7, 0x83, 0xCE, 0x07, 0x9C, 0x0E, 0x38, 0x3C,
  0x78, 0xF8, 0xFB, 0x70, 0xFF, 0xC0, 0xFB, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x30, 0xEF, 0x0D, 0xF1, 0xDF, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0xFF, 0x1F, 0xF3, 0xC3, 0x38, 0x03,
  0x80, 0x3C, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x1C, 0x01, 0xC8, 0x3C, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0x06, 0x03, 0x80,
  0xE0, 0x70, 0x7F, 0xDF, 0xE1, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0xF8, 0xFE, 0x1F,
  0x80, 0x1C, 0x1E, 0x38, 0x38, 0xF0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x07,
  0x8E, 0x0E, 0x3C, 0x1C, 0x70, 0x38, 0xE0, 0xF1, 0xC1, 0xE7, 0x83, 0x8F,
  0x0F, 0x1C, 0x1E, 0x3C, 0x7C, 0x7F, 0xB0, 0x7F, 0xE0, 0xFD, 0xC0, 0xE0,
  0x7F, 0x03, 0xB8, 0x3D, 0xC1, 0xCE, 0x0E, 0x70, 0xE3, 0x87, 0x1C, 0x70,
  0xE3, 0x87, 0x38, 0x39, 0xC1, 0xDE, 0x06, 0xE0, 0x37, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x00, 0xE0, 0xF0, 0x7F, 0x07, 0x83, 0xB8, 0x7C,
  0x39, 0xC3, 0xE1, 0xCE, 0x3F, 0x1E, 0x71, 0xF8, 0xE3, 0x8D, 0xC7, 0x1C,
  0xEE, 0x70, 0xE7, 0x73, 0x87, 0x73, 0xB8, 0x3B, 0x9D, 0xC1, 0xD8, 0xEE,
  0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF0,
  0x7C, 0x07, 0x83, 0xC0, 0x00, 0x07, 0x07, 0x83, 0x87, 0x81, 0xE3, 0x80,
  0x73, 0x80, 0x3B, 0xC0, 0x1D, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xF7, 0x00, 0x73, 0x80, 0x71,
  0xC0, 0x78, 0xF0, 0x78, 0x38, 0x78, 0x1C, 0x00, 0x07, 0x03, 0xC1, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x07, 0x07, 0x01, 0xC3, 0x80, 0x70, 0xE0,
  0x0E, 0x78, 0x03, 0x9C, 0x00, 0xEF, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x1E,
  0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x7E, 0x03,
  0x80, 0x1F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0x7C, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0x00, 0x7E, 0x07, 0xFE, 0x7C, 0xFF, 0xE0, 0xFE,
};

const GFXglyph NotoSans_Condensed_MediumItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 24, 8, 0, -24 },
  { 28, 11, 9, 13, 3, -24 },
  { 41, 18, 24, 17, 0, -24 },
  { 95, 15, 28, 15, 0, -26 },
  { 148, 20, 25, 23, 2, -25 },
  { 211, 17, 25, 18, 0, -25 },
  { 265, 5, 9, 7, 3, -24 },
  { 271, 11, 29, 9, 1, -24 },
  { 311, 11, 29, 9, -3, -24 },
  { 351, 13, 13, 15, 3, -26 },
  { 373, 14, 16, 16, 2, -20 },
  { 401, 7, 8, 8, -2, -4 },
  { 408, 8, 3, 10, 1, -11 },
  { 411, 5, 4, 8, 0, -4 },
  { 414, 17, 24, 12, -2, -24 },
  { 465, 14, 25, 15, 1, -25 },
  { 509, 10, 24, 15, 4, -24 },
  { 539, 16, 25, 15, -1, -25 },
  { 589, 15, 25, 15, 0, -25 },
  { 636, 15, 24, 15, 0, -24 },
  { 681, 15, 24, 15, 0, -24 },
  { 726, 15, 25, 15, 1, -25 },
  { 773, 16, 24, 15, 1, -24 },
  { 821, 15, 25, 15, 0, -25 },
  { 868, 15, 25, 15, 0, -25 },
  { 915, 7, 19, 8, 0, -19 },
  { 932, 10, 23, 8, -2, -19 },
  { 961, 14, 16, 16, 2, -20 },
  { 989, 13, 10, 16, 2, -17 },
  { 1006, 14, 16, 16, 2, -20 },
  { 1034, 12, 25, 12, 1, -25 },
  { 1072, 22, 27, 23, 1, -24 },
  { 1147, 16, 24, 16, -2, -24 },
  { 1195, 17, 24, 17, 0, -24 },
  { 1246, 16, 25, 16, 2, -25 },
  { 1296, 18, 24, 18, 0, -24 },
  { 1350, 16, 24, 14, 0, -24 },
  { 1398, 16, 24, 14, 0, -24 },
  { 1446, 17, 25, 19, 2, -25 },
  { 1500, 19, 24, 19, 0, -24 },
  { 1557, 13, 24, 10, -1, -24 },
  { 1596, 14, 31, 8, -5, -24 },
  { 1651, 19, 24, 16, 0, -24 },
  { 1708, 11, 24, 13, 0, -24 },
  { 1741, 25, 24, 24, 0, -24 },
  { 1816, 21, 24, 20, 0, -24 },
  { 1879, 17, 25, 20, 2, -25 },
  { 1933, 16, 24, 16, 0, -24 },
  { 1981, 17, 31, 20, 2, -25 },
  { 2047, 16, 24, 16, 0, -24 },
  { 2095, 16, 25, 14, 0, -25 },
  { 2145, 13, 24, 14, 3, -24 },
  { 2184, 17, 24, 19, 2, -24 },
  { 2235, 16, 24, 16, 3, -24 },
  { 2283, 25, 24, 25, 3, -24 },
  { 2358, 19, 24, 15, -2, -24 },
  { 2415, 14, 24, 14, 3, -24 },
  { 2457, 17, 24, 14, -1, -24 },
  { 2508, 13, 29, 10, -1, -24 },
  { 2556, 7, 24, 12, 3, -24 },
  { 2577, 13, 29, 10, -2, -24 },
  { 2625, 15, 14, 16, 0, -24 },
  { 2652, 12, 2, 11, -3, 3 },
  { 2655, 5, 5, 9, 5, -26 },
  { 2659, 15, 19, 16, 1, -19 },
  { 2695, 15, 26, 16, 0, -26 },
  { 2744, 12, 19, 13, 1, -19 },
  { 2773, 17, 26, 16, 1, -26 },
  { 2829, 13, 19, 15, 1, -19 },
  { 2860, 17, 34, 9, -4, -26 },
  { 2933, 16, 27, 16, 0, -19 },
  { 2987, 15, 26, 16, 0, -26 },
  { 3036, 9, 25, 8, 0, -25 },
  { 3065, 13, 33, 8, -4, -25 },
  { 3119, 16, 26, 14, 0, -26 },
  { 3171, 9, 26, 8, 0, -26 },
  { 3201, 23, 19, 24, 0, -19 },
  { 3256, 15, 19, 16, 0, -19 },
  { 3292, 14, 19, 16, 1, -19 },
  { 3326, 16, 27, 16, -1, -19 },
  { 3380, 15, 27, 16, 1, -19 },
  { 3431, 12, 19, 11, 0, -19 },
  { 3460, 12, 19, 12, 0, -19 },
  { 3489, 10, 22, 10, 1, -22 },
  { 3517, 15, 18, 16, 1, -18 },
  { 3551, 13, 18, 13, 2, -18 },
  { 3581, 21, 18, 21, 2, -18 },
  { 3629, 17, 18, 14, -2, -18 },
  { 3668, 18, 26, 13, -3, -18 },
  { 3727, 13, 18, 12, -1, -18 },
  { 3757, 13, 29, 11, 1, -24 },
  { 3805, 3, 34, 14, 6, -26 },
  { 3818, 13, 29, 11, -2, -24 },
  { 3866, 14, 4, 16, 2, -14 },
};

const GFXfont NotoSans_Condensed_MediumItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC34PT7B_H_
