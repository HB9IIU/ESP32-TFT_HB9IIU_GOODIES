#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC16PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x26, 0x64, 0x0C, 0xC0, 0xDC, 0xAD, 0x40, 0x0B, 0x1A,
  0x12, 0x7F, 0x14, 0x24, 0xFE, 0xFE, 0x48, 0x48, 0x58, 0x04, 0x3C, 0xF9,
  0x42, 0x86, 0x07, 0x0E, 0x15, 0x3B, 0xE1, 0x02, 0x00, 0x20, 0x9C, 0x4D,
  0x32, 0x48, 0x94, 0x25, 0x6E, 0xA9, 0x7B, 0x14, 0x89, 0x22, 0x59, 0x1C,
  0x0C, 0x1E, 0x36, 0x36, 0x3C, 0x18, 0x39, 0x4B, 0xCE, 0xCE, 0xCE, 0x76,
  0xEA, 0x1C, 0x43, 0x08, 0x61, 0x04, 0x30, 0xC3, 0x0C, 0x10, 0x41, 0x80,
  0x10, 0x86, 0x31, 0x8C, 0x63, 0x10, 0x8C, 0x46, 0x22, 0x00, 0x19, 0x4F,
  0xCC, 0x69, 0x20, 0x30, 0xC3, 0x3F, 0x30, 0xC3, 0x00, 0x2D, 0x60, 0xF0,
  0xF0, 0x03, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0,
  0x0C, 0x3C, 0xD9, 0x16, 0x6C, 0xD1, 0xA3, 0xC5, 0x99, 0x23, 0x80, 0x37,
  0xB3, 0x22, 0x66, 0x44, 0xC0, 0x08, 0x7C, 0x98, 0x30, 0x60, 0x83, 0x0C,
  0x30, 0xC3, 0x07, 0xE0, 0x08, 0x7C, 0x98, 0x30, 0x67, 0x8E, 0x06, 0x04,
  0x1A, 0x77, 0xC0, 0x06, 0x1C, 0x78, 0xA2, 0x4D, 0x93, 0x7F, 0xFC, 0x10,
  0x60, 0x3E, 0x60, 0x81, 0x07, 0xC9, 0x81, 0x02, 0x0D, 0x3B, 0xE0, 0x0C,
  0xF6, 0x10, 0xC3, 0xEC, 0xE3, 0x8A, 0x29, 0xBC, 0x7E, 0x08, 0x30, 0x41,
  0x82, 0x0C, 0x30, 0x61, 0x83, 0x00, 0x0C, 0x7C, 0x89, 0x12, 0x67, 0x8E,
  0x36, 0xC5, 0x8B, 0x33, 0xC0, 0x08, 0x7C, 0x9B, 0x36, 0x6C, 0xDB, 0x9A,
  0x04, 0x18, 0x67, 0x80, 0x27, 0x00, 0x00, 0x0C, 0xC0, 0x10, 0xC0, 0x00,
  0x00, 0x04, 0x62, 0x30, 0x0C, 0xEE, 0x30, 0x70, 0x70, 0x40, 0xFC, 0x00,
  0x3F, 0xFC, 0xC1, 0xC1, 0xC3, 0x3B, 0x88, 0x00, 0x37, 0xC2, 0x31, 0x19,
  0x88, 0xC0, 0x31, 0x00, 0x1F, 0x88, 0x24, 0x0D, 0x39, 0x92, 0xED, 0xAA,
  0x4A, 0x92, 0xBF, 0x20, 0x08, 0x01, 0xF0, 0x06, 0x0E, 0x0A, 0x1A, 0x12,
  0x12, 0x3E, 0x3E, 0x62, 0x43, 0xC3, 0x3E, 0x33, 0x33, 0x23, 0x3E, 0x7C,
  0x66, 0x46, 0x46, 0xCC, 0xF8, 0x0C, 0x7D, 0x83, 0x0C, 0x18, 0x30, 0x40,
  0x81, 0x83, 0x23, 0xC0, 0x3E, 0x33, 0x31, 0x21, 0x21, 0x63, 0x63, 0x42,
  0x46, 0xDC, 0xF8, 0x3E, 0x60, 0xC1, 0x03, 0xCF, 0x98, 0x20, 0x41, 0x83,
  0xE0, 0x3E, 0x60, 0xC1, 0x02, 0x0F, 0x98, 0x20, 0x41, 0x83, 0x00, 0x0C,
  0x3F, 0x70, 0x60, 0xC0, 0xC0, 0xCE, 0x86, 0x86, 0xC6, 0xC4, 0x7C, 0x31,
  0x98, 0xCC, 0x64, 0x23, 0xF3, 0xF9, 0x8C, 0x84, 0x42, 0x63, 0x31, 0x80,
  0x1E, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x43, 0xE0, 0x0C, 0x30,
  0xC2, 0x08, 0x61, 0x86, 0x10, 0x43, 0x0C, 0x63, 0x80, 0x33, 0x99, 0x0D,
  0x85, 0x83, 0x83, 0xC1, 0xA0, 0x98, 0x4C, 0x66, 0x31, 0x80, 0x31, 0x8C,
  0x42, 0x31, 0x88, 0x46, 0x3E, 0x38, 0x73, 0x86, 0x28, 0xE2, 0x8E, 0x29,
  0xE6, 0x96, 0x6B, 0x44, 0xA4, 0x4E, 0xCC, 0xCC, 0xCC, 0x80, 0x38, 0xCE,
  0x22, 0x88, 0xA6, 0x29, 0x9B, 0x46, 0xD1, 0x14, 0x47, 0x31, 0xCC, 0x60,
  0x0C, 0x3E, 0x63, 0x63, 0xC3, 0xC3, 0xC3, 0x82, 0x86, 0x86, 0xCC, 0x78,
  0x3E, 0x33, 0x33, 0x23, 0x26, 0x7E, 0x78, 0x40, 0x40, 0xC0, 0xC0, 0x0C,
  0x3E, 0x63, 0x63, 0xC3, 0xC3, 0xC3, 0x82, 0x86, 0x86, 0xCC, 0x78, 0x18,
  0x18, 0x0C, 0x3E, 0x33, 0x33, 0x23, 0x26, 0x7C, 0x68, 0x4C, 0x4C, 0xCC,
  0xC6, 0x0C, 0x7C, 0x83, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x1A, 0x67, 0xC0,
  0xFE, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x60, 0x83, 0x00, 0x63, 0x63,
  0x42, 0x42, 0xC6, 0xC6, 0xC6, 0x84, 0x8C, 0xCC, 0x78, 0xC3, 0xC6, 0x44,
  0x4C, 0x4C, 0x48, 0x58, 0x50, 0x70, 0x60, 0x60, 0xC6, 0x3C, 0x62, 0xCE,
  0x6C, 0xA4, 0xDA, 0xCD, 0x2C, 0xD2, 0x8F, 0x38, 0xE3, 0x0E, 0x30, 0xC6,
  0x00, 0x19, 0x8D, 0x86, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x68, 0x24, 0x33,
  0x31, 0x80, 0xC6, 0x99, 0x22, 0xC7, 0x0E, 0x18, 0x30, 0x60, 0x81, 0x00,
  0x1F, 0x03, 0x06, 0x04, 0x0C, 0x18, 0x18, 0x30, 0x20, 0x60, 0xFC, 0x3C,
  0xC2, 0x08, 0x21, 0x86, 0x10, 0x43, 0x0C, 0x20, 0xE3, 0x80, 0x92, 0x6D,
  0x92, 0x49, 0x80, 0x1C, 0x30, 0x82, 0x08, 0x61, 0x84, 0x10, 0x43, 0x08,
  0xE3, 0x80, 0x08, 0x38, 0xD1, 0x26, 0x78, 0x40, 0xF8, 0xCC, 0x1B, 0x3E,
  0x66, 0x66, 0x46, 0x44, 0xCC, 0x4C, 0x7C, 0x10, 0x60, 0xC1, 0x63, 0xEC,
  0x58, 0xB3, 0x46, 0x8B, 0xB5, 0xC0, 0x1C, 0xF6, 0x18, 0x41, 0x0C, 0x12,
  0x78, 0x01, 0x03, 0x03, 0x1B, 0x3E, 0x66, 0x66, 0x46, 0x44, 0xC4, 0x4C,
  0x7C, 0x1C, 0x69, 0x9A, 0x27, 0x88, 0x30, 0x22, 0x78, 0x07, 0x04, 0x0C,
  0x0E, 0x1E, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x20, 0xE0,
  0xC0, 0x1B, 0x3E, 0x66, 0x66, 0x46, 0x44, 0xCC, 0x4C, 0x7C, 0x0C, 0x08,
  0xB8, 0xF0, 0x10, 0x60, 0xC1, 0x63, 0xEC, 0xD9, 0xB3, 0x44, 0x8B, 0x36,
  0x60, 0x13, 0x02, 0x26, 0x66, 0x44, 0xCC, 0x04, 0x30, 0x02, 0x08, 0x61,
  0x86, 0x10, 0x43, 0x0C, 0x30, 0x8E, 0x30, 0x10, 0x60, 0xC1, 0x12, 0x4D,
  0x9E, 0x3C, 0x78, 0x93, 0x26, 0x60, 0x13, 0x32, 0x26, 0x66, 0x44, 0xCC,
  0x2C, 0xC7, 0xFD, 0x99, 0xB3, 0x36, 0x44, 0x88, 0x91, 0x36, 0x66, 0xCC,
  0x80, 0x2C, 0x7D, 0x9B, 0x36, 0x68, 0x91, 0x66, 0xCC, 0x1C, 0x7D, 0x9B,
  0x34, 0x68, 0xF1, 0x26, 0x78, 0x16, 0x1F, 0x31, 0x31, 0x33, 0x23, 0x22,
  0x76, 0x7C, 0x60, 0x40, 0x40, 0xC0, 0x1B, 0x3E, 0x66, 0x66, 0x46, 0x44,
  0xC4, 0x4C, 0x7C, 0x0C, 0x08, 0x08, 0x18, 0x2C, 0xF6, 0x18, 0x61, 0x04,
  0x30, 0xC0, 0x39, 0xB6, 0x18, 0x30, 0x61, 0xA6, 0xF0, 0x26, 0x7F, 0x4C,
  0xC8, 0x88, 0xE0, 0x45, 0x1C, 0xF3, 0xCE, 0x29, 0xA6, 0xF8, 0x8E, 0x38,
  0xA6, 0xD3, 0xCE, 0x38, 0xC0, 0x8C, 0xE7, 0x29, 0xDA, 0x74, 0xAF, 0x2B,
  0x8E, 0xE3, 0x38, 0xCC, 0x00, 0x33, 0x12, 0x16, 0x1C, 0x18, 0x18, 0x3C,
  0x6C, 0xC4, 0x21, 0x33, 0x32, 0x36, 0x34, 0x3C, 0x38, 0x38, 0x30, 0x30,
  0x20, 0xE0, 0xC0, 0x3E, 0x7C, 0x30, 0x41, 0x86, 0x08, 0x30, 0xF8, 0x0C,
  0x61, 0x04, 0x30, 0xCC, 0x18, 0x21, 0x86, 0x18, 0x70, 0x40, 0xFF, 0xFF,
  0x18, 0x20, 0x82, 0x18, 0x60, 0xC6, 0x30, 0xC3, 0x08, 0xE2, 0x00, 0xE7,
  0xF0,
};

const GFXglyph NotoSans_Condensed_MediumItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 5, 4, 6, 2, -11 },
  { 10, 8, 11, 8, 0, -11 },
  { 21, 7, 13, 7, 0, -12 },
  { 33, 10, 12, 11, 1, -12 },
  { 48, 8, 12, 8, 0, -12 },
  { 60, 2, 4, 3, 2, -11 },
  { 61, 6, 14, 4, 0, -11 },
  { 72, 5, 15, 4, -1, -12 },
  { 82, 6, 6, 7, 1, -12 },
  { 87, 6, 7, 8, 1, -9 },
  { 93, 3, 4, 4, -1, -2 },
  { 95, 4, 1, 5, 0, -5 },
  { 96, 2, 2, 4, 0, -2 },
  { 97, 8, 11, 6, -1, -11 },
  { 108, 7, 12, 7, 0, -12 },
  { 119, 4, 11, 7, 2, -11 },
  { 125, 7, 12, 7, 0, -12 },
  { 136, 7, 12, 7, 0, -12 },
  { 147, 7, 11, 7, 0, -11 },
  { 157, 7, 11, 7, 0, -11 },
  { 167, 6, 12, 7, 1, -12 },
  { 176, 7, 11, 7, 1, -11 },
  { 186, 7, 12, 7, 0, -12 },
  { 197, 7, 12, 7, 0, -12 },
  { 208, 4, 9, 4, 0, -9 },
  { 213, 5, 11, 4, -1, -9 },
  { 220, 6, 7, 8, 1, -9 },
  { 226, 6, 5, 8, 1, -8 },
  { 230, 6, 7, 8, 1, -9 },
  { 236, 5, 12, 5, 1, -12 },
  { 244, 10, 12, 11, 1, -11 },
  { 259, 8, 11, 8, -1, -11 },
  { 270, 8, 11, 8, 0, -11 },
  { 281, 7, 12, 7, 1, -12 },
  { 292, 8, 11, 9, 0, -11 },
  { 303, 7, 11, 7, 0, -11 },
  { 313, 7, 11, 6, 0, -11 },
  { 323, 8, 12, 9, 1, -12 },
  { 335, 9, 11, 9, 0, -11 },
  { 348, 7, 11, 5, -1, -11 },
  { 358, 6, 14, 4, -2, -11 },
  { 369, 9, 11, 7, 0, -11 },
  { 382, 5, 11, 6, 0, -11 },
  { 389, 12, 11, 12, 0, -11 },
  { 406, 10, 11, 9, 0, -11 },
  { 420, 8, 12, 9, 1, -12 },
  { 432, 8, 11, 7, 0, -11 },
  { 443, 8, 15, 9, 1, -12 },
  { 458, 8, 11, 8, 0, -11 },
  { 469, 7, 12, 7, 0, -12 },
  { 480, 7, 11, 6, 1, -11 },
  { 490, 8, 11, 9, 1, -11 },
  { 501, 8, 11, 7, 1, -11 },
  { 512, 12, 11, 12, 1, -11 },
  { 529, 9, 11, 7, -1, -11 },
  { 542, 7, 11, 7, 1, -11 },
  { 552, 8, 11, 6, -1, -11 },
  { 563, 6, 14, 5, 0, -11 },
  { 574, 3, 11, 6, 2, -11 },
  { 579, 6, 14, 5, -1, -11 },
  { 590, 7, 6, 7, 0, -11 },
  { 596, 5, 1, 5, -1, 1 },
  { 597, 3, 2, 4, 2, -12 },
  { 598, 8, 9, 8, 0, -9 },
  { 607, 7, 12, 8, 0, -12 },
  { 618, 6, 9, 6, 0, -9 },
  { 625, 8, 12, 8, 0, -12 },
  { 637, 7, 9, 7, 0, -9 },
  { 645, 8, 16, 4, -2, -12 },
  { 661, 8, 13, 8, 0, -9 },
  { 674, 7, 12, 8, 0, -12 },
  { 685, 4, 12, 4, 0, -12 },
  { 691, 6, 16, 4, -2, -12 },
  { 703, 7, 12, 7, 0, -12 },
  { 714, 4, 12, 4, 0, -12 },
  { 720, 11, 9, 11, 0, -9 },
  { 733, 7, 9, 8, 0, -9 },
  { 741, 7, 9, 7, 0, -9 },
  { 749, 8, 13, 8, -1, -9 },
  { 762, 8, 13, 8, 0, -9 },
  { 775, 6, 9, 5, 0, -9 },
  { 782, 6, 9, 6, 0, -9 },
  { 789, 4, 11, 5, 1, -11 },
  { 795, 6, 9, 8, 1, -9 },
  { 802, 6, 9, 6, 1, -9 },
  { 809, 10, 9, 10, 1, -9 },
  { 821, 8, 9, 6, -1, -9 },
  { 830, 8, 13, 6, -1, -9 },
  { 843, 7, 9, 6, -1, -9 },
  { 851, 6, 14, 5, 0, -11 },
  { 862, 1, 16, 7, 3, -12 },
  { 864, 6, 14, 5, -1, -11 },
  { 875, 6, 2, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_MediumItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC16PT7B_H_
