#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC30PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x18,
  0x18, 0x38, 0x38, 0x30, 0x00, 0x00, 0x60, 0x70, 0xF0, 0xE0, 0x73, 0xB9,
  0xD8, 0xCC, 0x6E, 0x77, 0x3B, 0x18, 0x01, 0xCE, 0x01, 0x8C, 0x01, 0x8C,
  0x03, 0x9C, 0x03, 0x18, 0x03, 0x18, 0x3F, 0xFF, 0x3F, 0xFE, 0x06, 0x30,
  0x0E, 0x30, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0xFF, 0xFC, 0xFF, 0xF8,
  0x18, 0xC0, 0x39, 0xC0, 0x31, 0x80, 0x31, 0x80, 0x71, 0x80, 0x63, 0x00,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x01, 0xFF, 0x0F, 0xF8, 0x7A, 0x61, 0xC8,
  0x07, 0x60, 0x1D, 0x80, 0x74, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x2F, 0x00, 0x9C, 0x02, 0x70, 0x19, 0x8C, 0x6E, 0x3F, 0xF0, 0xFF,
  0x80, 0x38, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0F, 0x81,
  0xC3, 0x70, 0x61, 0x8C, 0x30, 0x63, 0x1C, 0x38, 0xC6, 0x0C, 0x73, 0x83,
  0x1C, 0xC0, 0xC6, 0x60, 0x31, 0x99, 0xEC, 0xEC, 0xFB, 0xF7, 0x67, 0xF9,
  0x99, 0xDC, 0xEC, 0x70, 0x33, 0x1C, 0x18, 0xC6, 0x0E, 0x71, 0x83, 0x1C,
  0x61, 0xC7, 0x38, 0x61, 0xCC, 0x30, 0x3E, 0x1C, 0x0F, 0x00, 0x00, 0xC0,
  0x07, 0xE0, 0x1F, 0xE0, 0x31, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8C, 0x07,
  0x38, 0x0E, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0xFC, 0x03, 0xF8, 0xEF, 0x39,
  0x9C, 0x77, 0x70, 0xFE, 0xE0, 0xF9, 0xC1, 0xE3, 0x83, 0xC7, 0x8F, 0xC7,
  0xFB, 0x87, 0xE7, 0x80, 0x77, 0x76, 0xEE, 0xC0, 0x01, 0x81, 0xC1, 0xC1,
  0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x38, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x30, 0x1C, 0x00, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81,
  0x81, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x30, 0x30, 0x00, 0x07, 0x00,
  0xC0, 0x18, 0x73, 0x0F, 0x4E, 0xFF, 0xC7, 0xF9, 0xF0, 0x77, 0x1E, 0x60,
  0x8E, 0x01, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x39, 0xCE, 0xE7, 0x33, 0x98, 0xFF, 0xF8, 0x67,
  0xFF, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x01, 0x80, 0x7E, 0x0F, 0xF1, 0xE7, 0x1C, 0x73,
  0x87, 0x38, 0x77, 0x07, 0x70, 0x77, 0x07, 0x70, 0x7E, 0x07, 0xE0, 0x7E,
  0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0xE3, 0x8F, 0x78, 0x7F, 0x03,
  0xE0, 0x07, 0x87, 0xC7, 0xCF, 0xEF, 0x73, 0x38, 0x18, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x07,
  0x00, 0x00, 0xE0, 0x0F, 0xE0, 0xFF, 0xC1, 0x87, 0x04, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x80, 0x01, 0xC0, 0x7F, 0x87, 0xFE, 0x18, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x0F, 0x03, 0xF0, 0x1F, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xE0, 0x07, 0x20, 0x79, 0x87,
  0x8F, 0xF8, 0x7F, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x01, 0xF0, 0x1F,
  0x80, 0xD8, 0x0D, 0xC0, 0xEE, 0x06, 0x70, 0x63, 0x07, 0x38, 0x31, 0xC3,
  0x0E, 0x38, 0x71, 0x83, 0x1F, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xC0, 0xFF, 0x81, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE2, 0x07, 0x8E,
  0x7C, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x78, 0x1F, 0xC1, 0xFE, 0x1E, 0x01,
  0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x71, 0x03, 0xBE, 0x1F, 0xF8, 0xF1,
  0xCF, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x70,
  0xE7, 0x87, 0xF8, 0x1F, 0x80, 0x3F, 0xFC, 0xFF, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1F, 0xC0, 0xFF, 0x83,
  0x8F, 0x1C, 0x1C, 0x70, 0x71, 0xC3, 0x87, 0x0E, 0x0E, 0x70, 0x3F, 0x80,
  0x7C, 0x03, 0xF0, 0x3D, 0xE1, 0xE3, 0x87, 0x07, 0x38, 0x1C, 0xE0, 0x73,
  0x81, 0xCE, 0x0E, 0x1C, 0x78, 0x7F, 0xC0, 0xFE, 0x00, 0x01, 0xC0, 0x3F,
  0x83, 0xFC, 0x3C, 0x71, 0xC3, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39,
  0xC3, 0xCE, 0x1E, 0x7B, 0xF1, 0xFF, 0x0F, 0xB8, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0xF1, 0x0F, 0x0F, 0xF0, 0x7F, 0x00, 0x1C, 0x3C, 0x70,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x1E, 0x3C, 0x70, 0x07,
  0x83, 0xC1, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x00, 0x00, 0x08,
  0x01, 0xC0, 0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x80, 0x07, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x00, 0x60, 0x00, 0x0F,
  0x0F, 0xE3, 0xFC, 0x87, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x03, 0xC0,
  0xF0, 0x38, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xE0, 0x0F, 0x9E, 0x03, 0x80,
  0xE0, 0xE0, 0x0C, 0x38, 0x01, 0xC6, 0x0E, 0x19, 0x87, 0xE3, 0x31, 0xCC,
  0x6C, 0x71, 0x8D, 0x8C, 0x71, 0xB3, 0x8C, 0x7E, 0x61, 0x8D, 0x8C, 0x71,
  0xB1, 0x8E, 0x36, 0x31, 0x8C, 0xC7, 0x7B, 0x98, 0xFB, 0xE3, 0x06, 0x30,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0xFF, 0x80,
  0x01, 0x00, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xDC,
  0x07, 0x70, 0x19, 0xC0, 0xE7, 0x03, 0x9C, 0x1C, 0x70, 0x71, 0xC3, 0x87,
  0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC7, 0x07, 0x38, 0x1C, 0xE0, 0x77, 0x01,
  0xDC, 0x07, 0xF0, 0x1C, 0x07, 0xF8, 0x1F, 0xF8, 0x38, 0x78, 0x70, 0x70,
  0xE0, 0xE1, 0xC1, 0xC7, 0x07, 0x0E, 0x0E, 0x1C, 0x78, 0x3F, 0xE0, 0x7F,
  0xC1, 0xC3, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x38, 0x1C, 0x70, 0x38,
  0xE0, 0xE1, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xFC,
  0x1F, 0xF0, 0x78, 0x21, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xE6, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xFC, 0x0E, 0x3E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0F, 0x1C, 0x0F, 0x1C, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E,
  0x38, 0x0E, 0x38, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x70, 0x38, 0x70, 0x78,
  0x70, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x10,
  0x7F, 0x81, 0xFE, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F,
  0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x03, 0xFF, 0x07, 0xFF, 0x0F, 0x06, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x7E, 0x70, 0xFC, 0xF0, 0xFC,
  0xF0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xF0, 0x38, 0x70, 0x38, 0x70, 0x38,
  0x7C, 0x78, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0x03, 0x87, 0x01, 0xC3, 0x80,
  0xE1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0x01, 0xC3, 0x81, 0xC1, 0xC0, 0xE0,
  0xE0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07,
  0x0E, 0x03, 0x80, 0x0F, 0xF0, 0x7C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x0F, 0xF0, 0xFE, 0x00, 0x00,
  0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0x07, 0x87, 0x07, 0x03,
  0x87, 0x01, 0xC7, 0x80, 0xE3, 0x80, 0x73, 0x80, 0x73, 0x80, 0x3B, 0xC0,
  0x1D, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0x9C, 0x01, 0xCE,
  0x00, 0xE7, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x3C, 0x0E,
  0x0E, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x1C, 0x07, 0xFD, 0xFF, 0xFF, 0x80, 0x07, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x0D, 0x81, 0xF8, 0x36, 0x07, 0xE1,
  0xD8, 0x1B, 0x87, 0x60, 0xEC, 0x1D, 0x83, 0x70, 0x76, 0x1D, 0xC1, 0x98,
  0x67, 0x0E, 0x73, 0x9C, 0x39, 0xCC, 0x60, 0xE7, 0x73, 0x83, 0x1D, 0x8E,
  0x1C, 0x7E, 0x38, 0x71, 0xF0, 0xE1, 0xC7, 0xC7, 0x07, 0x1E, 0x1C, 0x18,
  0x78, 0x70, 0xE0, 0xC1, 0xC0, 0x07, 0x01, 0xC3, 0xE0, 0x70, 0xF8, 0x1C,
  0x3E, 0x06, 0x0D, 0x83, 0x83, 0x70, 0xE1, 0xDC, 0x38, 0x77, 0x0C, 0x1C,
  0xC7, 0x07, 0x31, 0xC1, 0x8E, 0x70, 0xE3, 0x9C, 0x38, 0xE6, 0x0E, 0x1B,
  0x83, 0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x0F, 0x07, 0x03, 0xC1,
  0x80, 0xF0, 0xE0, 0x3C, 0x00, 0x00, 0xE0, 0x03, 0xFC, 0x07, 0xFE, 0x0F,
  0x1E, 0x1E, 0x0E, 0x1C, 0x0F, 0x38, 0x07, 0x38, 0x07, 0x78, 0x07, 0x70,
  0x0F, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x3C, 0x70, 0x38, 0x70, 0x78, 0x7D, 0xF0, 0x3F, 0xE0, 0x1F,
  0x80, 0x07, 0xF8, 0x1F, 0xF8, 0x38, 0xF0, 0x70, 0xE0, 0xE1, 0xE1, 0xC3,
  0xC7, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0xF0, 0x7F, 0xE1, 0xFF, 0x03,
  0xF8, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xFC, 0x07, 0xFE, 0x0F,
  0x1E, 0x1E, 0x0E, 0x1C, 0x0F, 0x38, 0x07, 0x38, 0x07, 0x78, 0x07, 0x70,
  0x0F, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xE0, 0x1E, 0xE0,
  0x1C, 0xE0, 0x3C, 0x70, 0x38, 0x70, 0x78, 0x7D, 0xF0, 0x3F, 0xE0, 0x1F,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x07,
  0xF0, 0x3F, 0xF0, 0xE3, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x71, 0xC1, 0xC7,
  0x07, 0x1C, 0x3C, 0x73, 0xE1, 0xFF, 0x0F, 0xF0, 0x39, 0xC0, 0xE7, 0x03,
  0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0x1C, 0x1C, 0xE0, 0x70,
  0x00, 0xE0, 0x1F, 0xF0, 0xFF, 0x87, 0x86, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x88, 0x1E, 0x3D, 0xF0, 0xFF,
  0x83, 0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0x87, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x1E,
  0x07, 0x1C, 0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x38, 0x0E, 0x38,
  0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x38, 0x70,
  0x38, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0xF0, 0xF0, 0x79,
  0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0xE0, 0x3F, 0x81, 0xEE, 0x07, 0x38, 0x1C,
  0xE0, 0xE3, 0x83, 0x8E, 0x1C, 0x38, 0x70, 0xE3, 0x83, 0x8E, 0x0E, 0x38,
  0x39, 0xC0, 0xE7, 0x03, 0xB8, 0x0E, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x00, 0xE0, 0x70, 0x3F, 0x07, 0x81, 0xF8,
  0x3C, 0x1D, 0xC1, 0xE0, 0xEE, 0x1F, 0x0E, 0x70, 0xF8, 0x73, 0x8F, 0xC3,
  0x1C, 0x6E, 0x38, 0xE7, 0x71, 0xC6, 0x3B, 0x9C, 0x31, 0x9C, 0xE1, 0x9C,
  0xE6, 0x0C, 0xC7, 0x70, 0x6E, 0x3B, 0x83, 0x71, 0xF8, 0x1B, 0x0F, 0xC0,
  0xF8, 0x7C, 0x07, 0x83, 0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0xF0, 0x0E, 0x07,
  0x80, 0x00, 0x07, 0x03, 0x81, 0xC3, 0x80, 0xE3, 0xC0, 0x71, 0xC0, 0x39,
  0xC0, 0x0C, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3B, 0x80, 0x39, 0xC0, 0x1C, 0xE0,
  0x1C, 0x70, 0x1E, 0x38, 0x0E, 0x0E, 0x0E, 0x07, 0x0F, 0x03, 0x80, 0xE0,
  0x7E, 0x0E, 0xE0, 0xEE, 0x1C, 0xE3, 0x86, 0x38, 0x67, 0x07, 0x70, 0x7E,
  0x07, 0xE0, 0x7C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x00, 0x03,
  0xF0, 0x3F, 0x07, 0xE0, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7E,
  0x07, 0xC0, 0xFC, 0x00, 0xE3, 0x8E, 0x38, 0x61, 0x86, 0x1C, 0x71, 0xC7,
  0x0C, 0x30, 0xC3, 0x8E, 0x38, 0xE3, 0x86, 0x18, 0x70, 0x03, 0xE0, 0xFC,
  0x1F, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0xFC, 0x1F, 0x83, 0xF0, 0x00, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0xC0, 0x6E, 0x07, 0x30, 0x31, 0xC3, 0x8E,
  0x38, 0x31, 0x81, 0xDC, 0x0F, 0xC0, 0x30, 0xFF, 0xFF, 0xF8, 0xF3, 0x8C,
  0x71, 0x80, 0x0F, 0x98, 0xFF, 0xCF, 0x3E, 0x70, 0xE7, 0x07, 0x38, 0x39,
  0xC1, 0xDC, 0x0E, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC3, 0xCE, 0x1C, 0x79,
  0xE1, 0xFB, 0x0F, 0xB8, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0xBE, 0x1F, 0xF8, 0xF1, 0xC7, 0x0E, 0x38, 0x73,
  0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x30, 0x3B, 0x83, 0x9C, 0x1C, 0xE1,
  0xE7, 0x9E, 0x77, 0xE3, 0xBE, 0x00, 0x0F, 0xE3, 0xF8, 0xF1, 0x1C, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xE2, 0x1F, 0xC1, 0xF8, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x0E, 0x07, 0xDC, 0x1F, 0xF8, 0x79, 0xF0, 0xE1,
  0xC3, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x38, 0x1C, 0x70, 0x70, 0xE0, 0xE1,
  0xC1, 0xC3, 0x87, 0x87, 0x0E, 0x0F, 0x3C, 0x1F, 0xD8, 0x1F, 0x70, 0x00,
  0x0F, 0xC3, 0xFC, 0xF3, 0x9C, 0x37, 0x0E, 0xE1, 0xF9, 0xF7, 0xFC, 0xFE,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE1, 0x1F, 0xE1, 0xFC, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x03, 0xF8, 0x03, 0xF8, 0x05, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x9C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x07, 0xCC,
  0x3F, 0xF1, 0xE7, 0xC7, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x9C, 0x0E,
  0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x3C, 0x70, 0xE1, 0xEF, 0x87, 0xFE,
  0x0F, 0xB8, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0xC7, 0x83, 0xFC,
  0x0F, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xBE, 0x1F, 0xF8, 0xF1, 0xC7, 0x0E, 0x38, 0x73, 0x83,
  0x9C, 0x1C, 0xE0, 0xC7, 0x0E, 0x30, 0x73, 0x83, 0x9C, 0x1C, 0xE1, 0xC7,
  0x0E, 0x70, 0x73, 0x83, 0x80, 0x07, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70,
  0x70, 0xE0, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x02,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0xBC, 0x0F, 0x80, 0xF0, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x0F, 0x1C, 0x78, 0x71, 0xC1, 0xCE, 0x06, 0x70, 0x3B, 0x80, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x3B, 0x81, 0xCE, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0xC3,
  0x87, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70,
  0x70, 0xE0, 0xE0, 0x1D, 0xF3, 0xE1, 0xFF, 0xFF, 0x1E, 0x3E, 0x71, 0xC3,
  0xC7, 0x1C, 0x38, 0x73, 0x83, 0x87, 0x38, 0x30, 0x73, 0x87, 0x06, 0x38,
  0x70, 0xE3, 0x07, 0x0E, 0x70, 0x70, 0xE7, 0x0E, 0x0E, 0x70, 0xE0, 0xC7,
  0x0E, 0x1C, 0xE0, 0xE1, 0xCE, 0x0C, 0x1C, 0x1D, 0xF0, 0xFF, 0xC7, 0x8E,
  0x38, 0x71, 0xC3, 0x9C, 0x1C, 0xE0, 0xE7, 0x06, 0x38, 0x71, 0x83, 0x9C,
  0x1C, 0xE0, 0xE7, 0x0E, 0x38, 0x73, 0x83, 0x9C, 0x1C, 0x0F, 0xC1, 0xFE,
  0x3C, 0xF3, 0x87, 0x70, 0x77, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E,
  0xE0, 0xEE, 0x0E, 0xE1, 0xCF, 0x3C, 0x7F, 0x83, 0xF0, 0x0E, 0xF8, 0x3F,
  0xF0, 0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1C,
  0x1C, 0x60, 0x73, 0x83, 0x8E, 0x0E, 0x38, 0x78, 0xF3, 0xC3, 0x7E, 0x1D,
  0xF0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x0F, 0x98, 0xFF, 0xCF, 0x3E, 0x70, 0xE7, 0x07, 0x38, 0x39,
  0xC1, 0xDC, 0x0E, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC3, 0xCE, 0x1C, 0x79,
  0xE3, 0xFF, 0x0F, 0xB8, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1C, 0x00, 0x1D, 0xE3, 0xFC, 0x7F, 0x0F, 0x01, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38,
  0x07, 0x00, 0x0F, 0xE3, 0xFC, 0xE1, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x39, 0x8F, 0x3F, 0xC7, 0xF0,
  0x0C, 0x0C, 0x1C, 0x1C, 0x7F, 0x7F, 0xB8, 0x38, 0x38, 0x30, 0x70, 0x70,
  0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xFC, 0x7C, 0x38, 0x39, 0xC1, 0xCE,
  0x0C, 0x70, 0xE3, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x1C, 0x70, 0xE7, 0x07,
  0x38, 0x39, 0xC3, 0x8E, 0x1C, 0x7B, 0xE3, 0xFF, 0x0F, 0xB8, 0xE0, 0xFC,
  0x1F, 0x87, 0x70, 0xEE, 0x39, 0xC7, 0x39, 0xC7, 0x38, 0xEE, 0x1D, 0xC3,
  0xB0, 0x7E, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xE1, 0xC1, 0xF8, 0x70,
  0xEE, 0x3C, 0x3B, 0x8F, 0x0C, 0xE7, 0xC7, 0x39, 0xB1, 0xCE, 0x6C, 0xE3,
  0x33, 0x38, 0xCC, 0xCC, 0x37, 0x37, 0x0D, 0x8D, 0x83, 0x63, 0xE0, 0xF0,
  0xF8, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x38, 0xE0,
  0xE7, 0x03, 0x9C, 0x06, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x3E, 0x01, 0xD8, 0x07, 0x70, 0x39, 0xC1, 0xC7, 0x07, 0x0E, 0x38, 0x38,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x38, 0x07, 0x38, 0x07, 0x30, 0x07, 0x70, 0x07, 0x60, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x9E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xF1,
  0xFF, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01,
  0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0xF0,
  0x1F, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0E, 0x07, 0xC0, 0x70, 0x0F, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xE0, 0x1E, 0x00,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0x80, 0x7C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1F, 0x00, 0xE0, 0x3E, 0x07, 0x80,
  0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x0F,
  0xC0, 0xF8, 0x0C, 0x00, 0x38, 0x0B, 0xF0, 0xFF, 0xFF, 0x07, 0xE8, 0x00,
  0x00,
};

const GFXglyph NotoSans_Condensed_MediumItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 21, 7, 0, -21 },
  { 22, 9, 7, 11, 3, -21 },
  { 30, 16, 21, 15, 0, -21 },
  { 72, 14, 25, 13, 0, -23 },
  { 116, 18, 22, 21, 2, -22 },
  { 166, 15, 22, 16, 0, -22 },
  { 208, 4, 7, 6, 3, -21 },
  { 212, 9, 27, 8, 1, -22 },
  { 243, 9, 27, 8, -2, -22 },
  { 274, 11, 12, 13, 3, -23 },
  { 291, 13, 15, 14, 1, -18 },
  { 316, 5, 8, 7, -1, -4 },
  { 321, 7, 2, 8, 1, -9 },
  { 323, 4, 4, 7, 0, -4 },
  { 325, 14, 22, 11, -1, -22 },
  { 364, 12, 22, 13, 1, -22 },
  { 397, 9, 21, 13, 3, -21 },
  { 421, 14, 22, 13, -1, -22 },
  { 460, 13, 22, 13, 0, -22 },
  { 496, 13, 22, 13, 0, -22 },
  { 532, 14, 21, 13, 0, -21 },
  { 569, 13, 22, 13, 1, -22 },
  { 605, 14, 21, 13, 1, -21 },
  { 642, 14, 22, 13, 0, -22 },
  { 681, 13, 22, 13, 0, -22 },
  { 717, 7, 16, 7, 0, -16 },
  { 731, 9, 20, 7, -2, -16 },
  { 754, 13, 14, 14, 1, -18 },
  { 777, 13, 9, 14, 1, -15 },
  { 792, 13, 14, 14, 1, -18 },
  { 815, 10, 22, 10, 1, -22 },
  { 843, 19, 25, 20, 1, -22 },
  { 903, 14, 21, 14, -2, -21 },
  { 940, 15, 21, 15, 0, -21 },
  { 980, 15, 22, 14, 1, -22 },
  { 1022, 16, 21, 16, 0, -21 },
  { 1064, 14, 21, 13, 0, -21 },
  { 1101, 14, 21, 12, 0, -21 },
  { 1138, 16, 22, 17, 1, -22 },
  { 1182, 17, 21, 17, 0, -21 },
  { 1227, 12, 21, 9, -1, -21 },
  { 1259, 13, 27, 7, -5, -21 },
  { 1303, 17, 21, 14, 0, -21 },
  { 1348, 10, 21, 12, 0, -21 },
  { 1375, 22, 21, 22, 0, -21 },
  { 1433, 18, 21, 18, 0, -21 },
  { 1481, 16, 22, 17, 1, -22 },
  { 1525, 15, 21, 14, 0, -21 },
  { 1565, 16, 27, 17, 1, -22 },
  { 1619, 14, 21, 14, 0, -21 },
  { 1656, 14, 22, 13, 0, -22 },
  { 1695, 12, 21, 12, 2, -21 },
  { 1727, 16, 21, 16, 1, -21 },
  { 1769, 14, 21, 14, 3, -21 },
  { 1806, 21, 21, 22, 3, -21 },
  { 1862, 17, 21, 13, -2, -21 },
  { 1907, 12, 21, 13, 3, -21 },
  { 1939, 15, 21, 12, -1, -21 },
  { 1979, 12, 27, 9, -1, -22 },
  { 2020, 6, 22, 11, 3, -22 },
  { 2037, 11, 27, 9, -2, -22 },
  { 2075, 13, 12, 14, 0, -21 },
  { 2095, 11, 2, 10, -3, 3 },
  { 2098, 5, 5, 8, 4, -23 },
  { 2102, 13, 16, 14, 1, -16 },
  { 2128, 13, 23, 14, 0, -23 },
  { 2166, 11, 16, 11, 1, -16 },
  { 2188, 15, 23, 14, 1, -23 },
  { 2232, 11, 16, 13, 1, -16 },
  { 2254, 16, 30, 8, -4, -23 },
  { 2314, 14, 23, 14, 0, -16 },
  { 2355, 13, 23, 14, 0, -23 },
  { 2393, 8, 22, 7, 0, -22 },
  { 2415, 12, 29, 7, -4, -22 },
  { 2459, 14, 23, 13, 0, -23 },
  { 2500, 8, 23, 7, 0, -23 },
  { 2523, 20, 16, 21, 0, -16 },
  { 2563, 13, 16, 14, 0, -16 },
  { 2589, 12, 16, 14, 1, -16 },
  { 2613, 14, 23, 14, -1, -16 },
  { 2654, 13, 23, 14, 1, -16 },
  { 2692, 11, 16, 10, 0, -16 },
  { 2714, 11, 16, 11, 0, -16 },
  { 2736, 8, 20, 9, 1, -20 },
  { 2756, 13, 16, 14, 1, -16 },
  { 2782, 11, 16, 12, 2, -16 },
  { 2804, 18, 16, 19, 2, -16 },
  { 2840, 14, 16, 12, -1, -16 },
  { 2868, 16, 23, 12, -3, -16 },
  { 2914, 12, 16, 10, -1, -16 },
  { 2938, 12, 26, 10, 0, -21 },
  { 2977, 3, 30, 13, 5, -23 },
  { 2989, 12, 26, 10, -2, -21 },
  { 3028, 13, 5, 14, 1, -13 },
};

const GFXfont NotoSans_Condensed_MediumItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC30PT7B_H_
