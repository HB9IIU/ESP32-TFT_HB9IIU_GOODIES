#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_Condensed_MediumItalic
// Headers: 67

#include "NotoSans_Condensed_MediumItalic6pt7b.h"
#include "NotoSans_Condensed_MediumItalic7pt7b.h"
#include "NotoSans_Condensed_MediumItalic8pt7b.h"
#include "NotoSans_Condensed_MediumItalic9pt7b.h"
#include "NotoSans_Condensed_MediumItalic10pt7b.h"
#include "NotoSans_Condensed_MediumItalic11pt7b.h"
#include "NotoSans_Condensed_MediumItalic12pt7b.h"
#include "NotoSans_Condensed_MediumItalic13pt7b.h"
#include "NotoSans_Condensed_MediumItalic14pt7b.h"
#include "NotoSans_Condensed_MediumItalic15pt7b.h"
#include "NotoSans_Condensed_MediumItalic16pt7b.h"
#include "NotoSans_Condensed_MediumItalic17pt7b.h"
#include "NotoSans_Condensed_MediumItalic18pt7b.h"
#include "NotoSans_Condensed_MediumItalic19pt7b.h"
#include "NotoSans_Condensed_MediumItalic20pt7b.h"
#include "NotoSans_Condensed_MediumItalic21pt7b.h"
#include "NotoSans_Condensed_MediumItalic22pt7b.h"
#include "NotoSans_Condensed_MediumItalic23pt7b.h"
#include "NotoSans_Condensed_MediumItalic24pt7b.h"
#include "NotoSans_Condensed_MediumItalic25pt7b.h"
#include "NotoSans_Condensed_MediumItalic26pt7b.h"
#include "NotoSans_Condensed_MediumItalic27pt7b.h"
#include "NotoSans_Condensed_MediumItalic28pt7b.h"
#include "NotoSans_Condensed_MediumItalic29pt7b.h"
#include "NotoSans_Condensed_MediumItalic30pt7b.h"
#include "NotoSans_Condensed_MediumItalic31pt7b.h"
#include "NotoSans_Condensed_MediumItalic32pt7b.h"
#include "NotoSans_Condensed_MediumItalic33pt7b.h"
#include "NotoSans_Condensed_MediumItalic34pt7b.h"
#include "NotoSans_Condensed_MediumItalic35pt7b.h"
#include "NotoSans_Condensed_MediumItalic36pt7b.h"
#include "NotoSans_Condensed_MediumItalic37pt7b.h"
#include "NotoSans_Condensed_MediumItalic38pt7b.h"
#include "NotoSans_Condensed_MediumItalic39pt7b.h"
#include "NotoSans_Condensed_MediumItalic40pt7b.h"
#include "NotoSans_Condensed_MediumItalic41pt7b.h"
#include "NotoSans_Condensed_MediumItalic42pt7b.h"
#include "NotoSans_Condensed_MediumItalic43pt7b.h"
#include "NotoSans_Condensed_MediumItalic44pt7b.h"
#include "NotoSans_Condensed_MediumItalic45pt7b.h"
#include "NotoSans_Condensed_MediumItalic46pt7b.h"
#include "NotoSans_Condensed_MediumItalic47pt7b.h"
#include "NotoSans_Condensed_MediumItalic48pt7b.h"
#include "NotoSans_Condensed_MediumItalic49pt7b.h"
#include "NotoSans_Condensed_MediumItalic50pt7b.h"
#include "NotoSans_Condensed_MediumItalic51pt7b.h"
#include "NotoSans_Condensed_MediumItalic52pt7b.h"
#include "NotoSans_Condensed_MediumItalic53pt7b.h"
#include "NotoSans_Condensed_MediumItalic54pt7b.h"
#include "NotoSans_Condensed_MediumItalic55pt7b.h"
#include "NotoSans_Condensed_MediumItalic56pt7b.h"
#include "NotoSans_Condensed_MediumItalic57pt7b.h"
#include "NotoSans_Condensed_MediumItalic58pt7b.h"
#include "NotoSans_Condensed_MediumItalic59pt7b.h"
#include "NotoSans_Condensed_MediumItalic60pt7b.h"
#include "NotoSans_Condensed_MediumItalic61pt7b.h"
#include "NotoSans_Condensed_MediumItalic62pt7b.h"
#include "NotoSans_Condensed_MediumItalic63pt7b.h"
#include "NotoSans_Condensed_MediumItalic64pt7b.h"
#include "NotoSans_Condensed_MediumItalic65pt7b.h"
#include "NotoSans_Condensed_MediumItalic66pt7b.h"
#include "NotoSans_Condensed_MediumItalic67pt7b.h"
#include "NotoSans_Condensed_MediumItalic68pt7b.h"
#include "NotoSans_Condensed_MediumItalic69pt7b.h"
#include "NotoSans_Condensed_MediumItalic70pt7b.h"
#include "NotoSans_Condensed_MediumItalic71pt7b.h"
#include "NotoSans_Condensed_MediumItalic72pt7b.h"
