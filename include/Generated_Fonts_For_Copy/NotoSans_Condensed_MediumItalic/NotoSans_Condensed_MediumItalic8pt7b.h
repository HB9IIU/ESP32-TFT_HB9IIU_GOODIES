#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC8PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x20, 0xF0, 0x35, 0x66, 0xBA, 0x25, 0x42, 0x6C, 0x4D, 0xAC,
  0xF3, 0xAC, 0x25, 0x65, 0xAF, 0xC0, 0x29, 0x49, 0x20, 0x24, 0x92, 0xB0,
  0x5F, 0x00, 0x22, 0xF2, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x25, 0x9A,
  0xAC, 0x75, 0xA0, 0x61, 0x22, 0x4E, 0x61, 0x26, 0x2E, 0x12, 0x6A, 0xE2,
  0x74, 0x42, 0x2E, 0x34, 0xEA, 0xAE, 0x71, 0x22, 0x48, 0x65, 0x66, 0xAE,
  0x65, 0x96, 0x2C, 0x42, 0x42, 0x80, 0x16, 0xC3, 0xFF, 0x86, 0x3C, 0x64,
  0xA1, 0x00, 0x32, 0x6F, 0xBF, 0xC1, 0xC0, 0x11, 0x33, 0x5D, 0x65, 0x5A,
  0x9E, 0x34, 0x48, 0x86, 0x65, 0x59, 0x9E, 0x74, 0x4A, 0x8E, 0x74, 0x46,
  0x88, 0x3A, 0x11, 0x69, 0x38, 0x4A, 0x94, 0xE9, 0x48, 0x69, 0x29, 0x80,
  0x24, 0x94, 0x94, 0x55, 0x66, 0xAA, 0x49, 0x49, 0xC0, 0x45, 0x34, 0xAE,
  0xAA, 0xA0, 0x4A, 0x5D, 0x6B, 0x48, 0x35, 0x59, 0x96, 0x65, 0x56, 0x88,
  0x35, 0x59, 0x96, 0x20, 0x65, 0x56, 0xAA, 0x74, 0x42, 0x2E, 0xEA, 0x49,
  0x00, 0x4A, 0x95, 0x29, 0x30, 0xB7, 0x69, 0x00, 0xAD, 0x7B, 0xEB, 0x50,
  0x56, 0x64, 0xAA, 0xBB, 0x49, 0x00, 0x72, 0x24, 0x8E, 0x69, 0x49, 0x30,
  0xFC, 0x32, 0x22, 0x22, 0xC0, 0x26, 0x69, 0xE0, 0x80, 0x79, 0xAE, 0x46,
  0x59, 0xAE, 0x72, 0x60, 0x11, 0x7A, 0xAE, 0x7E, 0x70, 0x33, 0x62, 0x44,
  0x48, 0x79, 0xAE, 0x2C, 0x46, 0x5A, 0xAA, 0x46, 0xA0, 0x20, 0xA4, 0x94,
  0x45, 0x64, 0xAA, 0x56, 0xA0, 0x7D, 0x6B, 0x50, 0x7A, 0xAA, 0x76, 0xF0,
  0x79, 0xAE, 0x88, 0x7A, 0xAE, 0x22, 0x72, 0x40, 0xE9, 0x60, 0x7A, 0x4C,
  0x5A, 0xAE, 0xBA, 0x44, 0xAD, 0x75, 0xA0, 0x74, 0x4A, 0x5A, 0x98, 0x44,
  0x60, 0x6A, 0x60, 0x29, 0x64, 0xB0, 0xFF, 0x49, 0x35, 0x20, 0xF0,
};

const GFXglyph NotoSans_Condensed_MediumItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 6, 4, 0, -6 },
  { 10, 5, 6, 6, 0, -6 },
  { 14, 4, 6, 4, 0, -6 },
  { 17, 1, 2, 2, 1, -6 },
  { 18, 3, 7, 2, 0, -6 },
  { 21, 3, 7, 2, -1, -6 },
  { 24, 3, 3, 3, 1, -6 },
  { 26, 4, 4, 4, 0, -5 },
  { 28, 1, 2, 2, 0, -1 },
  { 29, 2, 1, 2, 0, -3 },
  { 30, 1, 1, 2, 0, -1 },
  { 31, 3, 6, 3, 0, -6 },
  { 34, 4, 6, 4, 0, -6 },
  { 37, 2, 6, 4, 1, -6 },
  { 39, 4, 6, 4, 0, -6 },
  { 42, 4, 6, 4, 0, -6 },
  { 45, 4, 6, 4, 0, -6 },
  { 48, 4, 6, 4, 0, -6 },
  { 51, 4, 6, 4, 0, -6 },
  { 54, 4, 6, 4, 0, -6 },
  { 57, 4, 6, 4, 0, -6 },
  { 60, 4, 6, 4, 0, -6 },
  { 63, 2, 4, 2, 0, -4 },
  { 64, 2, 5, 2, 0, -4 },
  { 66, 4, 4, 4, 0, -5 },
  { 68, 4, 2, 4, 0, -4 },
  { 69, 4, 4, 4, 0, -5 },
  { 71, 3, 6, 3, 0, -6 },
  { 74, 5, 7, 5, 0, -6 },
  { 79, 4, 6, 4, -1, -6 },
  { 82, 4, 6, 4, 0, -6 },
  { 85, 4, 6, 4, 0, -6 },
  { 88, 4, 6, 4, 0, -6 },
  { 91, 4, 6, 3, 0, -6 },
  { 94, 4, 6, 3, 0, -6 },
  { 97, 5, 6, 4, 0, -6 },
  { 101, 5, 6, 4, 0, -6 },
  { 105, 3, 6, 2, 0, -6 },
  { 108, 3, 8, 2, -1, -6 },
  { 111, 4, 6, 4, 0, -6 },
  { 114, 3, 6, 3, 0, -6 },
  { 117, 6, 6, 6, 0, -6 },
  { 122, 5, 6, 5, 0, -6 },
  { 126, 4, 6, 5, 0, -6 },
  { 129, 4, 6, 4, 0, -6 },
  { 132, 4, 7, 5, 0, -6 },
  { 136, 4, 6, 4, 0, -6 },
  { 139, 4, 6, 3, 0, -6 },
  { 142, 3, 6, 3, 1, -6 },
  { 145, 5, 6, 4, 0, -6 },
  { 149, 3, 6, 4, 1, -6 },
  { 152, 5, 6, 6, 1, -6 },
  { 156, 4, 6, 4, 0, -6 },
  { 159, 3, 6, 3, 1, -6 },
  { 162, 4, 6, 3, 0, -6 },
  { 165, 3, 7, 2, 0, -6 },
  { 168, 1, 6, 3, 1, -6 },
  { 169, 4, 7, 2, -1, -6 },
  { 173, 4, 4, 4, 0, -6 },
  { 175, 3, 1, 3, -1, 0 },
  { 176, 1, 1, 2, 1, -6 },
  { 177, 4, 4, 4, 0, -4 },
  { 179, 4, 6, 4, 0, -6 },
  { 182, 3, 4, 3, 0, -4 },
  { 184, 4, 6, 4, 0, -6 },
  { 187, 3, 4, 3, 0, -4 },
  { 189, 4, 8, 2, -1, -6 },
  { 193, 4, 6, 4, 0, -4 },
  { 196, 4, 6, 4, 0, -6 },
  { 199, 2, 6, 2, 0, -6 },
  { 201, 3, 8, 2, -1, -6 },
  { 204, 4, 6, 3, 0, -6 },
  { 207, 2, 6, 2, 0, -6 },
  { 209, 5, 4, 6, 0, -4 },
  { 212, 4, 4, 4, 0, -4 },
  { 214, 3, 4, 4, 0, -4 },
  { 216, 4, 6, 4, 0, -4 },
  { 219, 4, 6, 4, 0, -4 },
  { 222, 3, 4, 3, 0, -4 },
  { 224, 3, 4, 3, 0, -4 },
  { 226, 3, 5, 2, 0, -5 },
  { 228, 4, 4, 4, 0, -4 },
  { 230, 4, 4, 3, 0, -4 },
  { 232, 5, 4, 5, 0, -4 },
  { 235, 4, 4, 3, 0, -4 },
  { 237, 5, 6, 3, -1, -4 },
  { 241, 3, 4, 3, 0, -4 },
  { 243, 3, 7, 3, 0, -6 },
  { 246, 1, 8, 3, 1, -6 },
  { 247, 3, 7, 3, 0, -6 },
  { 250, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Condensed_MediumItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC8PT7B_H_
