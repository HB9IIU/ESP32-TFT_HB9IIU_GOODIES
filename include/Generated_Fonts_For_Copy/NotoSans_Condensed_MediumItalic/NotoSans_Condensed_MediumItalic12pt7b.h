#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC12PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0xA4, 0x82, 0xC0, 0x57, 0xAA, 0x14, 0x52, 0x9F, 0x29, 0x4F,
  0x94, 0xB0, 0x11, 0xD4, 0xA3, 0x1C, 0xBE, 0x22, 0x00, 0x45, 0x4A, 0xA5,
  0x8D, 0xFD, 0x4A, 0xAA, 0xCC, 0x10, 0xA2, 0x8C, 0x21, 0x59, 0xA6, 0xFC,
  0x5A, 0x12, 0x24, 0x44, 0x88, 0x8C, 0x40, 0x21, 0x11, 0x11, 0x32, 0x24,
  0x80, 0x27, 0x5F, 0xE2, 0x00, 0x22, 0xF2, 0x22, 0x6A, 0x00, 0xE0, 0x70,
  0x04, 0x10, 0x86, 0x10, 0x82, 0x10, 0xC0, 0x11, 0x52, 0x94, 0xE6, 0x7A,
  0x60, 0x17, 0xE2, 0x22, 0x44, 0x40, 0x33, 0x42, 0x11, 0x19, 0x98, 0xF0,
  0x32, 0x42, 0x13, 0x08, 0x62, 0xF0, 0x08, 0xC6, 0x55, 0x2B, 0xE2, 0x30,
  0x39, 0xD8, 0x87, 0x0C, 0x62, 0xF0, 0x1C, 0xC6, 0x10, 0x7B, 0x2C, 0xB6,
  0x70, 0x7C, 0x30, 0x86, 0x10, 0xC2, 0x10, 0xC0, 0x19, 0x52, 0xD3, 0x2A,
  0x33, 0x70, 0x13, 0x52, 0x95, 0xB4, 0x42, 0xE0, 0x2C, 0x01, 0x30, 0x13,
  0x00, 0x02, 0x44, 0x80, 0x16, 0x8C, 0x31, 0xF0, 0xF0, 0x83, 0x06, 0x6C,
  0x40, 0x32, 0xC6, 0x22, 0x21, 0x08, 0xC0, 0x0C, 0x32, 0x21, 0x5D, 0x55,
  0xA5, 0xAA, 0x94, 0x40, 0x38, 0x0C, 0x31, 0x45, 0x24, 0xF6, 0x51, 0xC4,
  0x30, 0xB2, 0x53, 0x71, 0x24, 0xB2, 0xF0, 0x3B, 0x71, 0x08, 0x42, 0x10,
  0xF0, 0x30, 0xB2, 0x51, 0x45, 0x14, 0xF6, 0xF0, 0x3C, 0x82, 0x10, 0x79,
  0x04, 0x30, 0xF0, 0x3C, 0x82, 0x10, 0x79, 0x04, 0x30, 0x80, 0x19, 0xBC,
  0x20, 0x9A, 0x28, 0xA6, 0xF0, 0x22, 0x4C, 0x92, 0x27, 0xC8, 0x93, 0x64,
  0x88, 0x72, 0x22, 0x64, 0x44, 0xE0, 0x08, 0x42, 0x31, 0x08, 0x46, 0x21,
  0x38, 0x26, 0x48, 0xA2, 0x87, 0x0A, 0x14, 0x6C, 0x88, 0x22, 0x24, 0x44,
  0x4C, 0xF0, 0x31, 0x98, 0xCC, 0xCA, 0x65, 0x52, 0xA9, 0x6D, 0xB4, 0x92,
  0x00, 0x22, 0x64, 0xCA, 0xB5, 0x4A, 0x93, 0x66, 0x8C, 0x31, 0xAC, 0xE3,
  0x8E, 0x28, 0xA4, 0xF0, 0x30, 0xB2, 0x53, 0x49, 0xC4, 0x30, 0x80, 0x31,
  0xAC, 0xE3, 0x8E, 0x28, 0xA6, 0xF0, 0x83, 0x00, 0x30, 0xB2, 0x53, 0x59,
  0xC5, 0x36, 0x88, 0x1B, 0x50, 0xC3, 0x08, 0x52, 0xF0, 0xF9, 0x18, 0x84,
  0x21, 0x18, 0x80, 0x45, 0x3C, 0xA2, 0x8A, 0x29, 0xA4, 0xE0, 0x8E, 0x29,
  0xA4, 0x92, 0x8A, 0x30, 0xC0, 0x89, 0xCC, 0xA6, 0x53, 0x4A, 0xA5, 0x73,
  0x31, 0x98, 0xC8, 0x00, 0x32, 0x28, 0x50, 0xC1, 0x83, 0x0A, 0x34, 0xC8,
  0x8C, 0xF4, 0xC6, 0x21, 0x08, 0x80, 0x7C, 0x21, 0x84, 0x21, 0x84, 0x20,
  0xF0, 0x32, 0x64, 0x44, 0x48, 0x88, 0xC0, 0xA5, 0x55, 0x40, 0x38, 0xC4,
  0x21, 0x08, 0x84, 0x21, 0x38, 0x11, 0x8C, 0x9C, 0x80, 0xF0, 0x90, 0x15,
  0xA4, 0x92, 0xCB, 0x67, 0x00, 0x21, 0x1C, 0xD4, 0xA5, 0x3B, 0xF0, 0x13,
  0x50, 0x8C, 0x61, 0xC0, 0x04, 0x11, 0x5A, 0x49, 0x2C, 0xB6, 0x70, 0x13,
  0x52, 0xEC, 0x61, 0xC0, 0x1C, 0x41, 0x0E, 0x20, 0x82, 0x08, 0x41, 0x04,
  0x20, 0x15, 0xA4, 0x92, 0xCB, 0x67, 0x04, 0x93, 0x80, 0x21, 0x1C, 0xD4,
  0xA5, 0x3B, 0x90, 0x24, 0xA4, 0x96, 0x80, 0x08, 0x42, 0x21, 0x08, 0x46,
  0x21, 0x09, 0x80, 0x20, 0x86, 0x52, 0x51, 0x87, 0x34, 0x90, 0x25, 0xA4,
  0x96, 0x80, 0x12, 0x6D, 0x49, 0x49, 0x4B, 0xD2, 0x92, 0x13, 0x52, 0x94,
  0xEE, 0x40, 0x13, 0x52, 0x9C, 0xED, 0xC0, 0x08, 0xD2, 0x49, 0x25, 0xB5,
  0x90, 0x43, 0x00, 0x15, 0xA4, 0x92, 0xCB, 0x67, 0x04, 0x10, 0x40, 0x17,
  0x44, 0x4C, 0x80, 0x35, 0x46, 0x33, 0xE0, 0x22, 0x54, 0x44, 0xC6, 0x6D,
  0x24, 0x92, 0xD9, 0xC0, 0x9A, 0xAC, 0xCC, 0xB7, 0x6B, 0x56, 0xCD, 0x92,
  0x00, 0x2C, 0xE1, 0x0C, 0x7B, 0x20, 0x24, 0xA2, 0x8C, 0x30, 0xC2, 0x18,
  0xC0, 0x72, 0x24, 0xCE, 0x09, 0x88, 0x42, 0x61, 0x08, 0x42, 0x18, 0xFF,
  0xF0, 0x20, 0x84, 0x21, 0x0C, 0xC4, 0x23, 0x30, 0xEC, 0x80,
};

const GFXglyph NotoSans_Condensed_MediumItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 4, 4, 4, 1, -9 },
  { 7, 6, 9, 6, 0, -9 },
  { 14, 5, 10, 5, 0, -9 },
  { 21, 7, 9, 8, 1, -9 },
  { 29, 6, 9, 6, 0, -9 },
  { 36, 2, 4, 3, 1, -9 },
  { 37, 4, 11, 3, 0, -9 },
  { 43, 4, 11, 3, -1, -9 },
  { 49, 5, 5, 5, 1, -9 },
  { 53, 4, 6, 6, 1, -7 },
  { 56, 3, 3, 3, -1, -1 },
  { 58, 3, 1, 3, 0, -4 },
  { 59, 2, 2, 3, 0, -2 },
  { 60, 6, 9, 4, -1, -9 },
  { 67, 5, 9, 5, 0, -9 },
  { 73, 4, 9, 5, 1, -9 },
  { 78, 5, 9, 5, 0, -9 },
  { 84, 5, 9, 5, 0, -9 },
  { 90, 5, 9, 5, 0, -9 },
  { 96, 5, 9, 5, 0, -9 },
  { 102, 6, 9, 5, 0, -9 },
  { 109, 6, 9, 5, 0, -9 },
  { 116, 5, 9, 5, 0, -9 },
  { 122, 5, 9, 5, 0, -9 },
  { 128, 3, 7, 3, 0, -7 },
  { 131, 4, 9, 3, -1, -7 },
  { 136, 4, 6, 6, 1, -7 },
  { 139, 4, 3, 6, 1, -6 },
  { 141, 5, 6, 6, 1, -7 },
  { 145, 5, 9, 4, 0, -9 },
  { 151, 8, 10, 8, 0, -9 },
  { 161, 6, 9, 6, -1, -9 },
  { 168, 6, 9, 6, 0, -9 },
  { 175, 5, 9, 6, 1, -9 },
  { 181, 6, 9, 6, 0, -9 },
  { 188, 6, 9, 5, 0, -9 },
  { 195, 6, 9, 5, 0, -9 },
  { 202, 6, 9, 7, 1, -9 },
  { 209, 7, 9, 7, 0, -9 },
  { 217, 4, 9, 4, 0, -9 },
  { 222, 5, 11, 3, -2, -9 },
  { 229, 7, 9, 6, 0, -9 },
  { 237, 4, 9, 5, 0, -9 },
  { 242, 9, 9, 9, 0, -9 },
  { 253, 7, 9, 7, 0, -9 },
  { 261, 6, 9, 7, 1, -9 },
  { 268, 6, 9, 6, 0, -9 },
  { 275, 6, 11, 7, 1, -9 },
  { 284, 6, 9, 6, 0, -9 },
  { 291, 5, 9, 5, 0, -9 },
  { 297, 5, 9, 5, 1, -9 },
  { 303, 6, 9, 7, 1, -9 },
  { 310, 6, 9, 6, 1, -9 },
  { 317, 9, 9, 9, 1, -9 },
  { 328, 7, 9, 5, -1, -9 },
  { 336, 5, 9, 5, 1, -9 },
  { 342, 6, 9, 5, 0, -9 },
  { 349, 4, 11, 3, 0, -9 },
  { 355, 2, 9, 4, 1, -9 },
  { 358, 5, 11, 3, -1, -9 },
  { 365, 5, 5, 5, 0, -9 },
  { 369, 4, 1, 4, -1, 1 },
  { 370, 2, 2, 3, 2, -9 },
  { 371, 6, 7, 6, 0, -7 },
  { 377, 5, 9, 6, 0, -9 },
  { 383, 5, 7, 4, 0, -7 },
  { 388, 6, 9, 6, 0, -9 },
  { 395, 5, 7, 5, 0, -7 },
  { 400, 6, 12, 3, -1, -9 },
  { 409, 6, 10, 6, 0, -7 },
  { 417, 5, 9, 6, 0, -9 },
  { 423, 3, 9, 3, 0, -9 },
  { 427, 5, 12, 3, -2, -9 },
  { 435, 6, 9, 5, 0, -9 },
  { 442, 3, 9, 3, 0, -9 },
  { 446, 8, 7, 8, 0, -7 },
  { 453, 5, 7, 6, 0, -7 },
  { 458, 5, 7, 6, 0, -7 },
  { 463, 6, 10, 6, -1, -7 },
  { 471, 6, 10, 6, 0, -7 },
  { 479, 4, 7, 4, 0, -7 },
  { 483, 4, 7, 4, 0, -7 },
  { 487, 4, 8, 3, 0, -8 },
  { 491, 6, 6, 6, 0, -6 },
  { 496, 4, 6, 5, 1, -6 },
  { 499, 7, 6, 7, 1, -6 },
  { 505, 6, 6, 5, -1, -6 },
  { 510, 6, 9, 5, -1, -6 },
  { 517, 4, 6, 4, 0, -6 },
  { 520, 5, 11, 4, 0, -9 },
  { 527, 1, 12, 5, 2, -9 },
  { 529, 5, 11, 4, -1, -9 },
  { 536, 5, 2, 6, 1, -5 },
};

const GFXfont NotoSans_Condensed_MediumItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC12PT7B_H_
