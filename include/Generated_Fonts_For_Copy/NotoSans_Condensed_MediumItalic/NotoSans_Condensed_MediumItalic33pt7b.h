#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC33PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x03, 0x83, 0xC1, 0xE0, 0x39, 0xDE, 0x77, 0x1D, 0xC7, 0x73, 0x9C, 0xE6,
  0x3B, 0x8E, 0xE3, 0x00, 0x00, 0xE3, 0x00, 0x61, 0x80, 0x31, 0xC0, 0x38,
  0xC0, 0x18, 0x60, 0x0C, 0x70, 0x0E, 0x30, 0x3F, 0xFF, 0x1F, 0xFF, 0x93,
  0x8E, 0x01, 0xC6, 0x00, 0xC3, 0x00, 0x63, 0x80, 0x71, 0x80, 0x30, 0xC1,
  0xFF, 0xFC, 0xFF, 0xFE, 0x0C, 0x30, 0x06, 0x38, 0x07, 0x18, 0x03, 0x8C,
  0x01, 0x8E, 0x00, 0xC7, 0x00, 0xE3, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x1F, 0xE0, 0x7F, 0xE1, 0xEB, 0x87, 0xB1, 0x0E, 0x60, 0x1C, 0xC0,
  0x39, 0x00, 0x7A, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xBC, 0x03, 0x38, 0x06, 0x70, 0x0C, 0xE4, 0x13, 0x8F, 0x6F, 0x1F, 0xFC,
  0x1F, 0xF0, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0E, 0x01,
  0xC1, 0xF0, 0x18, 0x3B, 0x83, 0x87, 0x38, 0x30, 0x73, 0x87, 0x06, 0x38,
  0xE0, 0xE3, 0x8C, 0x0E, 0x39, 0xC0, 0xE3, 0x18, 0x0C, 0x33, 0x80, 0xC7,
  0x73, 0xEC, 0x66, 0x7E, 0xEE, 0xEE, 0x7F, 0xCC, 0xC7, 0x79, 0xDC, 0x70,
  0x39, 0xC7, 0x03, 0x18, 0x60, 0x71, 0x86, 0x06, 0x18, 0xE0, 0xE3, 0x8E,
  0x1C, 0x38, 0xC1, 0xC1, 0x9C, 0x38, 0x1F, 0x87, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C,
  0x70, 0x0E, 0x70, 0x07, 0x78, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF0, 0x00,
  0xFC, 0x38, 0xEE, 0x38, 0xE7, 0x9C, 0xE1, 0xDE, 0x70, 0xEE, 0x78, 0x3F,
  0x38, 0x1F, 0x1C, 0x0F, 0x0F, 0x0F, 0x83, 0xDF, 0xE1, 0xFF, 0x70, 0x7E,
  0x3C, 0x3B, 0xDC, 0xE7, 0x39, 0x8C, 0xE0, 0x01, 0xC0, 0x60, 0x38, 0x1C,
  0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x00, 0xE0, 0x38,
  0x06, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0x80,
  0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x80, 0x70,
  0x07, 0x06, 0x70, 0xFE, 0x37, 0xFF, 0x0F, 0xF1, 0xF0, 0x3B, 0x07, 0xB8,
  0x71, 0xC2, 0x1C, 0x01, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x1E, 0x3C, 0x71, 0xE3, 0x87,
  0x1C, 0x70, 0xFF, 0xFE, 0xFE, 0x73, 0xFC, 0xE0, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1F, 0xC0,
  0xFF, 0x83, 0x8E, 0x1E, 0x38, 0x70, 0xF3, 0xC3, 0xCE, 0x0F, 0x78, 0x3D,
  0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0xF0, 0x3B, 0xC1, 0xEE, 0x07, 0xB8, 0x1C,
  0xE0, 0x73, 0x83, 0xCE, 0x0E, 0x38, 0x78, 0xF1, 0xC3, 0xFE, 0x07, 0xF8,
  0x0F, 0x80, 0x03, 0x83, 0xC3, 0xE7, 0xF7, 0xF7, 0xBB, 0x9C, 0x9E, 0x0E,
  0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07,
  0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x07,
  0x1E, 0x04, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F,
  0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0x60,
  0xF0, 0x81, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x88, 0x0F, 0x1E, 0xFC, 0x3F, 0xF0,
  0x7F, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1B, 0x80, 0x7E, 0x01, 0xDC, 0x03, 0x38, 0x0E, 0x70, 0x39, 0xE0, 0x63,
  0x81, 0xC7, 0x07, 0x0E, 0x1C, 0x1C, 0x30, 0x78, 0xFF, 0xFD, 0xFF, 0xFB,
  0xFF, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x3B, 0x00, 0x7F, 0x81, 0xFF, 0x81, 0x0F, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x88, 0x0F, 0x1E, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x7C, 0x07, 0xF0,
  0x3F, 0xC1, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xEF, 0x07, 0x7F, 0x1F, 0xFC, 0x78, 0x73, 0xC1, 0xEF, 0x07, 0xBC, 0x1C,
  0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x3C, 0xF1, 0xE1, 0xEF, 0x07, 0xFC,
  0x0F, 0xC0, 0x1F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x78, 0xF0, 0xE0, 0xE1, 0xC1, 0xC7, 0x83,
  0x87, 0x0E, 0x0E, 0x1C, 0x1E, 0xF0, 0x1F, 0xC0, 0x1E, 0x00, 0xFE, 0x03,
  0xDE, 0x0E, 0x1C, 0x38, 0x3C, 0x70, 0x39, 0xE0, 0x73, 0x80, 0xE7, 0x81,
  0xCF, 0x07, 0x0F, 0x3E, 0x1F, 0xF8, 0x0F, 0xE0, 0x01, 0xF0, 0x1F, 0xE0,
  0xFF, 0xC3, 0xC7, 0x1E, 0x1C, 0x70, 0x73, 0xC1, 0xCE, 0x07, 0x38, 0x1C,
  0xE0, 0x73, 0x83, 0xCF, 0x0F, 0x3E, 0xFC, 0x7F, 0xF0, 0xFB, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC3, 0xBF, 0x0F, 0xF8,
  0x3F, 0x80, 0x0E, 0x3C, 0x78, 0xF0, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x78, 0xF1, 0xE0, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x38,
  0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x1E,
  0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x00, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x80, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x78, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x78, 0x03, 0x00,
  0x10, 0x00, 0x0F, 0x83, 0xFE, 0x3F, 0xE3, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFE, 0x00, 0x7C, 0xF8, 0x07, 0x00,
  0xE0, 0x70, 0x03, 0x07, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x07, 0xE3, 0x38,
  0xFF, 0x19, 0x86, 0x38, 0xDC, 0x61, 0x86, 0xC7, 0x0C, 0x76, 0x38, 0xE3,
  0xF1, 0x87, 0x1B, 0x8C, 0x30, 0xDC, 0xE3, 0x8E, 0xC7, 0x1C, 0x66, 0x39,
  0xE7, 0x30, 0xFB, 0xF1, 0xC7, 0x9F, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x80, 0x3E, 0x3C, 0x00, 0xFF, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xEE, 0x00, 0xEE, 0x01, 0xCE, 0x01, 0xCE, 0x01, 0xCE, 0x03, 0x8E, 0x03,
  0x8E, 0x07, 0x0E, 0x07, 0x0E, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1C,
  0x0E, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0E, 0xF0,
  0x0F, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0x0F, 0x0F, 0x07, 0x0E,
  0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x0F, 0x1E, 0x1E, 0x1F, 0xFC, 0x1F,
  0xF0, 0x1F, 0xF8, 0x1C, 0x3C, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x1E, 0x38,
  0x1C, 0x78, 0x1C, 0x78, 0x3C, 0x70, 0x78, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xC0, 0x00, 0x7C, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0x82, 0x0F, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x10, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xE0, 0x07, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xE7, 0xE0, 0xF0, 0x78,
  0x78, 0x3C, 0x38, 0x1E, 0x1C, 0x07, 0x0E, 0x03, 0x8F, 0x01, 0xC7, 0x00,
  0xE3, 0x80, 0xF1, 0xC0, 0x78, 0xE0, 0x38, 0xF0, 0x1C, 0x70, 0x1E, 0x38,
  0x0F, 0x1C, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0x87, 0x0F, 0x83, 0xFF, 0x81,
  0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x7F,
  0xE0, 0xFF, 0x81, 0xFF, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F,
  0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xC1,
  0xFF, 0x03, 0xFE, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0xFC,
  0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xF0, 0x61, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x0F, 0xCE,
  0x0F, 0xE7, 0x07, 0xF3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E,
  0x38, 0x0F, 0x1E, 0x07, 0x0F, 0x03, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xE0, 0x07, 0x80, 0xE0, 0xE0, 0x3C, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0xF0,
  0x1C, 0x1E, 0x03, 0x83, 0x80, 0xF0, 0x70, 0x1C, 0x0E, 0x03, 0x83, 0xC0,
  0x70, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x38, 0x0E, 0x0F, 0x01,
  0xC1, 0xC0, 0x78, 0x38, 0x0F, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x3C, 0x07,
  0x07, 0x01, 0xE0, 0xE0, 0x38, 0x1C, 0x07, 0x07, 0x80, 0xE0, 0x07, 0xF8,
  0x7F, 0xC1, 0xFC, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x27, 0xC0, 0xFE, 0x03, 0xF0, 0x02, 0x00, 0x00, 0x07, 0x81, 0xC1, 0xC0,
  0xE0, 0x70, 0x78, 0x1C, 0x3C, 0x0F, 0x0E, 0x03, 0x87, 0x00, 0xE3, 0xC0,
  0x39, 0xE0, 0x0E, 0x70, 0x07, 0xB8, 0x01, 0xDE, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x03, 0xCE, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x3C,
  0x03, 0x87, 0x01, 0xE1, 0xC0, 0x70, 0x78, 0x1C, 0x1E, 0x07, 0x03, 0x83,
  0xC0, 0xF0, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xFF, 0xDF, 0xFF, 0xFE, 0x07,
  0xC0, 0x0F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xEE, 0x0F,
  0xC0, 0xFE, 0x1D, 0xC1, 0xDC, 0x1C, 0xC1, 0xDC, 0x1C, 0xC3, 0x9C, 0x1C,
  0xC3, 0x9C, 0x1C, 0xC7, 0x3C, 0x38, 0xE7, 0x38, 0x38, 0xEE, 0x38, 0x38,
  0xEE, 0x38, 0x38, 0xEC, 0x38, 0x78, 0xFC, 0x78, 0x70, 0xF8, 0x70, 0x70,
  0xF8, 0x70, 0x70, 0xF0, 0x70, 0x70, 0xF0, 0x70, 0xE0, 0xF0, 0xE0, 0x07,
  0x80, 0x70, 0x78, 0x07, 0x07, 0x80, 0xF0, 0x7C, 0x0E, 0x0F, 0xC0, 0xE0,
  0xFC, 0x0E, 0x0F, 0xC0, 0xE0, 0xEE, 0x1C, 0x0E, 0xE1, 0xC1, 0xCE, 0x1C,
  0x1C, 0xE1, 0xC1, 0xC6, 0x1C, 0x1C, 0x73, 0x81, 0xC7, 0x38, 0x38, 0x73,
  0x83, 0x87, 0x38, 0x38, 0x3B, 0x83, 0x83, 0xF0, 0x78, 0x3F, 0x07, 0x03,
  0xF0, 0x70, 0x1F, 0x07, 0x01, 0xE0, 0x70, 0x1E, 0x0E, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0xFF, 0x01, 0xFF, 0xC0, 0xF1, 0xF0, 0xF0, 0x78, 0xF0, 0x1C,
  0x70, 0x0E, 0x78, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xDE, 0x00, 0xEF, 0x00,
  0x77, 0x00, 0x7B, 0x80, 0x3D, 0xC0, 0x1D, 0xE0, 0x0E, 0xF0, 0x0F, 0x78,
  0x07, 0x1C, 0x07, 0x8E, 0x03, 0x87, 0x83, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0,
  0x3F, 0x80, 0x07, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0x1F, 0x0F, 0x0F,
  0x0F, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x0F, 0x1E, 0x0E, 0x1C, 0x1E,
  0x1C, 0x3E, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x01, 0xFF, 0xC0, 0xF1, 0xF0, 0xF0,
  0x78, 0xF0, 0x1C, 0x70, 0x0E, 0x78, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xDE,
  0x00, 0xEF, 0x00, 0x77, 0x00, 0x7B, 0x80, 0x3D, 0xC0, 0x1D, 0xE0, 0x0E,
  0xF0, 0x0F, 0x78, 0x07, 0x1C, 0x07, 0x8E, 0x03, 0x87, 0x83, 0xC3, 0xFF,
  0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xFC, 0x07, 0xFE,
  0x07, 0x1E, 0x0F, 0x0F, 0x0E, 0x0F, 0x0E, 0x0F, 0x0E, 0x0F, 0x0E, 0x0F,
  0x1E, 0x0E, 0x1C, 0x1E, 0x1C, 0x7C, 0x1F, 0xF8, 0x1F, 0xE0, 0x3C, 0xE0,
  0x38, 0xE0, 0x38, 0xF0, 0x38, 0xF0, 0x38, 0x70, 0x78, 0x70, 0x70, 0x78,
  0x70, 0x78, 0x70, 0x38, 0xF0, 0x3C, 0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8,
  0x78, 0x61, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x88, 0x1E, 0x1F, 0xFC, 0x3F,
  0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0x1C, 0x07, 0x8E, 0x03, 0xC7, 0x01,
  0xC7, 0x80, 0xE3, 0xC0, 0x71, 0xC0, 0x78, 0xE0, 0x38, 0x70, 0x1C, 0x78,
  0x0E, 0x3C, 0x0F, 0x1C, 0x07, 0x8E, 0x03, 0x87, 0x01, 0xC7, 0x80, 0xE3,
  0x80, 0xF1, 0xC0, 0x78, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x1E, 0x1C, 0x0E,
  0x0E, 0x0F, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0xE0, 0x0F, 0xC0,
  0x3F, 0x80, 0x77, 0x01, 0xEE, 0x03, 0x9C, 0x0F, 0x38, 0x1C, 0x70, 0x38,
  0xE0, 0xE1, 0xC1, 0xC3, 0x87, 0x87, 0x0E, 0x0E, 0x3C, 0x1C, 0x70, 0x38,
  0xE0, 0x73, 0x80, 0xE7, 0x00, 0xDC, 0x01, 0xB8, 0x03, 0x60, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0E,
  0xE0, 0x38, 0x0E, 0xE0, 0x78, 0x1C, 0xE0, 0x78, 0x1C, 0xE0, 0xF8, 0x3C,
  0xE0, 0xF8, 0x38, 0xE1, 0xD8, 0x38, 0xE1, 0xD8, 0x70, 0xE1, 0x98, 0x70,
  0xE3, 0x98, 0xF0, 0xE3, 0x98, 0xE0, 0xE7, 0x18, 0xE0, 0xE7, 0x19, 0xC0,
  0xE6, 0x19, 0xC0, 0xEE, 0x3B, 0xC0, 0xEE, 0x3B, 0x80, 0xFC, 0x3B, 0x80,
  0xFC, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00,
  0xF0, 0x3E, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x0E,
  0x0F, 0x01, 0xC1, 0xC0, 0x3C, 0x70, 0x03, 0x9E, 0x00, 0x73, 0x80, 0x0E,
  0xE0, 0x01, 0xDC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0x38, 0x01, 0xE7,
  0x00, 0x38, 0xE0, 0x0E, 0x1C, 0x03, 0xC3, 0xC0, 0x70, 0x78, 0x1E, 0x07,
  0x07, 0x80, 0xE0, 0xE0, 0x3F, 0x80, 0xEE, 0x07, 0xBC, 0x1C, 0x70, 0xE1,
  0xC3, 0x87, 0x1C, 0x1C, 0xF0, 0x73, 0x81, 0xDE, 0x07, 0x70, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x08, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xE1, 0x87, 0x1C,
  0x71, 0xC7, 0x1C, 0x70, 0xC3, 0x8E, 0x38, 0xE3, 0x8E, 0x18, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xE0, 0xFC, 0x00, 0x00,
  0xC0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3F, 0x00, 0xEE, 0x01, 0xDC,
  0x07, 0x1C, 0x0C, 0x38, 0x38, 0x70, 0x60, 0x71, 0xC0, 0xE7, 0x01, 0xDE,
  0x01, 0xC0, 0xFF, 0xFF, 0xFE, 0xF3, 0x9C, 0x71, 0x80, 0x07, 0xCE, 0x1F,
  0xB8, 0x7F, 0xF1, 0xE1, 0xE3, 0x83, 0xCF, 0x07, 0x1C, 0x0E, 0x38, 0x1C,
  0xF0, 0x39, 0xE0, 0xF3, 0x81, 0xC7, 0x03, 0x8E, 0x0F, 0x1C, 0x1E, 0x3C,
  0x7C, 0x7D, 0xF0, 0x7E, 0xE0, 0x79, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x3C, 0x0F, 0xFC,
  0x3B, 0xF8, 0x7C, 0x78, 0xF0, 0xF1, 0xC0, 0xE3, 0x83, 0xCF, 0x07, 0x9C,
  0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0xF3, 0xC1, 0xC7, 0x83, 0x8F, 0x0E,
  0x1F, 0x3C, 0x77, 0xF0, 0xE7, 0xC0, 0x03, 0xE0, 0xFF, 0x1F, 0xE3, 0xC0,
  0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0xB8, 0x7F, 0x83, 0xF8, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x07,
  0xDE, 0x0F, 0xFC, 0x1F, 0xFC, 0x3C, 0x3C, 0x38, 0x3C, 0x78, 0x38, 0x70,
  0x38, 0x70, 0x38, 0xF0, 0x38, 0xF0, 0x78, 0xE0, 0x70, 0xE0, 0x70, 0xE0,
  0xF0, 0xE0, 0xF0, 0xE1, 0xF0, 0xF3, 0xE0, 0x7F, 0xE0, 0x3C, 0xE0, 0x03,
  0xE0, 0x7F, 0x87, 0xFC, 0x78, 0x73, 0x83, 0xBC, 0x39, 0xC1, 0xCE, 0x7C,
  0xFF, 0xC7, 0xFC, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x18, 0x7F, 0xC1, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x40,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xE7, 0x07, 0xFE, 0x0F, 0xFE, 0x1E, 0x1E,
  0x1C, 0x1E, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x78, 0x1C, 0x78, 0x3C,
  0x70, 0x38, 0x70, 0x38, 0x70, 0x78, 0x70, 0x78, 0x70, 0xF8, 0x7D, 0xF0,
  0x3F, 0x70, 0x3E, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0,
  0x81, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7E, 0x00, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x9E, 0x0F, 0xFC,
  0x77, 0xF1, 0xF1, 0xC7, 0x87, 0x1C, 0x1C, 0x70, 0x73, 0xC1, 0xCE, 0x07,
  0x38, 0x3C, 0xE0, 0xE3, 0x83, 0x9E, 0x0E, 0x70, 0x79, 0xC1, 0xC7, 0x07,
  0x1C, 0x1C, 0xE0, 0x70, 0x02, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x78,
  0x70, 0x70, 0x70, 0xF0, 0xE0, 0x00, 0x20, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0xFC, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x07, 0x0E, 0x1C,
  0x3C, 0x70, 0x71, 0xE0, 0xE7, 0x81, 0xDE, 0x03, 0xB8, 0x0E, 0xE0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x7B, 0x80, 0xE7, 0x03, 0x8E, 0x07, 0x1E, 0x0E, 0x1C,
  0x1C, 0x38, 0x38, 0x78, 0xE0, 0xF0, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70,
  0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70,
  0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x00, 0x0C,
  0x78, 0xF8, 0x37, 0xF7, 0xF1, 0xFF, 0xFF, 0xC7, 0xC7, 0xC7, 0x1E, 0x1E,
  0x1C, 0x70, 0x70, 0x71, 0xC1, 0xC1, 0xCF, 0x0F, 0x0F, 0x38, 0x38, 0x38,
  0xE0, 0xE0, 0xE3, 0x83, 0x83, 0x8E, 0x0E, 0x0E, 0x78, 0x78, 0x79, 0xC1,
  0xC1, 0xC7, 0x07, 0x07, 0x1C, 0x1C, 0x1C, 0x70, 0x70, 0x73, 0x83, 0xC3,
  0xC0, 0x0C, 0x78, 0x37, 0xF1, 0xDF, 0xC7, 0xC7, 0x1E, 0x1C, 0x70, 0x71,
  0xC1, 0xCF, 0x07, 0x38, 0x1C, 0xE0, 0xF3, 0x83, 0x8E, 0x0E, 0x78, 0x39,
  0xC1, 0xE7, 0x07, 0x1C, 0x1C, 0xF0, 0x73, 0x81, 0xC0, 0x07, 0xE0, 0x7F,
  0x87, 0xFE, 0x78, 0x73, 0x83, 0xBC, 0x1D, 0xC0, 0xEE, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0xC0, 0xEE, 0x07, 0x70, 0x7B, 0xC3, 0x8F, 0x7C, 0x7F,
  0xC1, 0xF8, 0x00, 0x07, 0x3C, 0x06, 0xFE, 0x06, 0xFE, 0x0F, 0x8F, 0x0F,
  0x0F, 0x0E, 0x07, 0x0E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x0E, 0x1C,
  0x0E, 0x1C, 0x1E, 0x3C, 0x1C, 0x3C, 0x1C, 0x3C, 0x3C, 0x3E, 0xF8, 0x3F,
  0xF0, 0x73, 0xE0, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0xCE, 0x1F, 0xD8, 0x7F,
  0xF1, 0xE1, 0xE3, 0x83, 0xCF, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0xF0, 0x39,
  0xE0, 0xF3, 0x81, 0xC7, 0x03, 0x8E, 0x0F, 0x1C, 0x1E, 0x38, 0x7C, 0x7D,
  0xF0, 0x7E, 0xE0, 0xF9, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x70, 0xDF, 0x1D,
  0xE1, 0xF0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x07,
  0xE1, 0xFF, 0x1E, 0xE3, 0xC2, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x83, 0xCE, 0xF8, 0xFF,
  0x8F, 0xF0, 0x06, 0x07, 0x03, 0x81, 0x83, 0xFB, 0xFD, 0xFE, 0x78, 0x38,
  0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1E,
  0x8F, 0xC3, 0xE0, 0x1C, 0x1C, 0x70, 0x73, 0xC1, 0xCE, 0x0F, 0x38, 0x38,
  0xE0, 0xE3, 0x83, 0x9C, 0x0E, 0x70, 0x79, 0xC1, 0xC7, 0x07, 0x3C, 0x1C,
  0xE0, 0xF3, 0x83, 0xCE, 0x1E, 0x3F, 0xF8, 0xFE, 0xE1, 0xF3, 0x80, 0xE0,
  0x7F, 0x03, 0xB8, 0x3D, 0xC1, 0xCE, 0x1E, 0x70, 0xE3, 0x87, 0x1C, 0x70,
  0xE3, 0x87, 0x38, 0x39, 0xC1, 0xDC, 0x0E, 0xE0, 0x7E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x00, 0xE0, 0xF0, 0x7E, 0x0F, 0x0E, 0xE1, 0xF0,
  0xEE, 0x1F, 0x1E, 0xE3, 0xF1, 0xCE, 0x3F, 0x1C, 0xE3, 0x73, 0x8E, 0x77,
  0x38, 0xE6, 0x77, 0x0E, 0xE7, 0x70, 0xEE, 0x77, 0x0E, 0xC6, 0xE0, 0xFC,
  0x6E, 0x0F, 0x86, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0x80, 0xF0, 0x78, 0x0F,
  0x07, 0x80, 0x1E, 0x0F, 0x0E, 0x1E, 0x0E, 0x1C, 0x0F, 0x38, 0x07, 0x78,
  0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1C, 0xE0, 0x38, 0xE0, 0x78, 0xE0, 0x70, 0xF0,
  0xE0, 0x70, 0x07, 0x03, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x1C, 0x1C, 0x07,
  0x07, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x70, 0x03, 0x1C, 0x00, 0xCE,
  0x00, 0x33, 0x80, 0x0D, 0xC0, 0x03, 0x70, 0x00, 0xDC, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01,
  0xE0, 0x0F, 0xF8, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x10, 0x1F, 0x03, 0xF0,
  0x3C, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1C, 0x0F, 0xC0, 0xF0, 0x0F, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7C, 0x03,
  0xC0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x02, 0x00, 0x1E, 0x01, 0xF8, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xFC, 0x03,
  0xC0, 0x3E, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x00, 0x00,
  0x78, 0x0F, 0xF8, 0xFF, 0xFF, 0x07, 0xF8, 0x04, 0x00,
};

const GFXglyph NotoSans_Condensed_MediumItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 24, 8, 0, -24 },
  { 28, 10, 9, 12, 3, -24 },
  { 40, 17, 24, 17, 0, -24 },
  { 91, 15, 27, 15, 0, -25 },
  { 142, 20, 24, 23, 2, -24 },
  { 202, 17, 24, 17, 0, -24 },
  { 253, 5, 9, 7, 3, -24 },
  { 259, 10, 29, 9, 1, -24 },
  { 296, 10, 29, 9, -2, -24 },
  { 333, 12, 13, 14, 3, -25 },
  { 353, 13, 16, 16, 2, -20 },
  { 379, 7, 8, 8, -2, -4 },
  { 386, 8, 3, 9, 1, -10 },
  { 389, 5, 4, 8, 0, -4 },
  { 392, 16, 24, 12, -2, -24 },
  { 440, 14, 24, 15, 1, -24 },
  { 482, 9, 24, 15, 4, -24 },
  { 509, 16, 24, 15, -1, -24 },
  { 557, 15, 24, 15, 0, -24 },
  { 602, 15, 24, 15, 0, -24 },
  { 647, 15, 24, 15, 0, -24 },
  { 692, 14, 24, 15, 1, -24 },
  { 734, 15, 24, 15, 1, -24 },
  { 779, 15, 24, 15, 0, -24 },
  { 824, 14, 24, 15, 0, -24 },
  { 866, 7, 18, 8, 0, -18 },
  { 882, 9, 22, 8, -2, -18 },
  { 907, 13, 16, 16, 2, -20 },
  { 933, 13, 9, 16, 2, -16 },
  { 948, 13, 16, 16, 2, -20 },
  { 974, 12, 24, 11, 1, -24 },
  { 1010, 21, 27, 22, 1, -24 },
  { 1081, 16, 24, 16, -2, -24 },
  { 1129, 16, 24, 16, 0, -24 },
  { 1177, 16, 24, 15, 1, -24 },
  { 1225, 17, 24, 18, 0, -24 },
  { 1276, 15, 24, 14, 0, -24 },
  { 1321, 15, 24, 13, 0, -24 },
  { 1366, 17, 24, 18, 2, -24 },
  { 1417, 19, 24, 18, 0, -24 },
  { 1474, 13, 24, 10, -1, -24 },
  { 1513, 14, 31, 8, -5, -24 },
  { 1568, 18, 24, 15, 0, -24 },
  { 1622, 11, 24, 13, 0, -24 },
  { 1655, 24, 24, 24, 0, -24 },
  { 1727, 20, 24, 19, 0, -24 },
  { 1787, 17, 24, 19, 1, -24 },
  { 1838, 16, 24, 15, 0, -24 },
  { 1886, 17, 30, 19, 1, -24 },
  { 1950, 16, 24, 16, 0, -24 },
  { 1998, 15, 24, 14, 0, -24 },
  { 2043, 13, 24, 13, 3, -24 },
  { 2082, 17, 24, 18, 2, -24 },
  { 2133, 15, 24, 15, 3, -24 },
  { 2178, 24, 24, 24, 3, -24 },
  { 2250, 19, 24, 14, -2, -24 },
  { 2307, 14, 24, 14, 3, -24 },
  { 2349, 16, 24, 13, -1, -24 },
  { 2397, 13, 29, 10, -1, -24 },
  { 2445, 6, 24, 12, 3, -24 },
  { 2463, 12, 29, 10, -2, -24 },
  { 2507, 15, 14, 15, 0, -24 },
  { 2534, 12, 2, 11, -3, 3 },
  { 2537, 5, 5, 9, 5, -25 },
  { 2541, 15, 18, 16, 1, -18 },
  { 2575, 15, 25, 16, 0, -25 },
  { 2622, 12, 18, 12, 1, -18 },
  { 2649, 16, 25, 16, 1, -25 },
  { 2699, 13, 18, 14, 1, -18 },
  { 2729, 17, 33, 9, -4, -25 },
  { 2800, 16, 26, 16, 0, -18 },
  { 2852, 14, 25, 16, 0, -25 },
  { 2896, 8, 25, 7, 0, -25 },
  { 2921, 12, 33, 7, -4, -25 },
  { 2971, 15, 25, 14, 0, -25 },
  { 3018, 9, 25, 7, 0, -25 },
  { 3047, 22, 18, 23, 0, -18 },
  { 3097, 14, 18, 16, 0, -18 },
  { 3129, 13, 18, 15, 1, -18 },
  { 3159, 16, 26, 16, -1, -18 },
  { 3211, 15, 26, 16, 1, -18 },
  { 3260, 12, 18, 11, 0, -18 },
  { 3287, 12, 18, 12, 0, -18 },
  { 3314, 9, 22, 9, 1, -22 },
  { 3339, 14, 18, 16, 1, -18 },
  { 3371, 13, 18, 13, 2, -18 },
  { 3401, 20, 18, 20, 2, -18 },
  { 3446, 16, 18, 13, -1, -18 },
  { 3482, 18, 26, 13, -3, -18 },
  { 3541, 13, 18, 11, -1, -18 },
  { 3571, 12, 29, 11, 1, -24 },
  { 3615, 2, 33, 14, 6, -25 },
  { 3624, 13, 29, 11, -2, -24 },
  { 3672, 13, 5, 16, 2, -14 },
};

const GFXfont NotoSans_Condensed_MediumItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC33PT7B_H_
