#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC38PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x01, 0xE0, 0xF8, 0x3E, 0x07, 0x00, 0x79,
  0xEF, 0x3D, 0xC7, 0xB8, 0xE7, 0x1D, 0xE3, 0xB8, 0x77, 0x1C, 0xE3, 0x9C,
  0x70, 0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00, 0x61, 0xC0, 0x0E, 0x1C, 0x00,
  0xE1, 0x80, 0x0E, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x30, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x03, 0x87, 0x00, 0x38, 0xE0, 0x03, 0x0E, 0x00, 0x70, 0xE0,
  0x07, 0x0C, 0x00, 0x71, 0xC0, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF,
  0x81, 0xC3, 0x80, 0x1C, 0x30, 0x01, 0xC7, 0x00, 0x18, 0x70, 0x03, 0x87,
  0x00, 0x38, 0xE0, 0x03, 0x0E, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x0F, 0x80, 0x1F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC,
  0x1E, 0x62, 0x0E, 0x20, 0x07, 0x30, 0x03, 0x98, 0x01, 0xEC, 0x00, 0xFE,
  0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x5E, 0x00,
  0x67, 0x80, 0x33, 0xC0, 0x19, 0xE0, 0x0C, 0xF2, 0x04, 0x70, 0xC6, 0x78,
  0x7F, 0xF8, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x1F, 0x00, 0x70, 0x7F, 0x01, 0xC1,
  0xEE, 0x07, 0x03, 0x8E, 0x0E, 0x0E, 0x1C, 0x38, 0x1C, 0x38, 0x70, 0x38,
  0x61, 0xC0, 0x71, 0xC7, 0x01, 0xC3, 0x8E, 0x03, 0x87, 0x38, 0x07, 0x0E,
  0x71, 0x8E, 0x39, 0xCF, 0xDC, 0x73, 0xBF, 0xB9, 0xCE, 0x73, 0xBF, 0xB9,
  0xC7, 0x7E, 0x73, 0x8E, 0x21, 0xCE, 0x1C, 0x03, 0x9C, 0x38, 0x0E, 0x38,
  0x70, 0x38, 0x71, 0xC0, 0x71, 0xC3, 0x81, 0xC3, 0x87, 0x03, 0x87, 0x0C,
  0x0E, 0x0E, 0x38, 0x38, 0x0E, 0xE0, 0x70, 0x1F, 0xC1, 0xC0, 0x1F, 0x00,
  0x00, 0x10, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x01, 0xE7, 0x80, 0x38, 0x70,
  0x07, 0x0E, 0x01, 0xE1, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xC0,
  0x0E, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00,
  0xFF, 0x0F, 0x3E, 0xF1, 0xE7, 0x9E, 0x39, 0xE1, 0xEF, 0x38, 0x3D, 0xCF,
  0x03, 0xF9, 0xE0, 0x7E, 0x3C, 0x07, 0x87, 0x81, 0xF0, 0xF8, 0x7F, 0x0F,
  0xFF, 0xE1, 0xFF, 0x9E, 0x0F, 0xE3, 0xE0, 0x7B, 0xDE, 0xE7, 0x3B, 0x9C,
  0xE7, 0x00, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x38, 0x07, 0x80, 0xF0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x87,
  0x0E, 0x30, 0x7D, 0x8F, 0xFF, 0xE1, 0xFF, 0x0F, 0x00, 0xFC, 0x0E, 0x61,
  0xF3, 0x87, 0x1E, 0x10, 0x70, 0x02, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1F, 0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x78,
  0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x33, 0xDF, 0xF7, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x20, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0x8E, 0x0F, 0x0F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78,
  0x0E, 0x78, 0x0E, 0x78, 0x1E, 0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0x71,
  0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x01, 0xE0, 0x7C, 0x1F, 0x8F,
  0xE3, 0xFC, 0xFF, 0xBC, 0xF3, 0x1E, 0x43, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x3F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x03, 0x87, 0xC0, 0x80, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x02, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x00, 0x30, 0x01, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x60, 0xF8, 0x20,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0xC0, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0x70, 0x03,
  0xF8, 0x03, 0xBC, 0x01, 0xDC, 0x01, 0xCE, 0x01, 0xCF, 0x00, 0xE7, 0x80,
  0xE3, 0x80, 0xE1, 0xC0, 0xF1, 0xE0, 0x70, 0xF0, 0x70, 0x78, 0x70, 0x38,
  0x38, 0x1C, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0x67, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE2, 0x01, 0xF1, 0x81,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x3F, 0x03, 0xBF, 0xC3,
  0xFF, 0xE1, 0xF8, 0xF0, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x0F, 0x3C, 0x07,
  0x9E, 0x03, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF0, 0xE0, 0xF0, 0x78,
  0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0x3F, 0xFF,
  0x3F, 0xFF, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x10, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x78,
  0x78, 0x78, 0x1C, 0x3C, 0x0E, 0x1E, 0x07, 0x0F, 0x07, 0x87, 0x83, 0x83,
  0xC3, 0xC0, 0xF7, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xF0,
  0x3E, 0x3C, 0x1E, 0x1E, 0x1E, 0x07, 0x8E, 0x03, 0xCF, 0x01, 0xE7, 0x80,
  0xF3, 0xC0, 0x79, 0xE0, 0x38, 0x78, 0x3C, 0x3F, 0xFC, 0x0F, 0xFC, 0x03,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xF8,
  0xF0, 0x78, 0x38, 0x78, 0x1E, 0x3C, 0x0F, 0x1C, 0x07, 0x8E, 0x03, 0xCF,
  0x01, 0xE7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF8, 0x78, 0xFC, 0x3F, 0xFE,
  0x0F, 0xEE, 0x03, 0xE7, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xE0, 0x00, 0x02, 0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x78, 0xF8, 0xF8, 0xF0, 0x00,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x07, 0x81, 0xE0, 0x70,
  0x3C, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x38, 0x00, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x01, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x1F, 0x00, 0x0E, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3C, 0x01, 0xF8,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x00, 0xF0, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x7F, 0x8F, 0xFE, 0x3F, 0xF1, 0x07, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x00, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xF8, 0x3C, 0x01, 0xE0, 0x1E, 0x03,
  0x80, 0x0E, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1C, 0x0F, 0x87, 0x1C,
  0x3F, 0xE3, 0x38, 0x7D, 0xC3, 0x38, 0x71, 0xC3, 0x30, 0xE1, 0xC7, 0x70,
  0xC1, 0x87, 0x71, 0xC3, 0x87, 0x71, 0xC3, 0x87, 0x61, 0x83, 0x86, 0xE3,
  0x87, 0x0E, 0xE3, 0x87, 0x0E, 0xE3, 0x87, 0x1C, 0xE3, 0x8F, 0x1C, 0xE1,
  0xFB, 0xF8, 0xE1, 0xFB, 0xF0, 0xE0, 0xE1, 0xC0, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x01, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x07, 0x38, 0x03, 0xCE, 0x00,
  0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x38, 0x07, 0x0E, 0x03, 0xC3, 0x80, 0xE0,
  0xE0, 0x78, 0x38, 0x1E, 0x0E, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF8,
  0x78, 0x0E, 0x1E, 0x03, 0x8F, 0x00, 0xE3, 0xC0, 0x39, 0xE0, 0x0E, 0x78,
  0x03, 0xBC, 0x00, 0xFF, 0x00, 0x3C, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xC0, 0x78, 0x78,
  0x0F, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0xFF, 0x81, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0x8F, 0xC0, 0xF0, 0x78, 0x1C, 0x07, 0x87, 0x80,
  0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0x80, 0xF0, 0x70, 0x1E, 0x1E, 0x07,
  0xC3, 0xC1, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xC1, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x10, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x78, 0x7E,
  0x07, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0xF0, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xE0, 0x0F, 0x1E, 0x01, 0xE1, 0xE0,
  0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1C, 0x03, 0xE3, 0xC0, 0x3C, 0x3C,
  0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x0F, 0x83, 0x81, 0xF0, 0x78, 0x3E, 0x07,
  0x8F, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F,
  0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x20, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xC0,
  0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x03, 0xFC, 0xF0,
  0x3F, 0xCF, 0x03, 0xF8, 0xF0, 0x3F, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F,
  0x00, 0x70, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x80, 0xF0,
  0x7C, 0x0E, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xC0,
  0x3C, 0x0F, 0x00, 0xE0, 0x38, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78,
  0x1E, 0x01, 0xE0, 0x78, 0x07, 0x01, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C,
  0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0x80, 0x70, 0x1C, 0x03, 0xC0, 0xF0, 0x0F, 0x03,
  0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0x80, 0xE0, 0x1E, 0x07, 0x80,
  0x78, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1C, 0x0F, 0x00, 0xF0,
  0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x7F, 0x80, 0x7F,
  0x00, 0xFE, 0x00, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x80, 0xE0, 0x78, 0x0F,
  0x07, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xC0, 0x1C, 0x3C, 0x00, 0xE3, 0xC0,
  0x0F, 0x3E, 0x00, 0x79, 0xE0, 0x03, 0xDE, 0x00, 0x1D, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xEE, 0x00, 0x1E, 0x78, 0x01,
  0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0x78, 0x03, 0x83, 0xC0, 0x1C, 0x1E,
  0x01, 0xE0, 0xF0, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x3C,
  0x07, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0F, 0x01, 0x7F, 0xF3, 0xFF, 0xBF, 0xFC, 0x03, 0xE0,
  0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0xFF,
  0x01, 0xDC, 0x0F, 0xF0, 0x3D, 0xC0, 0xF7, 0x03, 0xBC, 0x0E, 0x70, 0x3B,
  0xC0, 0xE7, 0x07, 0x3C, 0x1E, 0x70, 0x73, 0x81, 0xE7, 0x0E, 0x38, 0x1E,
  0x70, 0xE7, 0x81, 0xC7, 0x1C, 0x78, 0x1C, 0x71, 0xC7, 0x83, 0xC7, 0x3C,
  0x70, 0x3C, 0x73, 0x8F, 0x03, 0x87, 0x78, 0xF0, 0x38, 0x77, 0x0F, 0x03,
  0x87, 0xF0, 0xE0, 0x78, 0x7E, 0x0E, 0x07, 0x87, 0xE1, 0xE0, 0x70, 0x7C,
  0x1E, 0x07, 0x07, 0xC1, 0xE0, 0xF0, 0x38, 0x1C, 0x00, 0x03, 0xE0, 0x1E,
  0x07, 0xC0, 0x3C, 0x0F, 0x80, 0x70, 0x3F, 0x00, 0xE0, 0x7E, 0x03, 0xC0,
  0xFE, 0x07, 0x81, 0xFC, 0x0F, 0x07, 0xB8, 0x1C, 0x0F, 0x70, 0x38, 0x1E,
  0xF0, 0xF0, 0x39, 0xE1, 0xE0, 0x71, 0xC3, 0xC1, 0xE3, 0x87, 0x03, 0xC7,
  0x0E, 0x07, 0x8F, 0x3C, 0x0E, 0x1E, 0x78, 0x1C, 0x1C, 0xE0, 0x78, 0x39,
  0xC0, 0xF0, 0x7B, 0x81, 0xC0, 0xFF, 0x03, 0x80, 0xFE, 0x07, 0x01, 0xF8,
  0x1E, 0x03, 0xF0, 0x3C, 0x07, 0xE0, 0x70, 0x07, 0xC0, 0xE0, 0x0F, 0x83,
  0xC0, 0x1E, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF,
  0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0xC7, 0x80, 0x79, 0xF0, 0x0F, 0x3C, 0x01,
  0xE7, 0x80, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F,
  0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0xC0, 0xF0,
  0x7C, 0x7C, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x1E, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x70, 0x1C, 0x3C, 0x07, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x38,
  0x1E, 0x1E, 0x0F, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xF8, 0x3C, 0x1E,
  0x07, 0xC7, 0x80, 0x79, 0xF0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3D, 0xE0,
  0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xCF, 0x00,
  0x79, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0xC0, 0xF0, 0x7C, 0x7E, 0x0F, 0xFF,
  0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x1E, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x3C,
  0x1C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x78, 0x38, 0x3E, 0x1E,
  0x3F, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x1C, 0x78, 0x0F, 0x1E,
  0x03, 0xC3, 0x80, 0xF0, 0xF0, 0x38, 0x3C, 0x0E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x07, 0x8F, 0x01, 0xF0, 0x00, 0x10, 0x00,
  0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0xF8, 0x30, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF1, 0x00, 0xF0,
  0xE0, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0xF0, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01,
  0xE1, 0xE0, 0x1C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0,
  0x3C, 0x38, 0x03, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78,
  0x07, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F,
  0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x87, 0xC0,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x03, 0xFC, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x3C, 0x70, 0x0F, 0x1C, 0x07, 0x87, 0x01, 0xE1,
  0xC0, 0x70, 0x70, 0x3C, 0x1C, 0x0F, 0x07, 0x07, 0x81, 0xC1, 0xE0, 0x70,
  0xF0, 0x1C, 0x3C, 0x07, 0x1E, 0x01, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0xF0,
  0x07, 0x38, 0x01, 0xDE, 0x00, 0x77, 0x80, 0x1D, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x0F, 0x00,
  0xFF, 0x00, 0xF0, 0x1E, 0xF0, 0x1F, 0x01, 0xEF, 0x01, 0xF0, 0x1C, 0xF0,
  0x1F, 0x03, 0xCF, 0x03, 0xF0, 0x38, 0xF0, 0x3F, 0x07, 0x8F, 0x07, 0x70,
  0x78, 0xF0, 0x77, 0x07, 0x0F, 0x0F, 0x70, 0xF0, 0xF0, 0xE7, 0x0E, 0x0F,
  0x0E, 0x71, 0xE0, 0xF1, 0xC7, 0x1E, 0x0F, 0x1C, 0x71, 0xC0, 0xF3, 0xC7,
  0x3C, 0x0F, 0x38, 0x73, 0x80, 0xF3, 0x87, 0x78, 0x0F, 0x70, 0x77, 0x80,
  0xF7, 0x07, 0x70, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0,
  0xEE, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0,
  0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x7C, 0x0F,
  0x01, 0xC0, 0x1C, 0x0F, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x8F,
  0x00, 0x0E, 0x38, 0x00, 0x39, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x70, 0x00, 0x79, 0xC0,
  0x01, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F,
  0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x00, 0xF0,
  0x0F, 0x70, 0x1E, 0x70, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x78, 0x78,
  0x78, 0x38, 0xF0, 0x38, 0xE0, 0x39, 0xE0, 0x39, 0xC0, 0x3F, 0xC0, 0x3F,
  0x80, 0x3F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x00,
  0xE1, 0xC3, 0xC7, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xE3, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x78, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x78,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0,
  0x07, 0xF8, 0x07, 0x38, 0x0E, 0x38, 0x0E, 0x3C, 0x1C, 0x1C, 0x3C, 0x1C,
  0x38, 0x1E, 0x78, 0x0E, 0x70, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF3, 0xC7, 0x1E, 0x38, 0x70, 0x01, 0xE0, 0x03, 0xF9,
  0xC3, 0xFF, 0xE3, 0xE7, 0xE1, 0xE1, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0xF0,
  0x1C, 0x78, 0x0E, 0x3C, 0x0F, 0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xC7,
  0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF8, 0xF0, 0x7C, 0x78, 0x7C, 0x1F, 0xEE,
  0x0F, 0xF7, 0x03, 0xE3, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x1C,
  0x07, 0xBF, 0x83, 0xFF, 0xC1, 0xF9, 0xF0, 0xF8, 0x78, 0xF8, 0x3C, 0x78,
  0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xE3,
  0xC0, 0xF1, 0xC0, 0x78, 0xE0, 0x38, 0xF0, 0x3C, 0x7C, 0x1E, 0x3E, 0x1E,
  0x1F, 0xFE, 0x1E, 0xFF, 0x0E, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0xF0, 0xFF,
  0x87, 0xE6, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x87, 0xFE, 0x0F, 0xF8, 0x1F, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x01, 0xE7, 0x80, 0xFE, 0xF0, 0x3F, 0xFE, 0x0F, 0x9F,
  0x81, 0xE1, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC3, 0xC0, 0x70, 0x78, 0x0E,
  0x0F, 0x03, 0xC1, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xC1, 0xE0, 0x78,
  0x3C, 0x0F, 0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x1F, 0x01, 0xFF, 0xE0,
  0x3F, 0xDC, 0x03, 0xE3, 0x80, 0x00, 0xF0, 0x07, 0xF0, 0x3F, 0xF0, 0xF8,
  0xE1, 0xE1, 0xE7, 0x83, 0xCE, 0x07, 0x3C, 0x1E, 0x78, 0x7C, 0xFF, 0xF1,
  0xFF, 0x87, 0xFC, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x21, 0xFF, 0xC1, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFE, 0x70, 0x7F, 0xFC, 0x3E,
  0x7E, 0x0F, 0x0F, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x1C, 0x3C, 0x07,
  0x0F, 0x03, 0xC3, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0E, 0x1E, 0x07, 0x87,
  0x81, 0xE1, 0xE0, 0xF8, 0x78, 0x3E, 0x1E, 0x1F, 0x03, 0xFD, 0xC0, 0xFF,
  0xF0, 0x1F, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x0C, 0x1F, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xC0, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x1C, 0x07, 0xBF, 0x83, 0xFF, 0xC1,
  0xF9, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x78, 0x1E, 0x3C, 0x0E, 0x1E, 0x0F,
  0x0E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xC3, 0xC0, 0xE1, 0xC0, 0xF0, 0xE0,
  0x78, 0xF0, 0x3C, 0x78, 0x1C, 0x3C, 0x0E, 0x1C, 0x0F, 0x0E, 0x07, 0x8F,
  0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x7C, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x43, 0xC1, 0xE0, 0xF0, 0xF0,
  0x3C, 0x78, 0x0E, 0x3C, 0x03, 0x8F, 0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x1D,
  0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3E, 0xF0, 0x0F, 0x3C,
  0x03, 0x8F, 0x01, 0xE1, 0xC0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x07, 0x81,
  0xC0, 0xE0, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81,
  0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x1C, 0x0E, 0x03, 0x9F, 0x8F,
  0xE0, 0xEF, 0xF7, 0xF8, 0x3F, 0x3F, 0x9E, 0x0F, 0x87, 0xC3, 0xC7, 0xC1,
  0xE0, 0xE1, 0xE0, 0x70, 0x38, 0x78, 0x3C, 0x0E, 0x1E, 0x0F, 0x07, 0x87,
  0x03, 0xC1, 0xE3, 0xC0, 0xE0, 0x78, 0xF0, 0x38, 0x1C, 0x3C, 0x1E, 0x07,
  0x0E, 0x07, 0x83, 0xC3, 0x81, 0xE0, 0xF1, 0xE0, 0x70, 0x38, 0x78, 0x3C,
  0x0E, 0x1E, 0x0F, 0x07, 0x87, 0x03, 0xC1, 0xE1, 0xC0, 0xE0, 0x78, 0xF0,
  0x38, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x3F, 0x83, 0xBF, 0xC1, 0xF9, 0xF0,
  0xF8, 0x78, 0xF8, 0x3C, 0x78, 0x1E, 0x3C, 0x0E, 0x1E, 0x0F, 0x0E, 0x07,
  0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xE1, 0xC0, 0xF0, 0xE0, 0x78, 0xF0,
  0x3C, 0x78, 0x1C, 0x3C, 0x0E, 0x1C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC0,
  0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF9, 0xF1, 0xE1, 0xE7, 0x81, 0xCF,
  0x03, 0xBC, 0x07, 0x78, 0x0E, 0xF0, 0x1D, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x0F, 0x78, 0x1E, 0xF0, 0x78, 0xF1, 0xF1, 0xFF, 0xC1,
  0xFF, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x73, 0xF8, 0x0E, 0xFF, 0x01,
  0xF9, 0xF0, 0x3E, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07,
  0x81, 0xE0, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xE0, 0xF0, 0x3C, 0x1C,
  0x07, 0x83, 0x80, 0xF0, 0xF0, 0x3C, 0x1F, 0x07, 0x83, 0xE1, 0xE0, 0x7F,
  0xF8, 0x0E, 0xFE, 0x03, 0xCF, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xF9, 0xC3, 0xFF, 0xC3, 0xE7,
  0xE1, 0xE1, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0xF0, 0x1C, 0x78, 0x0E, 0x3C,
  0x0F, 0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xC7, 0x81, 0xE3, 0xC0, 0xF1,
  0xE0, 0xF8, 0xF0, 0x7C, 0x78, 0x7C, 0x1F, 0xEE, 0x0F, 0xFF, 0x03, 0xE7,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x39, 0xF0,
  0xEF, 0x83, 0xFE, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x3F,
  0xF1, 0xFF, 0xC7, 0x86, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0xE2, 0x07, 0x8F, 0xFE, 0x3F, 0xF0, 0xFF, 0x80, 0x03, 0x00,
  0xE0, 0x1C, 0x07, 0x80, 0xE0, 0xFF, 0xDF, 0xF8, 0xF0, 0x1C, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xE0, 0x3F, 0x83, 0xF0, 0x7E, 0x00, 0x1E, 0x07, 0x8F,
  0x03, 0x87, 0x03, 0xC3, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x70, 0xF0, 0x38,
  0x70, 0x3C, 0x38, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x0F, 0x07, 0x87, 0x03,
  0xC7, 0x81, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0xF8, 0x7F, 0xDC, 0x1F,
  0xCE, 0x07, 0xCE, 0x00, 0xF0, 0x1F, 0xE0, 0x7B, 0xC0, 0xE7, 0x83, 0xCF,
  0x07, 0x9E, 0x1E, 0x3C, 0x3C, 0x38, 0xF0, 0x71, 0xE0, 0xE3, 0x81, 0xCF,
  0x03, 0x9C, 0x07, 0x78, 0x0E, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x7C, 0x1F, 0xE0, 0xF8, 0x3B,
  0xC3, 0xF0, 0xF7, 0x87, 0xE1, 0xEF, 0x0F, 0xC3, 0x9E, 0x3B, 0x8F, 0x3C,
  0x77, 0x1C, 0x79, 0xCE, 0x78, 0xF3, 0x9C, 0xE1, 0xE7, 0x39, 0xC3, 0xDC,
  0x77, 0x87, 0xB8, 0xEE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0x70, 0x3B, 0x86,
  0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0xF8,
  0x07, 0xC1, 0xF0, 0x00, 0x07, 0x83, 0xE0, 0xF0, 0xF0, 0x0E, 0x1E, 0x01,
  0xE7, 0x80, 0x3C, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0E,
  0xF0, 0x03, 0xCE, 0x00, 0xF1, 0xC0, 0x1E, 0x3C, 0x07, 0x87, 0x81, 0xE0,
  0x70, 0x7C, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x38, 0x3C, 0x03, 0x83, 0xC0, 0x38, 0x38, 0x03, 0x87, 0x80, 0x38, 0x70,
  0x03, 0x8F, 0x00, 0x38, 0xE0, 0x03, 0x9E, 0x00, 0x39, 0xC0, 0x03, 0xBC,
  0x00, 0x3B, 0x80, 0x03, 0xB8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x01, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x1F,
  0xC0, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x03, 0xE0, 0x3F, 0x00, 0xF0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x0F, 0xC0,
  0x3F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3F,
  0x00, 0x3C, 0x03, 0xF0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0xF8,
  0x0F, 0xC0, 0x3F, 0x00, 0xF0, 0x00, 0x3E, 0x03, 0xFF, 0x07, 0xFF, 0xFE,
  0x1F, 0xF8, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Condensed_MediumItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 27, 9, 0, -27 },
  { 35, 11, 10, 14, 4, -27 },
  { 49, 20, 27, 19, 0, -27 },
  { 117, 17, 31, 17, 0, -29 },
  { 183, 23, 28, 26, 2, -28 },
  { 264, 19, 28, 20, 0, -28 },
  { 331, 5, 10, 8, 4, -27 },
  { 338, 12, 33, 10, 1, -27 },
  { 388, 12, 33, 10, -3, -27 },
  { 438, 13, 15, 16, 4, -29 },
  { 463, 15, 18, 18, 2, -22 },
  { 497, 8, 9, 9, -2, -4 },
  { 506, 9, 3, 11, 1, -12 },
  { 510, 5, 5, 9, 0, -5 },
  { 514, 18, 27, 13, -2, -27 },
  { 575, 16, 28, 17, 1, -28 },
  { 631, 11, 27, 17, 4, -27 },
  { 669, 18, 28, 17, -1, -28 },
  { 732, 17, 28, 17, 0, -28 },
  { 792, 17, 27, 17, 0, -27 },
  { 850, 17, 27, 17, 0, -27 },
  { 908, 17, 28, 17, 1, -28 },
  { 968, 16, 27, 17, 2, -27 },
  { 1022, 17, 28, 17, 0, -28 },
  { 1082, 17, 28, 17, 0, -28 },
  { 1142, 8, 21, 9, 0, -21 },
  { 1163, 10, 26, 9, -2, -21 },
  { 1196, 15, 18, 18, 2, -23 },
  { 1230, 15, 11, 18, 2, -19 },
  { 1251, 15, 18, 18, 2, -23 },
  { 1285, 13, 28, 13, 1, -28 },
  { 1331, 24, 30, 26, 1, -27 },
  { 1421, 18, 27, 18, -2, -27 },
  { 1482, 19, 27, 19, 0, -27 },
  { 1547, 18, 28, 17, 2, -28 },
  { 1610, 20, 27, 20, 0, -27 },
  { 1678, 18, 27, 16, 0, -27 },
  { 1739, 18, 27, 15, 0, -27 },
  { 1800, 20, 28, 21, 2, -28 },
  { 1870, 22, 27, 21, 0, -27 },
  { 1945, 16, 27, 11, -2, -27 },
  { 1999, 16, 34, 9, -6, -27 },
  { 2067, 21, 27, 18, 0, -27 },
  { 2138, 13, 27, 15, 0, -27 },
  { 2182, 28, 27, 27, 0, -27 },
  { 2277, 23, 27, 22, 0, -27 },
  { 2355, 19, 28, 22, 2, -28 },
  { 2422, 18, 27, 18, 0, -27 },
  { 2483, 19, 34, 22, 2, -28 },
  { 2564, 18, 27, 18, 0, -27 },
  { 2625, 17, 28, 16, 0, -28 },
  { 2685, 15, 27, 15, 3, -27 },
  { 2736, 20, 27, 21, 2, -27 },
  { 2804, 18, 27, 18, 3, -27 },
  { 2865, 28, 27, 28, 3, -27 },
  { 2960, 22, 27, 17, -2, -27 },
  { 3035, 16, 27, 16, 3, -27 },
  { 3089, 19, 27, 15, -1, -27 },
  { 3154, 15, 33, 11, -1, -27 },
  { 3216, 7, 27, 14, 4, -27 },
  { 3240, 15, 33, 11, -3, -27 },
  { 3302, 16, 16, 17, 1, -27 },
  { 3334, 13, 3, 13, -3, 3 },
  { 3339, 6, 6, 10, 6, -29 },
  { 3344, 17, 21, 18, 1, -21 },
  { 3389, 17, 29, 18, 0, -29 },
  { 3451, 14, 21, 14, 1, -21 },
  { 3488, 19, 29, 18, 1, -29 },
  { 3557, 15, 21, 16, 1, -21 },
  { 3597, 19, 38, 10, -4, -29 },
  { 3688, 18, 30, 18, 0, -21 },
  { 3756, 17, 29, 18, 0, -29 },
  { 3818, 10, 28, 8, 0, -28 },
  { 3853, 15, 37, 9, -5, -28 },
  { 3923, 18, 29, 16, 0, -29 },
  { 3989, 10, 29, 8, 0, -29 },
  { 4026, 26, 21, 27, 0, -21 },
  { 4095, 17, 21, 18, 0, -21 },
  { 4140, 15, 21, 18, 1, -21 },
  { 4180, 19, 30, 18, -2, -21 },
  { 4252, 17, 30, 18, 1, -21 },
  { 4316, 14, 21, 12, 0, -21 },
  { 4353, 14, 21, 14, 0, -21 },
  { 4390, 11, 25, 11, 1, -25 },
  { 4425, 17, 20, 18, 1, -20 },
  { 4468, 15, 20, 15, 2, -20 },
  { 4506, 23, 20, 23, 2, -20 },
  { 4564, 19, 20, 15, -2, -20 },
  { 4612, 20, 29, 15, -3, -20 },
  { 4685, 15, 20, 13, -1, -20 },
  { 4723, 14, 33, 13, 1, -27 },
  { 4781, 3, 38, 16, 7, -29 },
  { 4796, 14, 33, 13, -2, -27 },
  { 4854, 15, 5, 18, 2, -16 },
};

const GFXfont NotoSans_Condensed_MediumItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC38PT7B_H_
