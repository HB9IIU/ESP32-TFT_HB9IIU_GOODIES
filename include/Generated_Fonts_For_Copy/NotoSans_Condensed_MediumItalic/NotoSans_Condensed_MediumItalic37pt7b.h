#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC37PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x07, 0x83, 0xE0, 0xF8, 0x1C, 0x00, 0x79, 0xEE,
  0x3D, 0xC7, 0x38, 0xEF, 0x1D, 0xC7, 0x38, 0xE7, 0x1C, 0xC3, 0x80, 0x00,
  0x71, 0xC0, 0x0C, 0x38, 0x03, 0x86, 0x00, 0x71, 0xC0, 0x0C, 0x38, 0x03,
  0x86, 0x00, 0x71, 0xC0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x0E,
  0x38, 0x01, 0x87, 0x00, 0x70, 0xC0, 0x0E, 0x38, 0x01, 0x87, 0x00, 0x70,
  0xC0, 0x7F, 0xFF, 0x9F, 0xFF, 0xF0, 0x70, 0xC0, 0x0E, 0x38, 0x01, 0xC7,
  0x00, 0x30, 0xE0, 0x0E, 0x18, 0x01, 0xC7, 0x00, 0x30, 0xE0, 0x0E, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1F, 0xC0, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3C, 0x8C, 0x1C, 0xC0, 0x0E, 0x60, 0x07, 0x30, 0x03, 0x98,
  0x01, 0xE8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0xDE, 0x00, 0x67, 0x00, 0x33, 0x80, 0x11, 0xC4, 0x18, 0xE1,
  0x8C, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xE0, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x01, 0xC1, 0xFC,
  0x0E, 0x0E, 0x70, 0x38, 0x38, 0xC1, 0xC1, 0xC3, 0x06, 0x07, 0x1C, 0x38,
  0x18, 0x71, 0xC0, 0xE1, 0xC7, 0x03, 0x87, 0x38, 0x0E, 0x18, 0xE0, 0x38,
  0xE7, 0x3E, 0xE3, 0xB9, 0xFF, 0x9C, 0xEF, 0x7F, 0xF7, 0x39, 0xDF, 0x9D,
  0xC7, 0x38, 0xE7, 0x1C, 0x07, 0x1C, 0x70, 0x1C, 0xE1, 0xC0, 0xE3, 0x87,
  0x03, 0x8E, 0x1C, 0x1C, 0x38, 0xE0, 0xE0, 0xE3, 0x83, 0x83, 0x8C, 0x1C,
  0x0E, 0x70, 0x70, 0x1F, 0x83, 0x80, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x01, 0xE7, 0x80, 0x38, 0xF0, 0x0F, 0x1E, 0x01, 0xE3,
  0xC0, 0x38, 0x70, 0x07, 0x9E, 0x00, 0xF3, 0x80, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x78, 0xF7, 0x0E, 0x3C, 0xF3,
  0xCF, 0x0E, 0x71, 0xC1, 0xFE, 0x78, 0x3F, 0x8F, 0x03, 0xF1, 0xE0, 0x7C,
  0x3C, 0x0F, 0x87, 0xC3, 0xF0, 0x7F, 0xFF, 0x0F, 0xFD, 0xE0, 0xFE, 0x1E,
  0x00, 0x7B, 0x9C, 0xEF, 0x73, 0x9C, 0xE0, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70,
  0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x00, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x18, 0xE0, 0x7B, 0x83, 0xFF, 0xF1, 0xFF, 0xC1,
  0xFF, 0x0F, 0x80, 0x7F, 0x03, 0xDC, 0x1E, 0x38, 0x10, 0xF0, 0x03, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1F, 0x1E,
  0x1C, 0x3C, 0x3C, 0x38, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xBF, 0xDF, 0xE0,
  0x33, 0xDF, 0xF7, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xF8, 0x1F, 0xF0, 0x3F,
  0xF0, 0xF1, 0xE3, 0xC1, 0xC7, 0x83, 0x8E, 0x07, 0x3C, 0x0E, 0x70, 0x1D,
  0xE0, 0x3B, 0xC0, 0xF7, 0x81, 0xEE, 0x03, 0xDC, 0x07, 0xF8, 0x0E, 0xF0,
  0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xCF, 0x07, 0x9E, 0x0E, 0x3C, 0x3C,
  0x78, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0xF8, 0x3F,
  0x0F, 0xE7, 0xFD, 0xF7, 0x1C, 0xE2, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0x00, 0x7C, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0xF9, 0xF0, 0x30, 0x78, 0x10, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7F,
  0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x03, 0xFF,
  0xC0, 0xF3, 0xE0, 0x40, 0xF0, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE1, 0x01, 0xF0, 0xFF, 0xF0, 0x7F,
  0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xB8, 0x01, 0xDC, 0x01, 0xDE, 0x01,
  0xCF, 0x00, 0xE7, 0x00, 0xE3, 0x80, 0xE1, 0xC0, 0x71, 0xE0, 0x70, 0xF0,
  0x70, 0x70, 0x78, 0x38, 0x38, 0x3C, 0x3F, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF,
  0xE0, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC3, 0x03, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0xF3, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0xE0, 0x3B, 0xF8, 0x7F, 0xF8,
  0x7E, 0x7C, 0x7C, 0x3C, 0x78, 0x1C, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0x78, 0xF0, 0x7F, 0xF0,
  0x3F, 0xE0, 0x1F, 0x80, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0xF1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x38, 0x1E, 0x1C,
  0x0F, 0x0E, 0x07, 0x07, 0x87, 0x81, 0xC7, 0x80, 0xFF, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0xE0, 0x3C, 0xF0, 0x3C, 0x3C, 0x3C, 0x0E, 0x1C, 0x07,
  0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xE3, 0xC0, 0xF0, 0xF0, 0x78, 0x7F,
  0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x01, 0xFC, 0x07, 0xFE,
  0x07, 0xDF, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07,
  0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x1E, 0x3F, 0x1F, 0xFE,
  0x1F, 0xEE, 0x0F, 0xDE, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x00,
  0x0F, 0x0F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x78, 0xF8, 0xF8, 0xF0, 0x01, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x06,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x01, 0xC0, 0x03, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x7C, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x78,
  0x00, 0xC0, 0x00, 0x03, 0xC0, 0xFF, 0x8F, 0xFC, 0x39, 0xF1, 0x07, 0x80,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x1C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x1C, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x1C,
  0x1F, 0xC7, 0x18, 0x3F, 0xC7, 0x38, 0x71, 0xC7, 0x30, 0xE1, 0x87, 0x70,
  0xC3, 0x86, 0x71, 0xC3, 0x86, 0x61, 0x83, 0x8E, 0x63, 0x87, 0x0E, 0xE3,
  0x87, 0x0C, 0xE3, 0x87, 0x1C, 0xE3, 0x8F, 0x1C, 0xE3, 0x8F, 0x38, 0xE3,
  0xFB, 0xF0, 0xE1, 0xF3, 0xF0, 0xE0, 0xE1, 0xC0, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x01, 0x00, 0x1E, 0x0E, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x01, 0xDC, 0x01, 0xCE, 0x00, 0xE7,
  0x00, 0xF3, 0xC0, 0x71, 0xE0, 0x78, 0xF0, 0x38, 0x78, 0x3C, 0x3C, 0x1E,
  0x1E, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0x81, 0xE3, 0x80, 0xF3,
  0xC0, 0x79, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0x81, 0xE0,
  0xE1, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xC0, 0xF0, 0x70,
  0x3C, 0x3C, 0x07, 0x0F, 0x01, 0xC3, 0xC0, 0xF0, 0xE0, 0x3C, 0x38, 0x0F,
  0x1E, 0x07, 0x87, 0x83, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xF8, 0x10, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x20, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xC3, 0xE0, 0x78, 0x3E, 0x0E, 0x03,
  0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x38, 0x07,
  0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x00, 0xF0, 0xE0, 0x1E,
  0x3C, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x1E, 0x1C, 0x07, 0x83, 0x81, 0xF0,
  0xF0, 0x7C, 0x1E, 0x3F, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xE0, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x83,
  0xFB, 0xE0, 0xF8, 0x04, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x7F, 0x3C, 0x0F, 0xE7, 0x83, 0xFC, 0xF0, 0x07, 0x1E, 0x00, 0xE3, 0xC0,
  0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1C, 0x3E, 0x07, 0x83, 0xE0,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x03, 0xC0, 0x78,
  0x1C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xE0, 0x78, 0x0F, 0x03, 0x80,
  0x78, 0x1C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xE0, 0x78, 0x0F, 0x03,
  0x80, 0x78, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x70, 0x0F,
  0x03, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1C, 0x0F, 0x01, 0xE0, 0x70,
  0x0F, 0x03, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1C, 0x0F, 0x01, 0xE0,
  0x70, 0x0F, 0x07, 0x80, 0x78, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x03, 0xC0, 0xF8, 0x1C, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x80,
  0x78, 0x78, 0x03, 0x87, 0x80, 0x1C, 0x78, 0x01, 0xE7, 0x80, 0x0F, 0x3C,
  0x00, 0x7B, 0xC0, 0x03, 0xBC, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xCE, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0,
  0x0F, 0x1E, 0x00, 0x70, 0x70, 0x03, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0,
  0xF0, 0x0F, 0x03, 0x80, 0x70, 0x1E, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0xFF, 0x7F, 0xFF,
  0xFF, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x3B, 0x83, 0xF8, 0x07,
  0xF0, 0x7F, 0x01, 0xDE, 0x0E, 0xE0, 0x3B, 0x81, 0xDC, 0x0F, 0x70, 0x3B,
  0xC1, 0xDE, 0x0F, 0x78, 0x7B, 0xC1, 0xE7, 0x0E, 0x78, 0x38, 0xE3, 0xCE,
  0x07, 0x1C, 0x71, 0xC0, 0xE3, 0x9E, 0x78, 0x3C, 0x73, 0x8F, 0x07, 0x8E,
  0x71, 0xE0, 0xE1, 0xDC, 0x38, 0x1C, 0x3B, 0x87, 0x03, 0x87, 0xE1, 0xE0,
  0xF0, 0xFC, 0x3C, 0x1E, 0x1F, 0x07, 0x03, 0x83, 0xE0, 0xE0, 0x70, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x80, 0x03, 0xC0, 0x1C, 0x0F, 0x80, 0x70, 0x7E,
  0x03, 0xC1, 0xF8, 0x0F, 0x07, 0xE0, 0x38, 0x1F, 0x80, 0xE0, 0xFF, 0x07,
  0x83, 0xDC, 0x1E, 0x0E, 0x70, 0x70, 0x39, 0xC1, 0xC0, 0xE7, 0x87, 0x07,
  0x9E, 0x3C, 0x1E, 0x38, 0xF0, 0x70, 0xE3, 0x81, 0xC3, 0x8E, 0x07, 0x0F,
  0x38, 0x3C, 0x1D, 0xE0, 0xF0, 0x77, 0x83, 0x81, 0xDC, 0x0E, 0x07, 0xF0,
  0x38, 0x1F, 0xC1, 0xE0, 0x3F, 0x07, 0x80, 0xFC, 0x1C, 0x03, 0xE0, 0x70,
  0x0F, 0x83, 0xC0, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x0F, 0xFE,
  0x03, 0xFF, 0xE0, 0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0x71, 0xE0, 0x0F,
  0x3C, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xEF, 0x00, 0x3D,
  0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0x9E, 0x00, 0xF3,
  0x80, 0x1E, 0x70, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3C, 0x3C, 0x0F, 0x87,
  0xC3, 0xE0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x1E, 0x1F, 0x07, 0x83, 0xC1, 0xC0, 0xF0,
  0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xE0, 0xE0, 0x78, 0x78,
  0x3E, 0x1E, 0x3F, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xF0, 0x3C, 0x3C, 0x07, 0x87,
  0x80, 0x71, 0xE0, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC,
  0x00, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0,
  0x03, 0x9E, 0x00, 0xF3, 0x80, 0x1E, 0x70, 0x07, 0x8F, 0x00, 0xF1, 0xE0,
  0x3C, 0x3C, 0x0F, 0x87, 0xC3, 0xE0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x1E,
  0x1E, 0x07, 0x83, 0xC1, 0xC0, 0xF0, 0x70, 0x3C, 0x3C, 0x0F, 0x0F, 0x03,
  0x83, 0x81, 0xE0, 0xE0, 0x78, 0x78, 0x7C, 0x1F, 0xFE, 0x07, 0xFF, 0x01,
  0xFF, 0x00, 0x71, 0xC0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xE0,
  0xE0, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x70, 0x1E,
  0x3C, 0x07, 0x80, 0x00, 0x78, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xE0,
  0xF0, 0x10, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC2, 0x01, 0xE1, 0x81, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x00, 0x0E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x0F, 0x01, 0xE1,
  0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1C, 0x3C, 0x07, 0x87,
  0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0x87, 0x80, 0x70, 0xF0, 0x1E, 0x1C,
  0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x70,
  0x0F, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3E, 0x1E, 0x07, 0xFF, 0xC0, 0x7F,
  0xF0, 0x07, 0xF8, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xBC, 0x03, 0xDE, 0x01,
  0xEF, 0x01, 0xE7, 0x80, 0xF1, 0xC0, 0xF0, 0xE0, 0x78, 0x70, 0x38, 0x38,
  0x3C, 0x1C, 0x1C, 0x0E, 0x1E, 0x07, 0x0E, 0x03, 0x8F, 0x01, 0xC7, 0x80,
  0xE7, 0x80, 0x73, 0xC0, 0x39, 0xC0, 0x1D, 0xE0, 0x0E, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x0E, 0x01, 0xFE, 0x03, 0xC0, 0x7B, 0xC0, 0x78, 0x0F, 0x78, 0x1F,
  0x01, 0xCF, 0x03, 0xE0, 0x79, 0xE0, 0x7C, 0x0F, 0x3C, 0x1F, 0x83, 0xC7,
  0x83, 0xF0, 0x78, 0xF0, 0xEE, 0x0E, 0x1E, 0x1D, 0xC3, 0xC3, 0xC3, 0xB8,
  0x78, 0x78, 0xE7, 0x0E, 0x0F, 0x1C, 0xE3, 0xC1, 0xE7, 0x1C, 0x70, 0x3C,
  0xE3, 0x9E, 0x07, 0xBC, 0x73, 0x80, 0xF7, 0x0E, 0x70, 0x1E, 0xE1, 0xDE,
  0x03, 0xF8, 0x3B, 0x80, 0x77, 0x07, 0xF0, 0x0E, 0xE0, 0xFC, 0x01, 0xF8,
  0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80,
  0x1F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0x70, 0x78,
  0x03, 0x83, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xC0, 0x07, 0x9E, 0x00, 0x1D,
  0xE0, 0x00, 0xEE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x3D, 0xE0, 0x01, 0xC7, 0x00, 0x1E, 0x38, 0x01, 0xE1, 0xE0, 0x0F,
  0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x07, 0x80, 0x78,
  0x00, 0xF0, 0x1F, 0x70, 0x1E, 0x70, 0x3C, 0x70, 0x3C, 0x78, 0x78, 0x78,
  0x70, 0x78, 0xF0, 0x78, 0xE0, 0x39, 0xE0, 0x39, 0xC0, 0x3B, 0xC0, 0x3F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x43, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xF0, 0x3F, 0xC0,
  0xFF, 0x00, 0xE1, 0xC3, 0x87, 0x0F, 0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xE3, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x78, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFF, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x80,
  0x7F, 0x00, 0xEE, 0x03, 0x8E, 0x07, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0xE0,
  0x73, 0xC0, 0xE7, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFC, 0xF9, 0xE3, 0x8F, 0x1C, 0x30, 0x03, 0xE7, 0x07, 0xF7, 0x0F,
  0xF7, 0x1E, 0x1F, 0x3C, 0x1F, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x70, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0xF8, 0x7F, 0xB8, 0x7F, 0x78, 0x3E, 0x70, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x3E, 0x07, 0xFF, 0x83, 0xBF, 0xC1, 0xF1,
  0xE1, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1C, 0x07, 0x1E,
  0x03, 0x8F, 0x03, 0xC7, 0x01, 0xE3, 0x80, 0xE1, 0xC0, 0xF1, 0xE0, 0x78,
  0xF0, 0x78, 0x7C, 0x3C, 0x3F, 0xFC, 0x3D, 0xFC, 0x1C, 0xFC, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0xFF, 0x87, 0x82, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF8, 0x41, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x03, 0xE7, 0x01, 0xFD, 0xC0, 0xFF, 0xF0, 0x78,
  0x7C, 0x3C, 0x1F, 0x0F, 0x07, 0x83, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E,
  0x1C, 0x07, 0x0F, 0x01, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x1F, 0xEE, 0x07, 0xF3, 0x80, 0xF9,
  0xC0, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0x87, 0x3C, 0x1C, 0xE0, 0x77,
  0x83, 0xDE, 0x1E, 0x71, 0xF9, 0xFF, 0x8F, 0xFC, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x11, 0xFF, 0x83, 0xFE, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x27, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xF3, 0x81, 0xFD, 0xC1, 0xFE, 0xE1, 0xE1, 0xF1, 0xE0, 0xF8, 0xF0,
  0x78, 0x70, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1C, 0x07, 0x1E, 0x03, 0x8F,
  0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x7C,
  0x1F, 0xFE, 0x0F, 0xEF, 0x03, 0xE7, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x80, 0xF0, 0x60, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x7E, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0x8F, 0x1F, 0x07, 0x1E, 0x07, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F,
  0x3C, 0x0E, 0x3C, 0x0E, 0x3C, 0x1E, 0x38, 0x1E, 0x38, 0x1E, 0x78, 0x1C,
  0x78, 0x1C, 0x78, 0x3C, 0x70, 0x3C, 0x70, 0x38, 0xF0, 0x38, 0x01, 0x01,
  0xC1, 0xE0, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x83, 0x81, 0xC1,
  0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC1, 0xE0,
  0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x00, 0x00, 0x08, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x02, 0x78, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x07, 0x87, 0x87, 0x83, 0x87, 0x81, 0xC7,
  0x80, 0xE3, 0xC0, 0xF3, 0xC0, 0x7B, 0xC0, 0x3B, 0xC0, 0x1F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xCE, 0x01, 0xC7, 0x81, 0xE3, 0xC0,
  0xF1, 0xE0, 0x70, 0x70, 0x38, 0x3C, 0x1C, 0x1E, 0x1E, 0x07, 0x00, 0x03,
  0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0,
  0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0,
  0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0x0E, 0x7E,
  0x3F, 0x07, 0x7F, 0x3F, 0x83, 0xFF, 0xFF, 0xE1, 0xF1, 0xF8, 0xF1, 0xF0,
  0xF8, 0x78, 0xF0, 0x78, 0x3C, 0x78, 0x3C, 0x1E, 0x38, 0x1C, 0x0E, 0x1C,
  0x0E, 0x07, 0x1E, 0x0F, 0x07, 0x8F, 0x07, 0x83, 0xC7, 0x83, 0xC1, 0xE3,
  0x81, 0xC0, 0xE1, 0xC0, 0xE0, 0x71, 0xE0, 0xF0, 0x78, 0xF0, 0x78, 0x3C,
  0x70, 0x3C, 0x1C, 0x38, 0x1C, 0x0E, 0x1C, 0x0E, 0x07, 0x1E, 0x0F, 0x07,
  0x80, 0x0E, 0x7E, 0x0E, 0xFF, 0x0F, 0xFF, 0x0F, 0x8F, 0x1F, 0x07, 0x1E,
  0x07, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C, 0x0E, 0x3C, 0x0E, 0x3C,
  0x1E, 0x38, 0x1E, 0x38, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x70,
  0x3C, 0xF0, 0x38, 0xF0, 0x38, 0x03, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0xF0,
  0xF3, 0xC1, 0xE7, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0x70, 0x1E, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0E, 0x78, 0x3C, 0x70,
  0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x03, 0x8F, 0x80, 0x77, 0xF8,
  0x0F, 0xFF, 0x01, 0xF1, 0xE0, 0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78,
  0x3C, 0x0F, 0x07, 0x01, 0xC1, 0xE0, 0x38, 0x3C, 0x0F, 0x07, 0x81, 0xE0,
  0xE0, 0x3C, 0x1C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x1F, 0x1F, 0x03,
  0xFF, 0xC0, 0x77, 0xF0, 0x1E, 0x7C, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE7, 0x07, 0xF7, 0x0F, 0xF7, 0x1E, 0x1F,
  0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1C,
  0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78,
  0xF0, 0xF8, 0x7F, 0xF8, 0x7F, 0x78, 0x3E, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x0E, 0x7C, 0x3B, 0xE0, 0xEF, 0x83, 0xF2, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0x07, 0xF0, 0x3F, 0xF1, 0xFF, 0x8F, 0x04, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0x78, 0x81, 0xE3, 0xFF, 0x0F, 0xFC, 0x3F, 0xC0,
  0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xFE, 0xFF, 0x9F, 0xF0, 0xE0, 0x1C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x78, 0x0F, 0x01, 0xFC, 0x1F, 0x83, 0xF0, 0x1E, 0x07, 0x1E,
  0x0F, 0x1C, 0x0F, 0x1C, 0x0E, 0x3C, 0x0E, 0x3C, 0x0E, 0x38, 0x1E, 0x38,
  0x1E, 0x38, 0x1C, 0x78, 0x1C, 0x78, 0x3C, 0x70, 0x3C, 0x70, 0x3C, 0xF0,
  0x38, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF8, 0xFF, 0xF0, 0x7F, 0x70, 0x3E,
  0x70, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xBC, 0x1E, 0xF0, 0x73, 0xC3, 0xCF,
  0x0E, 0x3C, 0x78, 0xF1, 0xC1, 0xCF, 0x07, 0x3C, 0x1C, 0xE0, 0x77, 0x81,
  0xDC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF0, 0x78, 0x1F, 0xE0, 0xF0, 0x7B, 0xC3, 0xE0, 0xF7, 0x87, 0xC1, 0xCF,
  0x0F, 0x87, 0x9E, 0x3F, 0x0E, 0x3C, 0x7E, 0x3C, 0x79, 0xDC, 0x70, 0xF3,
  0xB8, 0xE1, 0xE6, 0x73, 0xC3, 0xDC, 0xE7, 0x07, 0x39, 0xDE, 0x0E, 0xE3,
  0xB8, 0x1D, 0xC7, 0x70, 0x3B, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F,
  0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x83,
  0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x0E, 0x3C, 0x03, 0x8E, 0x00, 0xF7, 0x80,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xDE, 0x00, 0xF7, 0x80, 0x78, 0xE0, 0x1C, 0x38,
  0x0F, 0x0F, 0x07, 0x83, 0xC3, 0xE0, 0x70, 0x07, 0x80, 0xF0, 0x78, 0x1E,
  0x07, 0x81, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0x80, 0x38, 0x78, 0x03, 0x87,
  0x80, 0x38, 0xF0, 0x03, 0x8F, 0x00, 0x38, 0xE0, 0x03, 0x9E, 0x00, 0x39,
  0xC0, 0x03, 0xBC, 0x00, 0x3B, 0x80, 0x03, 0xB8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xF8,
  0x3F, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x01, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x7C,
  0x07, 0xE0, 0x1F, 0x80, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x0F, 0xC0,
  0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0x3C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0xC0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3E, 0x03, 0xF0,
  0x0F, 0x80, 0x38, 0x00, 0x10, 0x02, 0xFE, 0x07, 0xFF, 0xFF, 0x7F, 0xF8,
  0x1F, 0xD0, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_MediumItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 26, 9, 0, -26 },
  { 34, 11, 9, 14, 4, -26 },
  { 47, 19, 26, 19, 0, -26 },
  { 109, 17, 30, 17, 0, -28 },
  { 173, 22, 27, 26, 2, -27 },
  { 248, 19, 27, 19, 0, -27 },
  { 313, 5, 9, 8, 4, -26 },
  { 319, 12, 33, 10, 1, -27 },
  { 369, 12, 33, 10, -3, -27 },
  { 419, 14, 14, 16, 3, -28 },
  { 444, 15, 18, 18, 2, -22 },
  { 478, 8, 9, 8, -2, -4 },
  { 487, 9, 4, 10, 1, -12 },
  { 492, 5, 5, 8, 0, -5 },
  { 496, 18, 27, 13, -2, -27 },
  { 557, 15, 27, 17, 1, -27 },
  { 608, 11, 26, 17, 4, -26 },
  { 644, 17, 27, 17, -1, -27 },
  { 702, 17, 27, 17, 0, -27 },
  { 760, 17, 27, 17, 0, -27 },
  { 818, 17, 26, 17, 0, -26 },
  { 874, 16, 27, 17, 1, -27 },
  { 928, 16, 26, 17, 2, -26 },
  { 980, 17, 27, 17, 0, -27 },
  { 1038, 16, 27, 17, 0, -27 },
  { 1092, 8, 20, 9, 0, -20 },
  { 1112, 10, 25, 9, -2, -20 },
  { 1144, 15, 17, 18, 2, -22 },
  { 1176, 15, 10, 18, 2, -18 },
  { 1195, 15, 17, 18, 2, -22 },
  { 1227, 13, 27, 13, 1, -27 },
  { 1271, 24, 30, 25, 1, -27 },
  { 1361, 17, 26, 17, -2, -26 },
  { 1417, 18, 26, 18, 0, -26 },
  { 1476, 17, 27, 17, 2, -27 },
  { 1534, 19, 26, 20, 0, -26 },
  { 1596, 17, 26, 16, 0, -26 },
  { 1652, 17, 26, 15, 0, -26 },
  { 1708, 19, 27, 21, 2, -27 },
  { 1773, 21, 26, 21, 0, -26 },
  { 1842, 15, 26, 11, -2, -26 },
  { 1891, 16, 33, 9, -6, -26 },
  { 1957, 21, 26, 17, 0, -26 },
  { 2026, 12, 26, 15, 0, -26 },
  { 2065, 27, 26, 27, 0, -26 },
  { 2153, 22, 26, 22, 0, -26 },
  { 2225, 19, 27, 21, 2, -27 },
  { 2290, 18, 26, 17, 0, -26 },
  { 2349, 19, 33, 21, 2, -27 },
  { 2428, 18, 26, 18, 0, -26 },
  { 2487, 17, 27, 16, 0, -27 },
  { 2545, 15, 26, 15, 3, -26 },
  { 2594, 19, 26, 20, 2, -26 },
  { 2656, 17, 26, 17, 3, -26 },
  { 2712, 27, 26, 27, 3, -26 },
  { 2800, 21, 26, 16, -2, -26 },
  { 2869, 16, 26, 16, 3, -26 },
  { 2921, 18, 26, 15, -1, -26 },
  { 2980, 14, 33, 11, -1, -27 },
  { 3038, 7, 27, 13, 4, -27 },
  { 3062, 15, 33, 11, -3, -27 },
  { 3124, 15, 15, 17, 1, -26 },
  { 3153, 13, 3, 12, -3, 3 },
  { 3158, 6, 6, 10, 5, -28 },
  { 3163, 16, 20, 18, 1, -20 },
  { 3203, 17, 28, 18, 0, -28 },
  { 3263, 14, 20, 14, 1, -20 },
  { 3298, 18, 28, 18, 1, -28 },
  { 3361, 14, 20, 16, 1, -20 },
  { 3396, 18, 37, 10, -4, -28 },
  { 3480, 17, 29, 18, 0, -20 },
  { 3542, 16, 28, 18, 0, -28 },
  { 3598, 9, 28, 8, 0, -28 },
  { 3630, 14, 37, 8, -5, -28 },
  { 3695, 17, 28, 16, 0, -28 },
  { 3755, 10, 28, 8, 0, -28 },
  { 3790, 25, 20, 26, 0, -20 },
  { 3853, 16, 20, 18, 0, -20 },
  { 3893, 15, 20, 17, 1, -20 },
  { 3931, 19, 29, 18, -2, -20 },
  { 4000, 16, 29, 18, 1, -20 },
  { 4058, 14, 20, 12, 0, -20 },
  { 4093, 14, 20, 13, 0, -20 },
  { 4128, 11, 24, 11, 1, -24 },
  { 4161, 16, 20, 18, 1, -20 },
  { 4201, 14, 20, 15, 2, -20 },
  { 4236, 23, 20, 23, 2, -20 },
  { 4294, 18, 20, 15, -2, -20 },
  { 4339, 20, 29, 15, -3, -20 },
  { 4412, 15, 20, 13, -1, -20 },
  { 4450, 14, 32, 12, 1, -26 },
  { 4506, 3, 37, 16, 6, -28 },
  { 4520, 14, 32, 12, -2, -26 },
  { 4576, 15, 6, 18, 2, -16 },
};

const GFXfont NotoSans_Condensed_MediumItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC37PT7B_H_
