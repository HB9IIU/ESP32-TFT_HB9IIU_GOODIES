#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC63PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x30, 0x00, 0x1F, 0x87, 0xF1,
  0xF8, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xC3, 0xF0, 0xFC,
  0x3E, 0x0F, 0xC3, 0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xE0, 0xF8, 0x7C, 0x0F,
  0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0x78, 0x1F, 0x0F, 0x81,
  0xE0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x3E,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0xF0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0x3C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0x9C, 0x1C, 0x03, 0xF1, 0xC0, 0x80, 0x7E,
  0x1C, 0x00, 0x07, 0xE1, 0xC0, 0x00, 0x7E, 0x1C, 0x00, 0x07, 0xE3, 0x80,
  0x00, 0x7E, 0x38, 0x00, 0x07, 0xE3, 0x80, 0x00, 0x7F, 0x38, 0x00, 0x03,
  0xFB, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xEF, 0xE0, 0x00, 0x1C,
  0x7E, 0x00, 0x01, 0xC7, 0xE0, 0x00, 0x1C, 0x3E, 0x00, 0x01, 0xC3, 0xF0,
  0x00, 0x1C, 0x3E, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x38, 0x7E, 0x08, 0x03,
  0x87, 0xE0, 0xE0, 0x38, 0xFC, 0x0F, 0xC7, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3E,
  0x00, 0xFF, 0x80, 0x03, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0x00, 0xFF, 0xF0,
  0x01, 0xF0, 0x0F, 0xC7, 0xC0, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x07,
  0xC1, 0xF0, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0x1F, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x07, 0x80,
  0xF8, 0x3E, 0x00, 0x7C, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x1F, 0x00,
  0x1F, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x0F, 0x80, 0x07, 0x80, 0xF8,
  0xF8, 0x00, 0x3C, 0x0F, 0x87, 0xC0, 0xC1, 0xE0, 0x7C, 0x7C, 0x3F, 0xCF,
  0x03, 0xE3, 0xE3, 0xFF, 0x78, 0x3E, 0x3E, 0x3F, 0xFB, 0xC1, 0xF3, 0xE3,
  0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xF9, 0xF1, 0xF0, 0xFF, 0xFF,
  0x8F, 0x8F, 0x03, 0xDF, 0xF8, 0xF8, 0xF8, 0x1E, 0x7F, 0x8F, 0x87, 0xC1,
  0xF0, 0xC0, 0x7C, 0x7C, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x7C, 0x00, 0x3E,
  0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xF0, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0xF8,
  0x01, 0xF0, 0x7C, 0x07, 0x80, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F,
  0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xC1, 0xF0, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0x0F, 0x87,
  0xC0, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0x00,
  0x0F, 0xFE, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0x07, 0xF7, 0xE0,
  0x3F, 0x0F, 0xE7, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0,
  0xFC, 0x3F, 0x83, 0xF8, 0xFC, 0x3F, 0x01, 0xF9, 0xF8, 0x7E, 0x01, 0xFD,
  0xF8, 0x7E, 0x00, 0xFF, 0xF0, 0x7E, 0x00, 0xFF, 0xF0, 0x7E, 0x00, 0x7F,
  0xE0, 0xFE, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0xFF, 0xC0, 0x7F, 0x03, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC7,
  0xF0, 0x1F, 0xFF, 0x87, 0xF0, 0x07, 0xFE, 0x03, 0xF8, 0x00, 0xE0, 0x00,
  0x00, 0x1F, 0x8F, 0xC7, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x3F,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x04,
  0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x3E, 0x1E, 0x00, 0x7F, 0x3C, 0x03, 0xFF,
  0xFB, 0xFD, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xDF, 0x00, 0x3F, 0x1E,
  0x00, 0xFE, 0x3E, 0x03, 0xF8, 0x7E, 0x03, 0xE0, 0xFC, 0x03, 0xC0, 0xFC,
  0x03, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F,
  0x83, 0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x00, 0x7F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x80, 0x3C, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFC, 0x30, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xE3, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF8,
  0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8,
  0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xF3,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x1F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x1F, 0xE0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0x3F,
  0xFF, 0x1F, 0xEF, 0xCF, 0xE3, 0xF1, 0xF0, 0xFC, 0x78, 0x7E, 0x0C, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xF0,
  0x3F, 0x80, 0x0F, 0x00, 0x7F, 0x00, 0x18, 0x01, 0xFC, 0x00, 0x40, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0xF8, 0x0F, 0xF0, 0x06, 0x00, 0x7F, 0x00, 0x40, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x08, 0x00, 0x1F, 0xC0,
  0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8,
  0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xC0, 0xFC,
  0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x00,
  0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xC7, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x08, 0x00, 0x0F, 0xE0, 0xC0, 0x03,
  0xFC, 0x0F, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x38, 0x00, 0x7E, 0x3F, 0xC0, 0x1F, 0x9F, 0xFC, 0x03, 0xF7, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xF0, 0x7F,
  0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x8F, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xE0,
  0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03,
  0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0xFE,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC0, 0xFC,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0xFE, 0x0F,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x01,
  0xFF, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x1F, 0xC0,
  0x7E, 0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x87,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x03,
  0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x03, 0xFC, 0x3F, 0x00, 0x7F,
  0x87, 0xF0, 0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0x7E, 0x03, 0xFF, 0xDF, 0x80, 0x1F, 0xE3, 0xF0,
  0x00, 0x60, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x80, 0x3F, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x01, 0xF8,
  0x01, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x00,
  0x7F, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xF0,
  0x1F, 0xC1, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0xF0, 0x1F, 0x07, 0xC0, 0x3F,
  0xFE, 0x1F, 0x0F, 0x80, 0x7F, 0xFC, 0x1F, 0x0F, 0x80, 0xFF, 0xFC, 0x1F,
  0x1F, 0x01, 0xF8, 0x7C, 0x1F, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x1E, 0x07,
  0xC0, 0xF8, 0x1F, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x3E, 0x0F, 0x80, 0xF8,
  0x1F, 0x3C, 0x0F, 0x80, 0xF0, 0x1E, 0x7C, 0x0F, 0x01, 0xF0, 0x1E, 0x7C,
  0x1F, 0x01, 0xF0, 0x1E, 0x78, 0x1F, 0x01, 0xF0, 0x3E, 0x78, 0x1E, 0x01,
  0xE0, 0x3E, 0x78, 0x3E, 0x03, 0xE0, 0x3C, 0xF8, 0x3E, 0x03, 0xE0, 0x7C,
  0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0xF8, 0x3E, 0x07, 0xE0, 0x78, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0xF8, 0x3E, 0x0F, 0xC0, 0xF0, 0xF8, 0x3E, 0x0F, 0xC1,
  0xE0, 0xF8, 0x3F, 0x1D, 0xE3, 0xE0, 0xF8, 0x1F, 0xFD, 0xFF, 0xC0, 0xF8,
  0x1F, 0xF9, 0xFF, 0x80, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xF8, 0x07, 0xC0,
  0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x40,
  0x00, 0x0F, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x01,
  0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xFC,
  0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07,
  0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0x01, 0xF8,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x7E, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC,
  0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xF0,
  0x3F, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x01,
  0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F,
  0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7E,
  0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x7F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0,
  0x1F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFE, 0x0F,
  0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0xFE, 0x07, 0xE0, 0x0F, 0xF8, 0x1F, 0x81, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0x00, 0x7F, 0xC0, 0x08, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x02, 0x00, 0x3F, 0xC0,
  0x78, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFC, 0x07, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01,
  0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03,
  0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07,
  0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0xFF, 0x80, 0x7E, 0x03, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xF8, 0x01, 0xFE,
  0x00, 0x1C, 0x01, 0xFE, 0x00, 0x02, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x01, 0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0xF0, 0xFE, 0x00, 0x7F, 0xF8,
  0x7F, 0x00, 0x7F, 0xFC, 0x3F, 0x80, 0x3F, 0xFE, 0x1F, 0xC0, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03,
  0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFF, 0x00,
  0x1F, 0x80, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x1F, 0x80, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x1F, 0xC0, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x20, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x03, 0xF0,
  0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00,
  0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7E, 0x7F, 0x00,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x07, 0xE0, 0x07,
  0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xF8, 0x03,
  0xEF, 0x80, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x00, 0x1F, 0x7E, 0x01, 0xFB,
  0xE0, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x00, 0x0F, 0xBF, 0x00, 0x7E, 0xF8,
  0x00, 0xFD, 0xF8, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0xC0, 0x3F, 0x3F, 0x00,
  0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x03, 0xE3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F,
  0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xF0, 0x1F, 0x8F,
  0xC0, 0x3F, 0x0F, 0x80, 0xF8, 0x7E, 0x01, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0,
  0x0F, 0xC3, 0xE0, 0x7C, 0x3F, 0x00, 0x7E, 0x1F, 0x07, 0xE1, 0xF8, 0x03,
  0xE0, 0xF8, 0x3E, 0x0F, 0xC0, 0x3F, 0x07, 0xC3, 0xF0, 0x7E, 0x01, 0xF8,
  0x3E, 0x1F, 0x07, 0xE0, 0x0F, 0xC1, 0xF1, 0xF8, 0x3F, 0x00, 0x7E, 0x0F,
  0x8F, 0x81, 0xF8, 0x07, 0xE0, 0x7C, 0x7C, 0x0F, 0xC0, 0x3F, 0x03, 0xE7,
  0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0x3E, 0x07, 0xE0, 0x0F, 0xC0, 0xFB, 0xF0,
  0x3F, 0x00, 0x7C, 0x07, 0xFF, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0xF8, 0x0F,
  0xC0, 0x3F, 0x01, 0xFF, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xFC, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xFE, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xE0, 0x00,
  0x7E, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x7F,
  0xC0, 0x01, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x1F, 0xF8, 0x00, 0x7E,
  0x01, 0xFF, 0xC0, 0x07, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x7D, 0xF8,
  0x01, 0xF8, 0x03, 0xEF, 0xC0, 0x0F, 0xC0, 0x3F, 0x7E, 0x00, 0x7C, 0x01,
  0xF9, 0xF0, 0x07, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x00, 0x7E, 0x7E, 0x01,
  0xF8, 0x03, 0xE3, 0xF0, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x7C, 0x01, 0xF8,
  0x7C, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x3F, 0x00, 0x7E, 0x1F, 0x81, 0xF8,
  0x03, 0xE0, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x1F,
  0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x3F, 0x00, 0x7E, 0x07, 0xE1, 0xF8, 0x03,
  0xE0, 0x1F, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0x07, 0xE7,
  0xE0, 0x0F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE0,
  0x07, 0xCF, 0x80, 0x3F, 0x00, 0x3F, 0x7C, 0x01, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x07, 0xE0, 0x01,
  0xFF, 0x80, 0x3F, 0x00, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F,
  0xC0, 0x03, 0xFF, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x07, 0xE0, 0x00, 0x7F,
  0x80, 0x3F, 0x00, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC1, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0xFF, 0xE0, 0x0F,
  0xC0, 0x7F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x07, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x03, 0xF8, 0x01,
  0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0x01,
  0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xE0, 0x1F, 0x80, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x7F, 0x3F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7E, 0x1F, 0xF8, 0x03,
  0xF0, 0x1F, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xC0,
  0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F,
  0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0x03,
  0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xF8, 0x03, 0xFC, 0x0F, 0xC0,
  0x3F, 0xC0, 0x7E, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xF8,
  0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0,
  0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0x00,
  0x3F, 0xC0, 0x18, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x04, 0x00, 0x0F, 0xE0, 0x1C,
  0x00, 0x7F, 0x80, 0x7E, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01,
  0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F,
  0x0F, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x3F,
  0x00, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7C, 0xFC, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x9F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0xC0, 0x0F,
  0xE1, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xFF, 0xC0, 0x1F, 0x81,
  0xF8, 0x07, 0xDF, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0x7C, 0x03, 0xF0, 0x1F,
  0x80, 0xF9, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xE7, 0xC0, 0x7E, 0x01, 0xF8,
  0x1F, 0x9F, 0x01, 0xF8, 0x07, 0xE0, 0x7C, 0x7C, 0x0F, 0xC0, 0x1F, 0x81,
  0xF1, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0x87, 0xC0, 0xFC, 0x01, 0xF8, 0x3E,
  0x1F, 0x07, 0xE0, 0x07, 0xC1, 0xF8, 0x7C, 0x1F, 0x80, 0x1F, 0x07, 0xC1,
  0xF0, 0xFC, 0x00, 0x7C, 0x3F, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x1F,
  0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x7C, 0x7E, 0x00, 0x1F, 0x1F, 0x81, 0xF1,
  0xF8, 0x00, 0x7C, 0x7C, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xF0, 0x1F, 0x3F,
  0x00, 0x07, 0xCF, 0x80, 0x7C, 0xFC, 0x00, 0x1F, 0x3E, 0x01, 0xF7, 0xE0,
  0x00, 0x7D, 0xF8, 0x07, 0xDF, 0x80, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x00,
  0x07, 0xDF, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x1F, 0xC0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x03, 0xF0,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x03,
  0xFB, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x87, 0xE0,
  0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFE, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC3, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xCF,
  0xC0, 0x03, 0xF7, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F,
  0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x0F,
  0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xF1, 0xF0, 0x00,
  0x7E, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F,
  0x80, 0x1F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x3F,
  0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x1F,
  0x8F, 0x80, 0x01, 0xF3, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7C, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07,
  0xC0, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0x00, 0x7F, 0xE3,
  0xE0, 0x1F, 0xFF, 0x3E, 0x03, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0xFE, 0x07,
  0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01,
  0xFC, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x83,
  0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7E, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC,
  0x0F, 0xC0, 0x3F, 0xC0, 0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xEF, 0x80, 0x3F, 0xFC, 0xF8, 0x03, 0xFF, 0x8F,
  0x80, 0x1F, 0xE0, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x80, 0x01, 0xF8, 0x7F,
  0x80, 0x1F, 0x9F, 0xFC, 0x01, 0xFB, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01,
  0xF7, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0x03, 0xFE, 0x07, 0xF0, 0x3F, 0xC0,
  0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0,
  0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xE1, 0xF8,
  0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F,
  0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x7F,
  0xC0, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7D, 0xFF, 0xFC, 0x07, 0xCF, 0xFF,
  0x80, 0x7C, 0x7F, 0xF0, 0x0F, 0x83, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFE, 0x02, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x04, 0x0F,
  0xE0, 0x30, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x40, 0x7E, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x7F, 0xF3, 0xF0, 0x01, 0xFF,
  0xF7, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xC1,
  0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8,
  0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x07,
  0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xFC, 0x01, 0xFC,
  0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xEF, 0x80, 0x07, 0xFF, 0x9F, 0x00, 0x0F, 0xFE, 0x3E, 0x00, 0x0F, 0xF8,
  0x7C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFC, 0x7F,
  0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFE,
  0x7E, 0x03, 0xFC, 0x7E, 0x3F, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x60,
  0x7F, 0xC3, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x84, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x8F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F,
  0xF0, 0x7C, 0x00, 0x3F, 0xF1, 0xF0, 0x01, 0xFF, 0xF3, 0xE0, 0x07, 0xFF,
  0xF7, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x03,
  0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0,
  0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x80, 0x7E,
  0x00, 0xFE, 0x00, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xF8, 0x03, 0xF8,
  0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xBF, 0x00, 0x0F, 0xFE, 0x7E, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x03, 0x83,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x02, 0x00, 0x07, 0xE0, 0x06, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xC0, 0x01, 0xF8, 0x7F,
  0x80, 0x1F, 0x9F, 0xFC, 0x01, 0xFB, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01,
  0xF7, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0x03, 0xFE, 0x07, 0xF0, 0x3F, 0xC0,
  0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0,
  0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F,
  0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x87, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7F,
  0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7C, 0x3F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xFB,
  0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7D, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xBF, 0x00, 0x07, 0xF9, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8,
  0x7F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7F,
  0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x30, 0x00, 0x7C, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F,
  0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xCF, 0xFF, 0x1F, 0xFE, 0x01, 0xF7, 0xFF,
  0xEF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF, 0xE1,
  0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xC0,
  0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0xFC,
  0x01, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0x0F, 0xF8, 0x01,
  0xF1, 0xFF, 0xC0, 0x1F, 0x3F, 0xFE, 0x01, 0xF7, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0x03, 0xFC, 0x07, 0xF0,
  0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF0,
  0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFE,
  0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC,
  0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x07,
  0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x1F, 0x8F,
  0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xF9,
  0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F,
  0xBF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x03,
  0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0xFC, 0xFC, 0x00,
  0x7E, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x8F, 0xE0,
  0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x1F, 0xE0, 0x00, 0xF8, 0xFF, 0xE0,
  0x01, 0xF3, 0xFF, 0xE0, 0x03, 0xEF, 0xFF, 0xC0, 0x07, 0xDF, 0xFF, 0xC0,
  0x1F, 0xF8, 0x3F, 0x80, 0x3F, 0xE0, 0x7F, 0x00, 0x7F, 0x80, 0x7E, 0x00,
  0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0,
  0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x03,
  0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xEF, 0xFF, 0xC0, 0x0F, 0xDF, 0xFF, 0x00, 0x1F, 0x9F, 0xFC, 0x00,
  0x3E, 0x1F, 0xE0, 0x00, 0xFC, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0x00, 0x7F, 0xE3,
  0xE0, 0x1F, 0xFF, 0x3E, 0x01, 0xFF, 0xFB, 0xE0, 0x3F, 0xFF, 0xFE, 0x07,
  0xF8, 0x3F, 0xE0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01,
  0xFC, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83,
  0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC,
  0x0F, 0xC0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0xFF, 0xC0, 0x7F,
  0xFE, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFD, 0xF8, 0x03, 0xFF, 0x9F,
  0x80, 0x1F, 0xE1, 0xF8, 0x00, 0x38, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1C,
  0x03, 0xE1, 0xFC, 0x07, 0xC7, 0xF8, 0x0F, 0x9F, 0xE0, 0x1F, 0x7F, 0xC0,
  0x3E, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0x9F, 0x83, 0xF8, 0x06, 0x07, 0xE0,
  0x04, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x08, 0x00,
  0xFE, 0x1C, 0x03, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF,
  0xFE, 0x7F, 0xFF, 0x81, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x30, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x1F,
  0x80, 0x3F, 0x83, 0xF0, 0x0F, 0xF0, 0x7E, 0x03, 0xFC, 0x0F, 0xE0, 0xFF,
  0x81, 0xFF, 0xFD, 0xF0, 0x1F, 0xFF, 0xBE, 0x03, 0xFF, 0xE7, 0xC0, 0x3F,
  0xF9, 0xF0, 0x03, 0xFC, 0x3E, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xF8, 0x00, 0x7D, 0xF8, 0x00, 0x7D, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xF0,
  0x07, 0xEF, 0xC0, 0x3F, 0xC0, 0x1F, 0xBF, 0x00, 0xFF, 0x00, 0xFC, 0xFC,
  0x03, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0xC0,
  0x7E, 0x3F, 0x03, 0xFF, 0x01, 0xF8, 0xFC, 0x0F, 0xFC, 0x0F, 0xC3, 0xF0,
  0x3D, 0xF0, 0x3F, 0x0F, 0xC1, 0xF7, 0xC0, 0xF8, 0x3F, 0x07, 0xDF, 0x07,
  0xE0, 0xF8, 0x3E, 0x7C, 0x1F, 0x83, 0xE0, 0xF9, 0xF0, 0xFC, 0x0F, 0x83,
  0xC7, 0xC3, 0xF0, 0x3E, 0x1F, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x7C, 0x7E,
  0x03, 0xE3, 0xE1, 0xF1, 0xF0, 0x0F, 0x8F, 0x87, 0xCF, 0xC0, 0x3E, 0x7C,
  0x1F, 0x3F, 0x00, 0xF9, 0xF0, 0x7C, 0xF8, 0x03, 0xE7, 0xC1, 0xF7, 0xE0,
  0x0F, 0xBE, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x1F, 0x7C, 0x00, 0xFB, 0xC0,
  0x7F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF0,
  0x1F, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7D, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC,
  0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0xC0,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00,
  0x1F, 0x1F, 0x80, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x78, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x47, 0xFC, 0x00,
  0x17, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFB, 0x00, 0x1F, 0xFC, 0x80, 0x01, 0xFC, 0x00,
};

const GFXglyph NotoSans_Condensed_MediumItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 16, 46, 16, 1, -45 },
  { 93, 20, 16, 23, 6, -45 },
  { 133, 32, 45, 32, 1, -45 },
  { 313, 28, 52, 28, 1, -48 },
  { 495, 37, 47, 43, 4, -46 },
  { 713, 32, 47, 33, 0, -46 },
  { 901, 9, 16, 13, 6, -45 },
  { 919, 21, 55, 17, 1, -45 },
  { 1064, 21, 55, 17, -5, -45 },
  { 1209, 23, 25, 27, 6, -48 },
  { 1281, 26, 30, 30, 3, -37 },
  { 1379, 12, 15, 14, -3, -7 },
  { 1402, 15, 6, 18, 1, -20 },
  { 1414, 8, 9, 14, 1, -8 },
  { 1423, 30, 45, 22, -3, -45 },
  { 1592, 26, 47, 28, 2, -46 },
  { 1745, 18, 45, 28, 7, -45 },
  { 1847, 30, 46, 28, -2, -46 },
  { 2020, 28, 47, 28, 0, -46 },
  { 2185, 29, 45, 28, -1, -45 },
  { 2349, 28, 46, 28, 0, -45 },
  { 2510, 27, 47, 28, 2, -46 },
  { 2669, 28, 45, 28, 3, -45 },
  { 2827, 29, 47, 28, 0, -46 },
  { 2998, 27, 47, 28, 1, -46 },
  { 3157, 14, 35, 14, 0, -34 },
  { 3219, 17, 42, 14, -3, -34 },
  { 3309, 26, 29, 30, 3, -37 },
  { 3404, 26, 18, 30, 3, -31 },
  { 3463, 26, 29, 30, 3, -37 },
  { 3558, 22, 47, 22, 2, -46 },
  { 3688, 40, 50, 43, 2, -45 },
  { 3938, 30, 45, 30, -4, -45 },
  { 4107, 30, 45, 31, 1, -45 },
  { 4276, 30, 47, 29, 3, -46 },
  { 4453, 32, 45, 34, 1, -45 },
  { 4633, 28, 45, 26, 1, -45 },
  { 4791, 28, 45, 25, 1, -45 },
  { 4949, 33, 47, 35, 3, -46 },
  { 5143, 35, 45, 35, 1, -45 },
  { 5340, 26, 45, 19, -3, -45 },
  { 5487, 27, 57, 15, -10, -45 },
  { 5680, 34, 45, 29, 1, -45 },
  { 5872, 20, 45, 25, 1, -45 },
  { 5985, 45, 45, 45, 1, -45 },
  { 6239, 37, 45, 37, 1, -45 },
  { 6448, 32, 47, 36, 3, -46 },
  { 6636, 30, 45, 29, 1, -45 },
  { 6805, 32, 57, 36, 3, -46 },
  { 7033, 29, 45, 30, 1, -45 },
  { 7197, 30, 47, 27, -1, -46 },
  { 7374, 25, 45, 26, 5, -45 },
  { 7515, 33, 46, 34, 3, -45 },
  { 7705, 29, 45, 29, 6, -45 },
  { 7869, 46, 45, 46, 5, -45 },
  { 8128, 36, 45, 28, -4, -45 },
  { 8331, 26, 45, 27, 6, -45 },
  { 8478, 31, 45, 26, -2, -45 },
  { 8653, 25, 55, 18, -2, -45 },
  { 8825, 12, 45, 23, 6, -45 },
  { 8893, 24, 55, 18, -4, -45 },
  { 9058, 27, 26, 29, 1, -45 },
  { 9146, 22, 4, 21, -6, 5 },
  { 9157, 10, 10, 17, 9, -48 },
  { 9170, 28, 36, 30, 2, -35 },
  { 9296, 28, 49, 30, 0, -48 },
  { 9468, 23, 36, 23, 2, -35 },
  { 9572, 31, 49, 30, 2, -48 },
  { 9762, 24, 36, 27, 2, -35 },
  { 9870, 32, 63, 17, -7, -48 },
  { 10122, 31, 50, 30, -1, -35 },
  { 10316, 28, 48, 30, 0, -48 },
  { 10484, 16, 47, 14, 0, -47 },
  { 10578, 24, 62, 14, -8, -47 },
  { 10764, 29, 48, 27, 0, -48 },
  { 10938, 17, 48, 14, 0, -48 },
  { 11040, 42, 35, 44, 0, -35 },
  { 11224, 28, 35, 30, 0, -35 },
  { 11347, 25, 36, 29, 2, -35 },
  { 11460, 31, 50, 30, -3, -35 },
  { 11654, 28, 50, 30, 2, -35 },
  { 11829, 23, 35, 20, 0, -35 },
  { 11930, 23, 36, 23, 0, -35 },
  { 12034, 18, 43, 18, 2, -42 },
  { 12131, 27, 35, 30, 2, -34 },
  { 12250, 24, 34, 25, 4, -34 },
  { 12352, 38, 34, 39, 4, -34 },
  { 12514, 31, 34, 25, -3, -34 },
  { 12646, 34, 49, 25, -6, -34 },
  { 12855, 25, 34, 22, -2, -34 },
  { 12962, 24, 55, 21, 1, -45 },
  { 13127, 5, 63, 27, 11, -48 },
  { 13167, 23, 55, 21, -3, -45 },
  { 13326, 26, 9, 30, 3, -27 },
};

const GFXfont NotoSans_Condensed_MediumItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC63PT7B_H_
