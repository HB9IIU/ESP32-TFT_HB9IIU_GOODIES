#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC54PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x08, 0x00, 0x3F,
  0x1F, 0x9F, 0x8F, 0xCF, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8,
  0xF0, 0x78, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1E, 0x0F, 0x0F, 0x07,
  0x87, 0x83, 0xC7, 0x83, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0x83,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0x83, 0xC0, 0x00, 0x78,
  0x3C, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C,
  0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xE7, 0x1C, 0x07, 0xC7, 0x04, 0x0F, 0x86, 0x00, 0x0F, 0x8E,
  0x00, 0x0F, 0x8E, 0x00, 0x0F, 0x8E, 0x00, 0x0F, 0x8C, 0x00, 0x0F, 0xCC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x33, 0xF0, 0x00, 0x33, 0xF0, 0x00, 0x71, 0xF0, 0x00, 0x71,
  0xF0, 0x00, 0x61, 0xF0, 0x00, 0x61, 0xF0, 0x80, 0xE3, 0xF0, 0xC0, 0xE3,
  0xE0, 0xF0, 0xEF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x7C, 0x03, 0xF8, 0x00, 0x78, 0x07, 0xFC, 0x00, 0xF0, 0x0F, 0xFE,
  0x00, 0xF0, 0x1F, 0x1E, 0x01, 0xE0, 0x1E, 0x1E, 0x03, 0xE0, 0x3C, 0x1E,
  0x03, 0xC0, 0x3C, 0x1E, 0x07, 0x80, 0x7C, 0x1E, 0x07, 0x80, 0x78, 0x1E,
  0x0F, 0x00, 0x78, 0x1E, 0x1F, 0x00, 0x78, 0x3E, 0x1E, 0x00, 0xF8, 0x3C,
  0x3E, 0x00, 0xF0, 0x3C, 0x3C, 0x00, 0xF0, 0x3C, 0x78, 0x00, 0xF0, 0x7C,
  0x78, 0x30, 0xF0, 0x78, 0xF1, 0xFC, 0xF0, 0x79, 0xF3, 0xFE, 0xF0, 0xF1,
  0xE7, 0xFF, 0xF1, 0xF3, 0xC7, 0x8F, 0xFF, 0xE3, 0xCF, 0x8F, 0x7F, 0xC7,
  0x8F, 0x0F, 0x3F, 0x8F, 0x9E, 0x0F, 0x1F, 0x0F, 0x1E, 0x0F, 0x00, 0x1E,
  0x1E, 0x0F, 0x00, 0x1E, 0x3E, 0x0F, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x7C,
  0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x1F, 0x00, 0xF0, 0x3C, 0x1E, 0x00, 0xF0,
  0x3C, 0x1E, 0x01, 0xE0, 0x7C, 0x1E, 0x03, 0xE0, 0x78, 0x3C, 0x03, 0xC0,
  0x78, 0x3C, 0x07, 0xC0, 0x3C, 0x78, 0x07, 0x80, 0x3C, 0xF8, 0x0F, 0x00,
  0x3F, 0xF0, 0x1F, 0x00, 0x1F, 0xE0, 0x1E, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x07, 0xC0,
  0x07, 0xC1, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF3,
  0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x3E, 0x1F, 0xFE, 0x07, 0xC3, 0xE7, 0xE0, 0xF8, 0xF8, 0x7C, 0x3E, 0x3F,
  0x0F, 0xC7, 0xC7, 0xC0, 0xF9, 0xF1, 0xF0, 0x1F, 0xBE, 0x3E, 0x01, 0xFF,
  0x87, 0xC0, 0x3F, 0xF1, 0xF8, 0x07, 0xFC, 0x3F, 0x00, 0x7F, 0x07, 0xE0,
  0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0xFF, 0x81, 0xF8, 0x3F, 0xF8,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xF3, 0xF0, 0x3F, 0xFC, 0x7E, 0x03, 0xFE,
  0x07, 0xE0, 0x06, 0x00, 0x00, 0x3E, 0xFD, 0xFB, 0xE7, 0xCF, 0x9E, 0x3C,
  0xF9, 0xF3, 0xC7, 0x8F, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x40, 0x78,
  0x07, 0x07, 0x80, 0x7C, 0x70, 0x07, 0xF7, 0x07, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xF8, 0x00, 0xFB, 0x80, 0x1F,
  0xBC, 0x03, 0xF3, 0xE0, 0x7E, 0x1E, 0x03, 0xC1, 0xF0, 0x1C, 0x1F, 0x00,
  0x80, 0xE0, 0x00, 0x08, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8,
  0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x80, 0x7F,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x00, 0x39, 0xFF, 0xFF, 0xFF,
  0xFF, 0x88, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xC3, 0xE0, 0x7E, 0x0F, 0xC1, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3E, 0x01,
  0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF3,
  0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x7E, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0,
  0x0F, 0x9F, 0x00, 0x3E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0x80, 0x1F,
  0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3E, 0x3E,
  0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x3E, 0x03,
  0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x1E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0x87, 0xFF,
  0x1F, 0xFE, 0x7F, 0x7D, 0xF9, 0xF9, 0xE3, 0xE3, 0x87, 0xC2, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0x81, 0xFC, 0x03, 0x80, 0x7E, 0x00,
  0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xE0, 0x7F, 0x00, 0x80, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x80, 0x0F, 0xE0, 0xF0, 0x3F, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xDF, 0x00, 0x03,
  0xEF, 0x80, 0x01, 0xE7, 0xC0, 0x01, 0xE3, 0xE0, 0x01, 0xF3, 0xE0, 0x00,
  0xF1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0x78, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3C, 0x07, 0xC0,
  0x3C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1E, 0x00, 0xF8,
  0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0xC0, 0x0F, 0xE0, 0xF0,
  0x3F, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFD, 0xC0, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0x00,
  0x1F, 0x1F, 0xC0, 0x3E, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xFC, 0x3F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0x3E, 0x3F, 0x00, 0x7C, 0x7E,
  0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0,
  0x1F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03,
  0xF0, 0xF8, 0x07, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0xFE, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x40, 0x00,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xC7,
  0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3F, 0x03, 0xE0,
  0x1F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xC3, 0xF0, 0x03, 0xF3, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F,
  0x07, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF8, 0x01,
  0xF0, 0x7C, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x1F, 0x07, 0xE0,
  0x3E, 0x0F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xF8, 0x03,
  0xF1, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x1F, 0x80, 0x3E,
  0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7C, 0x07, 0xF0, 0xFC, 0x1F, 0xE1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xBE, 0x03, 0xFE, 0x7C, 0x03,
  0xF1, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x02, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x3F,
  0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xE0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC0, 0x7C, 0x01, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFB, 0xFC, 0x18, 0x0F, 0x84, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF0,
  0x07, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x03, 0xFE, 0x0F, 0x0F, 0x01, 0xFF,
  0xC3, 0xC7, 0x81, 0xFF, 0xE0, 0xF1, 0xE0, 0x78, 0x78, 0x3C, 0xF0, 0x3C,
  0x1E, 0x0F, 0x3C, 0x1E, 0x07, 0x83, 0xCF, 0x07, 0x83, 0xC0, 0xF7, 0x83,
  0xC0, 0xF0, 0x3D, 0xE0, 0xF0, 0x3C, 0x0E, 0x78, 0x78, 0x0F, 0x07, 0xBC,
  0x1E, 0x07, 0x81, 0xEF, 0x07, 0x81, 0xE0, 0x7B, 0xC1, 0xE0, 0x78, 0x1C,
  0xF0, 0xF0, 0x3E, 0x0F, 0x3C, 0x3C, 0x0F, 0x83, 0xCF, 0x0F, 0x03, 0xC1,
  0xE3, 0xC3, 0xC1, 0xF0, 0x78, 0xF0, 0xF8, 0xFC, 0x3C, 0x3C, 0x1F, 0x7F,
  0xBE, 0x0F, 0x07, 0xFD, 0xFF, 0x03, 0xC0, 0xFE, 0x3F, 0x80, 0xF0, 0x1E,
  0x07, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x40, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xE7, 0xC0,
  0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x07,
  0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xE0,
  0x7C, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xCF,
  0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7C, 0x0F, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0,
  0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x07,
  0xE0, 0x7C, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07,
  0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00,
  0x7E, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x7C,
  0x01, 0xF8, 0x1F, 0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0x80, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x08,
  0x03, 0xFC, 0x3C, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x03, 0xE0, 0xFF, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xE0, 0x0F, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x83, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F,
  0x87, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xC0,
  0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x07, 0xF0, 0x7C, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xE0, 0x7C, 0x03, 0xF8, 0x0F,
  0x81, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x70,
  0x07, 0xF0, 0x00, 0x80, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0xF0, 0xFC,
  0x03, 0xFF, 0x87, 0xE0, 0x1F, 0xFC, 0x3E, 0x00, 0xFF, 0xC1, 0xF0, 0x0F,
  0xFE, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xF8,
  0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x7F, 0x00,
  0x3E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xF8, 0x3F, 0x80, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0,
  0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x01,
  0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC,
  0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01,
  0xF0, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7E, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0,
  0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0,
  0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01,
  0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x83, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x7E, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x03,
  0xE0, 0x1F, 0x80, 0x1F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0x78,
  0x00, 0xFB, 0xE0, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x7D, 0xF0, 0x07, 0xDF,
  0x00, 0xFB, 0xE0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x07, 0xCF,
  0x80, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x03, 0xE7,
  0xC0, 0x3E, 0x7C, 0x07, 0x8F, 0x80, 0x7C, 0xF8, 0x1F, 0x1F, 0x01, 0xF0,
  0xF0, 0x3C, 0x7E, 0x03, 0xE1, 0xE0, 0xF8, 0xF8, 0x07, 0xC3, 0xC1, 0xE1,
  0xF0, 0x0F, 0x87, 0x87, 0xC3, 0xE0, 0x1F, 0x0F, 0x0F, 0x07, 0xC0, 0x7C,
  0x1E, 0x3E, 0x1F, 0x80, 0xF8, 0x3C, 0x78, 0x3E, 0x01, 0xF0, 0x79, 0xF0,
  0x7C, 0x03, 0xE0, 0xF3, 0xC0, 0xF8, 0x07, 0xC1, 0xFF, 0x81, 0xF0, 0x1F,
  0x03, 0xFE, 0x07, 0xC0, 0x3E, 0x07, 0xFC, 0x0F, 0x80, 0x7C, 0x0F, 0xF8,
  0x1F, 0x00, 0xF8, 0x1F, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0xC0, 0xFC, 0x07,
  0xC0, 0x7F, 0x01, 0xF0, 0x0F, 0x80, 0xFE, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0x01, 0xFC, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0x3E,
  0x01, 0xFE, 0x00, 0x3E, 0x01, 0xFE, 0x00, 0x3E, 0x03, 0xFE, 0x00, 0x7C,
  0x03, 0xFE, 0x00, 0x7C, 0x03, 0xFF, 0x00, 0x7C, 0x03, 0xDF, 0x00, 0x7C,
  0x03, 0xDF, 0x00, 0xFC, 0x07, 0xDF, 0x00, 0xF8, 0x07, 0xCF, 0x00, 0xF8,
  0x07, 0xCF, 0x80, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0x0F, 0x8F, 0x81, 0xF0,
  0x0F, 0x87, 0x81, 0xF0, 0x0F, 0x87, 0xC1, 0xF0, 0x0F, 0x87, 0xC1, 0xF0,
  0x0F, 0x87, 0xC1, 0xF0, 0x1F, 0x07, 0xC3, 0xE0, 0x1F, 0x03, 0xC3, 0xE0,
  0x1F, 0x03, 0xE3, 0xE0, 0x1F, 0x03, 0xE3, 0xE0, 0x1F, 0x03, 0xE3, 0xE0,
  0x3E, 0x01, 0xE7, 0xC0, 0x3E, 0x01, 0xF7, 0xC0, 0x3E, 0x01, 0xF7, 0xC0,
  0x3E, 0x01, 0xF7, 0xC0, 0x3E, 0x01, 0xF7, 0xC0, 0x7C, 0x00, 0xFF, 0x80,
  0x7C, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0xFF, 0x80,
  0xF8, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x7F, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7E, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00,
  0x1F, 0x87, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0,
  0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0xC7, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x05, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0x83, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0,
  0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xFC,
  0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x3F,
  0x03, 0xE0, 0x3F, 0x81, 0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x07, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F,
  0x1F, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7E, 0x7C,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x87,
  0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0xC7, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0x83,
  0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x81, 0xF0,
  0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3E,
  0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x7E, 0x07,
  0xC0, 0x7F, 0x03, 0xE0, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80,
  0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0x01, 0xC0, 0x3F, 0x80, 0x10, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x40, 0x03, 0xF0, 0x18, 0x01, 0xFC, 0x07, 0xE7,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80,
  0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x3F,
  0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07,
  0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F,
  0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07,
  0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F,
  0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x07,
  0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0x80,
  0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xE7, 0xC0,
  0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x7C,
  0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3E, 0x07,
  0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xF0,
  0x03, 0xC1, 0xF0, 0x01, 0xE1, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7F, 0xF0, 0x00, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xF0, 0x01, 0xF7,
  0xC0, 0x07, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0xC0, 0x0F, 0x9F, 0x00, 0x3F,
  0x80, 0x3F, 0x3E, 0x00, 0xFF, 0x00, 0x7C, 0x7C, 0x01, 0xFE, 0x00, 0xF8,
  0xF8, 0x03, 0xFC, 0x03, 0xE1, 0xF0, 0x0F, 0xF8, 0x07, 0xC3, 0xE0, 0x1F,
  0xF0, 0x1F, 0x87, 0xC0, 0x7F, 0xE0, 0x3E, 0x0F, 0x80, 0xF7, 0xC0, 0x7C,
  0x1F, 0x01, 0xEF, 0x81, 0xF0, 0x3E, 0x07, 0xDF, 0x03, 0xE0, 0x7C, 0x0F,
  0x3E, 0x0F, 0xC0, 0xF8, 0x3E, 0x7C, 0x1F, 0x01, 0xF0, 0x78, 0xF8, 0x3E,
  0x03, 0xE1, 0xF1, 0xF0, 0xF8, 0x07, 0xC3, 0xE3, 0xE1, 0xF0, 0x0F, 0x87,
  0x87, 0x87, 0xE0, 0x1F, 0x1F, 0x0F, 0x0F, 0x80, 0x3E, 0x3C, 0x1E, 0x1F,
  0x00, 0x7C, 0xF8, 0x3C, 0x7C, 0x00, 0xF9, 0xF0, 0x78, 0xF8, 0x01, 0xF3,
  0xC0, 0xF3, 0xE0, 0x03, 0xEF, 0x81, 0xE7, 0xC0, 0x07, 0xDE, 0x03, 0xCF,
  0x80, 0x0F, 0xFC, 0x07, 0xBE, 0x00, 0x1E, 0xF8, 0x0F, 0x7C, 0x00, 0x3D,
  0xE0, 0x1E, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xC0,
  0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFB, 0xE0, 0x03,
  0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x1F, 0x01, 0xF8,
  0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x7E, 0x03,
  0xF0, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x00, 0x1F,
  0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xF0, 0x78, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C,
  0x1E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x1E, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x04, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xF3,
  0xC0, 0x03, 0xE7, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3C, 0x1F,
  0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0xF8,
  0x3C, 0x00, 0xF0, 0xF8, 0x01, 0xF1, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xDF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFC, 0xFC, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x0F, 0x00, 0x18,
  0x00, 0x01, 0xFE, 0x3C, 0x07, 0xFC, 0x78, 0x1F, 0xFD, 0xF0, 0x7F, 0xFF,
  0xE1, 0xFC, 0x3F, 0xC7, 0xF0, 0x7F, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC,
  0x7E, 0x01, 0xF8, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0,
  0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x00,
  0xFC, 0x3E, 0x01, 0xF8, 0x7C, 0x07, 0xF0, 0xF8, 0x1F, 0xE1, 0xF8, 0x7F,
  0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xBE, 0x07, 0xFE, 0x7C, 0x03, 0xF8, 0xF0,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0xE0, 0x03, 0xE3, 0xF8, 0x03, 0xE7, 0xFC, 0x03, 0xEF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFC, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xF0,
  0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0,
  0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x3F, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x3F, 0x00,
  0x7C, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x3F, 0x01,
  0xF8, 0x7F, 0x03, 0xF0, 0x7F, 0x87, 0xF0, 0x7F, 0xFF, 0xE0, 0x7B, 0xFF,
  0xC0, 0x79, 0xFF, 0x80, 0xF8, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0E,
  0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xC1,
  0x87, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x02, 0x1F, 0xC1, 0x81,
  0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0xE0, 0xFC, 0x00, 0xFE, 0x3E, 0x00, 0x7F, 0xEF, 0x80, 0x3F, 0xFB,
  0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x07,
  0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0xFC, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x3E,
  0x01, 0xF8, 0x0F, 0x80, 0xFE, 0x03, 0xE0, 0x7F, 0x00, 0xFC, 0x3F, 0xC0,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0x7C, 0x01, 0xFF, 0x9F, 0x00, 0x1F, 0xC7,
  0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0xFC, 0x1F, 0x1F, 0x81, 0xF1, 0xF0,
  0x1F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x7E, 0x03, 0xF7, 0xC0, 0x7E, 0x7C,
  0x0F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x01, 0x0F, 0xE0, 0x30, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0x84, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xE3, 0xC0, 0x1F, 0xF9, 0xE0,
  0x1F, 0xFD, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xC3, 0xFC, 0x1F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F,
  0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x3F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0xF8,
  0x07, 0xE0, 0x7C, 0x07, 0xF0, 0x3E, 0x07, 0xF8, 0x1F, 0x87, 0xF8, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xBE, 0x01, 0xFF, 0x9F, 0x00, 0x7F, 0x9F, 0x00,
  0x04, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x08, 0x00, 0xF8, 0x06, 0x00, 0xFC,
  0x03, 0xF7, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0xE0, 0x03, 0xE3, 0xFC, 0x03, 0xE7, 0xFC, 0x03,
  0xEF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFC, 0x3F, 0x07, 0xF0, 0x3F, 0x07,
  0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F,
  0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7C, 0x1F,
  0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x1F,
  0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E,
  0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C,
  0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0x00, 0x78, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x1F, 0x01, 0xF8, 0x0F, 0x81,
  0xF8, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0xFC, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFD, 0xF0, 0x00, 0xFC, 0xF8, 0x00,
  0x7C, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xE0,
  0x0F, 0x83, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3F,
  0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xE0, 0x06, 0x00, 0x3E, 0x3F, 0x81, 0xFC, 0x03, 0xCF, 0xFC, 0x7F,
  0xE0, 0x3D, 0xFF, 0xEF, 0xFF, 0x03, 0xDF, 0xFF, 0xFF, 0xF0, 0x7F, 0x87,
  0xFC, 0x3F, 0x07, 0xF0, 0x3F, 0x81, 0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x01,
  0xF0, 0xFC, 0x07, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0xF8, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x03, 0xE1, 0xF8, 0x07, 0xC0, 0x3E, 0x1F,
  0x00, 0xFC, 0x07, 0xE1, 0xF0, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x07,
  0xC1, 0xF0, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x07, 0xC3, 0xE0, 0x1F,
  0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0xF8, 0x7E,
  0x01, 0xF0, 0x0F, 0x87, 0xC0, 0x3F, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0x1F,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E,
  0x01, 0xF0, 0x00, 0x00, 0xE0, 0x03, 0xE3, 0xFC, 0x03, 0xC7, 0xFE, 0x03,
  0xCF, 0xFE, 0x03, 0xDF, 0xFE, 0x07, 0xFC, 0x3F, 0x07, 0xF0, 0x3F, 0x07,
  0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F,
  0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7C, 0x1F,
  0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x3F,
  0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E,
  0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C,
  0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xFC, 0x03, 0xE0, 0x00, 0x0C, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xE0, 0xFC,
  0x7E, 0x07, 0xE3, 0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x80,
  0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7D, 0xF0, 0x03,
  0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xF8, 0xFC,
  0x0F, 0xC7, 0xF0, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3E, 0x3F,
  0x80, 0x0F, 0x1F, 0xF0, 0x03, 0xCF, 0xFE, 0x00, 0xF7, 0xFF, 0xC0, 0x3F,
  0xC3, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x1F, 0x01, 0xF8, 0x07, 0xC0,
  0x7E, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFF, 0xFF, 0x80, 0x7D, 0xFF,
  0xC0, 0x1F, 0x7F, 0xE0, 0x0F, 0xCF, 0xF0, 0x03, 0xE0, 0x40, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFE, 0x3C, 0x07, 0xFE, 0x78, 0x1F,
  0xFD, 0xF0, 0x7F, 0xFF, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0,
  0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xF8, 0x03, 0xE3, 0xF0, 0x07,
  0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xF8,
  0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F,
  0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x7C, 0x07, 0xF0, 0xF8,
  0x1F, 0xC1, 0xF8, 0x7F, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xBE, 0x07, 0xFE,
  0x7C, 0x07, 0xF9, 0xF0, 0x01, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x3E, 0x3F, 0x03,
  0xCF, 0xE0, 0x3C, 0xFE, 0x03, 0xDF, 0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x0C,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x80, 0x3F, 0x0E,
  0x07, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x0F, 0xFF, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF0,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x00, 0x40,
  0x00, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7C, 0x03,
  0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7C,
  0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3,
  0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C,
  0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0x80,
  0x7E, 0x1F, 0x01, 0xFC, 0x3E, 0x03, 0xF0, 0x7C, 0x0F, 0xE0, 0xFC, 0x3F,
  0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xDE, 0x03, 0xFF, 0x3C, 0x03, 0xFC, 0x78,
  0x00, 0x80, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0xFD,
  0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01,
  0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x7E, 0x07,
  0x83, 0xE0, 0x3C, 0x3F, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0x7C, 0xF8,
  0x03, 0xE7, 0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0xFC, 0x03, 0xF0, 0x0F, 0xBE, 0x01, 0xF8, 0x07, 0xDF, 0x01, 0xFC,
  0x07, 0xCF, 0x80, 0xFE, 0x03, 0xE7, 0xC0, 0xFF, 0x03, 0xF3, 0xE0, 0x7F,
  0x81, 0xF1, 0xF0, 0x3F, 0xC0, 0xF8, 0xF8, 0x3D, 0xE0, 0xF8, 0x7C, 0x1E,
  0xF0, 0x7C, 0x3E, 0x1F, 0x78, 0x7C, 0x1F, 0x0F, 0x3C, 0x3E, 0x0F, 0x8F,
  0x9E, 0x1F, 0x07, 0xC7, 0x8F, 0x1F, 0x03, 0xE3, 0xC7, 0x8F, 0x81, 0xF3,
  0xE3, 0xCF, 0x80, 0xF9, 0xE1, 0xE7, 0xC0, 0x7D, 0xF0, 0xF3, 0xC0, 0x3E,
  0xF0, 0x7B, 0xE0, 0x1F, 0x78, 0x3D, 0xF0, 0x0F, 0xFC, 0x1E, 0xF0, 0x07,
  0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE7, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xBE, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x7E, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x3E,
  0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xF8,
  0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x00, 0x02, 0x7F, 0xE0, 0x0D, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xB0, 0x03,
  0xFE, 0x40, 0x00, 0x60,
};

const GFXglyph NotoSans_Condensed_MediumItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 14, 40, 13, 1, -39 },
  { 71, 17, 14, 20, 5, -39 },
  { 101, 28, 39, 27, 0, -39 },
  { 238, 24, 44, 24, 1, -41 },
  { 370, 32, 40, 37, 3, -39 },
  { 530, 27, 40, 28, 0, -39 },
  { 665, 7, 14, 11, 6, -39 },
  { 678, 18, 48, 15, 1, -39 },
  { 786, 17, 48, 15, -4, -39 },
  { 888, 20, 21, 23, 5, -41 },
  { 941, 22, 26, 26, 3, -32 },
  { 1013, 11, 13, 12, -3, -6 },
  { 1031, 13, 5, 15, 1, -17 },
  { 1040, 6, 8, 12, 1, -7 },
  { 1046, 26, 39, 19, -3, -39 },
  { 1173, 22, 40, 24, 2, -39 },
  { 1283, 15, 39, 24, 6, -39 },
  { 1357, 25, 39, 24, -1, -39 },
  { 1479, 24, 40, 24, 0, -39 },
  { 1599, 25, 39, 24, -1, -39 },
  { 1721, 24, 40, 24, 0, -39 },
  { 1841, 23, 40, 24, 2, -39 },
  { 1956, 24, 39, 24, 2, -39 },
  { 2073, 25, 40, 24, 0, -39 },
  { 2198, 23, 40, 24, 1, -39 },
  { 2313, 12, 30, 12, 0, -29 },
  { 2358, 15, 36, 12, -3, -29 },
  { 2426, 23, 25, 26, 2, -32 },
  { 2498, 22, 16, 26, 3, -27 },
  { 2542, 22, 25, 26, 3, -32 },
  { 2611, 19, 40, 19, 2, -39 },
  { 2706, 34, 44, 37, 2, -39 },
  { 2893, 25, 39, 25, -3, -39 },
  { 3015, 26, 39, 27, 1, -39 },
  { 3142, 26, 40, 25, 2, -39 },
  { 3272, 27, 39, 29, 1, -39 },
  { 3404, 24, 39, 23, 1, -39 },
  { 3521, 24, 39, 21, 1, -39 },
  { 3638, 29, 40, 30, 2, -39 },
  { 3783, 30, 39, 30, 1, -39 },
  { 3930, 22, 39, 16, -2, -39 },
  { 4038, 22, 50, 13, -8, -39 },
  { 4176, 29, 39, 25, 1, -39 },
  { 4318, 17, 39, 21, 1, -39 },
  { 4401, 39, 39, 39, 1, -39 },
  { 4592, 32, 39, 32, 1, -39 },
  { 4748, 28, 40, 31, 2, -39 },
  { 4888, 25, 39, 25, 1, -39 },
  { 5010, 28, 48, 31, 2, -39 },
  { 5178, 25, 39, 26, 1, -39 },
  { 5300, 26, 40, 23, -1, -39 },
  { 5430, 22, 39, 22, 4, -39 },
  { 5538, 29, 40, 29, 2, -39 },
  { 5683, 25, 39, 25, 5, -39 },
  { 5805, 39, 39, 39, 5, -39 },
  { 5996, 31, 39, 24, -3, -39 },
  { 6148, 23, 39, 23, 5, -39 },
  { 6261, 27, 39, 22, -2, -39 },
  { 6393, 20, 48, 16, -1, -39 },
  { 6513, 9, 39, 19, 6, -39 },
  { 6557, 21, 48, 16, -4, -39 },
  { 6683, 23, 23, 25, 1, -39 },
  { 6750, 19, 3, 18, -5, 5 },
  { 6758, 8, 8, 15, 8, -41 },
  { 6766, 23, 31, 26, 2, -30 },
  { 6856, 24, 42, 26, 0, -41 },
  { 6982, 19, 31, 20, 2, -30 },
  { 7056, 26, 42, 26, 2, -41 },
  { 7193, 20, 31, 23, 2, -30 },
  { 7271, 27, 54, 15, -6, -41 },
  { 7454, 25, 43, 26, 0, -30 },
  { 7589, 24, 41, 26, 0, -41 },
  { 7712, 14, 40, 12, 0, -40 },
  { 7782, 21, 53, 12, -7, -40 },
  { 7922, 25, 41, 23, 0, -41 },
  { 8051, 14, 41, 12, 0, -41 },
  { 8123, 36, 30, 38, 0, -30 },
  { 8258, 24, 30, 26, 0, -30 },
  { 8348, 21, 31, 25, 2, -30 },
  { 8430, 26, 43, 26, -2, -30 },
  { 8570, 23, 43, 26, 2, -30 },
  { 8694, 20, 30, 18, 0, -30 },
  { 8769, 20, 31, 20, 0, -30 },
  { 8847, 15, 37, 15, 2, -36 },
  { 8917, 23, 30, 26, 2, -29 },
  { 9004, 21, 29, 21, 3, -29 },
  { 9081, 33, 29, 33, 3, -29 },
  { 9201, 26, 29, 22, -2, -29 },
  { 9296, 29, 42, 21, -5, -29 },
  { 9449, 22, 29, 19, -2, -29 },
  { 9529, 21, 48, 18, 1, -39 },
  { 9655, 5, 54, 23, 9, -41 },
  { 9689, 20, 48, 18, -3, -39 },
  { 9809, 23, 8, 26, 2, -23 },
};

const GFXfont NotoSans_Condensed_MediumItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC54PT7B_H_
