#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC53PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x00, 0x80, 0x00, 0x3F, 0x1F, 0x9F, 0x0F, 0x8F, 0x87, 0xC7,
  0xC3, 0xE3, 0xE3, 0xE1, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x3C,
  0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C,
  0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0x03, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x3C,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0x8C, 0x30, 0x3E, 0x18, 0x00, 0x7C, 0x70, 0x00, 0xF8,
  0xE0, 0x01, 0xF1, 0x80, 0x03, 0xE3, 0x00, 0x07, 0xC6, 0x00, 0x0F, 0xDC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x37, 0xE0,
  0x00, 0xE7, 0xC0, 0x01, 0xCF, 0xC0, 0x03, 0x8F, 0x80, 0x06, 0x1F, 0x00,
  0x0C, 0x3C, 0x00, 0x38, 0xF8, 0x60, 0x73, 0xF0, 0xF0, 0xCF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x78,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x78, 0x07, 0xF8, 0x00, 0xF0,
  0x0F, 0xFC, 0x00, 0xF0, 0x1F, 0x3C, 0x01, 0xE0, 0x1E, 0x3E, 0x03, 0xC0,
  0x3C, 0x1E, 0x03, 0xC0, 0x3C, 0x1E, 0x07, 0x80, 0x3C, 0x1E, 0x07, 0x80,
  0x78, 0x3E, 0x0F, 0x00, 0x78, 0x3C, 0x1F, 0x00, 0x78, 0x3C, 0x1E, 0x00,
  0xF8, 0x3C, 0x3C, 0x00, 0xF0, 0x3C, 0x3C, 0x00, 0xF0, 0x3C, 0x78, 0x00,
  0xF0, 0x78, 0xF8, 0x00, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0x79, 0xE3, 0xFC,
  0xF0, 0xF1, 0xE7, 0xFE, 0xF1, 0xF3, 0xC7, 0xFE, 0xFB, 0xE7, 0xCF, 0x1F,
  0x7F, 0xC7, 0x9F, 0x0F, 0x7F, 0xCF, 0x1E, 0x0F, 0x3F, 0x0F, 0x1E, 0x0F,
  0x00, 0x1E, 0x3C, 0x0F, 0x00, 0x3E, 0x3C, 0x1F, 0x00, 0x3C, 0x3C, 0x1E,
  0x00, 0x78, 0x3C, 0x1E, 0x00, 0x78, 0x78, 0x1E, 0x00, 0xF0, 0x78, 0x1E,
  0x00, 0xF0, 0x78, 0x3C, 0x01, 0xE0, 0x78, 0x3C, 0x03, 0xE0, 0x78, 0x3C,
  0x03, 0xC0, 0x78, 0x78, 0x07, 0x80, 0x78, 0x78, 0x07, 0x80, 0x7C, 0xF0,
  0x0F, 0x00, 0x3F, 0xF0, 0x1F, 0x00, 0x3F, 0xE0, 0x1E, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF0, 0x7C,
  0x00, 0x3E, 0x0F, 0x80, 0x07, 0x81, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x1F, 0x80,
  0x01, 0xF3, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x81, 0xF0,
  0x7F, 0xF0, 0x3E, 0x1F, 0xBE, 0x0F, 0x87, 0xE7, 0xE1, 0xF1, 0xF8, 0x7C,
  0x7C, 0x3E, 0x0F, 0xCF, 0x8F, 0x80, 0xFB, 0xE1, 0xF0, 0x1F, 0xFC, 0x3E,
  0x01, 0xFF, 0x0F, 0xC0, 0x3F, 0xE1, 0xF0, 0x03, 0xF8, 0x3E, 0x00, 0x7E,
  0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x07, 0xFC, 0x0F, 0xC1, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xBF, 0x01, 0xFF, 0xE3, 0xF0, 0x1F, 0xF0, 0x7E,
  0x00, 0x20, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C,
  0x7C, 0x78, 0x78, 0x78, 0x78, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0xC1, 0xF0,
  0x1E, 0x3C, 0x03, 0xF7, 0x80, 0xFF, 0xF3, 0xEF, 0xFF, 0xFC, 0x3F, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xF9, 0xE0,
  0x7E, 0x3C, 0x07, 0x87, 0xC0, 0x70, 0x7C, 0x04, 0x0F, 0x00, 0x01, 0x80,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x1F,
  0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0x83, 0xC0, 0xF0, 0x00, 0x7F,
  0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0x00, 0x19, 0xFF, 0xFF, 0xFF,
  0xFF, 0x88, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x9F, 0x83, 0xF0, 0x7C, 0x1F, 0x03,
  0xE1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x3E,
  0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xEF, 0xC0, 0x1F,
  0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x7F, 0xF8, 0x03, 0xEF, 0x80,
  0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x7E, 0xF8, 0x03, 0xE7,
  0xC0, 0x1F, 0x3E, 0x01, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07,
  0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xE3, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x87, 0xFF, 0x3F, 0xBE, 0xFE, 0xF9, 0xF9, 0xF1, 0xC3, 0xE1, 0x07, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x01, 0xFC, 0x7F, 0x00, 0xE0, 0x3F, 0x00, 0xC0, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xF0, 0xFE, 0x01, 0xC0,
  0x7E, 0x01, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x80, 0x0F, 0xE0, 0xE0, 0x1F,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0x78, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xDF, 0x00,
  0x03, 0xCF, 0x00, 0x03, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xE3, 0xE0,
  0x01, 0xE1, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0x78, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0x7C, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3C, 0x03, 0xF0, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x06, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x80, 0x0F, 0xE0, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x0F, 0xE0, 0x40, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x8F, 0xC0, 0x1F, 0x3F, 0xC0, 0x7D, 0xFF,
  0xC0, 0xFB, 0xFF, 0xC1, 0xFF, 0x3F, 0x83, 0xF8, 0x1F, 0x07, 0xE0, 0x3F,
  0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF1,
  0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0xFC, 0x0F, 0x80, 0xFC,
  0x7F, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01,
  0xF8, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03,
  0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x7E, 0x03, 0xF0, 0x7C, 0x01, 0xF1, 0xF8, 0x01, 0xFB, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x0F, 0xC7, 0xE0, 0x1F, 0x83, 0xF0, 0x3F, 0x01, 0xF0, 0x3E,
  0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC,
  0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7C,
  0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xF1, 0xF8, 0x1F, 0x83,
  0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xF1,
  0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x3F, 0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xE0,
  0x0F, 0xCF, 0x80, 0x3F, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xF1, 0xF0, 0x3F,
  0x87, 0xE3, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFB, 0xE0, 0x7F, 0xDF, 0x00,
  0xFC, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x02, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x3E, 0x07,
  0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE,
  0x0F, 0xC0, 0x7C, 0x03, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x18,
  0x00, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1E,
  0x0F, 0xC2, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x07,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC3,
  0xE0, 0x1F, 0x81, 0xE1, 0xE0, 0x3F, 0xF0, 0xF1, 0xE0, 0x3F, 0xF8, 0x78,
  0xF0, 0x3F, 0xFC, 0x1C, 0xF0, 0x3C, 0x1E, 0x1E, 0x78, 0x3C, 0x1E, 0x0F,
  0x3C, 0x1E, 0x0F, 0x07, 0xBC, 0x1E, 0x07, 0x83, 0xDE, 0x0F, 0x03, 0xC1,
  0xEF, 0x0F, 0x03, 0xC0, 0xF7, 0x07, 0x81, 0xE0, 0x77, 0x83, 0xC0, 0xF0,
  0x7B, 0xC3, 0xC0, 0xF8, 0x3D, 0xE1, 0xE0, 0x78, 0x1C, 0xF0, 0xF0, 0x3C,
  0x1E, 0x78, 0x78, 0x3E, 0x0F, 0x3C, 0x3C, 0x1F, 0x0F, 0x1E, 0x1E, 0x1F,
  0x87, 0x8F, 0x0F, 0x9D, 0xCF, 0x87, 0x83, 0xFE, 0xFF, 0x83, 0xC1, 0xFE,
  0x7F, 0x81, 0xE0, 0x7C, 0x1F, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x20, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xCF, 0x80,
  0x03, 0xE7, 0xC0, 0x01, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x9F,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0x80,
  0x7E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF8,
  0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x3F,
  0x01, 0xF8, 0x1F, 0x01, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xF0, 0x7F, 0x80, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x07,
  0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7E, 0x1F,
  0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0x9F, 0x00, 0x7F, 0x00, 0xC0, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x40, 0x0F, 0xF0, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7E,
  0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF0,
  0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x07,
  0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x07,
  0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0xFC,
  0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x1F, 0xC0, 0x7C, 0x0F, 0xF0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xC7, 0xE0,
  0x1F, 0xC0, 0x0C, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x04, 0x7E, 0x01, 0xFF,
  0x87, 0xC0, 0x1F, 0xF8, 0x7C, 0x03, 0xFF, 0x87, 0xC0, 0x3F, 0xF8, 0x7C,
  0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x01,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00,
  0x7C, 0x03, 0xFC, 0x0F, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0,
  0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x07,
  0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x7E, 0x03, 0xE0,
  0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x7E, 0x03, 0xE0,
  0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07,
  0xC0, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x7C, 0x03, 0xE0,
  0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x0F,
  0xC0, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x11, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF8, 0x03,
  0xF0, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x01,
  0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x07,
  0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xE1, 0xF0, 0x00,
  0x7C, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFD,
  0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x3F, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E,
  0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x7E,
  0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0x80, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x80,
  0xFF, 0x80, 0x07, 0xFE, 0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x0F, 0x78, 0x00,
  0xFF, 0xC0, 0x7D, 0xE0, 0x03, 0xDF, 0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x07,
  0xDE, 0x00, 0x7B, 0xE0, 0x1F, 0x78, 0x03, 0xEF, 0x80, 0xF9, 0xE0, 0x0F,
  0x3E, 0x03, 0xE7, 0x80, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xE3, 0xE0, 0x3E,
  0x7C, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x3C, 0x7C, 0x07, 0xC7, 0xC1, 0xF1,
  0xF0, 0x1F, 0x1F, 0x07, 0x87, 0xC0, 0x7C, 0x7C, 0x3E, 0x1F, 0x01, 0xF1,
  0xF0, 0xF8, 0xF8, 0x07, 0x83, 0xC7, 0xC3, 0xE0, 0x3E, 0x0F, 0x1F, 0x0F,
  0x80, 0xF8, 0x3C, 0xF8, 0x3E, 0x03, 0xE0, 0xF3, 0xE1, 0xF8, 0x0F, 0x83,
  0xCF, 0x07, 0xC0, 0x3C, 0x0F, 0x7C, 0x1F, 0x01, 0xF0, 0x3D, 0xE0, 0x7C,
  0x07, 0xC0, 0xFF, 0x81, 0xF0, 0x1F, 0x03, 0xFC, 0x0F, 0x80, 0x7C, 0x0F,
  0xF0, 0x3E, 0x03, 0xE0, 0x3F, 0x80, 0xF8, 0x0F, 0x80, 0xFE, 0x03, 0xE0,
  0x3E, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x7C, 0x07,
  0xF0, 0x00, 0xF8, 0x0F, 0xE0, 0x03, 0xE0, 0x1F, 0xC0, 0x07, 0xC0, 0x7F,
  0xC0, 0x0F, 0x80, 0xFF, 0x80, 0x1F, 0x01, 0xFF, 0x00, 0x3E, 0x03, 0xDE,
  0x00, 0xF8, 0x07, 0xBE, 0x01, 0xF0, 0x1F, 0x7C, 0x03, 0xE0, 0x3E, 0xF8,
  0x07, 0xC0, 0x7D, 0xF0, 0x1F, 0x00, 0xF9, 0xE0, 0x3E, 0x03, 0xE3, 0xE0,
  0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0x1F, 0x0F, 0x07,
  0xC0, 0x3E, 0x1F, 0x0F, 0x80, 0xF8, 0x3E, 0x1F, 0x01, 0xF0, 0x7C, 0x3E,
  0x03, 0xE0, 0x78, 0x7C, 0x07, 0xC0, 0xF1, 0xF0, 0x0F, 0x81, 0xF3, 0xE0,
  0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0x07, 0xCF, 0x80, 0xF8, 0x07, 0x9E, 0x01,
  0xF0, 0x0F, 0xFC, 0x03, 0xC0, 0x1F, 0xF8, 0x0F, 0x80, 0x3F, 0xF0, 0x1F,
  0x00, 0x3F, 0xE0, 0x3E, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0xFF, 0x01, 0xF0,
  0x01, 0xFE, 0x03, 0xE0, 0x03, 0xFC, 0x07, 0xC0, 0x03, 0xF8, 0x0F, 0x80,
  0x07, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xE3, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0,
  0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF1,
  0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF9, 0xF0, 0x00,
  0x1F, 0x3E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xF3, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0xFC,
  0x1F, 0x00, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x07, 0xF0,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F,
  0x83, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x81,
  0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF0,
  0x3E, 0x00, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x7E,
  0x07, 0xC0, 0x7F, 0x03, 0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xE3, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x03,
  0xE1, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF0,
  0x00, 0x3E, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1F,
  0x3E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0xBF, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00,
  0x7E, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x1F,
  0x00, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x03, 0xF0, 0x7F, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F,
  0x03, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F,
  0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0xFE,
  0x0F, 0x81, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x0F, 0x80, 0x3F, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0,
  0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF0,
  0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xC0, 0x30, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x80, 0x07, 0xE0, 0x60, 0x07, 0xE0, 0x3E, 0x1F,
  0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07,
  0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xC0, 0xFC, 0x00,
  0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x81,
  0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00,
  0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0,
  0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7C,
  0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x07, 0xF0, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03,
  0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x07,
  0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x1F,
  0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0x78, 0xFC, 0x00, 0x78, 0xF8, 0x00, 0x79, 0xF8,
  0x00, 0x79, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0x7B, 0xE0,
  0x00, 0x7B, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xEF, 0x80,
  0x0F, 0x80, 0x0F, 0xBE, 0x00, 0x7E, 0x00, 0x7E, 0xF8, 0x01, 0xF8, 0x01,
  0xF3, 0xE0, 0x0F, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x80, 0x3E, 0x3E, 0x00,
  0xFE, 0x00, 0xF8, 0xF8, 0x07, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0xE0, 0x1F,
  0x0F, 0x80, 0xFF, 0x80, 0xFC, 0x3E, 0x03, 0xDE, 0x03, 0xE0, 0xF8, 0x1F,
  0x78, 0x0F, 0x83, 0xE0, 0x79, 0xE0, 0x7C, 0x0F, 0x81, 0xE7, 0x81, 0xF0,
  0x3E, 0x0F, 0x9E, 0x0F, 0xC0, 0xF8, 0x3C, 0x78, 0x3E, 0x03, 0xE1, 0xF1,
  0xE0, 0xF8, 0x0F, 0x87, 0x87, 0x87, 0xC0, 0x3E, 0x1E, 0x1E, 0x1F, 0x00,
  0xF8, 0xF8, 0x78, 0x7C, 0x03, 0xE3, 0xC1, 0xE3, 0xE0, 0x0F, 0x9F, 0x07,
  0x8F, 0x80, 0x3E, 0x78, 0x1E, 0x7C, 0x00, 0xF9, 0xE0, 0x79, 0xF0, 0x03,
  0xCF, 0x81, 0xE7, 0xC0, 0x0F, 0x3C, 0x07, 0xBE, 0x00, 0x3D, 0xF0, 0x1E,
  0xF8, 0x00, 0xF7, 0x80, 0x7F, 0xC0, 0x03, 0xDE, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x1F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x1F,
  0x80, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xF0,
  0x3E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7C,
  0xFC, 0x03, 0xF1, 0xF0, 0x1F, 0x87, 0xC0, 0x7C, 0x1F, 0x03, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x7E, 0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0x80, 0x3C, 0x3E,
  0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xBE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1E,
  0x0F, 0x00, 0x7C, 0x1E, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0x80,
  0x78, 0x1F, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xE0, 0x03,
  0xE7, 0x80, 0x03, 0xDF, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x00, 0xF8, 0xFC, 0xFC, 0x7C, 0x3E, 0x3E, 0x1E, 0x0F, 0x0F,
  0x00, 0x7C, 0x1E, 0x03, 0xFE, 0x7C, 0x0F, 0xFC, 0xF8, 0x3F, 0xFD, 0xE0,
  0xFF, 0x7F, 0xC1, 0xF8, 0x3F, 0x87, 0xE0, 0x7F, 0x0F, 0x80, 0x7E, 0x3F,
  0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0,
  0x1F, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03,
  0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7E,
  0x1F, 0x01, 0xFC, 0x3E, 0x03, 0xF0, 0x7C, 0x0F, 0xE0, 0xFC, 0x3F, 0xC1,
  0xFF, 0xEF, 0x81, 0xFF, 0xDF, 0x03, 0xFF, 0x3C, 0x03, 0xF8, 0x78, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE1, 0xF0, 0x03, 0xE7, 0xF8, 0x03, 0xEF, 0xFC, 0x03, 0xFF, 0xFE,
  0x07, 0xFC, 0x7E, 0x07, 0xF8, 0x3E, 0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x3F,
  0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF0, 0x7F, 0x03, 0xF0,
  0x7F, 0x87, 0xE0, 0x7F, 0xFF, 0xE0, 0x7B, 0xFF, 0xC0, 0x79, 0xFF, 0x80,
  0xF0, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0x38, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x10, 0xFE, 0x0C, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE,
  0x01, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x1F, 0xF3, 0xE0, 0x1F,
  0xFD, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xCF, 0xF8, 0x0F, 0xC1, 0xFC, 0x0F,
  0xC0, 0xFE, 0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x83,
  0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF0,
  0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3E,
  0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x07,
  0xE0, 0x7C, 0x07, 0xE0, 0x3E, 0x07, 0xF0, 0x1F, 0x87, 0xF8, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xBC, 0x01, 0xFF, 0x9E, 0x00, 0x7F, 0x8F, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F,
  0xFE, 0x0F, 0xE3, 0xF0, 0xF8, 0x1F, 0x1F, 0x01, 0xF3, 0xF0, 0x1F, 0x3E,
  0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xE7, 0xC0, 0xFC, 0x7C, 0x7F, 0xCF,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFD, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x03, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF0, 0x0F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x87,
  0x80, 0x3F, 0xE7, 0xC0, 0x3F, 0xFB, 0xE0, 0x3F, 0xFD, 0xE0, 0x3F, 0x9F,
  0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0,
  0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E,
  0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x3F, 0x03,
  0xE0, 0x1F, 0x81, 0xF0, 0x1F, 0xC0, 0xF8, 0x0F, 0xC0, 0x7C, 0x0F, 0xE0,
  0x3F, 0x0F, 0xF0, 0x1F, 0xFE, 0xF8, 0x07, 0xFF, 0x7C, 0x03, 0xFF, 0x7C,
  0x00, 0xFE, 0x3E, 0x00, 0x08, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x10, 0x03,
  0xF0, 0x0C, 0x03, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x3E, 0x7F, 0xC0, 0x7D,
  0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0x7F, 0x07, 0xF8, 0x3E, 0x0F, 0xE0,
  0x7C, 0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF8, 0x07,
  0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF8,
  0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF8,
  0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0xF8, 0x7E, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x1F,
  0x03, 0xF0, 0x0F, 0x83, 0xF0, 0x07, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x03,
  0xE1, 0xF8, 0x01, 0xF1, 0xF8, 0x00, 0xF9, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFB, 0xE0, 0x01, 0xF9, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x81, 0xF0, 0x07, 0xC0, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x03, 0xC3, 0xF0,
  0x1F, 0x80, 0x3C, 0x7F, 0x87, 0xFC, 0x03, 0xCF, 0xFC, 0xFF, 0xE0, 0x3D,
  0xFF, 0xDF, 0xFE, 0x07, 0xFC, 0xFF, 0xE7, 0xE0, 0x7F, 0x07, 0xF8, 0x3F,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0xFC, 0x07, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0xF8,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x7C,
  0x1F, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8,
  0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x0F, 0x83, 0xE0,
  0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0x1F, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x1F, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xC1, 0xF0, 0x07,
  0x8F, 0xF8, 0x0F, 0x3F, 0xF0, 0x1E, 0xFF, 0xF0, 0x7F, 0xEF, 0xE0, 0xFF,
  0x07, 0xC1, 0xFC, 0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x80,
  0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F,
  0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0xFC, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x3E, 0x0F,
  0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xF0,
  0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFE, 0x7F, 0x0F, 0xC0, 0xF8,
  0x7E, 0x07, 0xE7, 0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x00,
  0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xFC,
  0x3F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x7F, 0xC0, 0x0F, 0x3F,
  0xF0, 0x03, 0xDF, 0xFE, 0x00, 0xFF, 0x1F, 0x80, 0x7F, 0x83, 0xE0, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF0,
  0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03,
  0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x81, 0xF0,
  0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0xE1, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xF7, 0xFF, 0x00, 0x7D, 0xFF, 0x80, 0x3E, 0x3F,
  0x80, 0x0F, 0x81, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x1E, 0x03,
  0xFE, 0x7C, 0x0F, 0xFE, 0xF8, 0x3F, 0xFD, 0xE0, 0xFE, 0x7F, 0xC1, 0xF8,
  0x3F, 0x87, 0xE0, 0x7F, 0x0F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x01,
  0xF1, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x80, 0x3E,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xC3,
  0xE0, 0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7E, 0x1F, 0x01, 0xFC, 0x3E,
  0x03, 0xF0, 0x7C, 0x0F, 0xE0, 0xFC, 0x3F, 0xC1, 0xFF, 0xEF, 0x81, 0xFF,
  0xDE, 0x03, 0xFF, 0x7C, 0x03, 0xF8, 0xF8, 0x00, 0x81, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC3, 0xE0,
  0x78, 0xFC, 0x0F, 0x3F, 0x81, 0xEF, 0xF0, 0x7F, 0xFC, 0x0F, 0xF8, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x1F,
  0xFF, 0x87, 0xFF, 0xF0, 0xFC, 0x3C, 0x3F, 0x00, 0x87, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC4, 0x01, 0xF8, 0xE0, 0x7E, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC,
  0x07, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xFF, 0x9F, 0xFE, 0x7F, 0xFC, 0xFF,
  0xF9, 0xFF, 0xF0, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00,
  0x20, 0x00, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C,
  0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x3E, 0x0F, 0x80,
  0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F,
  0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x3F, 0x0F,
  0x80, 0x7C, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x0F, 0xE0, 0xFC,
  0x3F, 0xC1, 0xFF, 0xEF, 0x03, 0xFF, 0xDE, 0x03, 0xFF, 0x3C, 0x03, 0xF8,
  0x78, 0x00, 0x80, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00,
  0xFD, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F,
  0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7C,
  0x07, 0x83, 0xE0, 0x3C, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x1F, 0x00, 0x78,
  0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xF3, 0xE0, 0x07, 0xBE, 0x00,
  0x3D, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x0F, 0xE0, 0x3E, 0xF8, 0x0F,
  0xE0, 0x3E, 0xF8, 0x0F, 0xE0, 0x7C, 0xF8, 0x1F, 0xE0, 0x7C, 0xF8, 0x1F,
  0xE0, 0x7C, 0xF8, 0x3D, 0xE0, 0xF8, 0xF8, 0x3D, 0xE0, 0xF8, 0xF8, 0x3D,
  0xE1, 0xF0, 0xF8, 0x79, 0xE1, 0xF0, 0xF8, 0x79, 0xE1, 0xF0, 0xF8, 0xF9,
  0xE3, 0xE0, 0xF8, 0xF1, 0xE3, 0xE0, 0xF8, 0xF1, 0xE3, 0xC0, 0xF9, 0xE1,
  0xE7, 0xC0, 0xF9, 0xE1, 0xE7, 0x80, 0xFB, 0xE1, 0xEF, 0x80, 0xFB, 0xC1,
  0xEF, 0x80, 0xFB, 0xC1, 0xEF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x87,
  0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x7D,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x7E, 0xF8, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x07, 0xC0,
  0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xFC,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x01,
  0xE0, 0x1F, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x03, 0xC0,
  0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x05, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x7F, 0xE8,
  0x00, 0x3E, 0x00,
};

const GFXglyph NotoSans_Condensed_MediumItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 39, 13, 1, -38 },
  { 65, 17, 14, 20, 5, -38 },
  { 95, 28, 38, 27, 0, -38 },
  { 228, 23, 43, 24, 1, -40 },
  { 352, 32, 39, 37, 3, -38 },
  { 508, 27, 39, 28, 0, -38 },
  { 640, 8, 14, 11, 5, -38 },
  { 654, 17, 46, 15, 1, -38 },
  { 752, 17, 46, 15, -4, -38 },
  { 850, 19, 21, 23, 5, -41 },
  { 900, 21, 25, 25, 3, -31 },
  { 966, 10, 13, 12, -2, -6 },
  { 983, 13, 5, 15, 1, -17 },
  { 992, 6, 8, 12, 1, -7 },
  { 998, 26, 38, 19, -3, -38 },
  { 1122, 21, 39, 24, 2, -38 },
  { 1225, 15, 38, 24, 6, -38 },
  { 1297, 24, 38, 24, -1, -38 },
  { 1411, 24, 39, 24, 0, -38 },
  { 1528, 25, 38, 24, -1, -38 },
  { 1647, 24, 39, 24, 0, -38 },
  { 1764, 23, 39, 24, 2, -38 },
  { 1877, 24, 38, 24, 2, -38 },
  { 1991, 24, 39, 24, 0, -38 },
  { 2108, 22, 39, 24, 1, -38 },
  { 2216, 12, 30, 12, 0, -29 },
  { 2261, 15, 36, 12, -3, -29 },
  { 2329, 22, 24, 25, 2, -31 },
  { 2395, 21, 15, 25, 3, -26 },
  { 2435, 21, 24, 25, 3, -31 },
  { 2498, 18, 39, 18, 2, -38 },
  { 2586, 33, 43, 36, 2, -38 },
  { 2764, 25, 38, 25, -3, -38 },
  { 2883, 25, 38, 26, 1, -38 },
  { 3002, 26, 39, 24, 2, -38 },
  { 3129, 27, 38, 28, 1, -38 },
  { 3258, 24, 38, 22, 1, -38 },
  { 3372, 24, 38, 21, 1, -38 },
  { 3486, 28, 39, 29, 2, -38 },
  { 3623, 29, 38, 29, 1, -38 },
  { 3761, 21, 38, 16, -2, -38 },
  { 3861, 22, 48, 13, -8, -38 },
  { 3993, 28, 38, 25, 1, -38 },
  { 4126, 16, 38, 21, 1, -38 },
  { 4202, 38, 38, 38, 1, -38 },
  { 4383, 31, 38, 31, 1, -38 },
  { 4531, 27, 39, 30, 2, -38 },
  { 4663, 25, 38, 25, 1, -38 },
  { 4782, 27, 47, 30, 2, -38 },
  { 4941, 24, 38, 25, 1, -38 },
  { 5055, 25, 39, 22, -1, -38 },
  { 5177, 22, 38, 21, 4, -38 },
  { 5282, 28, 39, 29, 2, -38 },
  { 5419, 24, 38, 25, 5, -38 },
  { 5533, 38, 38, 39, 5, -38 },
  { 5714, 30, 38, 23, -3, -38 },
  { 5857, 22, 38, 22, 5, -38 },
  { 5962, 27, 38, 21, -2, -38 },
  { 6091, 20, 46, 15, -1, -38 },
  { 6206, 10, 38, 19, 5, -38 },
  { 6254, 21, 46, 15, -4, -38 },
  { 6375, 23, 22, 24, 1, -38 },
  { 6439, 19, 3, 18, -5, 5 },
  { 6447, 8, 9, 14, 8, -41 },
  { 6456, 23, 30, 25, 2, -29 },
  { 6543, 24, 41, 25, 0, -40 },
  { 6666, 19, 30, 20, 2, -29 },
  { 6738, 25, 41, 25, 2, -40 },
  { 6867, 20, 30, 23, 2, -29 },
  { 6942, 27, 54, 14, -6, -41 },
  { 7125, 25, 42, 25, 0, -29 },
  { 7257, 23, 40, 25, 0, -40 },
  { 7372, 14, 39, 12, 0, -39 },
  { 7441, 21, 52, 12, -7, -39 },
  { 7578, 25, 40, 22, 0, -40 },
  { 7703, 14, 40, 12, 0, -40 },
  { 7773, 36, 29, 37, 0, -29 },
  { 7904, 23, 29, 25, 0, -29 },
  { 7988, 21, 30, 25, 2, -29 },
  { 8067, 26, 42, 25, -2, -29 },
  { 8204, 23, 42, 25, 2, -29 },
  { 8325, 19, 29, 17, 0, -29 },
  { 8394, 19, 30, 19, 0, -29 },
  { 8466, 15, 36, 15, 2, -35 },
  { 8534, 23, 30, 25, 2, -29 },
  { 8621, 21, 29, 21, 3, -29 },
  { 8698, 32, 29, 33, 3, -29 },
  { 8814, 25, 29, 21, -2, -29 },
  { 8905, 29, 42, 21, -5, -29 },
  { 9058, 21, 29, 18, -2, -29 },
  { 9135, 20, 46, 18, 1, -38 },
  { 9250, 4, 52, 22, 9, -40 },
  { 9276, 20, 46, 18, -3, -38 },
  { 9391, 22, 7, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_MediumItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC53PT7B_H_
