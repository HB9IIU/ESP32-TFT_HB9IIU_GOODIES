#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC28PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38,
  0x38, 0x30, 0x30, 0x00, 0x00, 0x20, 0x70, 0xF0, 0xE0, 0x77, 0x67, 0xE7,
  0xE6, 0xE6, 0xC6, 0xCE, 0x01, 0x8C, 0x03, 0x30, 0x0C, 0x60, 0x18, 0xC0,
  0x33, 0x00, 0xC6, 0x4F, 0xFF, 0x1F, 0xFE, 0x0C, 0x60, 0x18, 0xC0, 0x31,
  0x80, 0xE6, 0x0F, 0xFF, 0x9F, 0xFF, 0x06, 0x60, 0x18, 0xC0, 0x31, 0x80,
  0x67, 0x01, 0x8C, 0x03, 0x18, 0x00, 0x00, 0xC0, 0x04, 0x00, 0xFC, 0x1F,
  0xF1, 0xFF, 0x0C, 0xC0, 0x64, 0x03, 0x20, 0x1D, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x03, 0x70, 0x1B, 0x80, 0x9C, 0x84, 0xE7, 0xFE, 0x3F,
  0xE0, 0x3C, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x3C, 0x0E, 0x3E, 0x0C,
  0x66, 0x18, 0x66, 0x18, 0xC6, 0x30, 0xC6, 0x70, 0xC6, 0x60, 0xCE, 0xE0,
  0xCC, 0xCF, 0xCD, 0x9F, 0xF9, 0xB3, 0xF3, 0x33, 0x07, 0x63, 0x06, 0x63,
  0x0C, 0x63, 0x0C, 0x63, 0x18, 0x66, 0x38, 0x66, 0x30, 0x7C, 0x60, 0x78,
  0x03, 0xE0, 0x1F, 0xC0, 0xE7, 0x03, 0x9C, 0x0C, 0x70, 0x31, 0x80, 0xEE,
  0x03, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF1, 0xCE, 0xE7, 0x73, 0x99, 0x87,
  0xEE, 0x1F, 0x38, 0x3C, 0xE0, 0xE3, 0xCF, 0xC7, 0xFF, 0x0F, 0x8E, 0x76,
  0x6E, 0xEC, 0xC0, 0x03, 0x83, 0x03, 0x81, 0x81, 0xC1, 0xC0, 0xE0, 0x60,
  0x70, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x07, 0x03, 0x80, 0xC0, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E,
  0x06, 0x07, 0x03, 0x03, 0x81, 0x81, 0xC1, 0xC1, 0xC0, 0x0E, 0x03, 0x0C,
  0xC3, 0xF1, 0xFF, 0xC7, 0xF3, 0xC1, 0xD8, 0xE7, 0x11, 0xC0, 0x40, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x39, 0xDC, 0xE6, 0x73,
  0x00, 0x7E, 0xFF, 0xF8, 0x27, 0xFE, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x00, 0x07, 0xC1, 0xFC, 0x73, 0x9C, 0x33, 0x86, 0x60, 0xDC,
  0x1B, 0x83, 0x60, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0D, 0xC3, 0xB0, 0x76,
  0x1C, 0xE3, 0x9C, 0xE1, 0xF8, 0x3E, 0x00, 0x07, 0x0F, 0x1F, 0x7E, 0xF6,
  0x4E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x38,
  0x30, 0x30, 0x70, 0x03, 0xF0, 0x7F, 0xC3, 0x8E, 0x08, 0x70, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1F, 0xF9, 0xFF, 0xC0,
  0x07, 0xE1, 0xFF, 0x0C, 0x70, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x0E,
  0x03, 0xC0, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xC8, 0x3C, 0xFF, 0x8F, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x3F, 0x01, 0xB0, 0x1B, 0x81, 0xDC, 0x0C, 0xE0, 0xC6, 0x0E, 0x30,
  0xE3, 0x86, 0x1C, 0x7F, 0xFB, 0xFF, 0xDF, 0xFC, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x18, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x78, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC6, 0x1E, 0x3F, 0xE1, 0xFC, 0x00,
  0x03, 0xF0, 0x7F, 0x0F, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x30,
  0x7F, 0xC7, 0xFC, 0xF1, 0xCE, 0x0E, 0xE0, 0xCE, 0x0C, 0xE1, 0xCE, 0x1C,
  0xE1, 0xCE, 0x38, 0x7F, 0x03, 0xE0, 0x3F, 0xF9, 0xFF, 0x80, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0x9E, 0x38, 0x71, 0xC3, 0x8E,
  0x18, 0x71, 0xC3, 0x9C, 0x0F, 0xC0, 0x3C, 0x07, 0xE0, 0x73, 0x87, 0x0E,
  0x30, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x8E, 0x1F, 0xF0, 0x7E, 0x00,
  0x07, 0xE0, 0xFE, 0x1E, 0x71, 0xC7, 0x38, 0x33, 0x83, 0x38, 0x73, 0x07,
  0x30, 0x73, 0x8F, 0x3F, 0xF1, 0xF6, 0x0E, 0xE0, 0x0E, 0x00, 0xC0, 0x1C,
  0x03, 0x88, 0x70, 0xFF, 0x0F, 0xC0, 0x1C, 0x71, 0xC2, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0xF3, 0xCE, 0x00, 0x0E, 0x1C, 0x38, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x86, 0x1C, 0x30, 0xE1, 0x83, 0x00, 0x00,
  0x10, 0x03, 0x00, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x0F, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0xF0,
  0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x0F, 0x03, 0xE0, 0xF8, 0x7E,
  0x0F, 0x80, 0xC0, 0x08, 0x00, 0x1F, 0x1F, 0xE2, 0x3C, 0x07, 0x01, 0xC0,
  0x60, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x00, 0x00,
  0x00, 0x20, 0x38, 0x0E, 0x03, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x70,
  0x30, 0x30, 0x06, 0x18, 0x01, 0x8E, 0x1C, 0x33, 0x1F, 0x8D, 0x8E, 0x63,
  0x63, 0x18, 0xD9, 0x8E, 0x6C, 0x63, 0x1B, 0x18, 0xC6, 0xCE, 0x31, 0xB3,
  0x1C, 0xCC, 0xE7, 0x33, 0x1E, 0xF8, 0xC3, 0x1C, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xCC, 0x0E, 0x60, 0x73, 0x07, 0x18, 0x38,
  0xC1, 0x86, 0x1C, 0x30, 0xFF, 0x8F, 0xFC, 0x70, 0x67, 0x03, 0x38, 0x1B,
  0x80, 0xDC, 0x07, 0xC0, 0x30, 0x0F, 0xF0, 0x3F, 0xE0, 0xE3, 0xC3, 0x87,
  0x0C, 0x1C, 0x70, 0x71, 0xC1, 0x87, 0x0E, 0x1F, 0xF0, 0xFF, 0x03, 0xFE,
  0x0E, 0x1C, 0x38, 0x70, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0xF1, 0xC7,
  0x87, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0xF1, 0x87, 0x80, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE3, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3B, 0xF0, 0x70, 0xE0, 0xC1,
  0xC3, 0x83, 0x87, 0x03, 0x8E, 0x07, 0x1C, 0x1C, 0x70, 0x38, 0xE0, 0x71,
  0xC0, 0xE3, 0x81, 0xC6, 0x07, 0x1C, 0x0E, 0x38, 0x38, 0x70, 0xE0, 0xEF,
  0xC1, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0x70,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xE1,
  0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0x80, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x00, 0x01,
  0xFC, 0x0F, 0xFC, 0x3C, 0x30, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE1, 0xFB, 0x83, 0xE7, 0x0F, 0xCE, 0x03, 0x9C,
  0x07, 0x38, 0x0C, 0x78, 0x38, 0x70, 0x70, 0xF0, 0xE0, 0xFF, 0xC0, 0xFF,
  0x00, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x06, 0x0C, 0x0E, 0x1C,
  0x0E, 0x1C, 0x0E, 0x1C, 0x0C, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x38,
  0x1C, 0x38, 0x18, 0x30, 0x38, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0x70,
  0x30, 0x60, 0x70, 0xE0, 0x70, 0x0F, 0xE1, 0xFC, 0x0C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x07, 0xE0, 0xF8, 0x08, 0x00, 0x0E, 0x0F, 0x0E,
  0x1C, 0x0E, 0x1C, 0x0E, 0x38, 0x0C, 0x70, 0x1C, 0xE0, 0x1D, 0xE0, 0x1D,
  0xC0, 0x1B, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x39, 0x80, 0x31,
  0xC0, 0x71, 0xC0, 0x71, 0xC0, 0x70, 0xE0, 0x70, 0xE0, 0x60, 0xE0, 0xE0,
  0xE0, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0xFF, 0xF0,
  0x0F, 0x00, 0xF8, 0x78, 0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xE0, 0xF8,
  0x1F, 0x0F, 0xC1, 0xF0, 0x7E, 0x0D, 0x83, 0xF0, 0xFC, 0x1B, 0x86, 0xE1,
  0xDC, 0x77, 0x0E, 0xE3, 0x30, 0x73, 0x39, 0x83, 0x19, 0x9C, 0x18, 0xDC,
  0xE1, 0xC6, 0xC7, 0x0E, 0x3E, 0x30, 0x71, 0xE3, 0x83, 0x0F, 0x1C, 0x18,
  0x70, 0xE1, 0xC3, 0x87, 0x00, 0x0F, 0x03, 0x87, 0x81, 0xC3, 0xC0, 0xC1,
  0xE0, 0x60, 0xF8, 0x70, 0xFC, 0x38, 0x76, 0x1C, 0x33, 0x0C, 0x19, 0xC6,
  0x1C, 0xE7, 0x0E, 0x73, 0x87, 0x19, 0xC3, 0x0C, 0xC1, 0x87, 0x61, 0xC3,
  0xF0, 0xE0, 0xF8, 0x70, 0x78, 0x30, 0x3C, 0x18, 0x1E, 0x1C, 0x07, 0x00,
  0x03, 0xF0, 0x0F, 0xF0, 0x3C, 0xF0, 0xE0, 0xE3, 0xC0, 0xC7, 0x01, 0xCE,
  0x03, 0xB8, 0x07, 0x70, 0x0C, 0xE0, 0x39, 0x80, 0x77, 0x00, 0xEE, 0x01,
  0xDC, 0x07, 0x38, 0x0E, 0x70, 0x38, 0x70, 0xF0, 0xF3, 0xC1, 0xFF, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0xE7, 0x83, 0x8E, 0x0C, 0x1C, 0x70,
  0x71, 0xC1, 0x87, 0x0E, 0x18, 0x38, 0xE3, 0xC3, 0xFE, 0x0F, 0xF0, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3C, 0xF0, 0xE0, 0xE3, 0xC0, 0xC7, 0x01,
  0xCE, 0x03, 0xB8, 0x07, 0x70, 0x0C, 0xE0, 0x39, 0x80, 0x77, 0x00, 0xEE,
  0x01, 0xDC, 0x07, 0x38, 0x0E, 0x70, 0x38, 0x70, 0xF0, 0xF3, 0xC0, 0xFF,
  0x00, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0,
  0x0F, 0xE0, 0x7F, 0x83, 0x9E, 0x1C, 0x70, 0xC1, 0x8E, 0x0C, 0x70, 0xE3,
  0x87, 0x18, 0x78, 0xCF, 0x8F, 0xF8, 0x7F, 0x03, 0x98, 0x18, 0xE1, 0xC7,
  0x0E, 0x38, 0x70, 0xE3, 0x87, 0x18, 0x39, 0xC1, 0xC0, 0x07, 0xF0, 0x7F,
  0xC7, 0x8C, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x81,
  0xC7, 0x3C, 0x3F, 0xE1, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x30, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E,
  0x07, 0x1C, 0x0C, 0x30, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0x87, 0x07,
  0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x30, 0xE0, 0xE0, 0xE7, 0xC1, 0xFF, 0x01,
  0xF8, 0x00, 0xE0, 0x3B, 0x01, 0xD8, 0x1C, 0xC0, 0xE6, 0x0E, 0x30, 0x71,
  0x83, 0x0C, 0x38, 0x61, 0xC3, 0x1C, 0x18, 0xE0, 0xCE, 0x06, 0x70, 0x33,
  0x01, 0xB8, 0x0D, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x60,
  0x70, 0x3B, 0x03, 0x83, 0x98, 0x3C, 0x1C, 0xC1, 0xE1, 0xC6, 0x0F, 0x0E,
  0x30, 0xD8, 0x61, 0x86, 0xC7, 0x0C, 0x76, 0x38, 0xE3, 0x33, 0x87, 0x3B,
  0x9C, 0x39, 0x9C, 0xC1, 0xCC, 0xEE, 0x0E, 0xE7, 0x70, 0x76, 0x3B, 0x03,
  0xF1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x1E,
  0x01, 0xE0, 0xF0, 0x00, 0x07, 0x07, 0x07, 0x06, 0x03, 0x0E, 0x03, 0x9C,
  0x03, 0x9C, 0x03, 0xB8, 0x03, 0xB0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0x60, 0x1C, 0x60,
  0x1C, 0x70, 0x38, 0x70, 0x70, 0x70, 0xF0, 0x70, 0xE0, 0x76, 0x0E, 0x70,
  0xE7, 0x1C, 0x71, 0xC7, 0x38, 0x73, 0x83, 0x70, 0x36, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x07, 0xE0, 0xFC, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60,
  0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30,
  0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x1F, 0x07, 0xE0, 0xC7, 0x39,
  0xCE, 0x31, 0x8C, 0x63, 0x9C, 0xE3, 0x18, 0xC6, 0x39, 0xCE, 0x70, 0x07,
  0xE0, 0xFC, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x18, 0x3F, 0x07, 0xE0, 0x01, 0x80, 0x38, 0x03,
  0xC0, 0x7C, 0x0E, 0xC0, 0xCC, 0x1C, 0xE1, 0x86, 0x38, 0x63, 0x07, 0x60,
  0x3E, 0x03, 0x7F, 0xFF, 0xF0, 0xE3, 0x8C, 0x70, 0x0F, 0x31, 0xFF, 0x38,
  0xF7, 0x0E, 0x70, 0xE7, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xCE, 0x1C, 0xE1,
  0xCE, 0x3C, 0xE7, 0xCF, 0xD8, 0x79, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x77, 0x83, 0xFE, 0x1E, 0x70, 0xE1, 0xCE,
  0x0E, 0x70, 0x63, 0x83, 0x18, 0x38, 0xC1, 0xCE, 0x0E, 0x70, 0xE3, 0x87,
  0x1E, 0x71, 0xFF, 0x8C, 0xF0, 0x00, 0x0F, 0xC7, 0xF3, 0x89, 0xC0, 0x70,
  0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE1, 0x1F, 0xC3,
  0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0xF7, 0x07, 0xFC, 0x38, 0xF1, 0xC3, 0x87, 0x0E, 0x18, 0x38, 0xE0, 0xE3,
  0x83, 0x8E, 0x0C, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0x0E, 0x3C, 0x3F, 0x60,
  0x79, 0x80, 0x0F, 0xC3, 0xF8, 0xE3, 0x38, 0x77, 0x0C, 0xC3, 0xBF, 0xE7,
  0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x10, 0xFE, 0x0F, 0xC0, 0x00,
  0x7C, 0x03, 0xE0, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x7F, 0x03,
  0xF8, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x03, 0xE0, 0x0F, 0x00, 0x38, 0x00,
  0x07, 0x98, 0x7F, 0xC7, 0x1E, 0x70, 0xE3, 0x87, 0x1C, 0x39, 0xC1, 0xCE,
  0x0E, 0x70, 0x63, 0x87, 0x1C, 0x38, 0xE3, 0xC7, 0x3E, 0x3F, 0x60, 0xF7,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x20, 0xE1, 0xFE, 0x0F, 0xE0, 0x3C, 0x00,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1D, 0xE1, 0xFF,
  0x1E, 0x71, 0xC7, 0x38, 0x73, 0x87, 0x38, 0x73, 0x07, 0x30, 0x67, 0x0E,
  0x70, 0xE7, 0x0E, 0x60, 0xCE, 0x0C, 0xE1, 0xC0, 0x06, 0x1C, 0x38, 0x20,
  0x00, 0x07, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xE1,
  0x87, 0x0E, 0x00, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x20, 0x00, 0x00, 0x00,
  0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60,
  0x1C, 0x1F, 0x83, 0xE0, 0x70, 0x00, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0xE3, 0x8E, 0x18, 0xE0, 0xCE, 0x0E, 0xE0,
  0x7E, 0x03, 0x70, 0x1F, 0x80, 0xEC, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x18,
  0x61, 0xC3, 0x8E, 0x1C, 0x00, 0x06, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E,
  0x1C, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xE1, 0x87, 0x0E, 0x00,
  0x19, 0xE7, 0xC3, 0x7F, 0xFC, 0x79, 0xE3, 0x8E, 0x3C, 0x73, 0x87, 0x0E,
  0x70, 0xE1, 0x8E, 0x18, 0x31, 0x83, 0x0E, 0x30, 0xE1, 0xCE, 0x1C, 0x39,
  0xC3, 0x86, 0x38, 0x60, 0xC6, 0x0C, 0x39, 0xC3, 0x87, 0x38, 0x70, 0xE0,
  0x19, 0xE1, 0xBF, 0x1E, 0x71, 0xC7, 0x38, 0x73, 0x87, 0x38, 0x73, 0x07,
  0x30, 0x67, 0x0E, 0x70, 0xE7, 0x0E, 0x60, 0xCE, 0x0C, 0xE1, 0xC0, 0x0F,
  0x83, 0xF8, 0xE3, 0xB8, 0x77, 0x0E, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1B, 0x87, 0x70, 0xEE, 0x38, 0xFE, 0x0F, 0x80, 0x0E, 0xF0, 0x37, 0xE0,
  0xF3, 0x83, 0x87, 0x1C, 0x1C, 0x70, 0x61, 0xC1, 0x86, 0x0E, 0x18, 0x38,
  0xE0, 0xE3, 0x87, 0x0E, 0x1C, 0x3C, 0xE1, 0xFF, 0x87, 0x78, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x0F,
  0x31, 0xFF, 0x38, 0xF7, 0x0E, 0x70, 0xE6, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0,
  0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0xE7, 0xCF, 0xD8, 0x7B, 0x80, 0x38, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x19, 0xC6, 0xF1, 0xF4,
  0x70, 0x3C, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60,
  0x38, 0x0E, 0x00, 0x1F, 0xCF, 0xF3, 0x84, 0xC0, 0x38, 0x0E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0C, 0x87, 0x3F, 0xCF, 0xE0, 0x0C, 0x18,
  0x18, 0x7F, 0xFE, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0,
  0xE0, 0xE0, 0xF8, 0x78, 0x38, 0x73, 0x87, 0x30, 0x63, 0x06, 0x70, 0xE7,
  0x0E, 0x70, 0xE6, 0x0C, 0xE0, 0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0xE7, 0x8F,
  0xD8, 0x79, 0x80, 0xC1, 0xF0, 0x7C, 0x3B, 0x0E, 0xC3, 0x31, 0xCC, 0x63,
  0x38, 0xCC, 0x37, 0x0D, 0x83, 0x60, 0xF0, 0x3C, 0x0F, 0x00, 0xC3, 0xC3,
  0xE1, 0xE3, 0xB0, 0xF1, 0xD8, 0xF9, 0xCC, 0x7C, 0xE6, 0x7E, 0x63, 0x37,
  0x71, 0x9B, 0x30, 0xD9, 0xB8, 0x6C, 0xDC, 0x3E, 0x6C, 0x1E, 0x3E, 0x0F,
  0x1E, 0x07, 0x0F, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x63, 0x83, 0x1C, 0x1D,
  0xC0, 0xFC, 0x03, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x80, 0xFC, 0x07, 0xE0,
  0x73, 0x07, 0x1C, 0x38, 0xE3, 0x87, 0x00, 0x0C, 0x1E, 0x18, 0x38, 0x30,
  0x60, 0x61, 0xC0, 0xC3, 0x01, 0xCE, 0x03, 0x98, 0x07, 0x70, 0x0E, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x07, 0xC0, 0x0F, 0x00, 0x18, 0x00,
  0x00, 0x0F, 0xE3, 0xFC, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70,
  0x0C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0xE0,
  0x7C, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0,
  0x70, 0x3C, 0x07, 0x01, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xF0, 0x1E, 0x07, 0x81, 0xC0, 0x30,
  0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x3E, 0x07, 0x80, 0x38,
  0x1F, 0xF3, 0xFF, 0xF8, 0x3E,
};

const GFXglyph NotoSans_Condensed_MediumItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 20, 7, 0, -20 },
  { 21, 8, 7, 10, 3, -20 },
  { 28, 15, 20, 14, 0, -20 },
  { 66, 13, 23, 12, 0, -21 },
  { 104, 16, 20, 19, 2, -20 },
  { 144, 14, 20, 15, 0, -20 },
  { 179, 4, 7, 6, 3, -20 },
  { 183, 9, 24, 8, 1, -20 },
  { 210, 9, 24, 8, -2, -20 },
  { 237, 10, 11, 12, 3, -21 },
  { 251, 12, 14, 13, 1, -17 },
  { 272, 5, 7, 6, -1, -3 },
  { 277, 7, 3, 8, 0, -9 },
  { 280, 4, 4, 6, 0, -4 },
  { 282, 13, 20, 10, -1, -20 },
  { 315, 11, 20, 12, 1, -20 },
  { 343, 8, 20, 13, 3, -20 },
  { 363, 13, 20, 12, -1, -20 },
  { 396, 12, 20, 12, 0, -20 },
  { 426, 13, 20, 13, 0, -20 },
  { 459, 13, 20, 12, 0, -20 },
  { 492, 12, 20, 12, 1, -20 },
  { 522, 13, 20, 12, 1, -20 },
  { 555, 13, 20, 12, 0, -20 },
  { 588, 12, 20, 12, 0, -20 },
  { 618, 6, 15, 6, 0, -15 },
  { 630, 7, 19, 6, -1, -15 },
  { 647, 12, 14, 13, 1, -17 },
  { 668, 12, 8, 13, 1, -14 },
  { 680, 12, 14, 13, 1, -17 },
  { 701, 10, 20, 10, 1, -20 },
  { 726, 18, 22, 19, 1, -20 },
  { 776, 13, 20, 13, -2, -20 },
  { 809, 14, 20, 14, 0, -20 },
  { 844, 14, 20, 13, 1, -20 },
  { 879, 15, 20, 15, 0, -20 },
  { 917, 13, 20, 12, 0, -20 },
  { 950, 13, 20, 11, 0, -20 },
  { 983, 15, 20, 16, 1, -20 },
  { 1021, 16, 20, 16, 0, -20 },
  { 1061, 11, 20, 8, -1, -20 },
  { 1089, 11, 26, 7, -4, -20 },
  { 1125, 16, 20, 13, 0, -20 },
  { 1165, 9, 20, 11, 0, -20 },
  { 1188, 21, 20, 20, 0, -20 },
  { 1241, 17, 20, 16, 0, -20 },
  { 1284, 15, 20, 16, 1, -20 },
  { 1322, 14, 20, 13, 0, -20 },
  { 1357, 15, 25, 16, 1, -20 },
  { 1404, 13, 20, 13, 0, -20 },
  { 1437, 13, 20, 12, 0, -20 },
  { 1470, 12, 20, 11, 2, -20 },
  { 1500, 15, 20, 15, 1, -20 },
  { 1538, 13, 20, 13, 2, -20 },
  { 1571, 21, 20, 20, 2, -20 },
  { 1624, 16, 20, 12, -2, -20 },
  { 1664, 12, 20, 12, 2, -20 },
  { 1694, 14, 20, 11, -1, -20 },
  { 1729, 11, 24, 8, -1, -20 },
  { 1762, 5, 20, 10, 3, -20 },
  { 1775, 11, 24, 8, -2, -20 },
  { 1808, 12, 12, 13, 0, -20 },
  { 1826, 10, 2, 9, -3, 2 },
  { 1829, 5, 4, 8, 4, -21 },
  { 1832, 12, 15, 13, 1, -15 },
  { 1855, 13, 21, 13, 0, -21 },
  { 1890, 10, 15, 10, 1, -15 },
  { 1909, 14, 21, 13, 1, -21 },
  { 1946, 11, 15, 12, 1, -15 },
  { 1967, 14, 28, 8, -3, -21 },
  { 2016, 13, 22, 13, 0, -15 },
  { 2052, 12, 21, 13, 0, -21 },
  { 2084, 7, 21, 6, 0, -21 },
  { 2103, 11, 28, 6, -4, -21 },
  { 2142, 13, 21, 12, 0, -21 },
  { 2177, 7, 21, 6, 0, -21 },
  { 2196, 19, 15, 20, 0, -15 },
  { 2232, 12, 15, 13, 0, -15 },
  { 2255, 11, 15, 13, 1, -15 },
  { 2276, 14, 22, 13, -1, -15 },
  { 2315, 12, 22, 13, 1, -15 },
  { 2348, 10, 15, 9, 0, -15 },
  { 2367, 10, 15, 10, 0, -15 },
  { 2386, 8, 18, 8, 1, -18 },
  { 2404, 12, 15, 13, 1, -15 },
  { 2427, 10, 15, 11, 2, -15 },
  { 2446, 17, 15, 17, 2, -15 },
  { 2478, 13, 15, 11, -1, -15 },
  { 2503, 15, 22, 11, -2, -15 },
  { 2545, 11, 15, 10, -1, -15 },
  { 2566, 11, 24, 9, 0, -20 },
  { 2599, 2, 28, 12, 5, -21 },
  { 2606, 11, 24, 9, -2, -20 },
  { 2639, 12, 4, 13, 1, -12 },
};

const GFXfont NotoSans_Condensed_MediumItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC28PT7B_H_
