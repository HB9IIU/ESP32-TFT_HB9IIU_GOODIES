#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC42PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x01, 0xF0, 0x7E, 0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x79, 0xE3, 0xDE, 0x3C,
  0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xC3, 0x8E, 0x1C, 0x70, 0xE7, 0x8E, 0x38,
  0x70, 0x00, 0x3C, 0x38, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1E, 0x1C,
  0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x70, 0x0F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x01, 0xC3,
  0x80, 0x0E, 0x0E, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x07, 0x87, 0x00,
  0x1C, 0x38, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x38,
  0x70, 0x00, 0xE1, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0,
  0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xE3, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0F, 0xFC,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3E, 0xCE, 0x0F, 0x18, 0x41, 0xE3, 0x00,
  0x3C, 0xC0, 0x07, 0x98, 0x00, 0xF3, 0x00, 0x1F, 0x60, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x6F, 0x80,
  0x0C, 0xF0, 0x01, 0x9E, 0x00, 0x33, 0xC0, 0x06, 0x78, 0x01, 0x8F, 0x0C,
  0x33, 0xE1, 0xF7, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x0E,
  0x03, 0xF8, 0x07, 0x81, 0xEF, 0x01, 0xC0, 0x71, 0xC0, 0xE0, 0x38, 0x70,
  0x78, 0x0E, 0x1C, 0x1C, 0x07, 0x87, 0x0F, 0x01, 0xC1, 0xC3, 0x80, 0x70,
  0xF1, 0xC0, 0x1C, 0x38, 0x70, 0x07, 0x0E, 0x38, 0x03, 0xC3, 0x9E, 0x00,
  0xF1, 0xE7, 0x1F, 0x3C, 0x73, 0x9F, 0xEF, 0x3C, 0xE7, 0xF9, 0xFE, 0x73,
  0x8E, 0x7F, 0x3C, 0xE3, 0xCF, 0x8E, 0x70, 0xF0, 0x07, 0x1C, 0x38, 0x01,
  0xC7, 0x0E, 0x00, 0xE3, 0xC3, 0x80, 0x78, 0xE0, 0xE0, 0x1C, 0x38, 0x38,
  0x0F, 0x0E, 0x1C, 0x03, 0x83, 0x87, 0x01, 0xC0, 0xE3, 0xC0, 0xF0, 0x38,
  0xE0, 0x38, 0x0F, 0xF8, 0x1E, 0x01, 0xFC, 0x0F, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xC7, 0x80, 0x3C, 0x3C,
  0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC7, 0x80, 0x1E,
  0x3C, 0x00, 0xF3, 0xC0, 0x07, 0xBC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xFE, 0x0F, 0x1F, 0x78, 0x79, 0xF3, 0xC3, 0xCF, 0x1F,
  0x3C, 0xF0, 0x79, 0xE7, 0x83, 0xFE, 0x3C, 0x0F, 0xF3, 0xC0, 0x7F, 0x1E,
  0x01, 0xF0, 0xF0, 0x0F, 0x87, 0xC0, 0xFC, 0x1F, 0x1F, 0xF0, 0xFF, 0xF7,
  0x83, 0xFF, 0x3E, 0x0F, 0xE1, 0xF0, 0x3C, 0xF3, 0xDE, 0x79, 0xE7, 0x1C,
  0x71, 0xCE, 0x00, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x02, 0x0E,
  0x06, 0x1C, 0x1F, 0x30, 0x3F, 0xFF, 0x9F, 0xFF, 0x07, 0xFE, 0x1F, 0x80,
  0x7F, 0x01, 0xE7, 0x07, 0xCE, 0x0F, 0x1E, 0x0C, 0x1E, 0x08, 0x30, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3C,
  0x3C, 0x78, 0x70, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x39, 0xF7,
  0xFE, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8,
  0x1F, 0x3E, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x3C, 0x78, 0x0F, 0x1E,
  0x03, 0xCF, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x9E, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x0F, 0x9E, 0x03, 0xCF, 0x80, 0xF3,
  0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF0, 0xF0,
  0x3C, 0x1E, 0x1E, 0x07, 0xCF, 0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF0,
  0x00, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0xFE, 0x3F, 0xE7, 0xDE, 0xFB, 0xCF,
  0x3C, 0x63, 0xC4, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x00, 0x7F,
  0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0x3E, 0x3E, 0x03, 0x81, 0xE0, 0x10,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xC3, 0xE0, 0x20,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x10, 0x07, 0xC3, 0x83, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x0E, 0xE0, 0x03, 0xBC, 0x00, 0xF7, 0x80, 0x1C,
  0xF0, 0x07, 0x1E, 0x01, 0xE7, 0x80, 0x38, 0xF0, 0x0E, 0x1E, 0x03, 0xC3,
  0xC0, 0xF0, 0x70, 0x1C, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x38, 0x0F,
  0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xB0, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0x40, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x10, 0x07, 0xC3, 0x83, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xF8, 0x20, 0x3E,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x7E, 0x03, 0xDF, 0xE0, 0x7F, 0xFC, 0x1F, 0xEF,
  0xC3, 0xF0, 0x78, 0x7C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07,
  0x8F, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0x80, 0xF0, 0x78, 0x1E,
  0x0F, 0x07, 0x81, 0xF1, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xE1, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC3,
  0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x78, 0x1E, 0x1F, 0x03,
  0xE7, 0xC0, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x0F,
  0xBE, 0x03, 0xC3, 0xC0, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0x80, 0xF8, 0xF0,
  0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x78, 0xF8, 0x0F, 0x0F, 0x03, 0xE1, 0xF0,
  0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x01,
  0xFF, 0x81, 0xFF, 0xC1, 0xF1, 0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E,
  0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0,
  0xF9, 0xE0, 0x7C, 0xF0, 0x7E, 0x7E, 0xFE, 0x3F, 0xFF, 0x0F, 0xF7, 0x83,
  0xE3, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x20, 0xFC, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xF8,
  0x00, 0x03, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x8F,
  0xC7, 0xC1, 0xE0, 0x00, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0,
  0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0xE0,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0x00, 0x00, 0x07,
  0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xE1, 0xF1, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7C, 0x03, 0xC0, 0x1E, 0x00,
  0x3C, 0x07, 0x80, 0x03, 0x81, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x0E,
  0x07, 0xF0, 0xE3, 0xC1, 0xFF, 0x1C, 0x70, 0x7F, 0xC3, 0x9E, 0x1C, 0x38,
  0x73, 0x87, 0x07, 0x0E, 0x70, 0xE1, 0xE1, 0xDC, 0x38, 0x38, 0x3B, 0x87,
  0x07, 0x0E, 0x70, 0xE0, 0xE1, 0xCE, 0x3C, 0x3C, 0x39, 0xC7, 0x07, 0x07,
  0x70, 0xE0, 0xE1, 0xCE, 0x1C, 0x3C, 0x39, 0xC3, 0x87, 0x8E, 0x38, 0x7B,
  0xFB, 0x87, 0x07, 0xE7, 0xF0, 0xF0, 0xF8, 0xF8, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x80, 0x07, 0xC0, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xCE, 0x00,
  0x3C, 0xE0, 0x03, 0xCE, 0x00, 0x78, 0xE0, 0x07, 0x8E, 0x00, 0xF0, 0xF0,
  0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xF8, 0x0F, 0x0F, 0x00,
  0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF3, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0,
  0x0F, 0x7C, 0x00, 0xFF, 0x80, 0x0F, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x03,
  0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x7C, 0x1E,
  0x07, 0xC0, 0xF0, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0xF0,
  0x1E, 0x0F, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x83, 0xE0,
  0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x07, 0xC3,
  0xC0, 0x7C, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0x1E, 0x07,
  0xC0, 0x40, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x1C, 0x03, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xFC, 0x03, 0xC1, 0xF8, 0x0F, 0x03, 0xE0, 0x7C, 0x07, 0x81,
  0xE0, 0x1F, 0x07, 0x80, 0x7C, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0xC3, 0xE0,
  0x1F, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0x87, 0xC0, 0x1E,
  0x1E, 0x00, 0x78, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x3E,
  0x01, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x3E, 0x0F, 0x01, 0xF0, 0x3C, 0x0F,
  0x81, 0xF0, 0x7E, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFE, 0x3E, 0x07, 0xE0, 0x10, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x81, 0xFF, 0x3E, 0x07, 0xF8, 0xF8,
  0x1F, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF8, 0xF0, 0x03,
  0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3E, 0x00, 0xF0, 0xF8, 0x07, 0xC1,
  0xF0, 0x1E, 0x07, 0xF0, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x01, 0xE0, 0x0F, 0x03, 0xE0, 0x0F, 0x03, 0xC0, 0x1F, 0x03,
  0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x07, 0xC0, 0x1E, 0x07,
  0x80, 0x3C, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x0F,
  0x80, 0x7C, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x1E, 0x00, 0xF8, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E,
  0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x3C,
  0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0x78,
  0x03, 0xC0, 0x78, 0x03, 0xC0, 0xF8, 0x03, 0xC0, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0x7F, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x37, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x3E,
  0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x1E, 0x07, 0xC0, 0x3C, 0x1F, 0x00,
  0x78, 0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x8F, 0x80, 0x0F,
  0x3E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xF0, 0x00, 0xF7, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0x78,
  0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xE0, 0x07, 0x83, 0xC0,
  0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0xF8, 0x1E, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xFF, 0xDF,
  0xFF, 0x7F, 0xFB, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01,
  0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F,
  0xC0, 0x7F, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0xF0, 0x1D, 0xE0, 0x3D, 0xE0,
  0x79, 0xC0, 0x73, 0xC0, 0xF3, 0x81, 0xEF, 0x01, 0xE7, 0x03, 0x9E, 0x03,
  0xCE, 0x0F, 0x3C, 0x0F, 0x1C, 0x1C, 0x78, 0x1E, 0x38, 0x79, 0xE0, 0x3C,
  0x70, 0xE3, 0xC0, 0x78, 0xE3, 0xC7, 0x80, 0xF1, 0xC7, 0x0F, 0x03, 0xC3,
  0xDE, 0x1E, 0x07, 0x87, 0xB8, 0x78, 0x0F, 0x0F, 0xF0, 0xF0, 0x1E, 0x1F,
  0xC1, 0xE0, 0x38, 0x3F, 0x83, 0xC0, 0xF0, 0x7E, 0x07, 0x81, 0xE0, 0xFC,
  0x1E, 0x03, 0xC1, 0xF8, 0x3C, 0x07, 0x83, 0xE0, 0x78, 0x1E, 0x03, 0xC0,
  0xF0, 0x00, 0x01, 0xF0, 0x07, 0x81, 0xF8, 0x03, 0xC0, 0xFC, 0x01, 0xE0,
  0x7E, 0x00, 0xF0, 0x3F, 0x00, 0x70, 0x1F, 0xC0, 0x78, 0x1F, 0xE0, 0x3C,
  0x0F, 0xF0, 0x1E, 0x07, 0xB8, 0x0F, 0x03, 0xDE, 0x0F, 0x01, 0xCF, 0x07,
  0x81, 0xE7, 0x83, 0xC0, 0xF1, 0xC1, 0xE0, 0x78, 0xE0, 0xF0, 0x3C, 0x78,
  0xF0, 0x3C, 0x3C, 0x78, 0x1E, 0x1E, 0x3C, 0x0F, 0x07, 0x1E, 0x07, 0x83,
  0xCE, 0x03, 0xC1, 0xEF, 0x03, 0xC0, 0xF7, 0x81, 0xE0, 0x3B, 0xC0, 0xF0,
  0x1F, 0xE0, 0x78, 0x0F, 0xE0, 0x38, 0x07, 0xF0, 0x3C, 0x03, 0xF8, 0x1E,
  0x00, 0xFC, 0x0F, 0x00, 0x7E, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x1F, 0x00,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C,
  0x0F, 0x87, 0xC0, 0x7C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0x79,
  0xE0, 0x03, 0xCF, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xBC,
  0x00, 0x3D, 0xE0, 0x03, 0xEF, 0x00, 0x1E, 0x78, 0x01, 0xF3, 0xC0, 0x0F,
  0x1F, 0x00, 0xF8, 0xF8, 0x07, 0x83, 0xE0, 0xFC, 0x1F, 0x8F, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xC1, 0xF0, 0x3C, 0x0F, 0x07, 0xC0,
  0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF0,
  0x1F, 0x0F, 0x01, 0xE0, 0xF0, 0x3E, 0x0F, 0x0F, 0xC1, 0xFF, 0xF8, 0x1F,
  0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x0F, 0x87,
  0xC0, 0x7C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0x79, 0xE0, 0x03,
  0xCF, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x3D,
  0xE0, 0x03, 0xEF, 0x00, 0x1E, 0x78, 0x01, 0xF3, 0xC0, 0x0F, 0x1F, 0x00,
  0xF8, 0xF8, 0x07, 0x83, 0xE0, 0xFC, 0x1F, 0x8F, 0xC0, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xC1,
  0xF0, 0x3C, 0x0F, 0x07, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78,
  0x0F, 0x07, 0x81, 0xF0, 0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0xF0, 0x7C, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1E, 0x3C, 0x01,
  0xE3, 0xC0, 0x3E, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0,
  0x3C, 0x1F, 0x07, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF8, 0x78, 0x0F,
  0x8F, 0x80, 0x78, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFB,
  0xE0, 0xF8, 0x04, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3E, 0x10, 0x07, 0xC3, 0xE7, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x3C, 0x3C, 0x01,
  0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x7C, 0x03, 0xE1,
  0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xE0,
  0x1F, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x87, 0xC0, 0x1E,
  0x1E, 0x00, 0xF8, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x3E,
  0x01, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x03,
  0xE0, 0xF0, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0xC7, 0xE0, 0x1F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0x7B, 0xC0,
  0x0F, 0x78, 0x03, 0xEF, 0x00, 0x79, 0xE0, 0x1F, 0x3C, 0x03, 0xC7, 0x80,
  0xF8, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x07,
  0x81, 0xE0, 0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF1, 0xF0, 0x1E, 0x3C,
  0x03, 0xC7, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x1D, 0xE0,
  0x03, 0xB8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x3E,
  0x01, 0xEF, 0x00, 0xF8, 0x07, 0xBC, 0x03, 0xE0, 0x3E, 0xF0, 0x1F, 0x80,
  0xF3, 0xC0, 0x7E, 0x03, 0xCF, 0x03, 0xF8, 0x1E, 0x3C, 0x0F, 0xE0, 0x78,
  0xF0, 0x3F, 0x83, 0xE3, 0xC1, 0xFE, 0x0F, 0x0F, 0x07, 0x78, 0x3C, 0x3C,
  0x3D, 0xE1, 0xE0, 0xF0, 0xE7, 0x87, 0x83, 0xC7, 0x9E, 0x3C, 0x0F, 0x1E,
  0x78, 0xF0, 0x3C, 0x71, 0xE3, 0xC0, 0xF3, 0xC7, 0x9E, 0x03, 0xCE, 0x1E,
  0x78, 0x0F, 0x78, 0x7B, 0xC0, 0x3D, 0xE1, 0xEF, 0x00, 0xF7, 0x07, 0xBC,
  0x03, 0xBC, 0x1D, 0xE0, 0x0E, 0xE0, 0x77, 0x80, 0x3B, 0x81, 0xDC, 0x00,
  0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x1F, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x78, 0x00,
  0xF0, 0xF8, 0x00, 0xF0, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0xF1, 0xE0, 0x00,
  0xF3, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xDE, 0x00, 0x03,
  0xCF, 0x00, 0x07, 0x8F, 0x00, 0x0F, 0x8F, 0x00, 0x0F, 0x0F, 0x00, 0x1E,
  0x0F, 0x00, 0x3E, 0x0F, 0x80, 0x3C, 0x07, 0x80, 0x7C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xDE,
  0x03, 0xCF, 0x03, 0xE3, 0xC1, 0xE1, 0xE1, 0xF0, 0xF0, 0xF0, 0x78, 0xF8,
  0x3C, 0x78, 0x1E, 0x78, 0x07, 0x3C, 0x03, 0xBC, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x00, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x78, 0x78, 0x78, 0x78, 0x38,
  0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x00, 0xFF, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x39, 0xC0, 0x1E, 0x78, 0x07, 0x1E, 0x03, 0xC3, 0x80, 0xE0, 0xE0, 0x78,
  0x3C, 0x3C, 0x07, 0x0E, 0x01, 0xC7, 0x80, 0x79, 0xC0, 0x0E, 0xF0, 0x03,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0xF8, 0xF1, 0xE1, 0xE1, 0xC3, 0xC3, 0x80,
  0x01, 0xF1, 0xE0, 0x7F, 0x3C, 0x1F, 0xF7, 0x07, 0xEF, 0xE1, 0xF0, 0xFC,
  0x3C, 0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0x3C, 0x3C, 0x07, 0x8F, 0x80, 0xF1,
  0xE0, 0x1E, 0x3C, 0x07, 0x87, 0x80, 0xF1, 0xF0, 0x1E, 0x3E, 0x03, 0xC7,
  0x80, 0xF8, 0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xE1, 0xF8, 0x3C, 0x7F, 0x07,
  0xFD, 0xE0, 0xFF, 0x38, 0x0F, 0xC7, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF1, 0xE0, 0x1E, 0xFE, 0x03, 0xBF, 0xE0,
  0xFF, 0x7C, 0x1F, 0x87, 0xC3, 0xE0, 0x78, 0x78, 0x0F, 0x1F, 0x01, 0xE3,
  0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x78, 0x07, 0x8F,
  0x00, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x87, 0x80, 0xF1, 0xF0, 0x3C, 0x3E,
  0x0F, 0x87, 0xE3, 0xE0, 0xEF, 0xFC, 0x1D, 0xFF, 0x07, 0x9F, 0x80, 0x00,
  0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x30, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x8F, 0x00,
  0xFE, 0x78, 0x0F, 0xFF, 0x80, 0xFD, 0xFC, 0x0F, 0x83, 0xE0, 0x78, 0x1F,
  0x07, 0xC0, 0xF8, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0,
  0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x83, 0xE0, 0x3C, 0x1E, 0x01, 0xE0,
  0xF0, 0x1F, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0x8F,
  0xE0, 0x3F, 0xEF, 0x01, 0xFE, 0x70, 0x07, 0xE3, 0x80, 0x00, 0xFC, 0x03,
  0xFE, 0x07, 0xFF, 0x0F, 0x8F, 0x1F, 0x0F, 0x1E, 0x07, 0x3C, 0x0F, 0x3C,
  0x0F, 0x7C, 0x1E, 0x78, 0x7E, 0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xC0, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x18, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0x20, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x02, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0xF0, 0x1F, 0xCF, 0x03, 0xFE, 0xE0, 0x7E, 0xFE, 0x0F, 0x87, 0xE0, 0xF0,
  0x3E, 0x1F, 0x03, 0xE1, 0xE0, 0x3C, 0x1E, 0x03, 0xC3, 0xE0, 0x3C, 0x3C,
  0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x07, 0x87, 0xC0, 0x78, 0x7C, 0x07, 0x87,
  0x80, 0xF8, 0x78, 0x0F, 0x07, 0x81, 0xF0, 0x7C, 0x3F, 0x03, 0xC7, 0xF0,
  0x3F, 0xEF, 0x03, 0xFD, 0xE0, 0x1F, 0x9E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x80, 0x78, 0x0F, 0x3F,
  0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE7, 0xC0, 0x7B, 0xF8, 0x1D, 0xFF,
  0x0F, 0xFF, 0xC3, 0xF0, 0xF0, 0xF8, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC7,
  0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0x8F, 0x01, 0xE3, 0xC0,
  0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C,
  0x78, 0x0F, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xC0, 0x78, 0x01, 0xC0, 0x7C,
  0x0F, 0x81, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0xBF, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x3C, 0x1E, 0x0F, 0x83, 0xC3, 0xE0, 0xF0, 0xF8, 0x1E, 0x1E, 0x03,
  0xC7, 0x80, 0x79, 0xE0, 0x0E, 0x7C, 0x03, 0xDF, 0x00, 0x7B, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xDE, 0x01, 0xF3, 0xC0, 0x3C,
  0x78, 0x07, 0x8F, 0x01, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0,
  0x7C, 0x1E, 0x07, 0x87, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0x80, 0x07, 0x1F, 0x07, 0xC0, 0x73, 0xF8, 0xFE, 0x07, 0x7F, 0xDF,
  0xF0, 0xFF, 0x7F, 0xDF, 0x0F, 0xC3, 0xF0, 0xF0, 0xF8, 0x3E, 0x0F, 0x0F,
  0x03, 0xC0, 0xF0, 0xF0, 0x3C, 0x0F, 0x1E, 0x03, 0xC0, 0xF1, 0xE0, 0x78,
  0x0F, 0x1E, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0x1E, 0x3C, 0x07, 0x81, 0xE3,
  0xC0, 0x78, 0x1E, 0x3C, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x3C, 0x3C, 0x0F,
  0x03, 0xC7, 0x80, 0xF0, 0x3C, 0x78, 0x1E, 0x03, 0xC7, 0x81, 0xE0, 0x78,
  0x78, 0x1E, 0x07, 0x87, 0x81, 0xE0, 0x78, 0xF0, 0x1E, 0x07, 0x80, 0x07,
  0x1F, 0x01, 0xCF, 0xE0, 0x77, 0xFC, 0x3F, 0xFF, 0x0F, 0xC3, 0xC3, 0xE0,
  0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x7C,
  0x78, 0x1E, 0x3E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3E, 0x3C,
  0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x1E, 0x1E, 0x07,
  0x8F, 0x01, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFB, 0xE1,
  0xF0, 0xF8, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x7C, 0x07, 0xBC, 0x03,
  0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7F, 0x80, 0x7B, 0xC0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x1E, 0x78, 0x0F, 0x1E, 0x0F, 0x0F, 0x8F, 0x87, 0xFF, 0x81,
  0xFF, 0x80, 0x7F, 0x80, 0x01, 0xC7, 0xC0, 0x0E, 0x7F, 0x00, 0x77, 0xFC,
  0x07, 0xF3, 0xE0, 0x3F, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78,
  0x0F, 0x07, 0xC0, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x3E, 0x0F, 0x01, 0xE0,
  0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x07, 0xC1, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x3F, 0x1F, 0x01, 0xFF, 0xF8, 0x0E,
  0xFF, 0x80, 0xF3, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0x7F, 0x3C,
  0x1F, 0xF7, 0x07, 0xEF, 0xE1, 0xF0, 0xFC, 0x3C, 0x0F, 0x8F, 0x81, 0xE1,
  0xE0, 0x3C, 0x3C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0x87,
  0x80, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x1E,
  0x07, 0xC3, 0xE1, 0xF8, 0x3C, 0x7F, 0x07, 0xFD, 0xE0, 0xFF, 0x78, 0x0F,
  0xCF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x07, 0x1E, 0x0E, 0x7C, 0x1D, 0xF8, 0x7F, 0xF0, 0xFE, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF8,
  0x0F, 0xFC, 0x3F, 0xF8, 0xF8, 0xE1, 0xE0, 0x43, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x01, 0xF2, 0x03, 0xE6, 0x0F, 0x8F,
  0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80,
  0xE0, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF, 0xE7, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F, 0x00, 0x0F, 0x01, 0xC3,
  0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xE1, 0xE0,
  0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C,
  0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x3E,
  0x0F, 0x8F, 0x87, 0xE3, 0xE3, 0xF0, 0x7F, 0xDC, 0x1F, 0xE7, 0x03, 0xF1,
  0xC0, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x07, 0xCE, 0x03, 0xC7, 0x01, 0xE3,
  0x81, 0xE1, 0xC0, 0xF0, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x78, 0x1E, 0x3C,
  0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xE0, 0x3C, 0x07, 0xF0, 0x3E, 0x07, 0xB8, 0x1F, 0x03, 0xDC,
  0x0F, 0x81, 0xEE, 0x0F, 0xC1, 0xE7, 0x07, 0xE0, 0xF3, 0x87, 0xF0, 0xF1,
  0xC3, 0xB8, 0x78, 0xE1, 0xDC, 0x38, 0x71, 0xCE, 0x3C, 0x38, 0xE7, 0x1E,
  0x1C, 0xF3, 0x9E, 0x0E, 0x71, 0xCF, 0x07, 0x38, 0xE7, 0x03, 0xB8, 0x77,
  0x81, 0xDC, 0x3B, 0xC0, 0xFE, 0x1D, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x07,
  0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xC0,
  0x7C, 0x00, 0x07, 0x80, 0xF8, 0x3E, 0x0F, 0x80, 0xF0, 0x78, 0x07, 0x87,
  0x80, 0x3C, 0x7C, 0x00, 0xF3, 0xC0, 0x07, 0xBC, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x79,
  0xE0, 0x07, 0x87, 0x80, 0x7C, 0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x0F, 0x83,
  0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F,
  0x1E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xF7,
  0x80, 0x00, 0xEE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x0B, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80,
  0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x78, 0x07,
  0xF0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xC0, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0xBF,
  0xC0, 0x7F, 0xFC, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x01, 0xF0,
};

const GFXglyph NotoSans_Condensed_MediumItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 11, 30, 10, 0, -30 },
  { 43, 13, 11, 16, 4, -30 },
  { 61, 22, 30, 21, 0, -30 },
  { 144, 19, 34, 19, 0, -32 },
  { 225, 26, 30, 29, 2, -30 },
  { 323, 21, 30, 22, 0, -30 },
  { 402, 6, 11, 9, 4, -30 },
  { 411, 13, 37, 12, 1, -30 },
  { 472, 13, 37, 12, -3, -30 },
  { 533, 15, 16, 18, 4, -32 },
  { 563, 17, 20, 20, 2, -25 },
  { 606, 8, 11, 10, -2, -5 },
  { 617, 10, 4, 12, 1, -13 },
  { 622, 6, 5, 10, 0, -5 },
  { 626, 20, 30, 15, -2, -30 },
  { 701, 18, 30, 19, 1, -30 },
  { 769, 12, 30, 19, 5, -30 },
  { 814, 20, 30, 19, -1, -30 },
  { 889, 19, 30, 19, 0, -30 },
  { 961, 19, 30, 19, 0, -30 },
  { 1033, 19, 30, 19, 0, -30 },
  { 1105, 19, 30, 19, 1, -30 },
  { 1177, 18, 30, 19, 2, -30 },
  { 1245, 19, 30, 19, 0, -30 },
  { 1317, 17, 30, 19, 1, -30 },
  { 1381, 9, 23, 10, 0, -23 },
  { 1407, 11, 29, 10, -2, -23 },
  { 1447, 17, 20, 20, 2, -25 },
  { 1490, 17, 12, 20, 2, -21 },
  { 1516, 17, 20, 20, 2, -25 },
  { 1559, 15, 30, 14, 1, -30 },
  { 1616, 27, 34, 28, 1, -30 },
  { 1731, 20, 30, 20, -3, -30 },
  { 1806, 21, 30, 21, 0, -30 },
  { 1885, 20, 30, 19, 2, -30 },
  { 1960, 22, 30, 23, 0, -30 },
  { 2043, 19, 30, 18, 0, -30 },
  { 2115, 19, 30, 17, 0, -30 },
  { 2187, 22, 30, 23, 2, -30 },
  { 2270, 24, 30, 23, 0, -30 },
  { 2360, 17, 30, 12, -2, -30 },
  { 2424, 17, 38, 10, -6, -30 },
  { 2505, 23, 30, 20, 0, -30 },
  { 2592, 14, 30, 17, 0, -30 },
  { 2645, 31, 30, 30, 0, -30 },
  { 2762, 25, 30, 25, 0, -30 },
  { 2856, 21, 30, 24, 2, -30 },
  { 2935, 20, 30, 20, 0, -30 },
  { 3010, 21, 37, 24, 2, -30 },
  { 3108, 20, 30, 20, 0, -30 },
  { 3183, 19, 30, 18, 0, -30 },
  { 3255, 17, 30, 17, 3, -30 },
  { 3319, 22, 30, 23, 2, -30 },
  { 3402, 19, 30, 19, 4, -30 },
  { 3474, 30, 30, 31, 4, -30 },
  { 3587, 24, 30, 18, -2, -30 },
  { 3677, 17, 30, 18, 4, -30 },
  { 3741, 20, 30, 17, -1, -30 },
  { 3816, 16, 37, 12, -1, -30 },
  { 3890, 8, 30, 15, 4, -30 },
  { 3920, 16, 37, 12, -3, -30 },
  { 3994, 18, 17, 19, 1, -30 },
  { 4033, 15, 2, 14, -4, 4 },
  { 4037, 7, 7, 11, 6, -32 },
  { 4044, 19, 23, 20, 1, -23 },
  { 4099, 19, 32, 20, 0, -32 },
  { 4175, 16, 23, 16, 1, -23 },
  { 4221, 21, 32, 20, 1, -32 },
  { 4305, 16, 23, 18, 1, -23 },
  { 4351, 21, 42, 11, -5, -32 },
  { 4462, 20, 33, 20, 0, -23 },
  { 4545, 18, 32, 20, 0, -32 },
  { 4617, 11, 31, 9, 0, -31 },
  { 4660, 16, 41, 9, -5, -31 },
  { 4742, 19, 32, 18, 0, -32 },
  { 4818, 11, 32, 9, 0, -32 },
  { 4862, 28, 23, 30, 0, -23 },
  { 4943, 18, 23, 20, 0, -23 },
  { 4995, 17, 23, 19, 1, -23 },
  { 5044, 21, 33, 20, -2, -23 },
  { 5131, 19, 33, 20, 1, -23 },
  { 5210, 15, 23, 14, 0, -23 },
  { 5254, 15, 23, 15, 0, -23 },
  { 5298, 11, 28, 12, 2, -28 },
  { 5337, 18, 23, 20, 1, -23 },
  { 5389, 17, 23, 16, 2, -23 },
  { 5438, 25, 23, 26, 3, -23 },
  { 5510, 21, 23, 17, -2, -23 },
  { 5571, 23, 33, 17, -4, -23 },
  { 5666, 16, 23, 14, -1, -23 },
  { 5712, 16, 37, 14, 1, -30 },
  { 5786, 4, 42, 18, 7, -32 },
  { 5807, 15, 37, 14, -2, -30 },
  { 5877, 17, 6, 20, 2, -18 },
};

const GFXfont NotoSans_Condensed_MediumItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC42PT7B_H_
