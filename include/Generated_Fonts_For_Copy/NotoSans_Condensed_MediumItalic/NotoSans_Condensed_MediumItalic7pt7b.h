#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC7PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0x80, 0xE0, 0x57, 0x6E, 0xC0, 0x79, 0x3C, 0x56, 0xBE, 0xD7,
  0x00, 0x66, 0x5A, 0xE0, 0xC0, 0x5A, 0xA0, 0x24, 0x95, 0x80, 0xB0, 0x5D,
  0x00, 0xC0, 0xC0, 0x80, 0x29, 0x48, 0x76, 0xDC, 0x6A, 0x80, 0x64, 0xAC,
  0x65, 0x1C, 0x2E, 0xF4, 0x69, 0x9C, 0x6A, 0xDC, 0x65, 0x28, 0x6D, 0x5C,
  0x77, 0x9C, 0x42, 0x42, 0x80, 0x39, 0x80, 0xFC, 0xC7, 0x00, 0x65, 0x48,
  0x33, 0xF7, 0xE8, 0x30, 0x2D, 0xFA, 0x6D, 0xDE, 0x74, 0x88, 0x60, 0x65,
  0x9A, 0xE0, 0x69, 0xCC, 0x69, 0xC8, 0x74, 0xB9, 0x60, 0x55, 0x6A, 0xA0,
  0x69, 0x4C, 0x25, 0x25, 0x80, 0x56, 0x4A, 0xA0, 0x5A, 0xC0, 0x4A, 0xF7,
  0x5B, 0x00, 0x55, 0xBA, 0xA0, 0x75, 0x99, 0x60, 0x6F, 0xC8, 0x75, 0x99,
  0x62, 0x6D, 0xDA, 0x71, 0x1C, 0xEA, 0x80, 0x55, 0x9A, 0xE0, 0xBB, 0x48,
  0xAE, 0xAD, 0x4A, 0x00, 0x76, 0x4C, 0xA0, 0xFA, 0x48, 0x65, 0x4C, 0x6A,
  0x49, 0x00, 0xF8, 0x55, 0xA0, 0x4E, 0x80, 0xE0, 0x80, 0x76, 0xF0, 0x4E,
  0xDC, 0x72, 0x60, 0x16, 0xAA, 0xE0, 0x77, 0x70, 0x36, 0x44, 0x44, 0x80,
  0x76, 0xF3, 0x80, 0x4E, 0xDA, 0x5A, 0x80, 0x25, 0x24, 0xA0, 0x4D, 0x6A,
  0x5A, 0x80, 0x7D, 0x6B, 0x60, 0x76, 0xD0, 0x76, 0xE0, 0x76, 0xF9, 0x00,
  0x76, 0xF2, 0x80, 0x72, 0x40, 0x71, 0x60, 0x7A, 0xC0, 0x76, 0xF0, 0xB5,
  0x20, 0xAD, 0xBD, 0x40, 0xA9, 0x60, 0x55, 0x22, 0x48, 0x6A, 0x60, 0x29,
  0x49, 0x80, 0xFE, 0x55, 0xA0, 0xE0,
};

const GFXglyph NotoSans_Condensed_MediumItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 3, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 3, 5, 3, 0, -5 },
  { 9, 5, 5, 5, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 1, 1, -5 },
  { 17, 2, 6, 2, 0, -5 },
  { 19, 3, 6, 2, -1, -5 },
  { 22, 2, 2, 3, 1, -5 },
  { 23, 3, 3, 3, 0, -4 },
  { 25, 1, 2, 2, 0, -1 },
  { 26, 2, 1, 2, 0, -2 },
  { 27, 1, 1, 2, 0, -1 },
  { 28, 3, 5, 2, 0, -5 },
  { 30, 3, 5, 3, 0, -5 },
  { 32, 2, 5, 3, 1, -5 },
  { 34, 3, 5, 3, 0, -5 },
  { 36, 3, 5, 3, 0, -5 },
  { 38, 3, 5, 3, 0, -5 },
  { 40, 3, 5, 3, 0, -5 },
  { 42, 3, 5, 3, 0, -5 },
  { 44, 3, 5, 3, 0, -5 },
  { 46, 3, 5, 3, 0, -5 },
  { 48, 3, 5, 3, 0, -5 },
  { 50, 2, 4, 2, 0, -4 },
  { 51, 2, 5, 2, 0, -4 },
  { 53, 3, 3, 3, 0, -4 },
  { 55, 3, 2, 3, 0, -3 },
  { 56, 3, 3, 3, 0, -4 },
  { 58, 3, 5, 2, 0, -5 },
  { 60, 5, 6, 5, 0, -5 },
  { 64, 3, 5, 3, 0, -5 },
  { 66, 3, 5, 3, 0, -5 },
  { 68, 4, 5, 3, 0, -5 },
  { 71, 4, 5, 4, 0, -5 },
  { 74, 3, 5, 3, 0, -5 },
  { 76, 3, 5, 3, 0, -5 },
  { 78, 4, 5, 4, 0, -5 },
  { 81, 4, 5, 4, 0, -5 },
  { 84, 3, 5, 2, 0, -5 },
  { 86, 3, 6, 2, -1, -5 },
  { 89, 4, 5, 3, 0, -5 },
  { 92, 2, 5, 3, 0, -5 },
  { 94, 5, 5, 5, 0, -5 },
  { 98, 4, 5, 4, 0, -5 },
  { 101, 4, 5, 4, 0, -5 },
  { 104, 3, 5, 3, 0, -5 },
  { 106, 4, 6, 4, 0, -5 },
  { 109, 3, 5, 3, 0, -5 },
  { 111, 3, 5, 3, 0, -5 },
  { 113, 2, 5, 3, 1, -5 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 3, 5, 3, 1, -5 },
  { 120, 5, 5, 5, 1, -5 },
  { 124, 4, 5, 3, 0, -5 },
  { 127, 3, 5, 3, 1, -5 },
  { 129, 3, 5, 3, 0, -5 },
  { 131, 3, 6, 2, 0, -5 },
  { 134, 1, 5, 3, 1, -5 },
  { 135, 2, 6, 2, 0, -5 },
  { 137, 3, 3, 3, 0, -5 },
  { 139, 3, 1, 2, -1, 0 },
  { 140, 1, 1, 2, 1, -5 },
  { 141, 3, 4, 3, 0, -4 },
  { 143, 3, 5, 3, 0, -5 },
  { 145, 3, 4, 3, 0, -4 },
  { 147, 4, 5, 3, 0, -5 },
  { 150, 3, 4, 3, 0, -4 },
  { 152, 4, 7, 2, -1, -5 },
  { 156, 3, 6, 3, 0, -4 },
  { 159, 3, 5, 3, 0, -5 },
  { 161, 2, 5, 2, 0, -5 },
  { 163, 3, 7, 2, -1, -5 },
  { 166, 3, 5, 3, 0, -5 },
  { 168, 2, 5, 2, 0, -5 },
  { 170, 5, 4, 5, 0, -4 },
  { 173, 3, 4, 3, 0, -4 },
  { 175, 3, 4, 3, 0, -4 },
  { 177, 3, 6, 3, 0, -4 },
  { 180, 3, 6, 3, 0, -4 },
  { 183, 3, 4, 2, 0, -4 },
  { 185, 3, 4, 3, 0, -4 },
  { 187, 2, 5, 2, 0, -5 },
  { 189, 3, 4, 3, 0, -4 },
  { 191, 3, 4, 3, 0, -4 },
  { 193, 5, 4, 4, 0, -4 },
  { 196, 3, 4, 3, 0, -4 },
  { 198, 4, 6, 3, -1, -4 },
  { 201, 3, 4, 2, 0, -4 },
  { 203, 3, 6, 2, 0, -5 },
  { 206, 1, 7, 3, 1, -5 },
  { 207, 2, 6, 2, 0, -5 },
  { 209, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_MediumItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC7PT7B_H_
