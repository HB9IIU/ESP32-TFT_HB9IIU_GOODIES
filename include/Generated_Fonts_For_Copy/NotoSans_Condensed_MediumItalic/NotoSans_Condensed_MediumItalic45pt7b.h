#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC45PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x07,
  0x80, 0x3E, 0x3C, 0xF1, 0xF3, 0xC7, 0xCF, 0x1E, 0x3C, 0x79, 0xE1, 0xE7,
  0x87, 0x9E, 0x1C, 0x70, 0xF1, 0xC3, 0xCF, 0x0E, 0x00, 0x00, 0x1E, 0x1C,
  0x00, 0x38, 0x78, 0x00, 0xF0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80,
  0x0F, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0xF0, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x1E, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0x70, 0xF0, 0x01, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07,
  0x00, 0x0E, 0x1E, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x23, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x1E, 0x00, 0x3C, 0x38, 0x00,
  0x70, 0x70, 0x00, 0xE1, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7E,
  0xCE, 0x07, 0x8C, 0x20, 0x79, 0xC0, 0x0F, 0x18, 0x00, 0xF1, 0x80, 0x0F,
  0x18, 0x00, 0xF9, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x6F, 0x80, 0x06, 0x78,
  0x00, 0x67, 0x80, 0x0E, 0x7C, 0x00, 0xC7, 0x80, 0x0C, 0x78, 0x40, 0xC7,
  0x87, 0x0D, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0xFE,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFC, 0x01, 0xE0, 0x7F, 0x80, 0x38,
  0x0F, 0xF8, 0x0F, 0x03, 0xCF, 0x01, 0xC0, 0xF0, 0xE0, 0x70, 0x1E, 0x1C,
  0x1E, 0x03, 0x83, 0x83, 0x80, 0xF0, 0xF0, 0xF0, 0x1E, 0x1E, 0x1C, 0x03,
  0x83, 0xC7, 0x80, 0x70, 0x71, 0xE0, 0x0E, 0x0E, 0x38, 0x01, 0xC3, 0xCF,
  0x0E, 0x38, 0x71, 0xC7, 0xE7, 0x1E, 0x79, 0xFE, 0xE3, 0x9E, 0x7B, 0xDF,
  0xF3, 0x9E, 0x3B, 0xFC, 0xF3, 0x87, 0x3F, 0x1C, 0x70, 0xF1, 0x07, 0x9E,
  0x1C, 0x01, 0xE3, 0x83, 0x80, 0x38, 0x70, 0x70, 0x0F, 0x1E, 0x0E, 0x01,
  0xC3, 0xC3, 0xC0, 0x78, 0x78, 0x70, 0x0E, 0x0E, 0x0E, 0x03, 0x81, 0xC3,
  0xC0, 0xF0, 0x38, 0x70, 0x1C, 0x07, 0x9E, 0x07, 0x80, 0xFF, 0x80, 0xE0,
  0x0F, 0xE0, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0x1E, 0x00, 0x3C, 0x3C, 0x00,
  0x78, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x87, 0xC0, 0x0F,
  0x0F, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x3C, 0x3F, 0xF0,
  0xF0, 0xF9, 0xE1, 0xE3, 0xE3, 0xE7, 0xCF, 0x87, 0xCF, 0x1E, 0x07, 0xFE,
  0x3C, 0x0F, 0xF8, 0xF8, 0x0F, 0xF1, 0xF0, 0x1F, 0xC3, 0xE0, 0x1F, 0x07,
  0xC0, 0x7E, 0x0F, 0x81, 0xFE, 0x0F, 0xCF, 0xFC, 0x1F, 0xFF, 0x7C, 0x1F,
  0xFC, 0xF8, 0x1F, 0xE0, 0xF8, 0x7D, 0xF7, 0x9E, 0x7B, 0xCF, 0x3C, 0xF3,
  0x8E, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x08, 0x3C, 0x07, 0x1E, 0x03, 0xEE, 0x03, 0xFF, 0x7E, 0x7F,
  0xFF, 0x07, 0xFF, 0x83, 0xE7, 0xC3, 0xF8, 0x03, 0xFE, 0x03, 0xE7, 0x03,
  0xE3, 0xC0, 0xE1, 0xE0, 0x30, 0x78, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x87, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x78,
  0x78, 0x3C, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xE0, 0x19, 0xF7, 0xDF,
  0xFD, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xE0, 0x03,
  0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0x7C, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x7C,
  0x0F, 0x0F, 0x01, 0xE3, 0xE0, 0x3C, 0x78, 0x07, 0x9F, 0x01, 0xF3, 0xE0,
  0x3E, 0x78, 0x07, 0xCF, 0x00, 0xFB, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x00,
  0x79, 0xE0, 0x1F, 0x3C, 0x03, 0xE7, 0x80, 0x79, 0xF0, 0x0F, 0x3E, 0x03,
  0xE7, 0xC0, 0x78, 0xF8, 0x0F, 0x1F, 0x03, 0xE3, 0xE0, 0x78, 0x3C, 0x1F,
  0x07, 0x87, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xC0,
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFC, 0x1F, 0xE1, 0xFF, 0x1F, 0x79, 0xF7,
  0xDF, 0x3C, 0x71, 0xE1, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x06, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x3F, 0x00, 0xE0, 0x7C, 0x04, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x0F,
  0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xC3, 0xF0, 0x30, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xE0,
  0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x80, 0x3F, 0x0F, 0x9F, 0xE0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3B, 0xC0, 0x03, 0xFC, 0x00, 0x3D, 0xE0, 0x01, 0xCF, 0x00, 0x1E, 0x78,
  0x01, 0xE7, 0xC0, 0x0E, 0x3C, 0x00, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF0,
  0x78, 0x07, 0x07, 0xC0, 0x78, 0x3C, 0x07, 0x81, 0xE0, 0x38, 0x0F, 0x03,
  0xC0, 0xF8, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE4, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x08,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x0C, 0x03, 0xF0, 0xF8, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0x84, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF9, 0xF8,
  0x1E, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0x3F, 0x1F, 0x83, 0xE3, 0xE0, 0x3C,
  0x7C, 0x07, 0xCF, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78,
  0xF0, 0x1F, 0x1E, 0x03, 0xE3, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x87, 0xC1,
  0xFB, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xE1, 0xF0, 0x7C, 0x0F, 0x07, 0x80, 0xF0,
  0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x81, 0xF0, 0x78, 0x1E,
  0x07, 0xC3, 0xE0, 0x3E, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0xE0, 0x0F, 0xDF, 0x01, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xC0,
  0x78, 0x78, 0x07, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8,
  0x07, 0xCF, 0x80, 0x78, 0x7C, 0x0F, 0x87, 0xE3, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xE0, 0x0F, 0xFE,
  0x03, 0xFF, 0xE0, 0xFC, 0x7C, 0x1F, 0x07, 0x87, 0xC0, 0xF8, 0xF0, 0x1F,
  0x1E, 0x03, 0xE7, 0xC0, 0x7C, 0xF0, 0x0F, 0x9E, 0x01, 0xF3, 0xC0, 0x3E,
  0x78, 0x07, 0x8F, 0x01, 0xF1, 0xE0, 0x7E, 0x3E, 0x0F, 0xC7, 0xFF, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFB, 0xC0, 0xFE, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x81, 0x8F, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0x01, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xE0, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0x78, 0x00, 0x00, 0x40, 0x1F, 0x01,
  0xF0, 0x3F, 0x03, 0xF0, 0x1E, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C,
  0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x06, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00,
  0x78, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xF0, 0xFF, 0xF1, 0xFF,
  0xF3, 0xC7, 0xE2, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F,
  0x07, 0x00, 0xC0, 0x38, 0x70, 0x3F, 0xE1, 0xC7, 0x83, 0xFF, 0x0E, 0x38,
  0x3C, 0x78, 0x71, 0xC3, 0xC3, 0x83, 0x9C, 0x1C, 0x1C, 0x1C, 0xE1, 0xE0,
  0xE1, 0xE7, 0x0E, 0x0F, 0x0F, 0x78, 0x70, 0x70, 0x73, 0x87, 0x83, 0x83,
  0x9C, 0x38, 0x3C, 0x1C, 0xE1, 0xC1, 0xE1, 0xC7, 0x0E, 0x0E, 0x0E, 0x78,
  0x70, 0xF0, 0xF3, 0xC3, 0x87, 0x87, 0x1E, 0x1C, 0x7C, 0x78, 0xF0, 0xFF,
  0x7F, 0x87, 0x83, 0xF3, 0xF8, 0x1C, 0x0F, 0x0F, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x04, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x77, 0x00, 0x07, 0xB8, 0x00, 0x3D,
  0xC0, 0x03, 0xCE, 0x00, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00,
  0x78, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F,
  0x01, 0xF0, 0x78, 0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x1E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0x78,
  0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xF3, 0xE0, 0x07, 0xBE, 0x00,
  0x3D, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xF0, 0x3C,
  0x03, 0xC0, 0xF0, 0x0F, 0x07, 0xC0, 0x3C, 0x1F, 0x01, 0xF0, 0x78, 0x07,
  0x81, 0xE0, 0x3E, 0x07, 0x81, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3C, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0x7C, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C,
  0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x7E, 0x1F, 0x03, 0xF0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFC, 0xF0,
  0x1F, 0x80, 0x40, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x02, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3E, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0xF0,
  0x0F, 0x81, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3C, 0x1E, 0x00,
  0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F,
  0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x7C, 0x01, 0xF0,
  0xF8, 0x03, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x78, 0x07, 0xC0, 0xF0, 0x3F, 0x03, 0xE0,
  0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFE, 0xFC, 0x03, 0xF0, 0x0C, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x0F, 0xF8, 0xF8, 0x0F, 0xF8, 0xF8, 0x0F, 0xF8, 0xF8, 0x0F,
  0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0x7C, 0x03,
  0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x1E,
  0x00, 0x78, 0x07, 0x80, 0x1E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0,
  0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07,
  0xC0, 0x78, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0xC0, 0x0F, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1E, 0x00, 0x78,
  0x07, 0x80, 0x1E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00,
  0xF8, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x01, 0xF0, 0x07, 0xC0, 0x7C,
  0x01, 0xF0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x03, 0xE0, 0x0F, 0x80,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x08, 0x7E, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0xF0, 0x0F, 0x80, 0x78, 0x0F, 0x80,
  0x3C, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1E, 0x07, 0xC0, 0x0F, 0x07, 0xC0,
  0x07, 0x87, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xE3, 0xE0,
  0x00, 0xF3, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xEF,
  0x80, 0x03, 0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0xC0, 0x0F,
  0x03, 0xE0, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x01,
  0xE0, 0x1F, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xFF,
  0xEF, 0xFF, 0xDF, 0xFF, 0x7F, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F,
  0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07,
  0xF8, 0x03, 0xFE, 0x07, 0xBC, 0x01, 0xFE, 0x03, 0xDE, 0x01, 0xEF, 0x01,
  0xEF, 0x00, 0xF7, 0x80, 0xF7, 0x80, 0xF7, 0xC0, 0x7B, 0xC0, 0x7B, 0xE0,
  0x79, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x3C, 0x78,
  0x0F, 0x3C, 0x1E, 0x7C, 0x07, 0x9E, 0x1E, 0x3C, 0x07, 0x87, 0x0F, 0x1E,
  0x03, 0xC3, 0x8F, 0x0F, 0x01, 0xE1, 0xC7, 0x87, 0x80, 0xF0, 0xE7, 0x87,
  0xC0, 0xF8, 0x7B, 0xC3, 0xC0, 0x78, 0x3D, 0xC1, 0xE0, 0x3C, 0x1F, 0xE0,
  0xF0, 0x1E, 0x0F, 0xE0, 0xF8, 0x0F, 0x07, 0xF0, 0x7C, 0x0F, 0x83, 0xF8,
  0x3C, 0x07, 0x81, 0xF8, 0x1E, 0x03, 0xC0, 0xFC, 0x0F, 0x01, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xE0, 0x3F, 0x00,
  0x3C, 0x07, 0xE0, 0x0F, 0x81, 0xFC, 0x01, 0xE0, 0x3F, 0x80, 0x3C, 0x07,
  0xF8, 0x07, 0x80, 0xFF, 0x00, 0xF0, 0x1F, 0xE0, 0x3E, 0x07, 0xBC, 0x07,
  0x80, 0xF7, 0x80, 0xF0, 0x1E, 0x78, 0x1E, 0x03, 0xCF, 0x03, 0xC0, 0x79,
  0xE0, 0xF8, 0x1F, 0x3C, 0x1E, 0x03, 0xC3, 0xC3, 0xC0, 0x78, 0x78, 0x78,
  0x0F, 0x0F, 0x1F, 0x01, 0xE1, 0xE3, 0xC0, 0x78, 0x3C, 0x78, 0x0F, 0x03,
  0xCF, 0x01, 0xE0, 0x79, 0xE0, 0x3C, 0x0F, 0x3C, 0x0F, 0x81, 0xEF, 0x01,
  0xE0, 0x1F, 0xE0, 0x3C, 0x03, 0xFC, 0x07, 0x80, 0x7F, 0x80, 0xF0, 0x0F,
  0xF0, 0x3E, 0x01, 0xFC, 0x07, 0x80, 0x1F, 0x80, 0xF0, 0x03, 0xF0, 0x1E,
  0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0x9F, 0xC0, 0xFC, 0x0F, 0x83,
  0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0xF8,
  0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00,
  0x0F, 0xBE, 0x00, 0x1F, 0x78, 0x00, 0x3F, 0xF0, 0x00, 0x7B, 0xE0, 0x01,
  0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0x3E, 0x00, 0x3E,
  0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x83,
  0xE0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x3C, 0x07,
  0xC0, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x78, 0x07, 0xC1,
  0xE0, 0x1E, 0x07, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xC1,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0x9F, 0xC0,
  0xFC, 0x0F, 0x83, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xEF, 0x80,
  0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x78, 0x00, 0x3F, 0xF0, 0x00,
  0x7B, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F,
  0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3,
  0xE0, 0x0F, 0x83, 0xE0, 0x3F, 0x07, 0xC0, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xE0, 0xF8, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0xC0, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xE0, 0x78,
  0x07, 0x81, 0xE0, 0x3E, 0x07, 0x80, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3F,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07,
  0xC7, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x83,
  0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3E, 0x03, 0xC0, 0xF8, 0x1F, 0x01, 0xE0,
  0x7C, 0x07, 0x81, 0xE0, 0x1F, 0x07, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x00,
  0x06, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x03, 0xE0, 0x30, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC1, 0x00, 0x3E,
  0x0C, 0x03, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x1F,
  0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E,
  0x00, 0x78, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x3C,
  0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x78,
  0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8,
  0x03, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xFC,
  0x1F, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xBC, 0x00, 0x7D, 0xE0, 0x07,
  0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF0, 0xF8,
  0x0F, 0x87, 0xC0, 0x78, 0x3E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x83, 0xE0,
  0x7C, 0x1F, 0x03, 0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x78, 0x03, 0xC7,
  0xC0, 0x1E, 0x3C, 0x00, 0xF3, 0xE0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01,
  0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x1F, 0xF0, 0x07,
  0xC0, 0x1E, 0xF0, 0x07, 0xC0, 0x3E, 0xF0, 0x0F, 0xC0, 0x3E, 0xF0, 0x0F,
  0xC0, 0x3C, 0xF0, 0x0F, 0xC0, 0x7C, 0xF0, 0x1F, 0xC0, 0x78, 0xF0, 0x1D,
  0xC0, 0x78, 0xF0, 0x3D, 0xC0, 0xF8, 0xF0, 0x3D, 0xC0, 0xF0, 0xF0, 0x79,
  0xC1, 0xF0, 0xF0, 0x79, 0xC1, 0xE0, 0xF0, 0x71, 0xC1, 0xE0, 0xF0, 0xF1,
  0xC3, 0xC0, 0xF0, 0xF3, 0xC3, 0xC0, 0xF1, 0xE3, 0xC7, 0xC0, 0xF1, 0xE3,
  0xC7, 0x80, 0xF1, 0xC3, 0xC7, 0x80, 0xF3, 0xC3, 0xCF, 0x00, 0xF3, 0xC3,
  0xCF, 0x00, 0xF7, 0x83, 0xDF, 0x00, 0xF7, 0x83, 0xDE, 0x00, 0xF7, 0x03,
  0xDE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF0, 0x01, 0xE0, 0x7C, 0x00,
  0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xE0,
  0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0x7C,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1E, 0x03, 0xE0, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x1E, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xFF, 0x00, 0xFB, 0xE0,
  0x1E, 0x3C, 0x07, 0xC7, 0x80, 0xF0, 0xF0, 0x3E, 0x1E, 0x07, 0x83, 0xC1,
  0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x78, 0x03, 0xDF,
  0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x08, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x77,
  0x80, 0x1E, 0x70, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3C, 0x1C, 0x07, 0x83,
  0xC1, 0xE0, 0x78, 0x78, 0x07, 0x0F, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x01,
  0xDE, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xF9, 0xF1, 0xE1,
  0xE3, 0xC3, 0x83, 0x80, 0x00, 0x70, 0x00, 0x1F, 0xCF, 0x03, 0xFE, 0xF0,
  0x7F, 0xEF, 0x0F, 0xC7, 0xE1, 0xF8, 0x3E, 0x1F, 0x03, 0xE3, 0xE0, 0x3E,
  0x3E, 0x03, 0xE3, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0xC0, 0x3C, 0x78, 0x07,
  0xC7, 0x80, 0x7C, 0x78, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80,
  0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0x78, 0x3F, 0x07, 0xC7, 0xF0, 0x7F,
  0xEF, 0x03, 0xFC, 0xE0, 0x1F, 0x8E, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x30, 0x07, 0x9F, 0xC0, 0x7B,
  0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0x1F, 0x0F, 0xC1, 0xF0, 0xFC, 0x0F, 0x0F,
  0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xF0, 0x0F, 0x1E, 0x01, 0xF1,
  0xE0, 0x1F, 0x1E, 0x01, 0xE3, 0xE0, 0x1E, 0x3E, 0x03, 0xE3, 0xC0, 0x3E,
  0x3C, 0x03, 0xC3, 0xC0, 0x7C, 0x7E, 0x07, 0x87, 0xE0, 0xF8, 0x7F, 0x1F,
  0x07, 0xFF, 0xE0, 0x73, 0xFE, 0x0F, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFC, 0x20, 0xFC, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x83, 0xF3, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x01, 0xC3, 0xC0, 0x1F, 0xCF, 0x00, 0xFF, 0xBC, 0x07,
  0xFF, 0xF0, 0x3F, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x03,
  0xE0, 0xF8, 0x0F, 0x83, 0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x7C, 0x03, 0xC1,
  0xE0, 0x1F, 0x07, 0x80, 0x7C, 0x1E, 0x01, 0xE0, 0xF8, 0x07, 0x83, 0xE0,
  0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0xFC,
  0x07, 0xC7, 0xF0, 0x1F, 0xFB, 0xC0, 0x3F, 0xCE, 0x00, 0x7E, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0x87, 0x87,
  0xC1, 0xF1, 0xE0, 0x78, 0xF8, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xE7, 0xC3,
  0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x04, 0x1F,
  0x87, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0x40, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xF3,
  0xC0, 0x7F, 0xDE, 0x07, 0xFE, 0xF0, 0x7E, 0x3F, 0x07, 0xE0, 0xF8, 0x3E,
  0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x80, 0x78,
  0x7C, 0x03, 0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x80,
  0x78, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07,
  0xC1, 0xF8, 0x1F, 0x3F, 0xC0, 0xFF, 0xFE, 0x03, 0xFD, 0xE0, 0x0F, 0xCF,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x02, 0x00, 0xF0, 0x18, 0x1F, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x30, 0x07, 0x9F, 0xC0, 0x7B, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE1, 0xF0, 0x1E, 0x1E, 0x03, 0xE1, 0xE0,
  0x3E, 0x1E, 0x03, 0xC3, 0xE0, 0x3C, 0x3E, 0x03, 0xC3, 0xC0, 0x7C, 0x3C,
  0x07, 0xC3, 0xC0, 0x78, 0x7C, 0x07, 0x87, 0xC0, 0x78, 0x78, 0x0F, 0x87,
  0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x80, 0xF0, 0x01, 0xE0, 0x1F, 0x03, 0xE0,
  0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0x80,
  0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x41, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x78, 0x3E, 0x03, 0xC3,
  0xE0, 0x3E, 0x3E, 0x01, 0xE3, 0xE0, 0x0F, 0x1E, 0x00, 0x79, 0xE0, 0x03,
  0xDF, 0x00, 0x3D, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0x7C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78,
  0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xE0,
  0x78, 0x1F, 0x07, 0xC0, 0x78, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0x00, 0x07, 0x00,
  0xE0, 0x1E, 0x7F, 0x0F, 0xE0, 0x7B, 0xFE, 0x7F, 0xC1, 0xFF, 0xFB, 0xFF,
  0x07, 0xE3, 0xFC, 0x7C, 0x3F, 0x07, 0xE0, 0xF0, 0xF8, 0x1F, 0x03, 0xC3,
  0xE0, 0x7C, 0x0F, 0x0F, 0x01, 0xE0, 0x3C, 0x3C, 0x07, 0x81, 0xF1, 0xF0,
  0x3E, 0x07, 0x87, 0x80, 0xF0, 0x1E, 0x1E, 0x03, 0xC0, 0x78, 0x78, 0x0F,
  0x01, 0xE3, 0xE0, 0x3C, 0x0F, 0x8F, 0x81, 0xF0, 0x3C, 0x3C, 0x07, 0x80,
  0xF0, 0xF0, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x0F, 0x1F, 0x03, 0xE0, 0x7C,
  0x7C, 0x0F, 0x81, 0xE1, 0xE0, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0x1E, 0x1E,
  0x03, 0xC0, 0xF8, 0xF8, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x79, 0xFC,
  0x07, 0xBF, 0xE0, 0x7F, 0xFE, 0x07, 0xF3, 0xF0, 0xFC, 0x1F, 0x0F, 0xC1,
  0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x1F, 0x01, 0xE1, 0xE0,
  0x3E, 0x1E, 0x03, 0xE1, 0xE0, 0x3C, 0x3E, 0x03, 0xC3, 0xE0, 0x3C, 0x3C,
  0x07, 0xC3, 0xC0, 0x7C, 0x3C, 0x07, 0x87, 0xC0, 0x78, 0x7C, 0x07, 0x87,
  0x80, 0xF8, 0x78, 0x0F, 0x87, 0x80, 0xF0, 0xF8, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0x87, 0xC7, 0xC0, 0xF1,
  0xF0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0xC0, 0x3D, 0xE0,
  0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xBE, 0x03, 0xEF, 0x80, 0xF1, 0xE0, 0x7C, 0x78, 0x3E, 0x1F, 0x9F, 0x83,
  0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x9F,
  0xC0, 0x1E, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x7C, 0x0F, 0xC1, 0xF0,
  0x3F, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x7C,
  0x03, 0xC1, 0xE0, 0x1F, 0x07, 0x80, 0x7C, 0x1E, 0x01, 0xE0, 0x78, 0x07,
  0x83, 0xE0, 0x3E, 0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xC0, 0xF0, 0x1F, 0x07,
  0xE0, 0x78, 0x1F, 0x83, 0xE0, 0x7F, 0x3F, 0x01, 0xFF, 0xFC, 0x07, 0xBF,
  0xE0, 0x3E, 0x7E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x1F, 0xCF, 0x03, 0xFE, 0xF0, 0x7F, 0xEF, 0x0F, 0xC7, 0xE0, 0xF0,
  0x3E, 0x1F, 0x03, 0xE1, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xC0, 0x3C, 0x7C,
  0x03, 0xC7, 0xC0, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0x8F,
  0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xF0,
  0x78, 0x3F, 0x07, 0xC7, 0xF0, 0x7F, 0xFF, 0x03, 0xFD, 0xE0, 0x1F, 0x9E,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x83, 0xCF, 0x81, 0xEF, 0xC0, 0xFF,
  0xE0, 0x77, 0xE0, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x01, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xE1, 0xF0, 0x60, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x88, 0x0F, 0x87, 0x0F, 0xC3, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0xF0, 0x3F, 0xF7, 0xFF, 0xFF, 0xF1, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF9, 0x0F, 0xF0, 0xFF, 0x07,
  0xF0, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xE1, 0xF0, 0x1E, 0x1F,
  0x01, 0xE1, 0xE0, 0x3E, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x3E, 0x03, 0xC3,
  0xC0, 0x3C, 0x3C, 0x07, 0xC3, 0xC0, 0x78, 0x3C, 0x07, 0x87, 0xC0, 0x78,
  0x78, 0x0F, 0x87, 0x80, 0xF8, 0x78, 0x0F, 0x07, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x83, 0xF0, 0x7C, 0xFF, 0x07, 0xFE, 0xE0, 0x7F, 0xDE, 0x03, 0xF9,
  0xE0, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x03, 0xE7,
  0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x3C, 0x3C,
  0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xEF, 0x80, 0xF7,
  0x80, 0x7B, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x1F, 0x03, 0xFE, 0x07, 0xE0, 0x7B, 0xC0,
  0xFC, 0x1F, 0x78, 0x3F, 0x83, 0xCF, 0x07, 0xF0, 0x79, 0xE1, 0xFE, 0x1E,
  0x3C, 0x3F, 0xC3, 0xC7, 0x87, 0x78, 0xF8, 0xF1, 0xEF, 0x1E, 0x1E, 0x39,
  0xE3, 0xC3, 0xCF, 0x38, 0xF0, 0x79, 0xE7, 0x1E, 0x0F, 0x38, 0xE7, 0xC1,
  0xEF, 0x1C, 0xF0, 0x3D, 0xC3, 0x9E, 0x07, 0xF8, 0x77, 0x80, 0xFF, 0x0E,
  0xF0, 0x1D, 0xC1, 0xDC, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x0F,
  0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C,
  0x00, 0x07, 0xC0, 0x7C, 0x0F, 0x03, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x78,
  0x01, 0xE3, 0xE0, 0x07, 0x9F, 0x00, 0x1E, 0x78, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xDE, 0x00,
  0x3E, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0xC7, 0xC0, 0x3E, 0x0F, 0x00, 0xF0,
  0x3C, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xE0, 0x01, 0xE0, 0x1F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0,
  0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE1,
  0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xE3, 0xE0, 0x00, 0xE3, 0xC0, 0x00, 0xE7,
  0xC0, 0x00, 0xE7, 0x80, 0x00, 0xE7, 0x80, 0x00, 0xEF, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x2F, 0xF8, 0x0F, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFD, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_Condensed_MediumItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 12, 32, 11, 0, -32 },
  { 49, 14, 11, 17, 4, -32 },
  { 69, 23, 32, 23, 0, -32 },
  { 161, 20, 37, 20, 0, -34 },
  { 254, 27, 33, 31, 3, -33 },
  { 366, 23, 33, 24, 0, -33 },
  { 461, 6, 11, 10, 5, -32 },
  { 470, 14, 39, 12, 1, -32 },
  { 539, 14, 39, 12, -3, -32 },
  { 608, 17, 17, 19, 4, -34 },
  { 645, 19, 22, 22, 2, -27 },
  { 698, 9, 11, 10, -2, -5 },
  { 711, 11, 4, 13, 1, -14 },
  { 717, 6, 6, 10, 0, -6 },
  { 722, 22, 32, 16, -2, -32 },
  { 810, 19, 33, 20, 1, -33 },
  { 889, 13, 32, 20, 5, -32 },
  { 941, 21, 33, 20, -1, -33 },
  { 1028, 20, 33, 20, 0, -33 },
  { 1111, 21, 32, 20, -1, -32 },
  { 1195, 20, 32, 20, 0, -32 },
  { 1275, 19, 33, 20, 2, -33 },
  { 1354, 20, 32, 20, 2, -32 },
  { 1434, 20, 33, 20, 0, -33 },
  { 1517, 19, 33, 20, 1, -33 },
  { 1596, 10, 25, 10, 0, -25 },
  { 1628, 12, 31, 10, -2, -25 },
  { 1675, 19, 21, 22, 2, -27 },
  { 1725, 18, 13, 22, 2, -22 },
  { 1755, 19, 21, 22, 2, -27 },
  { 1805, 15, 33, 15, 2, -33 },
  { 1867, 29, 36, 31, 1, -32 },
  { 1998, 21, 32, 21, -3, -32 },
  { 2082, 22, 32, 22, 0, -32 },
  { 2170, 22, 33, 21, 2, -33 },
  { 2261, 23, 32, 24, 0, -32 },
  { 2353, 21, 32, 19, 0, -32 },
  { 2437, 21, 32, 18, 0, -32 },
  { 2521, 24, 33, 25, 2, -33 },
  { 2620, 26, 32, 25, 0, -32 },
  { 2724, 18, 32, 13, -2, -32 },
  { 2796, 19, 41, 11, -7, -32 },
  { 2894, 25, 32, 21, 0, -32 },
  { 2994, 15, 32, 18, 0, -32 },
  { 3054, 33, 32, 32, 0, -32 },
  { 3186, 27, 32, 26, 0, -32 },
  { 3294, 23, 33, 26, 2, -33 },
  { 3389, 22, 32, 21, 0, -32 },
  { 3477, 23, 41, 26, 2, -33 },
  { 3595, 22, 32, 22, 0, -32 },
  { 3683, 21, 33, 19, 0, -33 },
  { 3770, 18, 32, 18, 4, -32 },
  { 3842, 24, 32, 24, 2, -32 },
  { 3938, 21, 32, 21, 4, -32 },
  { 4022, 32, 32, 33, 4, -32 },
  { 4150, 26, 32, 20, -3, -32 },
  { 4254, 19, 32, 19, 4, -32 },
  { 4330, 22, 32, 18, -1, -32 },
  { 4418, 17, 39, 13, -1, -32 },
  { 4501, 8, 32, 16, 5, -32 },
  { 4533, 17, 39, 13, -3, -32 },
  { 4616, 19, 18, 21, 1, -32 },
  { 4659, 16, 3, 15, -4, 4 },
  { 4665, 7, 7, 12, 7, -34 },
  { 4672, 20, 25, 21, 1, -25 },
  { 4735, 20, 34, 21, 0, -34 },
  { 4820, 17, 25, 17, 1, -25 },
  { 4874, 22, 34, 22, 1, -34 },
  { 4968, 18, 25, 19, 1, -25 },
  { 5025, 23, 45, 12, -5, -34 },
  { 5155, 21, 36, 22, 0, -25 },
  { 5250, 20, 34, 21, 0, -34 },
  { 5335, 12, 33, 10, 0, -33 },
  { 5385, 18, 44, 10, -6, -33 },
  { 5484, 21, 34, 19, 0, -34 },
  { 5574, 12, 34, 10, 0, -34 },
  { 5625, 30, 25, 32, 0, -25 },
  { 5719, 20, 25, 21, 0, -25 },
  { 5782, 18, 25, 21, 1, -25 },
  { 5839, 22, 36, 21, -2, -25 },
  { 5938, 20, 36, 22, 1, -25 },
  { 6028, 17, 25, 15, 0, -25 },
  { 6082, 17, 25, 16, 0, -25 },
  { 6136, 12, 30, 13, 2, -30 },
  { 6181, 20, 24, 21, 1, -24 },
  { 6241, 17, 24, 18, 3, -24 },
  { 6292, 27, 24, 28, 3, -24 },
  { 6373, 22, 24, 18, -2, -24 },
  { 6439, 24, 35, 18, -4, -24 },
  { 6544, 17, 24, 16, -1, -24 },
  { 6595, 17, 39, 15, 1, -32 },
  { 6678, 3, 45, 19, 8, -34 },
  { 6695, 16, 39, 15, -2, -32 },
  { 6773, 19, 6, 22, 2, -19 },
};

const GFXfont NotoSans_Condensed_MediumItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC45PT7B_H_
