#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC41PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0F,
  0x83, 0xF0, 0x7C, 0x07, 0x80, 0x3C, 0xFB, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7,
  0x8E, 0x38, 0x71, 0xC7, 0x8E, 0x3C, 0xE1, 0xC7, 0x0E, 0x00, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00,
  0x70, 0x70, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFE, 0x03, 0x87, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E,
  0x1C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9,
  0xFF, 0xFF, 0x80, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x87,
  0x00, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07,
  0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x1F,
  0x80, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3C, 0xC4, 0x0F, 0x30,
  0x01, 0xE6, 0x00, 0x3C, 0xC0, 0x07, 0x98, 0x00, 0xF3, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x6F, 0x80, 0x0C, 0xF0, 0x01, 0x9E, 0x00, 0x63, 0xC0, 0x0C, 0x78,
  0x41, 0x9E, 0x0F, 0x3F, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x02, 0x07, 0xE0, 0x0E, 0x03, 0xF8, 0x07, 0x03, 0x9C, 0x07, 0x03, 0xCF,
  0x07, 0x81, 0xC3, 0x83, 0x81, 0xE1, 0xC3, 0x80, 0xE1, 0xE1, 0xC0, 0x70,
  0xE1, 0xC0, 0x38, 0x71, 0xE0, 0x1C, 0x38, 0xE0, 0x1E, 0x1C, 0xE0, 0x0E,
  0x1C, 0x71, 0xE7, 0x0E, 0x73, 0xFB, 0x8F, 0x79, 0xFD, 0xE7, 0x39, 0xCF,
  0x7F, 0x39, 0xE3, 0xBF, 0x1C, 0xE1, 0xC7, 0x1C, 0x70, 0xE0, 0x1E, 0x70,
  0x70, 0x0E, 0x38, 0x78, 0x0F, 0x1C, 0x38, 0x07, 0x0E, 0x1C, 0x07, 0x07,
  0x0E, 0x03, 0x83, 0x8F, 0x03, 0x81, 0xC7, 0x03, 0xC0, 0xE7, 0x81, 0xC0,
  0x7F, 0x81, 0xC0, 0x3F, 0x81, 0xE0, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xCF, 0x00, 0x3C, 0x3C, 0x01, 0xE1, 0xE0,
  0x0F, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x87, 0x80, 0x1C, 0x38, 0x00, 0xF3,
  0xC0, 0x07, 0xBC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x78, 0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0xF0, 0xFB,
  0xC7, 0x83, 0xDE, 0x3C, 0x1F, 0xE3, 0xC0, 0x7F, 0x1E, 0x03, 0xF0, 0xF0,
  0x0F, 0x07, 0xC0, 0xFC, 0x1E, 0x1F, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0x3C,
  0x0F, 0xE1, 0xF0, 0x3C, 0xE7, 0x9E, 0x79, 0xC7, 0x1C, 0xF3, 0x80, 0x00,
  0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01,
  0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x02, 0x1E, 0x07, 0x38, 0x1F, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0x07, 0xFE,
  0x1F, 0x80, 0x7F, 0x01, 0xE7, 0x07, 0x8E, 0x06, 0x1E, 0x04, 0x3C, 0x00,
  0x20, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0F, 0x1F, 0x1E, 0x1E, 0x3C, 0x3C,
  0x38, 0x78, 0x70, 0xF0, 0xFF, 0xFF, 0xEF, 0xFB, 0xFE, 0x39, 0xF7, 0xFE,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x7C,
  0xF8, 0x7C, 0x3C, 0x3C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x9F, 0x03, 0xCF,
  0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x1E,
  0x78, 0x0F, 0x3C, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xCF, 0x01, 0xE7, 0x80,
  0xF3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x7C, 0x78, 0x3C, 0x1E, 0x3C, 0x0F,
  0xFE, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x1F, 0x07, 0xF0, 0xFF,
  0x1F, 0xE3, 0xFE, 0xF9, 0xE7, 0x1E, 0x23, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xF0,
  0x3C, 0x3E, 0x06, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07,
  0x07, 0xC0, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0xFF, 0x80, 0x3F, 0x00,
  0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x20, 0x0F,
  0x8E, 0x0F, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x07, 0x78, 0x01, 0xDE, 0x00, 0xE7, 0x00, 0x73, 0xC0, 0x3C, 0xF0, 0x0E,
  0x3C, 0x07, 0x0F, 0x03, 0xC3, 0x80, 0xE1, 0xE0, 0x70, 0x78, 0x3C, 0x1E,
  0x0E, 0x07, 0x87, 0x03, 0xC3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x80, 0x3E, 0x1C, 0x1F, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x80, 0x3D, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xF8,
  0x7C, 0x7C, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F,
  0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0x78, 0x3E, 0x1E, 0x0F, 0x07,
  0xC7, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xCF,
  0xFF, 0xF3, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03,
  0xC1, 0xE0, 0x78, 0x1E, 0x1E, 0x03, 0xC7, 0xC0, 0x3D, 0xF0, 0x07, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xE7, 0xC0, 0xF0, 0x78,
  0x3E, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78,
  0xF0, 0x0F, 0x0F, 0x03, 0xC1, 0xF0, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0,
  0xF0, 0xF0, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03,
  0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF9, 0xE0, 0x7C, 0xF0, 0x7C, 0x7C,
  0x7E, 0x3F, 0xFF, 0x0F, 0xF7, 0x83, 0xF7, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x20, 0xF8,
  0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0x87, 0xC3, 0xE1, 0xF0,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0x80, 0x01, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x01,
  0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01,
  0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0xF8, 0x00, 0x70, 0x00, 0x20, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0xF0,
  0x7F, 0xF0, 0xFF, 0xE1, 0x83, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x1E, 0x03, 0xC0, 0x03, 0x80, 0xE0, 0x00,
  0xF0, 0x70, 0x00, 0x1C, 0x38, 0x04, 0x07, 0x0E, 0x0F, 0xF1, 0xC7, 0x07,
  0xFC, 0x71, 0xC3, 0xC7, 0x1C, 0xE1, 0xE3, 0x87, 0x38, 0x70, 0xE1, 0xDC,
  0x38, 0x38, 0x77, 0x0E, 0x0E, 0x1D, 0xC7, 0x87, 0x07, 0x71, 0xC1, 0xC3,
  0x9C, 0x70, 0x70, 0xEE, 0x1C, 0x3C, 0x3B, 0x87, 0x0E, 0x1C, 0xE1, 0xC7,
  0x87, 0x38, 0x7B, 0xF3, 0x8E, 0x1F, 0xDF, 0xC3, 0x83, 0xE3, 0xE0, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x40, 0x07, 0xC0, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1D, 0xE0, 0x03, 0xDE, 0x00, 0x39, 0xE0,
  0x07, 0x9E, 0x00, 0x79, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x1E, 0x1E,
  0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x03, 0xC1, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0x80, 0xE0, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xE0,
  0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF7, 0x80, 0x0F, 0xF8,
  0x00, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3C, 0x3F,
  0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80,
  0xF0, 0x78, 0x1F, 0x0F, 0x01, 0xE0, 0xF0, 0x7C, 0x0F, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0xFF, 0x01, 0xE1, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x1E,
  0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0xC3,
  0xC0, 0x78, 0x78, 0x0F, 0x87, 0x87, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x81, 0xFF,
  0xF0, 0x7E, 0x0C, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x70, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07,
  0x8F, 0xE0, 0x3C, 0x1F, 0x03, 0xC0, 0x7C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F,
  0x07, 0x80, 0x78, 0x3C, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0,
  0x07, 0x87, 0x80, 0x3C, 0x7C, 0x03, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF0,
  0xF0, 0x07, 0x87, 0x80, 0x7C, 0x7C, 0x03, 0xC3, 0xC0, 0x3E, 0x1E, 0x01,
  0xE0, 0xF0, 0x1F, 0x07, 0x81, 0xF0, 0x78, 0x1F, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xE0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF,
  0xF0, 0x7E, 0x07, 0x07, 0xE0, 0x08, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x7F, 0x9F, 0x03, 0xFC, 0xF0, 0x1F, 0xE7, 0x81,
  0xFF, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3,
  0xC0, 0x1F, 0x1F, 0x00, 0xF0, 0xF8, 0x07, 0x83, 0xE0, 0x3C, 0x1F, 0x83,
  0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0xE0, 0x1F,
  0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1E, 0x00, 0xF0,
  0x1E, 0x00, 0xF0, 0x1E, 0x01, 0xF0, 0x3E, 0x01, 0xE0, 0x3C, 0x01, 0xE0,
  0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x03, 0xC0,
  0x78, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0xF8, 0x07, 0x80,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x3E,
  0x07, 0x80, 0xF0, 0x0F, 0x03, 0xE0, 0x1E, 0x0F, 0x80, 0x3C, 0x1E, 0x00,
  0xF0, 0x78, 0x01, 0xE1, 0xF0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x00, 0x0F,
  0x3C, 0x00, 0x3C, 0xF8, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x78, 0x00, 0x3C, 0x78,
  0x00, 0x78, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x83, 0xC0,
  0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x78, 0x1F, 0x00, 0xF0, 0x1E, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x03, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x81,
  0xFE, 0x01, 0xDE, 0x07, 0x78, 0x0F, 0x70, 0x1D, 0xE0, 0x3B, 0xC0, 0xF7,
  0x81, 0xEF, 0x03, 0xDE, 0x07, 0x3C, 0x0F, 0x78, 0x3C, 0xF0, 0x39, 0xE0,
  0xE7, 0x81, 0xE7, 0x87, 0x9E, 0x07, 0x8E, 0x1C, 0x78, 0x1E, 0x38, 0xF1,
  0xE0, 0x78, 0xE3, 0x87, 0x01, 0xC3, 0x9E, 0x3C, 0x0F, 0x0E, 0x78, 0xF0,
  0x3C, 0x39, 0xC3, 0xC0, 0xF0, 0xEF, 0x0F, 0x03, 0xC3, 0xB8, 0x78, 0x0E,
  0x0F, 0xE1, 0xE0, 0x78, 0x3F, 0x07, 0x81, 0xE0, 0xFC, 0x1E, 0x07, 0x83,
  0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x03, 0xE0,
  0x07, 0x81, 0xF8, 0x03, 0x80, 0xFC, 0x03, 0xC0, 0x7E, 0x01, 0xE0, 0x3F,
  0x00, 0xF0, 0x3F, 0x80, 0x78, 0x1F, 0xE0, 0x38, 0x0F, 0xF0, 0x3C, 0x07,
  0x78, 0x1E, 0x03, 0x9C, 0x0F, 0x03, 0xCF, 0x07, 0x81, 0xE7, 0x87, 0x80,
  0xF3, 0xC3, 0xC0, 0x70, 0xE1, 0xE0, 0x78, 0x78, 0xF0, 0x3C, 0x3C, 0x70,
  0x1E, 0x1E, 0x78, 0x0F, 0x07, 0x3C, 0x07, 0x03, 0x9E, 0x07, 0x81, 0xEF,
  0x03, 0xC0, 0xF7, 0x01, 0xE0, 0x7B, 0x80, 0xF0, 0x1F, 0xC0, 0x70, 0x0F,
  0xE0, 0x78, 0x07, 0xF0, 0x3C, 0x03, 0xF0, 0x1E, 0x00, 0xF8, 0x0F, 0x00,
  0x7C, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xC0, 0x7C, 0x1F, 0x07, 0xC0, 0x78, 0x7C, 0x03, 0xC3,
  0xC0, 0x1F, 0x3E, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0xF8, 0x01,
  0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x7F, 0xE0, 0x03, 0xDF, 0x00, 0x1E, 0xF0,
  0x00, 0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x7D, 0xE0, 0x03, 0xCF, 0x00, 0x1E,
  0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xC0,
  0xF8, 0x1F, 0x8F, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3C, 0x3E, 0x03, 0xC1,
  0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78,
  0x1F, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0xF0, 0x7C, 0x1F,
  0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0,
  0x7C, 0x1F, 0x07, 0xC0, 0x78, 0x7C, 0x03, 0xC3, 0xC0, 0x1F, 0x3E, 0x00,
  0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0xF8, 0x01, 0xF7, 0x80, 0x0F, 0xBC,
  0x00, 0x7F, 0xE0, 0x03, 0xDF, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x0F,
  0xBC, 0x00, 0x7D, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x01, 0xF3, 0xC0,
  0x0F, 0x1E, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x1F, 0x8F, 0xC0,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3C,
  0x7E, 0x03, 0xC1, 0xE0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0x78, 0x1F, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x3E, 0x0F, 0x07, 0xC0,
  0xF1, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xE3, 0xC0,
  0x1E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E,
  0x03, 0xC1, 0xE0, 0x78, 0x1F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80,
  0xF0, 0xF8, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0x7C, 0x18, 0x1F, 0x01, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3E, 0x10, 0x0F, 0x83, 0xC7, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xBF, 0xFF, 0xC0, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x78, 0x78, 0x03, 0xC3,
  0xC0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03,
  0xC3, 0xC0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78,
  0x03, 0xC3, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78,
  0x78, 0x03, 0xC3, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00,
  0x78, 0x78, 0x07, 0xC3, 0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0xF8, 0x1E, 0x07,
  0xE3, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0xF0,
  0x03, 0xFE, 0x00, 0xFB, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF1, 0xE0,
  0x1E, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x3E, 0x1E, 0x07, 0x83, 0xC0,
  0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x8F,
  0x00, 0xF1, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x78,
  0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x7F,
  0x80, 0x78, 0x07, 0xBC, 0x03, 0xC0, 0x3D, 0xE0, 0x3E, 0x01, 0xEF, 0x01,
  0xF0, 0x1E, 0x78, 0x1F, 0x80, 0xF3, 0xC0, 0xFC, 0x0F, 0x1E, 0x0F, 0xE0,
  0x78, 0xF0, 0x77, 0x03, 0xC7, 0x83, 0xB8, 0x3C, 0x3C, 0x3D, 0xC1, 0xE1,
  0xE1, 0xCE, 0x1E, 0x0E, 0x1E, 0x70, 0xF0, 0x70, 0xE3, 0x87, 0x83, 0x87,
  0x1C, 0x78, 0x1C, 0x78, 0xE3, 0xC0, 0xE3, 0x87, 0x3C, 0x07, 0x3C, 0x39,
  0xE0, 0x39, 0xC1, 0xCF, 0x01, 0xCE, 0x0E, 0xF0, 0x0E, 0xF0, 0x77, 0x80,
  0x77, 0x03, 0xB8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0xFC,
  0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x0F,
  0x80, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x78,
  0x07, 0x81, 0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x79, 0xE0, 0x00, 0xF7, 0xC0, 0x00, 0xEF, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x78,
  0x00, 0x1E, 0xF0, 0x00, 0x78, 0xE0, 0x01, 0xF1, 0xE0, 0x03, 0xC3, 0xC0,
  0x0F, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x78, 0x1F, 0x01, 0xF0, 0x1E, 0x03,
  0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x07,
  0x9E, 0x07, 0xCF, 0x03, 0xC3, 0x83, 0xE1, 0xE1, 0xE0, 0xF1, 0xE0, 0x78,
  0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x03, 0xBC, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xF0, 0xF0, 0x70,
  0x70, 0x70, 0x78, 0x78, 0x78, 0x78, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x3C,
  0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0F, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1D, 0xE0, 0x1E, 0x70, 0x0E, 0x38, 0x0F, 0x1E, 0x07, 0x0F, 0x07,
  0x83, 0x83, 0x81, 0xE3, 0xC0, 0xF3, 0xC0, 0x39, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0xF9, 0xE7, 0x8F, 0x1C, 0x70,
  0x00, 0x40, 0x00, 0xFC, 0x70, 0x7F, 0xBC, 0x3F, 0xFF, 0x0F, 0x8F, 0xC7,
  0x83, 0xE3, 0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x9E, 0x01, 0xE7, 0x80,
  0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0x78,
  0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x87, 0xE1, 0xE3, 0xF0, 0x7F, 0xDC, 0x1F,
  0xE7, 0x03, 0xF3, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x84,
  0x01, 0xEF, 0xC0, 0x77, 0xF8, 0x3F, 0xFF, 0x0F, 0xC3, 0xC3, 0xE0, 0xF0,
  0xF0, 0x3C, 0x7C, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x70,
  0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F,
  0x9F, 0x03, 0xC7, 0xC1, 0xF1, 0xF8, 0xF8, 0x77, 0xFC, 0x1D, 0xFE, 0x0E,
  0x3F, 0x00, 0x00, 0x20, 0x03, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xF8, 0x43,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE1, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x41, 0xC0, 0x3F, 0x3C, 0x07,
  0xFB, 0xC0, 0xFF, 0xFC, 0x0F, 0x0F, 0xC1, 0xE0, 0xF8, 0x3E, 0x07, 0x83,
  0xC0, 0x78, 0x3C, 0x07, 0x87, 0x80, 0x78, 0x78, 0x0F, 0x07, 0x80, 0xF0,
  0x78, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E,
  0x0F, 0x03, 0xE0, 0xF8, 0x7E, 0x07, 0x8F, 0xC0, 0x7F, 0xDC, 0x07, 0xF9,
  0xC0, 0x3F, 0x1C, 0x00, 0x00, 0x20, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFF,
  0x0F, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x1E, 0x78, 0x3E,
  0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x18, 0x7F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x3F, 0x9C, 0x0F, 0xF3, 0x83, 0xFF, 0xF0,
  0x78, 0x7E, 0x1E, 0x0F, 0x87, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0xF8, 0x0F, 0x1E,
  0x03, 0xC3, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x03, 0xE1, 0xF0, 0xFC, 0x3E,
  0x3F, 0x03, 0xFF, 0xE0, 0x7F, 0xBC, 0x07, 0xE7, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x08, 0x0F, 0x81, 0xFF,
  0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x84, 0x01, 0xEF, 0xC0, 0x77, 0xF8, 0x3F, 0xFF,
  0x0F, 0xC7, 0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1E, 0x03, 0xC7,
  0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0,
  0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xE1, 0xE0, 0x78,
  0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x01, 0xE0, 0x00, 0x80, 0x38, 0x0F, 0x81,
  0xE0, 0x3C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x3C, 0x00, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x7C,
  0x1C, 0x1F, 0x07, 0x83, 0xC0, 0xF0, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x00,
  0x73, 0xE0, 0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x9E, 0x01, 0xE3, 0xC0, 0x38, 0x78, 0x0F,
  0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x3C,
  0x07, 0x80, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x00, 0x00, 0x04, 0x01,
  0x00, 0x73, 0xF0, 0xFC, 0x07, 0x7F, 0x9F, 0xE0, 0xFF, 0xFB, 0xFE, 0x0F,
  0xC7, 0xF1, 0xE0, 0xF8, 0x3E, 0x0F, 0x0F, 0x03, 0xC0, 0xE0, 0xF0, 0x7C,
  0x1E, 0x1E, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0x1E, 0x1E, 0x07, 0x81, 0xE1,
  0xE0, 0x78, 0x1E, 0x3C, 0x07, 0x03, 0xC3, 0xC0, 0xF0, 0x3C, 0x3C, 0x0F,
  0x03, 0xC3, 0xC0, 0xF0, 0x3C, 0x3C, 0x0F, 0x03, 0x87, 0x81, 0xE0, 0x78,
  0x78, 0x1E, 0x07, 0x87, 0x81, 0xE0, 0x78, 0x78, 0x1E, 0x07, 0x87, 0x01,
  0xC0, 0x70, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x04, 0x01, 0xCF, 0xE0, 0x77,
  0xF8, 0x3F, 0xFF, 0x0F, 0xC7, 0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F,
  0x1F, 0x03, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x3C, 0x07, 0x8F,
  0x01, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1E, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x01, 0xE0, 0x00, 0x20,
  0x00, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xF0, 0xF0, 0xF0, 0x78, 0xF8,
  0x1E, 0x78, 0x0F, 0x7C, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xE7,
  0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x3E, 0xF0, 0x1E, 0x78, 0x1F,
  0x1E, 0x0F, 0x0F, 0x0F, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x00, 0x00,
  0x01, 0x00, 0x1C, 0xFC, 0x01, 0xDF, 0xE0, 0x3F, 0xFF, 0x03, 0xF0, 0xF0,
  0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F,
  0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x01,
  0xE0, 0xF0, 0x1E, 0x0F, 0x03, 0xE1, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xF8,
  0xF8, 0x1F, 0xFF, 0x01, 0xDF, 0xE0, 0x3C, 0xFC, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x40,
  0x00, 0xFE, 0x70, 0x7F, 0x9C, 0x3F, 0xFF, 0x0F, 0x0F, 0xC7, 0x83, 0xE3,
  0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF1, 0xE0,
  0x3C, 0x78, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E,
  0x3C, 0x0F, 0x8F, 0x87, 0xE3, 0xE3, 0xF0, 0x7F, 0xFC, 0x1F, 0xEF, 0x03,
  0xF3, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x00, 0x04, 0x0E, 0x7C, 0x1D, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xF8,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x40, 0x0F,
  0xF8, 0x3F, 0xF8, 0xFF, 0xE1, 0xE0, 0xC3, 0xC0, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xE2, 0x03, 0xC6, 0x0F, 0x8F, 0xFE,
  0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0F,
  0x01, 0xFF, 0x7F, 0xF7, 0xFE, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x0F, 0x80, 0x7F, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0x03,
  0xC7, 0x80, 0xF1, 0xE0, 0x38, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE3,
  0xC0, 0x78, 0xF0, 0x1C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0x80, 0xF1, 0xE0,
  0x3C, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xC0, 0xF8, 0xF0, 0x3E,
  0x3C, 0x1F, 0x0F, 0x8F, 0xC1, 0xFF, 0xF0, 0x7F, 0xBC, 0x0F, 0xCE, 0x00,
  0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0x70, 0x3C, 0x70, 0x3C,
  0x70, 0x78, 0x70, 0x78, 0x70, 0xF0, 0x70, 0xF0, 0x71, 0xE0, 0x71, 0xE0,
  0x73, 0xC0, 0x73, 0xC0, 0x73, 0x80, 0x77, 0x80, 0x77, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x70, 0x3E, 0x07, 0xB8,
  0x1F, 0x03, 0xDC, 0x0F, 0x83, 0xCE, 0x0F, 0xC1, 0xE7, 0x07, 0xE1, 0xE3,
  0x87, 0x70, 0xF1, 0xC3, 0xB8, 0x70, 0xE1, 0xDC, 0x78, 0x71, 0xCE, 0x3C,
  0x38, 0xE7, 0x3C, 0x1C, 0xF3, 0x9E, 0x0E, 0x71, 0xCE, 0x07, 0x78, 0xEF,
  0x03, 0xB8, 0x77, 0x83, 0xDC, 0x3B, 0x81, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F,
  0xC0, 0x7F, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1,
  0xF8, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0x81, 0xF0, 0x3C, 0x1E, 0x03, 0xC3,
  0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0x80, 0x1C, 0xF0, 0x01, 0xEF, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xBC, 0x00, 0x7B, 0xC0, 0x0F, 0x3C, 0x01,
  0xE3, 0xC0, 0x1E, 0x1E, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x81, 0xF0,
  0x03, 0xC0, 0x3C, 0x07, 0x00, 0xF0, 0x1C, 0x07, 0x80, 0x70, 0x1E, 0x01,
  0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3,
  0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x00,
  0x07, 0xBC, 0x00, 0x1E, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0,
  0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0xFE, 0x01, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xE0,
  0x03, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3C, 0x03, 0xF8, 0x0F, 0xC0,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xF8, 0x07, 0xE0,
};

const GFXglyph NotoSans_Condensed_MediumItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 11, 29, 10, 0, -29 },
  { 41, 13, 10, 15, 4, -29 },
  { 58, 21, 29, 21, 0, -29 },
  { 135, 19, 33, 18, 0, -31 },
  { 214, 25, 30, 28, 2, -30 },
  { 308, 21, 30, 21, 0, -30 },
  { 387, 6, 10, 9, 4, -29 },
  { 395, 13, 35, 11, 1, -29 },
  { 452, 13, 36, 11, -3, -30 },
  { 511, 15, 16, 18, 4, -31 },
  { 541, 17, 19, 20, 2, -24 },
  { 582, 8, 10, 9, -2, -5 },
  { 592, 10, 4, 12, 1, -13 },
  { 597, 6, 5, 9, 0, -5 },
  { 601, 20, 29, 15, -2, -29 },
  { 674, 17, 30, 18, 1, -30 },
  { 738, 12, 29, 18, 4, -29 },
  { 782, 19, 30, 18, -1, -30 },
  { 854, 18, 30, 18, 0, -30 },
  { 922, 18, 29, 18, 0, -29 },
  { 988, 19, 29, 18, 0, -29 },
  { 1057, 18, 30, 18, 1, -30 },
  { 1125, 18, 29, 18, 2, -29 },
  { 1191, 19, 30, 18, 0, -30 },
  { 1263, 17, 30, 18, 1, -30 },
  { 1327, 9, 22, 9, 0, -22 },
  { 1352, 11, 27, 9, -2, -22 },
  { 1390, 17, 19, 20, 2, -24 },
  { 1431, 17, 11, 20, 2, -20 },
  { 1455, 17, 19, 20, 2, -24 },
  { 1496, 15, 30, 14, 1, -30 },
  { 1553, 26, 32, 28, 1, -29 },
  { 1657, 20, 29, 19, -3, -29 },
  { 1730, 20, 29, 20, 0, -29 },
  { 1803, 19, 30, 19, 2, -30 },
  { 1875, 21, 29, 22, 0, -29 },
  { 1952, 19, 29, 17, 0, -29 },
  { 2021, 19, 29, 16, 0, -29 },
  { 2090, 21, 30, 23, 2, -30 },
  { 2169, 24, 29, 23, 0, -29 },
  { 2256, 17, 29, 12, -2, -29 },
  { 2318, 17, 37, 10, -6, -29 },
  { 2397, 23, 29, 19, 0, -29 },
  { 2481, 13, 29, 16, 0, -29 },
  { 2529, 30, 29, 29, 0, -29 },
  { 2638, 25, 29, 24, 0, -29 },
  { 2729, 21, 30, 24, 2, -30 },
  { 2808, 20, 29, 19, 0, -29 },
  { 2881, 21, 37, 24, 2, -30 },
  { 2979, 20, 29, 20, 0, -29 },
  { 3052, 19, 30, 17, 0, -30 },
  { 3124, 17, 29, 17, 3, -29 },
  { 3186, 21, 29, 22, 2, -29 },
  { 3263, 19, 29, 19, 4, -29 },
  { 3332, 29, 29, 30, 4, -29 },
  { 3438, 23, 29, 18, -2, -29 },
  { 3522, 17, 29, 17, 4, -29 },
  { 3584, 20, 29, 17, -1, -29 },
  { 3657, 16, 36, 12, -1, -29 },
  { 3729, 8, 29, 15, 4, -29 },
  { 3758, 16, 36, 12, -3, -29 },
  { 3830, 17, 17, 19, 1, -29 },
  { 3867, 15, 2, 14, -4, 4 },
  { 3871, 6, 6, 11, 6, -31 },
  { 3876, 18, 23, 20, 1, -23 },
  { 3928, 18, 31, 20, 0, -31 },
  { 3998, 15, 23, 15, 1, -23 },
  { 4042, 20, 31, 20, 1, -31 },
  { 4120, 16, 23, 18, 1, -23 },
  { 4166, 21, 41, 11, -5, -31 },
  { 4274, 19, 33, 20, 0, -23 },
  { 4353, 18, 31, 19, 0, -31 },
  { 4423, 11, 31, 9, 0, -31 },
  { 4466, 16, 41, 9, -5, -31 },
  { 4548, 19, 31, 17, 0, -31 },
  { 4622, 11, 31, 9, 0, -31 },
  { 4665, 28, 23, 29, 0, -23 },
  { 4746, 18, 23, 19, 0, -23 },
  { 4798, 17, 23, 19, 1, -23 },
  { 4847, 20, 33, 20, -2, -23 },
  { 4930, 18, 33, 20, 1, -23 },
  { 5005, 15, 23, 13, 0, -23 },
  { 5049, 15, 23, 15, 0, -23 },
  { 5093, 12, 27, 12, 1, -27 },
  { 5134, 18, 22, 19, 1, -22 },
  { 5184, 16, 22, 16, 2, -22 },
  { 5228, 25, 22, 25, 2, -22 },
  { 5297, 20, 22, 17, -2, -22 },
  { 5352, 22, 32, 16, -4, -22 },
  { 5440, 16, 22, 14, -1, -22 },
  { 5484, 15, 35, 14, 1, -29 },
  { 5550, 3, 41, 17, 7, -31 },
  { 5566, 15, 35, 14, -2, -29 },
  { 5632, 17, 5, 20, 2, -17 },
};

const GFXfont NotoSans_Condensed_MediumItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC41PT7B_H_
