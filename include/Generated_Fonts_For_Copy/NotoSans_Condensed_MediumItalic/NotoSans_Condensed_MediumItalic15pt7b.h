#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC15PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x22, 0x26, 0x44, 0x0C, 0xC0, 0x6A, 0xD7, 0xA0, 0x0A, 0x12,
  0x12, 0x7F, 0x34, 0x24, 0x2C, 0xFE, 0x48, 0x58, 0xD0, 0x08, 0x7C, 0xAB,
  0x43, 0x07, 0x07, 0x0E, 0xAD, 0xF0, 0x81, 0x00, 0x71, 0x29, 0x24, 0x92,
  0x8B, 0xD5, 0x5F, 0x52, 0x29, 0x25, 0x32, 0x91, 0x80, 0x1C, 0x34, 0x24,
  0x24, 0x38, 0x31, 0x7A, 0xCE, 0xCC, 0xCC, 0x76, 0xEA, 0x08, 0x8C, 0x46,
  0x21, 0x18, 0xC6, 0x30, 0x84, 0x00, 0x10, 0x86, 0x31, 0x8C, 0x42, 0x11,
  0x88, 0xCC, 0x00, 0x13, 0x43, 0xDC, 0x58, 0x20, 0x82, 0x3F, 0x20, 0x82,
  0x00, 0x2D, 0x60, 0xFF, 0xF0, 0x03, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10,
  0x30, 0x20, 0x40, 0xC0, 0x1C, 0x68, 0x9B, 0x34, 0x68, 0x91, 0x66, 0xCC,
  0xB1, 0xC0, 0x37, 0xEA, 0x26, 0x64, 0x44, 0xC0, 0x1C, 0x78, 0x18, 0x20,
  0x41, 0x06, 0x18, 0x61, 0x83, 0xE0, 0x1C, 0x4C, 0x18, 0x20, 0xC6, 0x03,
  0x06, 0x0D, 0x33, 0xC0, 0x06, 0x18, 0x30, 0xA2, 0xCD, 0x92, 0x7E, 0xFC,
  0x30, 0x60, 0x3E, 0x7C, 0x81, 0x07, 0x0F, 0x83, 0x06, 0x0D, 0x33, 0xC0,
  0x1C, 0xD6, 0x10, 0xF3, 0x68, 0xA2, 0x9A, 0x4F, 0x00, 0x7F, 0xF0, 0xC2,
  0x10, 0xC2, 0x18, 0x43, 0x08, 0x00, 0x1C, 0x6C, 0x99, 0x33, 0xC7, 0x1B,
  0x66, 0xCD, 0x99, 0xE0, 0x1C, 0x69, 0x9A, 0x34, 0x4D, 0x9D, 0x06, 0x08,
  0x33, 0xC0, 0x2C, 0x00, 0x36, 0x13, 0x00, 0x00, 0x26, 0x4C, 0x04, 0x77,
  0x30, 0x60, 0x60, 0x40, 0xFC, 0x00, 0x3F, 0x83, 0x03, 0x03, 0x3B, 0x88,
  0x00, 0x76, 0xC6, 0x23, 0x31, 0x18, 0x04, 0x20, 0x07, 0x06, 0x23, 0x04,
  0x9D, 0x4A, 0x54, 0x95, 0x25, 0x5A, 0xDF, 0x90, 0x04, 0x00, 0xF8, 0x06,
  0x1C, 0x28, 0xD1, 0x22, 0x4C, 0x9F, 0x62, 0x87, 0x08, 0x3C, 0x7C, 0x89,
  0x12, 0x6F, 0x19, 0x23, 0x45, 0x9B, 0xE0, 0x1E, 0x69, 0x86, 0x0C, 0x10,
  0x20, 0x40, 0x81, 0x91, 0xE0, 0x3C, 0x3E, 0x23, 0x23, 0x23, 0x63, 0x62,
  0x46, 0x46, 0xCC, 0xF8, 0x3E, 0x7C, 0x81, 0x02, 0x0F, 0x98, 0x20, 0x41,
  0x83, 0xE0, 0x3E, 0x7C, 0x81, 0x02, 0x0F, 0x9E, 0x20, 0x41, 0x83, 0x00,
  0x1F, 0x36, 0x60, 0xC0, 0xC0, 0x8E, 0x8E, 0x84, 0x84, 0xCC, 0x7C, 0x31,
  0x98, 0x88, 0x44, 0x62, 0x33, 0xF1, 0x88, 0x84, 0x46, 0x63, 0x31, 0x00,
  0x1C, 0xA1, 0x86, 0x10, 0x41, 0x0C, 0x30, 0x8F, 0x00, 0x0C, 0x30, 0x82,
  0x08, 0x61, 0x84, 0x10, 0xC3, 0x0C, 0xE3, 0x00, 0x31, 0x32, 0x26, 0x2C,
  0x38, 0x78, 0x78, 0x48, 0x48, 0xCC, 0xCC, 0x31, 0x88, 0x42, 0x31, 0x88,
  0x46, 0x3E, 0x30, 0x66, 0x1C, 0xE3, 0x9C, 0xE3, 0x94, 0xF6, 0x92, 0xB2,
  0x56, 0x4C, 0x99, 0x93, 0x26, 0x00, 0x30, 0x98, 0xCE, 0x67, 0x22, 0x93,
  0x49, 0x2C, 0x9E, 0x46, 0x63, 0x31, 0x80, 0x1C, 0x6D, 0x8E, 0x1C, 0x30,
  0x61, 0xC3, 0x85, 0x99, 0xE0, 0x3C, 0x7C, 0x89, 0x12, 0x6D, 0x9E, 0x20,
  0x41, 0x83, 0x00, 0x1C, 0x6D, 0x8E, 0x1C, 0x30, 0x61, 0xC3, 0x85, 0x99,
  0xE0, 0x81, 0x81, 0x00, 0x3C, 0x7C, 0x89, 0x12, 0x6F, 0x9E, 0x24, 0x49,
  0x9B, 0x30, 0x1C, 0x7D, 0x83, 0x02, 0x07, 0x06, 0x06, 0x09, 0x33, 0xC0,
  0xFF, 0xF3, 0x08, 0x20, 0x86, 0x18, 0x41, 0x0C, 0x00, 0x63, 0x62, 0x42,
  0x46, 0xC6, 0xC4, 0xC4, 0x8C, 0x8C, 0xD8, 0xF0, 0xC3, 0x8F, 0x16, 0x6C,
  0x8B, 0x14, 0x28, 0x70, 0xC1, 0x80, 0xC4, 0x38, 0x8F, 0x31, 0x66, 0x6D,
  0xC9, 0xA9, 0x35, 0x67, 0x28, 0xE7, 0x1C, 0xC3, 0x18, 0x00, 0x11, 0x89,
  0x86, 0x83, 0xC0, 0xC0, 0x40, 0x70, 0x78, 0x24, 0x32, 0x31, 0x80, 0xC6,
  0x99, 0x22, 0xC5, 0x0E, 0x18, 0x30, 0x40, 0x83, 0x00, 0x1F, 0x1F, 0x06,
  0x04, 0x0C, 0x08, 0x10, 0x30, 0x20, 0x60, 0xFC, 0x39, 0x08, 0x42, 0x31,
  0x08, 0x46, 0x31, 0x0E, 0x00, 0xAA, 0xBD, 0x54, 0x1C, 0x20, 0x82, 0x08,
  0x61, 0x04, 0x10, 0xC3, 0x08, 0xE0, 0x08, 0x30, 0x61, 0x66, 0x58, 0xC0,
  0xF8, 0xCC, 0x3A, 0x4D, 0x9A, 0x24, 0x59, 0x93, 0x3C, 0x30, 0x60, 0x81,
  0xE6, 0x6C, 0xD1, 0xA2, 0x45, 0x9A, 0xE0, 0x3D, 0x86, 0x10, 0x43, 0x04,
  0x9E, 0x03, 0x02, 0x02, 0x3A, 0x26, 0x66, 0x44, 0x44, 0xCC, 0x4C, 0x78,
  0x3D, 0x94, 0x5E, 0x43, 0x04, 0x9E, 0x07, 0x0C, 0x0C, 0x1E, 0x08, 0x18,
  0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0xE0, 0xC0, 0x3A, 0xCD, 0x9A,
  0x24, 0x59, 0xB3, 0x3C, 0x08, 0x33, 0xC3, 0x00, 0x30, 0x60, 0x81, 0xE6,
  0x6C, 0x91, 0x22, 0x4D, 0x9B, 0x20, 0x32, 0x02, 0x66, 0x44, 0x4C, 0xC0,
  0x0C, 0x20, 0x02, 0x18, 0x61, 0x04, 0x10, 0xC3, 0x08, 0x23, 0x8C, 0x00,
  0x30, 0x60, 0x81, 0x36, 0xCF, 0x1C, 0x38, 0x59, 0x93, 0x20, 0x33, 0x22,
  0x66, 0x44, 0x4C, 0xC0, 0x3D, 0xD9, 0x96, 0x45, 0x13, 0x44, 0xD3, 0x2C,
  0x8B, 0x26, 0x3C, 0xCD, 0x92, 0x24, 0x49, 0xB3, 0x64, 0x3C, 0xC9, 0x1A,
  0x24, 0x59, 0x92, 0x3C, 0x1E, 0x33, 0x33, 0x23, 0x22, 0x22, 0x66, 0x7C,
  0x40, 0x40, 0x40, 0xC0, 0x3A, 0x4D, 0x9A, 0x24, 0x59, 0x93, 0x3C, 0x08,
  0x10, 0x60, 0xC0, 0x3D, 0xC6, 0x10, 0x41, 0x0C, 0x30, 0x7D, 0x04, 0x18,
  0x30, 0x69, 0x3C, 0x24, 0xF4, 0xCC, 0x88, 0x8C, 0x26, 0xCD, 0x92, 0x24,
  0x49, 0xB3, 0x3C, 0x8E, 0x69, 0x24, 0xA2, 0x8E, 0x30, 0x99, 0xCC, 0xA6,
  0xD5, 0x4A, 0xA7, 0x73, 0x31, 0x98, 0x33, 0x16, 0x1C, 0x18, 0x18, 0x38,
  0x6C, 0xCC, 0x23, 0x22, 0x24, 0x24, 0x2C, 0x28, 0x38, 0x30, 0x30, 0x20,
  0xE0, 0x80, 0x78, 0xC4, 0x66, 0x23, 0x1E, 0x0C, 0x61, 0x04, 0x30, 0xCE,
  0x18, 0x21, 0x86, 0x10, 0x60, 0xFF, 0xFE, 0x10, 0x60, 0x86, 0x18, 0x60,
  0xC6, 0x30, 0xC2, 0x08, 0xE0, 0xF6, 0x60,
};

const GFXglyph NotoSans_Condensed_MediumItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 5, 4, 6, 1, -11 },
  { 10, 8, 11, 8, 0, -11 },
  { 21, 7, 12, 7, 0, -11 },
  { 32, 9, 11, 10, 1, -11 },
  { 45, 8, 11, 8, 0, -11 },
  { 56, 2, 4, 3, 2, -11 },
  { 57, 5, 13, 4, 0, -11 },
  { 66, 5, 13, 4, -1, -11 },
  { 75, 6, 5, 6, 1, -11 },
  { 79, 6, 7, 7, 1, -9 },
  { 85, 3, 4, 3, -1, -2 },
  { 87, 4, 2, 4, 0, -5 },
  { 88, 2, 2, 3, 0, -2 },
  { 89, 8, 11, 5, -1, -11 },
  { 100, 7, 11, 7, 0, -11 },
  { 110, 4, 11, 7, 2, -11 },
  { 116, 7, 11, 7, 0, -11 },
  { 126, 7, 11, 7, 0, -11 },
  { 136, 7, 11, 7, 0, -11 },
  { 146, 7, 11, 7, 0, -11 },
  { 156, 6, 11, 7, 1, -11 },
  { 165, 6, 11, 7, 1, -11 },
  { 174, 7, 11, 7, 0, -11 },
  { 184, 7, 11, 7, 0, -11 },
  { 194, 3, 8, 3, 0, -8 },
  { 197, 4, 10, 3, -1, -8 },
  { 202, 6, 7, 7, 1, -9 },
  { 208, 6, 4, 7, 1, -7 },
  { 211, 6, 7, 7, 1, -9 },
  { 217, 5, 11, 5, 1, -11 },
  { 224, 10, 12, 10, 0, -11 },
  { 239, 7, 11, 7, -1, -11 },
  { 249, 7, 11, 7, 0, -11 },
  { 259, 7, 11, 7, 1, -11 },
  { 269, 8, 11, 8, 0, -11 },
  { 280, 7, 11, 6, 0, -11 },
  { 290, 7, 11, 6, 0, -11 },
  { 300, 8, 11, 8, 1, -11 },
  { 311, 9, 11, 8, 0, -11 },
  { 324, 6, 11, 4, -1, -11 },
  { 333, 6, 14, 4, -2, -11 },
  { 344, 8, 11, 7, 0, -11 },
  { 355, 5, 11, 6, 0, -11 },
  { 362, 11, 11, 11, 0, -11 },
  { 378, 9, 11, 9, 0, -11 },
  { 391, 7, 11, 9, 1, -11 },
  { 401, 7, 11, 7, 0, -11 },
  { 411, 7, 14, 9, 1, -11 },
  { 424, 7, 11, 7, 0, -11 },
  { 434, 7, 11, 6, 0, -11 },
  { 444, 6, 11, 6, 1, -11 },
  { 453, 8, 11, 8, 1, -11 },
  { 464, 7, 11, 7, 1, -11 },
  { 474, 11, 11, 11, 1, -11 },
  { 490, 9, 11, 7, -1, -11 },
  { 503, 7, 11, 6, 1, -11 },
  { 513, 8, 11, 6, -1, -11 },
  { 524, 5, 13, 4, 0, -11 },
  { 533, 2, 11, 5, 2, -11 },
  { 536, 6, 13, 4, -1, -11 },
  { 546, 7, 6, 7, 0, -11 },
  { 552, 5, 1, 5, -1, 1 },
  { 553, 3, 2, 4, 2, -11 },
  { 554, 7, 8, 7, 0, -8 },
  { 561, 7, 11, 7, 0, -11 },
  { 571, 6, 8, 6, 0, -8 },
  { 577, 8, 11, 7, 0, -11 },
  { 588, 6, 8, 6, 0, -8 },
  { 594, 8, 15, 4, -2, -11 },
  { 609, 7, 12, 7, 0, -8 },
  { 620, 7, 11, 7, 0, -11 },
  { 630, 4, 11, 3, 0, -11 },
  { 636, 6, 15, 3, -2, -11 },
  { 648, 7, 11, 6, 0, -11 },
  { 658, 4, 11, 3, 0, -11 },
  { 664, 10, 8, 11, 0, -8 },
  { 674, 7, 8, 7, 0, -8 },
  { 681, 7, 8, 7, 0, -8 },
  { 688, 8, 12, 7, -1, -8 },
  { 700, 7, 12, 7, 0, -8 },
  { 711, 6, 8, 5, 0, -8 },
  { 717, 6, 8, 5, 0, -8 },
  { 723, 4, 10, 4, 1, -10 },
  { 728, 7, 8, 7, 0, -8 },
  { 735, 6, 8, 6, 1, -8 },
  { 741, 9, 8, 9, 1, -8 },
  { 750, 8, 8, 6, -1, -8 },
  { 758, 8, 12, 6, -1, -8 },
  { 770, 5, 8, 5, 0, -8 },
  { 775, 6, 13, 5, 0, -11 },
  { 785, 1, 15, 6, 3, -11 },
  { 787, 6, 13, 5, -1, -11 },
  { 797, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_Condensed_MediumItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC15PT7B_H_
