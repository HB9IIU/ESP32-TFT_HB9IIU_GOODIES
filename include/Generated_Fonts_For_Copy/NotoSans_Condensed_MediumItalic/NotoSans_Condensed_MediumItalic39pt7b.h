#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC39PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01,
  0xC0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x78, 0x3E, 0x0F, 0x81, 0xC0,
  0x78, 0xF7, 0x8F, 0x78, 0xE7, 0x1E, 0x71, 0xE7, 0x1C, 0xF1, 0xCE, 0x1C,
  0xE1, 0xCE, 0x38, 0x00, 0x38, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07,
  0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x38, 0x1F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x38, 0x70, 0x03, 0x86, 0x00,
  0x38, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x1C, 0x07, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x0C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x30,
  0x01, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0xE0, 0x07, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x01, 0xFF,
  0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x3C, 0xC4, 0x0F, 0x30, 0x03, 0x8C, 0x00,
  0xE2, 0x00, 0x39, 0x80, 0x0F, 0x60, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x02, 0x78, 0x01, 0x9E,
  0x00, 0x63, 0x80, 0x19, 0xE1, 0x06, 0x78, 0x71, 0x3C, 0x1F, 0xFF, 0x0F,
  0xFF, 0x00, 0xFF, 0x80, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x07, 0x80, 0x3C, 0x0F, 0xC0, 0x38, 0x1F, 0xE0, 0x70, 0x38, 0xE0,
  0x70, 0x38, 0xE0, 0xE0, 0x70, 0xE1, 0xC0, 0x70, 0xE1, 0xC0, 0x70, 0xE3,
  0x80, 0x70, 0xE3, 0x80, 0xE1, 0xC7, 0x00, 0xE1, 0xCE, 0x00, 0xE1, 0xCE,
  0x3C, 0xE3, 0x9C, 0xFE, 0xE3, 0x9D, 0xFE, 0xFF, 0x39, 0xCE, 0x7F, 0x7B,
  0x87, 0x3C, 0x73, 0x87, 0x00, 0xE3, 0x8E, 0x00, 0xE7, 0x0E, 0x01, 0xC7,
  0x0E, 0x03, 0xC7, 0x0E, 0x03, 0x87, 0x0E, 0x07, 0x07, 0x1C, 0x07, 0x07,
  0x1C, 0x0E, 0x07, 0x3C, 0x0E, 0x07, 0x78, 0x1C, 0x07, 0xF0, 0x38, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3C, 0x78, 0x03,
  0x87, 0x80, 0x38, 0x78, 0x07, 0x87, 0x00, 0x78, 0x70, 0x07, 0x8F, 0x00,
  0x39, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0xF1, 0xFF, 0x0E, 0x3C, 0xF1, 0xE3, 0xC7, 0x9E, 0x78, 0x7B,
  0xC7, 0x03, 0xFC, 0xF0, 0x3F, 0x8F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x03,
  0xF0, 0xF8, 0x7F, 0x07, 0xFF, 0xF8, 0x7F, 0xE7, 0x81, 0xFC, 0x7C, 0x7B,
  0xDE, 0xF7, 0x39, 0xDE, 0xE7, 0x00, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x3C,
  0x03, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x01, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x38, 0x20, 0xE0,
  0xE3, 0x83, 0xEC, 0x1F, 0xFF, 0xCF, 0xFF, 0x0F, 0xFC, 0x7E, 0x03, 0xDC,
  0x1E, 0x70, 0xF9, 0xE0, 0xC3, 0x82, 0x0C, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x0F, 0x1F, 0x1E, 0x1E,
  0x3C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3B, 0xFF,
  0xF7, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFC, 0x01,
  0xFE, 0x03, 0xFE, 0x07, 0x8F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x07, 0x1E,
  0x07, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0xF0, 0x79, 0xF0, 0x7F,
  0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0xF0, 0x3E, 0x07, 0xE0, 0xFE, 0x1F,
  0xE7, 0xDC, 0xFB, 0xC7, 0x3C, 0x23, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x00,
  0x7E, 0x00, 0x7F, 0xE0, 0x7F, 0xFC, 0x0F, 0x1F, 0x03, 0x03, 0xC0, 0x80,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3,
  0xFF, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0xE1, 0xF0, 0x40,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x07, 0xC0, 0x3F, 0xC0, 0x3F, 0x00, 0x1F, 0xE0, 0x01, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF1, 0x00, 0x78, 0xC0, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xB8, 0x01, 0xDC, 0x01, 0xDE, 0x01, 0xEF, 0x00, 0xE7, 0x00,
  0xE3, 0x80, 0xF3, 0xC0, 0x71, 0xE0, 0x70, 0xF0, 0x70, 0x70, 0x38, 0x78,
  0x38, 0x3C, 0x38, 0x1E, 0x3C, 0x0F, 0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF,
  0xF8, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x83, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xE2, 0x01, 0xF0, 0xC0, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0,
  0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x18, 0x07, 0x3F, 0x07, 0xBF, 0xC3, 0xFF, 0xF1, 0xF0,
  0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF,
  0x01, 0xE7, 0x81, 0xE3, 0xC0, 0xF0, 0xE0, 0xF0, 0x78, 0xF8, 0x3F, 0xF8,
  0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7,
  0xFF, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8,
  0x1E, 0x1E, 0x07, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0x78, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0xFC,
  0x00, 0x7F, 0x80, 0x7D, 0xF0, 0x3E, 0x3C, 0x0F, 0x07, 0x87, 0x81, 0xE1,
  0xC0, 0x38, 0xF0, 0x0E, 0x3C, 0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0x78,
  0x3C, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0xC0, 0xF1, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x78, 0x1E, 0x3C,
  0x0F, 0x1C, 0x07, 0x8E, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xF3, 0xC0, 0xF8,
  0xF0, 0xF8, 0x7D, 0xFC, 0x3F, 0xFE, 0x0F, 0xEF, 0x03, 0xC7, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x81,
  0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0x07, 0xC3, 0xC1,
  0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x3C, 0x3E, 0x1F, 0x0F, 0x00, 0x01, 0xC0, 0x7C, 0x0F,
  0x81, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x78, 0x0E, 0x03,
  0xC0, 0x78, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x00, 0x00, 0x01, 0x00, 0x07,
  0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00,
  0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xF0, 0xFF, 0xE1, 0xFF, 0x86,
  0x1F, 0x10, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x3C,
  0x00, 0x38, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x1C, 0x1F, 0xE3, 0x8E,
  0x1F, 0xF1, 0xCE, 0x1E, 0x38, 0xE7, 0x0E, 0x38, 0x73, 0x0E, 0x1C, 0x3B,
  0x87, 0x0E, 0x1D, 0xC7, 0x07, 0x0C, 0xE3, 0x87, 0x0E, 0x61, 0xC3, 0x87,
  0x70, 0xC1, 0xC3, 0xB8, 0xE1, 0xE3, 0x9C, 0x70, 0xF1, 0xCE, 0x1C, 0xF9,
  0xC7, 0x0F, 0xFF, 0xC3, 0x87, 0xE7, 0xC1, 0xC0, 0xC0, 0x80, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x10, 0x01, 0xF0,
  0x70, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0E, 0xE0, 0x07, 0xB8,
  0x01, 0xCE, 0x00, 0xF3, 0x80, 0x3C, 0xE0, 0x0E, 0x38, 0x07, 0x8E, 0x01,
  0xC3, 0x80, 0xF0, 0xE0, 0x3C, 0x38, 0x1E, 0x0E, 0x07, 0xFF, 0xC3, 0xFF,
  0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x03,
  0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xC3, 0xF0, 0x78, 0x1E, 0x0F,
  0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x01, 0xE1, 0xE0, 0x3C, 0x3C,
  0x0F, 0x07, 0x87, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xF0,
  0x78, 0x1E, 0x07, 0x83, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0,
  0x78, 0x78, 0x0F, 0x0E, 0x03, 0xE3, 0xC0, 0xF8, 0x78, 0x3E, 0x0F, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F,
  0xFC, 0x1F, 0x86, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x18, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0x83, 0xE0, 0x78, 0x1F,
  0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0,
  0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C, 0x3C,
  0x07, 0xC3, 0xC0, 0x78, 0x38, 0x0F, 0x07, 0x83, 0xF0, 0x79, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7E, 0x1E, 0x0F,
  0x80, 0x21, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x03, 0xFC,
  0xF0, 0x3F, 0xCF, 0x03, 0xFC, 0xF0, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x07,
  0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x70, 0xF0, 0x0F, 0x0F, 0x80,
  0xF0, 0x7C, 0x0F, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x03,
  0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xE0, 0x0F, 0x07, 0x80,
  0x38, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x00, 0x78,
  0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x07,
  0x83, 0xC0, 0x1C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03,
  0x80, 0x3C, 0x1E, 0x00, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80,
  0x78, 0x3C, 0x01, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3F, 0x80, 0x7F, 0xE0, 0xFF, 0xC0,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x7C, 0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0xE0, 0x78, 0x07,
  0x83, 0xC0, 0x1E, 0x1F, 0x00, 0x78, 0xF8, 0x01, 0xE3, 0xC0, 0x07, 0x1E,
  0x00, 0x3C, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xDE, 0x00, 0x0E, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0x71,
  0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0,
  0x03, 0x83, 0xC0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x07,
  0x81, 0xF0, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFF, 0xDF,
  0xFD, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0xFC,
  0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03,
  0xF8, 0x1D, 0xC0, 0x3F, 0x80, 0xEE, 0x01, 0xDC, 0x07, 0x70, 0x1F, 0xE0,
  0x7B, 0x80, 0xEF, 0x03, 0xDC, 0x0F, 0x78, 0x1C, 0xE0, 0x73, 0x80, 0xE7,
  0x07, 0xBC, 0x0F, 0x38, 0x39, 0xE0, 0x79, 0xC3, 0xCF, 0x03, 0xCE, 0x1C,
  0x78, 0x1C, 0x71, 0xE3, 0x80, 0xE3, 0x8E, 0x3C, 0x0F, 0x1E, 0xF1, 0xE0,
  0x78, 0xF7, 0x0F, 0x03, 0xC7, 0xB8, 0x70, 0x1C, 0x3F, 0x83, 0x80, 0xE0,
  0xFC, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xF0,
  0x70, 0x1C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x00, 0x03, 0xE0, 0x0F,
  0x03, 0xE0, 0x0E, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x1E, 0x07, 0xF0, 0x1E,
  0x07, 0xF0, 0x1C, 0x07, 0x70, 0x1C, 0x07, 0x70, 0x3C, 0x07, 0x78, 0x3C,
  0x0F, 0x78, 0x3C, 0x0F, 0x78, 0x38, 0x0E, 0x38, 0x38, 0x0E, 0x38, 0x78,
  0x1E, 0x3C, 0x78, 0x1E, 0x3C, 0x78, 0x1E, 0x1C, 0x70, 0x1C, 0x1C, 0x70,
  0x1C, 0x1E, 0xF0, 0x3C, 0x1E, 0xF0, 0x3C, 0x0E, 0xE0, 0x3C, 0x0E, 0xE0,
  0x38, 0x0E, 0xE0, 0x38, 0x0F, 0xE0, 0x78, 0x0F, 0xE0, 0x78, 0x07, 0xC0,
  0x78, 0x07, 0xC0, 0x70, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0x00, 0x7F, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7C, 0x7E, 0x0F, 0x81, 0xE1, 0xF0, 0x1E,
  0x1E, 0x01, 0xF3, 0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0xC0, 0x0F, 0x78, 0x00,
  0xF7, 0x80, 0x1F, 0x78, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0,
  0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x0F, 0x81, 0xF0, 0x7C, 0x7E, 0x07,
  0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x78,
  0x3C, 0x0F, 0x07, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x0F, 0x07, 0x81, 0xE0,
  0xF0, 0x7C, 0x3C, 0x1F, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7C, 0x7E,
  0x0F, 0x81, 0xE1, 0xF0, 0x1E, 0x1E, 0x01, 0xF3, 0xE0, 0x0F, 0x3C, 0x00,
  0xF7, 0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0,
  0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x0F,
  0x81, 0xF0, 0x7C, 0x7E, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x01, 0xCF, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C,
  0x0F, 0x07, 0x01, 0xE1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xE0, 0xF0,
  0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0x8F,
  0x00, 0xF0, 0xE0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0E, 0x07,
  0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x7C, 0x78, 0x07,
  0x80, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0x9E, 0x0F, 0x81,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC2, 0x01, 0xF0, 0xE0, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0E, 0x00, 0xF1, 0xE0, 0x0E, 0x1E, 0x01,
  0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xC3, 0xC0,
  0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x03, 0x87, 0x80, 0x78, 0x78,
  0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x8F, 0x00, 0x70, 0xF0, 0x0F, 0x0F,
  0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x03, 0xE0,
  0xF8, 0x7C, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0xF0, 0x03,
  0xFC, 0x00, 0xF7, 0x00, 0x79, 0xC0, 0x1E, 0x70, 0x0F, 0x1C, 0x03, 0xC7,
  0x00, 0xF1, 0xC0, 0x78, 0x70, 0x1E, 0x1C, 0x0F, 0x07, 0x03, 0xC1, 0xC1,
  0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x07, 0x8F, 0x01, 0xE3, 0x80, 0x79, 0xE0,
  0x1E, 0x78, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x70, 0x07, 0x00, 0x7B, 0x80, 0x78, 0x07, 0x9C, 0x03, 0xC0, 0x3C,
  0xE0, 0x3E, 0x03, 0xC7, 0x01, 0xF0, 0x1E, 0x38, 0x0F, 0x80, 0xE1, 0xC0,
  0xFC, 0x0F, 0x0E, 0x07, 0xE0, 0x78, 0x70, 0x7F, 0x07, 0x83, 0x83, 0xB8,
  0x3C, 0x3C, 0x1D, 0xC1, 0xC1, 0xE1, 0xCE, 0x1E, 0x0F, 0x0E, 0x70, 0xF0,
  0x78, 0xF3, 0x8F, 0x03, 0xC7, 0x1C, 0x78, 0x1E, 0x78, 0xE3, 0x80, 0xF3,
  0x87, 0x3C, 0x07, 0x9C, 0x39, 0xC0, 0x3D, 0xE1, 0xDE, 0x01, 0xEE, 0x0E,
  0xF0, 0x0F, 0x70, 0x77, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0x80,
  0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x3E,
  0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x07, 0x01,
  0xE0, 0x1E, 0x0F, 0x80, 0x78, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80,
  0x0E, 0x3C, 0x00, 0x3C, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xE0, 0x01,
  0xE7, 0x80, 0x07, 0x9E, 0x00, 0x3C, 0x78, 0x01, 0xE0, 0xE0, 0x07, 0x83,
  0xC0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x03, 0xE0,
  0xF0, 0x07, 0xB8, 0x07, 0x9E, 0x07, 0xCF, 0x03, 0xC7, 0x83, 0xC3, 0xC1,
  0xE1, 0xE1, 0xE0, 0x70, 0xF0, 0x38, 0xF0, 0x1C, 0x70, 0x0F, 0x78, 0x07,
  0xB8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x00, 0xE1,
  0xE3, 0xC7, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xF1, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x3C, 0x78, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x3C, 0x78, 0x70,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x3F, 0xC0,
  0x7F, 0x01, 0xFE, 0x00, 0x00, 0x60, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xF8, 0x03, 0xB8, 0x07, 0x38, 0x07, 0x3C, 0x0E, 0x1C, 0x1E, 0x1C,
  0x1C, 0x1C, 0x3C, 0x0E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x07, 0xE0, 0x07,
  0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0xF3, 0xC7, 0x9E, 0x38, 0x70, 0x03,
  0xF3, 0x83, 0xFD, 0xC3, 0xFF, 0xE3, 0xE3, 0xF1, 0xE0, 0xF1, 0xE0, 0x78,
  0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x1E, 0x07, 0x9E, 0x03,
  0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x7C, 0x7C,
  0x7E, 0x1F, 0xFF, 0x0F, 0xF7, 0x03, 0xF3, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x9F, 0x83, 0xDF, 0xC1, 0xFF, 0xF0, 0xFC, 0x78,
  0x7C, 0x3C, 0x7C, 0x0E, 0x3C, 0x07, 0x1E, 0x03, 0x8F, 0x03, 0xC7, 0x01,
  0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x38, 0xF0, 0x3C, 0x78, 0x1E, 0x7C,
  0x1E, 0x3E, 0x0F, 0x1F, 0x0F, 0x0F, 0xFF, 0x8F, 0x7F, 0x87, 0x1F, 0x80,
  0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0xC7, 0xC2, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x87, 0xFE, 0x0F, 0xF8, 0x1F,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x7E,
  0x70, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xF1, 0xF8, 0x3C, 0x1E, 0x0F, 0x03,
  0xC1, 0xE0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x38, 0x38, 0x0F,
  0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x81, 0xE0, 0xF0, 0x3C,
  0x1E, 0x0F, 0x83, 0xE3, 0xF0, 0x3F, 0xFC, 0x07, 0xFB, 0x80, 0x7E, 0x70,
  0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0xF0, 0xF1, 0xE0, 0xE7, 0x83,
  0xCE, 0x07, 0xBC, 0x1E, 0x78, 0xFC, 0xFF, 0xF3, 0xFF, 0x87, 0xF8, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x21, 0xFF,
  0xC1, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xF2, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF9, 0xC0, 0xFF, 0x70,
  0x7F, 0xFC, 0x3E, 0x3F, 0x0F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF0,
  0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xC3, 0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x0F,
  0x1E, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x3E, 0x1F, 0x1F, 0x83,
  0xFF, 0xC0, 0xFF, 0x70, 0x1F, 0xBC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x08, 0x1F, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xE0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x9F,
  0x83, 0xDF, 0xC1, 0xFF, 0xF0, 0xFC, 0x78, 0x7C, 0x3C, 0x3C, 0x1E, 0x3C,
  0x0F, 0x1E, 0x07, 0x8F, 0x03, 0x87, 0x01, 0xC7, 0x81, 0xE3, 0xC0, 0xF1,
  0xE0, 0x78, 0xF0, 0x38, 0x70, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07,
  0x8F, 0x03, 0x87, 0x03, 0xC7, 0x81, 0xE0, 0x01, 0xC0, 0xF0, 0x3C, 0x0F,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x7C, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x0F,
  0x1E, 0x03, 0x8F, 0x00, 0xE7, 0xC0, 0x79, 0xE0, 0x1E, 0xF0, 0x07, 0x78,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xBC, 0x03, 0xCF, 0x00,
  0xE1, 0xC0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xC0, 0xE0, 0x70,
  0x3C, 0x3C, 0x0F, 0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x70, 0x3C, 0x00, 0x07, 0x3E, 0x1F, 0x83, 0x9F, 0xCF,
  0xF0, 0xEF, 0xFF, 0xFC, 0x3E, 0x1F, 0x8F, 0x0F, 0x07, 0xC3, 0xC3, 0xC1,
  0xE0, 0xF1, 0xE0, 0x78, 0x3C, 0x78, 0x1C, 0x0F, 0x1E, 0x0F, 0x03, 0xC7,
  0x03, 0xC0, 0xE3, 0xC0, 0xF0, 0x78, 0xF0, 0x3C, 0x1E, 0x3C, 0x0E, 0x07,
  0x8F, 0x07, 0x81, 0xC3, 0x81, 0xE0, 0x71, 0xE0, 0x78, 0x3C, 0x78, 0x1C,
  0x0F, 0x1E, 0x07, 0x03, 0xC7, 0x03, 0xC0, 0xE1, 0xC0, 0xF0, 0x38, 0xF0,
  0x3C, 0x1E, 0x00, 0x07, 0x3F, 0x07, 0x3F, 0xC3, 0xBF, 0xE1, 0xF8, 0xF0,
  0xF8, 0x78, 0xF8, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8E, 0x07,
  0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x70, 0xE0, 0x78, 0xF0,
  0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x1E, 0x07, 0x8F, 0x03, 0xC0,
  0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1E, 0x1E, 0x0F, 0x3C, 0x0F,
  0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x0E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x7C, 0x78, 0xF8,
  0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x01, 0xCF, 0xC0, 0x7B, 0xF8, 0x0E,
  0xFF, 0x81, 0xF8, 0xF0, 0x3E, 0x1E, 0x07, 0x81, 0xC1, 0xE0, 0x38, 0x3C,
  0x07, 0x07, 0x81, 0xE0, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0,
  0x1E, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0xF8, 0x3C, 0x1F, 0x07, 0x83, 0xE1,
  0xE0, 0x77, 0xFC, 0x0E, 0xFF, 0x03, 0xCF, 0xC0, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF3, 0x83, 0xFD, 0xC3, 0xFF,
  0xE3, 0xE3, 0xF1, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0xF0, 0x1E, 0x78,
  0x0F, 0x3C, 0x07, 0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3,
  0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x7C, 0x7C, 0x7E, 0x1F, 0xFE, 0x0F, 0xF7,
  0x03, 0xF7, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x3C,
  0x39, 0xF0, 0xEF, 0xC3, 0xFA, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x00, 0x07,
  0xF8, 0x3F, 0xF1, 0xFF, 0xC7, 0x82, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF2, 0x07, 0x8F, 0xFE, 0x3F, 0xF0, 0xFF, 0x80,
  0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x3F, 0xDF, 0xFB, 0xFF, 0x1E,
  0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0xF8, 0x7F, 0x0F, 0xE0,
  0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xE1, 0xC0, 0xF1, 0xE0,
  0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x38, 0x0E, 0x1C, 0x0F, 0x1E, 0x07, 0x8F,
  0x03, 0xC7, 0x81, 0xC3, 0x81, 0xE1, 0xC0, 0xF1, 0xE0, 0xF8, 0xF0, 0x7C,
  0x78, 0x7C, 0x3F, 0xFE, 0x0F, 0xF7, 0x03, 0xF3, 0x80, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0xF7, 0x81, 0xEF, 0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0x38, 0x78,
  0x70, 0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0x9E, 0x07, 0x38, 0x0E, 0xF0, 0x1D,
  0xC0, 0x3B, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0xF0, 0x3C, 0x0F, 0xF0, 0x7C, 0x0E, 0xF0, 0x7C, 0x1E, 0xF0, 0x7C,
  0x1C, 0xF0, 0xFC, 0x3C, 0xF0, 0xFC, 0x3C, 0xF1, 0xDC, 0x38, 0xF1, 0xDC,
  0x78, 0xF1, 0xDC, 0x70, 0xF3, 0x9C, 0xF0, 0xF3, 0x9C, 0xE0, 0xF7, 0x1C,
  0xE0, 0xF7, 0x1D, 0xE0, 0xF7, 0x1D, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F,
  0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xF8, 0x1F,
  0x00, 0xF8, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x0E, 0x1E, 0x01,
  0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0x9C, 0x00, 0x77, 0x80, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xEE, 0x00, 0x79, 0xC0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF0,
  0x70, 0x3C, 0x0F, 0x0F, 0x81, 0xE0, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07,
  0x81, 0xE0, 0x38, 0x1E, 0x03, 0x81, 0xC0, 0x38, 0x3C, 0x03, 0x83, 0x80,
  0x38, 0x78, 0x03, 0x87, 0x00, 0x38, 0xF0, 0x03, 0x8E, 0x00, 0x39, 0xE0,
  0x03, 0x9E, 0x00, 0x39, 0xC0, 0x03, 0xBC, 0x00, 0x3B, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE,
  0x00, 0x00, 0x1E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x7F, 0x00, 0xFC, 0x01, 0xE0, 0x03, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x1F, 0xC0, 0xF8, 0x03, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x7F, 0x01,
  0xFF, 0xC7, 0xFF, 0xFF, 0xC1, 0xFE, 0x80, 0x7C,
};

const GFXglyph NotoSans_Condensed_MediumItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 28, 10, 0, -28 },
  { 36, 12, 10, 14, 4, -28 },
  { 51, 20, 28, 20, 0, -28 },
  { 121, 18, 32, 17, 0, -30 },
  { 193, 24, 28, 27, 2, -28 },
  { 277, 20, 28, 20, 0, -28 },
  { 347, 5, 10, 8, 4, -28 },
  { 354, 12, 34, 11, 1, -28 },
  { 405, 13, 34, 11, -3, -28 },
  { 461, 14, 15, 17, 4, -30 },
  { 488, 16, 18, 19, 2, -23 },
  { 524, 8, 10, 9, -2, -5 },
  { 534, 9, 3, 11, 1, -12 },
  { 538, 5, 5, 9, 0, -5 },
  { 542, 19, 28, 14, -2, -28 },
  { 609, 16, 28, 17, 1, -28 },
  { 665, 12, 28, 17, 4, -28 },
  { 707, 18, 28, 17, -1, -28 },
  { 770, 17, 28, 17, 0, -28 },
  { 830, 17, 28, 17, 0, -28 },
  { 890, 18, 28, 17, 0, -28 },
  { 953, 17, 28, 17, 1, -28 },
  { 1013, 17, 28, 17, 2, -28 },
  { 1073, 18, 28, 17, 0, -28 },
  { 1136, 17, 28, 17, 0, -28 },
  { 1196, 9, 21, 9, 0, -21 },
  { 1220, 11, 26, 9, -2, -21 },
  { 1256, 16, 18, 19, 2, -23 },
  { 1292, 16, 11, 19, 2, -19 },
  { 1314, 16, 18, 19, 2, -23 },
  { 1350, 14, 28, 13, 1, -28 },
  { 1399, 25, 31, 26, 1, -28 },
  { 1496, 18, 28, 18, -2, -28 },
  { 1559, 19, 28, 19, 0, -28 },
  { 1626, 18, 28, 18, 2, -28 },
  { 1689, 20, 28, 21, 0, -28 },
  { 1759, 18, 28, 16, 0, -28 },
  { 1822, 18, 28, 15, 0, -28 },
  { 1885, 20, 28, 22, 2, -28 },
  { 1955, 22, 28, 22, 0, -28 },
  { 2032, 16, 28, 12, -2, -28 },
  { 2088, 16, 36, 9, -6, -28 },
  { 2160, 22, 28, 18, 0, -28 },
  { 2237, 13, 28, 15, 0, -28 },
  { 2283, 29, 28, 28, 0, -28 },
  { 2385, 24, 28, 23, 0, -28 },
  { 2469, 20, 28, 22, 2, -28 },
  { 2539, 19, 28, 18, 0, -28 },
  { 2606, 20, 35, 22, 2, -28 },
  { 2694, 19, 28, 19, 0, -28 },
  { 2761, 18, 28, 17, 0, -28 },
  { 2824, 16, 28, 16, 3, -28 },
  { 2880, 20, 28, 21, 2, -28 },
  { 2950, 18, 28, 18, 3, -28 },
  { 3013, 29, 28, 28, 3, -28 },
  { 3115, 22, 28, 17, -2, -28 },
  { 3192, 17, 28, 16, 3, -28 },
  { 3252, 19, 28, 16, -1, -28 },
  { 3319, 15, 34, 11, -1, -28 },
  { 3383, 7, 28, 14, 4, -28 },
  { 3408, 15, 34, 11, -3, -28 },
  { 3472, 16, 16, 18, 1, -28 },
  { 3504, 14, 3, 13, -4, 3 },
  { 3510, 6, 6, 11, 6, -30 },
  { 3515, 17, 21, 19, 1, -21 },
  { 3560, 17, 30, 19, 0, -30 },
  { 3624, 14, 21, 14, 1, -21 },
  { 3661, 19, 30, 19, 1, -30 },
  { 3733, 15, 21, 17, 1, -21 },
  { 3773, 20, 39, 11, -5, -30 },
  { 3871, 18, 30, 19, 0, -21 },
  { 3939, 17, 30, 18, 0, -30 },
  { 4003, 10, 29, 9, 0, -29 },
  { 4040, 15, 38, 9, -5, -29 },
  { 4112, 18, 30, 16, 0, -30 },
  { 4180, 10, 30, 9, 0, -30 },
  { 4218, 26, 21, 28, 0, -21 },
  { 4287, 17, 21, 18, 0, -21 },
  { 4332, 16, 21, 18, 1, -21 },
  { 4374, 19, 30, 19, -2, -21 },
  { 4446, 17, 30, 19, 1, -21 },
  { 4510, 14, 21, 13, 0, -21 },
  { 4547, 14, 21, 14, 0, -21 },
  { 4584, 11, 26, 11, 1, -26 },
  { 4620, 17, 21, 18, 1, -21 },
  { 4665, 15, 21, 15, 2, -21 },
  { 4705, 24, 21, 24, 2, -21 },
  { 4768, 19, 21, 16, -2, -21 },
  { 4818, 20, 30, 15, -3, -21 },
  { 4893, 15, 21, 13, -1, -21 },
  { 4933, 15, 34, 13, 1, -28 },
  { 4997, 3, 39, 17, 7, -30 },
  { 5012, 14, 34, 13, -2, -28 },
  { 5072, 16, 6, 19, 2, -17 },
};

const GFXfont NotoSans_Condensed_MediumItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC39PT7B_H_
