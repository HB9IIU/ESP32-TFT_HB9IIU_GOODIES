#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC23PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0x86, 0x18, 0x63, 0x0C, 0x30, 0xC2, 0x10, 0x01, 0x8E,
  0x38, 0x76, 0xCD, 0x9A, 0x6C, 0xD9, 0x80, 0x06, 0x60, 0x66, 0x06, 0x40,
  0x4C, 0x3F, 0xF3, 0xFF, 0x08, 0x81, 0x98, 0x19, 0x8F, 0xFE, 0xFF, 0xC3,
  0x30, 0x22, 0x06, 0x60, 0x66, 0x06, 0x40, 0x01, 0x00, 0xC0, 0xFC, 0x6B,
  0x32, 0x0C, 0x83, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x26, 0x09, 0xB2,
  0xEF, 0xF1, 0xF0, 0x10, 0x04, 0x00, 0x18, 0x08, 0xF0, 0x42, 0x63, 0x19,
  0x98, 0x66, 0x61, 0x13, 0x0C, 0xC8, 0x33, 0x6E, 0xCB, 0x7D, 0xED, 0x32,
  0x6C, 0xC1, 0x33, 0x0C, 0xCC, 0x62, 0x21, 0x89, 0x8C, 0x36, 0x60, 0xF0,
  0x03, 0x00, 0xF8, 0x0C, 0xC1, 0x8C, 0x18, 0xC1, 0x98, 0x1F, 0x80, 0xF0,
  0x1E, 0x03, 0xE7, 0x66, 0x66, 0x3E, 0xC3, 0xCC, 0x38, 0xE3, 0x8F, 0xFC,
  0x7C, 0xE0, 0x76, 0x66, 0x4C, 0x0E, 0x30, 0x61, 0x83, 0x0C, 0x18, 0x70,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x03, 0x00, 0x04,
  0x06, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0x07, 0x06, 0x06, 0x06, 0x06,
  0x0C, 0x0C, 0x0C, 0x18, 0x38, 0x30, 0x60, 0xC0, 0x08, 0x06, 0x23, 0x1D,
  0x07, 0xF8, 0xCC, 0xF0, 0xCC, 0x26, 0x00, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC7, 0xFF, 0xFE, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x33, 0x76, 0x6C, 0x7F,
  0xF0, 0x7F, 0x80, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0xC0, 0x00, 0x06, 0x0F, 0x8E, 0xE6, 0x37, 0x1B, 0x0D, 0x87, 0xC3,
  0xC1, 0xE1, 0xF0, 0xD8, 0x6C, 0x76, 0x33, 0x39, 0xF8, 0x78, 0x00, 0x0E,
  0x3C, 0xFF, 0x64, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C,
  0x38, 0x03, 0x81, 0xF8, 0x73, 0x84, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06,
  0x01, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0xFC, 0xFF,
  0x80, 0x07, 0x07, 0xF1, 0x9C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x1C, 0x1E,
  0x03, 0xC0, 0x38, 0x06, 0x03, 0x80, 0xE8, 0x73, 0xFC, 0xFC, 0x00, 0x00,
  0xC0, 0x70, 0x3C, 0x0B, 0x07, 0x83, 0x60, 0xD8, 0x66, 0x33, 0x88, 0xC6,
  0x33, 0x0C, 0xFF, 0xC1, 0xC0, 0x60, 0x18, 0x06, 0x00, 0x0F, 0xC7, 0xF1,
  0x80, 0x60, 0x18, 0x0C, 0x03, 0xF0, 0xFE, 0x03, 0x80, 0x60, 0x18, 0x06,
  0x03, 0xA1, 0xCF, 0xE3, 0xF0, 0x03, 0x83, 0xF1, 0xC4, 0xE0, 0x30, 0x18,
  0x06, 0x01, 0xFC, 0xF7, 0x38, 0xCC, 0x33, 0x0C, 0xC3, 0x30, 0xCC, 0x63,
  0xF8, 0x7C, 0x00, 0x7F, 0xDF, 0xF0, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60,
  0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0x03,
  0x03, 0xF1, 0xCC, 0x63, 0x38, 0xCE, 0x31, 0x98, 0x7C, 0x0E, 0x0F, 0xC7,
  0x39, 0x86, 0xC1, 0xB0, 0x6E, 0x39, 0xFC, 0x3E, 0x00, 0x07, 0x03, 0xE1,
  0xDC, 0xE3, 0x30, 0xCC, 0x37, 0x0D, 0xC7, 0x31, 0xCF, 0xE1, 0xD8, 0x06,
  0x03, 0x00, 0xC0, 0x63, 0xF0, 0xF8, 0x00, 0x11, 0xCE, 0x20, 0x00, 0x00,
  0x00, 0x19, 0xCE, 0x00, 0x08, 0x71, 0xC2, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x0C, 0x61, 0x8C, 0x30, 0x00, 0x40, 0x70, 0x78, 0x78, 0x78, 0x38, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0C, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x80, 0x30, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x3C, 0x78, 0x78,
  0x38, 0x08, 0x00, 0x1C, 0x7E, 0x67, 0x03, 0x03, 0x06, 0x0E, 0x1C, 0x38,
  0x30, 0x60, 0x60, 0x00, 0x00, 0xC0, 0xE0, 0xC0, 0x00, 0x40, 0x1F, 0xC0,
  0xC1, 0x86, 0x03, 0x30, 0x0C, 0x8F, 0x96, 0x66, 0x51, 0x11, 0xCC, 0xCF,
  0x23, 0x3C, 0x8C, 0xE6, 0x62, 0x99, 0x9A, 0x3B, 0xCC, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xFE, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x1B, 0x06,
  0xC3, 0x30, 0xCC, 0x73, 0x18, 0xC7, 0xF3, 0xFC, 0xC3, 0x70, 0xD8, 0x3E,
  0x0F, 0x03, 0x0F, 0xC3, 0xBC, 0x61, 0x8C, 0x31, 0x86, 0x71, 0xCF, 0xF1,
  0xF8, 0x31, 0xC6, 0x19, 0xC3, 0x30, 0x66, 0x1C, 0xC3, 0x1F, 0xE7, 0xF0,
  0x03, 0x81, 0xFC, 0x79, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0xF8, 0x3F, 0x00,
  0x0F, 0xC1, 0xFE, 0x18, 0x71, 0x87, 0x18, 0x73, 0x83, 0x38, 0x73, 0x07,
  0x30, 0x73, 0x06, 0x70, 0xE6, 0x0C, 0x61, 0xC6, 0x38, 0x7F, 0x0F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0F, 0xE1, 0xFC, 0x30,
  0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3,
  0xF8, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xFC, 0x3F, 0x06, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x01, 0xC0, 0xFF, 0x1E,
  0x63, 0x80, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE3, 0xEE, 0x3E, 0xC0,
  0xCC, 0x0C, 0xC0, 0xCE, 0x0C, 0x61, 0xC7, 0xF8, 0x3F, 0x80, 0x0C, 0x18,
  0xE1, 0xC6, 0x0E, 0x30, 0x61, 0x83, 0x1C, 0x18, 0xFF, 0xC7, 0xFC, 0x30,
  0x61, 0x83, 0x1C, 0x18, 0xC1, 0xC6, 0x0C, 0x30, 0x61, 0x83, 0x1C, 0x38,
  0x1F, 0x83, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06,
  0x03, 0x01, 0x81, 0xC1, 0xE1, 0xF8, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30,
  0x18, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38,
  0x18, 0x0C, 0x3E, 0x1E, 0x04, 0x00, 0x0C, 0x38, 0xE3, 0x06, 0x38, 0x33,
  0x81, 0xB8, 0x1D, 0x80, 0xD8, 0x07, 0xC0, 0x3E, 0x01, 0xB8, 0x1C, 0xC0,
  0xC6, 0x06, 0x30, 0x31, 0xC1, 0x86, 0x1C, 0x30, 0x0C, 0x1C, 0x18, 0x18,
  0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x7F, 0xFE,
  0x0E, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xC3, 0xC1, 0xE1, 0xE1, 0xB1, 0xF0,
  0xD8, 0xD8, 0xD8, 0x6C, 0x6C, 0x36, 0x66, 0x1B, 0x33, 0x1D, 0xB3, 0x8C,
  0x59, 0x86, 0x3C, 0xC3, 0x1C, 0x61, 0x8E, 0x31, 0x86, 0x38, 0x0C, 0x0C,
  0x78, 0x71, 0xE1, 0x87, 0x86, 0x1E, 0x18, 0xEC, 0x63, 0x33, 0x0C, 0xCC,
  0x33, 0x30, 0xCE, 0xC7, 0x1B, 0x18, 0x78, 0x61, 0xE1, 0x87, 0x86, 0x0E,
  0x30, 0x38, 0x03, 0x80, 0xFE, 0x1C, 0xE3, 0x87, 0x30, 0x77, 0x07, 0x60,
  0x76, 0x07, 0xE0, 0x7E, 0x06, 0xC0, 0x6C, 0x0E, 0xC0, 0xCE, 0x1C, 0xE3,
  0x87, 0xF0, 0x3E, 0x00, 0x0F, 0xC3, 0xFC, 0x61, 0x8C, 0x31, 0x86, 0x70,
  0xCE, 0x39, 0x8E, 0x3F, 0x87, 0xC1, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0x03, 0x80, 0xFE, 0x1C, 0xE3, 0x87, 0x30, 0x77, 0x07, 0x60,
  0x76, 0x07, 0xE0, 0x7E, 0x06, 0xC0, 0x6C, 0x0E, 0xC0, 0xCE, 0x1C, 0xE3,
  0x87, 0xF0, 0x3E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x80, 0x0F, 0xC3,
  0xFC, 0x63, 0x8C, 0x31, 0x86, 0x71, 0xCC, 0x31, 0xFE, 0x3F, 0x06, 0xE1,
  0xCC, 0x31, 0x86, 0x30, 0xC7, 0x18, 0x67, 0x0C, 0x03, 0x03, 0xF1, 0xCC,
  0xE0, 0x30, 0x0C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0C, 0x03,
  0x80, 0xC8, 0x73, 0xF8, 0xFC, 0x00, 0xFF, 0xFF, 0xC6, 0x03, 0x01, 0x81,
  0xC0, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80,
  0x38, 0x33, 0x07, 0x30, 0x63, 0x06, 0x30, 0x67, 0x06, 0x60, 0xE6, 0x0C,
  0x60, 0xCE, 0x0C, 0xE1, 0xCC, 0x18, 0xC1, 0x8E, 0x38, 0x7F, 0x07, 0xE0,
  0xC0, 0xF8, 0x3B, 0x06, 0x60, 0xCC, 0x31, 0x86, 0x31, 0x86, 0x30, 0xCE,
  0x19, 0x83, 0xF0, 0x7C, 0x0D, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0xC1, 0x83,
  0xE0, 0xC1, 0xB0, 0xE1, 0x98, 0x70, 0xCC, 0x68, 0xE6, 0x3C, 0x63, 0x36,
  0x31, 0x9B, 0x30, 0xCD, 0x98, 0x6C, 0xDC, 0x36, 0x6C, 0x1E, 0x36, 0x0F,
  0x1E, 0x07, 0x8F, 0x03, 0x87, 0x81, 0xC3, 0x80, 0x1C, 0x38, 0x63, 0x83,
  0x18, 0x1D, 0x80, 0x7C, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x06, 0xC0, 0x37, 0x03, 0x18, 0x38, 0xC1, 0x86, 0x18, 0x38, 0xC1, 0xF8,
  0xEE, 0x31, 0x98, 0x66, 0x1B, 0x06, 0xC1, 0xE0, 0x78, 0x0C, 0x07, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0xE0, 0x1C,
  0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0x86, 0x03, 0x01, 0x80, 0xC0,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0,
  0x60, 0x30, 0x1E, 0x1F, 0x00, 0xC2, 0x18, 0xC6, 0x31, 0x8C, 0x61, 0x8C,
  0x63, 0x18, 0xC6, 0x38, 0x0F, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C,
  0x1E, 0x1F, 0x00, 0x06, 0x01, 0xC0, 0xF0, 0x2C, 0x19, 0x8C, 0x63, 0x19,
  0x83, 0xE0, 0xC0, 0xFF, 0xE6, 0x63, 0x0C, 0x0F, 0xB3, 0xB9, 0xC6, 0x61,
  0xB8, 0x6C, 0x3B, 0x0C, 0xC3, 0x31, 0xCC, 0x73, 0xEC, 0x76, 0x00, 0x0C,
  0x07, 0x01, 0x80, 0x60, 0x19, 0x07, 0xF3, 0xDC, 0xE3, 0x30, 0xCC, 0x37,
  0x0D, 0x83, 0x61, 0xD8, 0x66, 0x3B, 0x7C, 0xDE, 0x00, 0x0E, 0x1F, 0x39,
  0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFC, 0x7C, 0x00, 0x60,
  0x18, 0x03, 0x00, 0x60, 0xCC, 0x7D, 0x8C, 0xE3, 0x0C, 0x61, 0x9C, 0x33,
  0x0E, 0x61, 0x8C, 0x31, 0x8E, 0x31, 0xC7, 0xD8, 0x76, 0x00, 0x0E, 0x1F,
  0x33, 0x63, 0x63, 0xC7, 0xFE, 0xF0, 0xC0, 0xC0, 0xC0, 0xFE, 0x7E, 0x00,
  0x60, 0x1F, 0x01, 0x90, 0x18, 0x03, 0x00, 0x30, 0x0F, 0xC0, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x0B, 0x80, 0xF0, 0x04, 0x00, 0x06,
  0x03, 0xEC, 0x67, 0x1C, 0x63, 0x0C, 0xE1, 0x98, 0x73, 0x0C, 0x61, 0x8C,
  0x71, 0x8E, 0x3F, 0xC3, 0xB0, 0x06, 0x00, 0xC0, 0x38, 0xCE, 0x1F, 0x80,
  0x80, 0x00, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x19, 0x07, 0xF3, 0xDC, 0xE3,
  0x30, 0xCC, 0x33, 0x1D, 0x86, 0x61, 0x98, 0x66, 0x3B, 0x8C, 0xC3, 0x00,
  0x0C, 0x70, 0x80, 0x00, 0x63, 0x8C, 0x30, 0xC3, 0x1C, 0x61, 0x86, 0x38,
  0xC0, 0x01, 0x81, 0xC0, 0x40, 0x00, 0x00, 0x18, 0x1C, 0x0C, 0x06, 0x03,
  0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x0B,
  0x07, 0x81, 0x00, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x82, 0x31, 0x8E,
  0x61, 0x98, 0x36, 0x07, 0xC0, 0xF8, 0x3F, 0x06, 0x60, 0xCC, 0x19, 0xC7,
  0x18, 0xC3, 0x00, 0x0C, 0x71, 0x86, 0x18, 0x63, 0x8C, 0x30, 0xC3, 0x1C,
  0x61, 0x86, 0x38, 0xC0, 0x09, 0x0C, 0x2F, 0xBC, 0xF7, 0x99, 0xC6, 0x33,
  0x0C, 0x66, 0x38, 0xCC, 0x61, 0xB0, 0xC7, 0x61, 0x8C, 0xC3, 0x19, 0x8C,
  0x37, 0x18, 0x6C, 0x31, 0xC0, 0x09, 0x05, 0xF3, 0xDC, 0xE3, 0x30, 0xCC,
  0x33, 0x1D, 0xC6, 0x61, 0x98, 0x66, 0x3B, 0x8C, 0xC3, 0x00, 0x0C, 0x1F,
  0x8C, 0xEC, 0x36, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0x61, 0xB1, 0xDF, 0xC7,
  0xC0, 0x04, 0x81, 0x7C, 0x79, 0x8E, 0x31, 0x86, 0x30, 0xC6, 0x19, 0x83,
  0x30, 0xE6, 0x18, 0xC7, 0x3F, 0xC6, 0xF0, 0xC0, 0x18, 0x03, 0x00, 0xE0,
  0x18, 0x00, 0x0C, 0x0F, 0xB3, 0x39, 0x86, 0x61, 0xB8, 0x6C, 0x3B, 0x0C,
  0xC3, 0x31, 0xCC, 0x73, 0xFC, 0x76, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x09, 0x17, 0x3F, 0x38, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60,
  0x60, 0xE0, 0xC0, 0x0E, 0x3F, 0x31, 0x70, 0x70, 0x38, 0x3C, 0x1E, 0x0E,
  0x06, 0x8E, 0xFC, 0xFC, 0x18, 0xC3, 0x3F, 0x71, 0x86, 0x18, 0x63, 0x8C,
  0x30, 0xC3, 0xCF, 0x00, 0x31, 0xD8, 0x66, 0x19, 0x86, 0x63, 0xB8, 0xCC,
  0x33, 0x0C, 0xC7, 0x31, 0xCF, 0xE3, 0xD8, 0xC1, 0xE1, 0xB8, 0xDC, 0xC6,
  0x63, 0x61, 0xB0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x00, 0xE3, 0x8F, 0x1C,
  0x6C, 0x71, 0xB1, 0x46, 0xCD, 0x33, 0x24, 0xCD, 0x96, 0x36, 0x58, 0xD1,
  0x63, 0xC7, 0x0E, 0x1C, 0x38, 0x60, 0x18, 0xE3, 0x38, 0x36, 0x07, 0x80,
  0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x3B, 0x06, 0x61, 0x8C, 0x71, 0xC0, 0x1C,
  0x31, 0xC6, 0x0C, 0x60, 0xCC, 0x0C, 0xC0, 0xD8, 0x0D, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x0B, 0x80, 0xF0,
  0x04, 0x00, 0x1F, 0x80, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x70, 0x30, 0x30,
  0x38, 0x1F, 0x9F, 0xC0, 0x03, 0x83, 0x83, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x30, 0x38, 0x30, 0x3C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x18,
  0x0E, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x1E, 0x06,
  0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0E, 0x03, 0x0F, 0x1C, 0x18, 0x18, 0x18,
  0x38, 0x30, 0x70, 0xE0, 0xC0, 0x70, 0x7F, 0x38, 0xFA, 0x00,
};

const GFXglyph NotoSans_Condensed_MediumItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 16, 6, 0, -16 },
  { 13, 7, 6, 9, 2, -16 },
  { 19, 12, 16, 12, 0, -16 },
  { 43, 10, 18, 10, 0, -17 },
  { 66, 14, 17, 16, 1, -17 },
  { 96, 12, 17, 12, 0, -17 },
  { 122, 4, 6, 5, 2, -16 },
  { 125, 7, 20, 6, 1, -16 },
  { 143, 8, 21, 6, -2, -17 },
  { 164, 9, 9, 10, 2, -18 },
  { 175, 9, 11, 11, 1, -14 },
  { 188, 4, 6, 5, -1, -3 },
  { 191, 6, 2, 6, 0, -7 },
  { 193, 3, 3, 5, 0, -3 },
  { 195, 11, 17, 8, -1, -17 },
  { 219, 9, 17, 10, 1, -17 },
  { 239, 7, 16, 10, 2, -16 },
  { 253, 11, 17, 10, -1, -17 },
  { 277, 10, 17, 10, 0, -17 },
  { 299, 10, 17, 10, 0, -17 },
  { 321, 10, 16, 10, 0, -16 },
  { 341, 10, 17, 10, 1, -17 },
  { 363, 10, 16, 10, 1, -16 },
  { 383, 10, 17, 10, 0, -17 },
  { 405, 10, 17, 10, 0, -17 },
  { 427, 5, 13, 5, 0, -13 },
  { 436, 6, 16, 5, -1, -13 },
  { 448, 10, 11, 11, 1, -14 },
  { 462, 9, 6, 11, 1, -11 },
  { 469, 10, 11, 11, 1, -14 },
  { 483, 8, 17, 8, 1, -17 },
  { 500, 14, 19, 16, 1, -17 },
  { 534, 10, 16, 11, -1, -16 },
  { 554, 11, 16, 11, 0, -16 },
  { 576, 11, 17, 11, 1, -17 },
  { 600, 12, 16, 12, 0, -16 },
  { 624, 11, 16, 10, 0, -16 },
  { 646, 11, 16, 9, 0, -16 },
  { 668, 12, 17, 13, 1, -17 },
  { 694, 13, 16, 13, 0, -16 },
  { 720, 9, 16, 7, -1, -16 },
  { 738, 9, 21, 5, -3, -16 },
  { 762, 13, 16, 11, 0, -16 },
  { 788, 8, 16, 9, 0, -16 },
  { 804, 17, 16, 17, 0, -16 },
  { 838, 14, 16, 13, 0, -16 },
  { 866, 12, 17, 13, 1, -17 },
  { 892, 11, 16, 11, 0, -16 },
  { 914, 12, 21, 13, 1, -17 },
  { 946, 11, 16, 11, 0, -16 },
  { 968, 10, 17, 10, 0, -17 },
  { 990, 9, 16, 9, 2, -16 },
  { 1008, 12, 16, 13, 1, -16 },
  { 1032, 11, 16, 11, 2, -16 },
  { 1054, 17, 16, 17, 2, -16 },
  { 1088, 13, 16, 10, -1, -16 },
  { 1114, 10, 16, 10, 2, -16 },
  { 1134, 12, 16, 9, -1, -16 },
  { 1158, 9, 20, 7, -1, -16 },
  { 1181, 5, 17, 8, 2, -17 },
  { 1192, 9, 20, 7, -2, -16 },
  { 1215, 10, 9, 10, 0, -16 },
  { 1227, 8, 1, 8, -2, 2 },
  { 1228, 4, 4, 6, 3, -18 },
  { 1230, 10, 13, 11, 1, -13 },
  { 1247, 10, 17, 11, 0, -17 },
  { 1269, 8, 13, 9, 1, -13 },
  { 1282, 11, 17, 11, 1, -17 },
  { 1306, 8, 13, 10, 1, -13 },
  { 1319, 12, 24, 6, -3, -18 },
  { 1355, 11, 19, 11, 0, -13 },
  { 1382, 10, 17, 11, 0, -17 },
  { 1404, 6, 17, 5, 0, -17 },
  { 1417, 9, 23, 5, -3, -17 },
  { 1443, 11, 17, 10, 0, -17 },
  { 1467, 6, 17, 5, 0, -17 },
  { 1480, 15, 13, 16, 0, -13 },
  { 1505, 10, 13, 11, 0, -13 },
  { 1522, 9, 13, 11, 1, -13 },
  { 1537, 11, 18, 11, -1, -13 },
  { 1562, 10, 19, 11, 1, -13 },
  { 1586, 8, 13, 7, 0, -13 },
  { 1599, 8, 13, 8, 0, -13 },
  { 1612, 6, 15, 7, 1, -15 },
  { 1624, 10, 12, 11, 1, -12 },
  { 1639, 9, 12, 9, 1, -12 },
  { 1653, 14, 12, 14, 1, -12 },
  { 1674, 11, 12, 9, -1, -12 },
  { 1691, 12, 18, 9, -2, -12 },
  { 1718, 9, 12, 8, -1, -12 },
  { 1732, 9, 20, 8, 0, -16 },
  { 1755, 2, 23, 10, 4, -18 },
  { 1761, 8, 20, 8, -1, -16 },
  { 1781, 10, 4, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_MediumItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC23PT7B_H_
