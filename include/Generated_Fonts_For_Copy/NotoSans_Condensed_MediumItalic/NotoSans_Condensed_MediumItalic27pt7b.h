#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC27PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xE1, 0x83,
  0x00, 0x00, 0x00, 0x71, 0xE3, 0x80, 0x67, 0xE7, 0xE6, 0xC6, 0xC6, 0xCC,
  0xCC, 0x03, 0x98, 0x0C, 0x60, 0x31, 0x80, 0xCC, 0x06, 0x30, 0xFF, 0xF3,
  0xFF, 0xC3, 0x18, 0x0C, 0x60, 0x33, 0x01, 0x8C, 0x3F, 0xFC, 0xFF, 0xF0,
  0x66, 0x03, 0x18, 0x0C, 0x60, 0x33, 0x01, 0x8C, 0x06, 0x70, 0x00, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x7F, 0x0F, 0xF1, 0xD2, 0x19, 0x01, 0x90, 0x1B,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x6C, 0x04, 0xE0, 0x4C, 0x84,
  0xCF, 0xFC, 0xFF, 0x83, 0xE0, 0x08, 0x00, 0x80, 0x18, 0x00, 0x08, 0x00,
  0x3C, 0x0C, 0x7E, 0x18, 0x66, 0x18, 0xC6, 0x30, 0xC6, 0x70, 0xC6, 0x60,
  0xCC, 0xC0, 0xCC, 0xCC, 0xCD, 0xBE, 0xDB, 0xB7, 0xF3, 0x63, 0x26, 0x63,
  0x06, 0x67, 0x0C, 0xE6, 0x1C, 0xC6, 0x18, 0xC6, 0x30, 0xCC, 0x30, 0xFC,
  0x60, 0x78, 0x00, 0x80, 0x1F, 0x80, 0x7E, 0x03, 0x9C, 0x0C, 0x70, 0x31,
  0x80, 0xCE, 0x03, 0x70, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x4E, 0xC6, 0x73,
  0xB9, 0x8E, 0xEE, 0x1F, 0x38, 0x78, 0xE1, 0xE3, 0x8F, 0x87, 0xF7, 0x0F,
  0x9C, 0x76, 0xEE, 0xCC, 0xC0, 0x07, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30,
  0x70, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xE0, 0x60, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x06,
  0x07, 0x03, 0x03, 0x03, 0x83, 0x80, 0x0A, 0x06, 0x03, 0x19, 0x8F, 0xF9,
  0xFC, 0xF0, 0xF8, 0xE6, 0x23, 0x81, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x61, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x39, 0x9C, 0xC6, 0x63, 0x00, 0x7F, 0xFC, 0x7F, 0xE0, 0x00, 0x38,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x30, 0x00, 0x01, 0x01, 0xF8, 0x7F, 0x0E, 0x73, 0x8E,
  0x61, 0xDC, 0x3B, 0x87, 0x60, 0xFC, 0x1F, 0x83, 0x70, 0x6E, 0x1D, 0x83,
  0xB0, 0x66, 0x1C, 0xC3, 0x9C, 0xE3, 0xF8, 0x3E, 0x00, 0x0F, 0x1E, 0x3E,
  0x7E, 0xEE, 0x4E, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x38,
  0x30, 0x30, 0x70, 0x70, 0x00, 0xC0, 0x3F, 0x83, 0xFE, 0x18, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x81, 0x1F, 0xF1, 0xFF,
  0x80, 0x01, 0x00, 0xFE, 0x1F, 0xF0, 0x87, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0E, 0x01, 0xC0, 0xF8, 0x0F, 0x81, 0x3C, 0x01, 0xC0, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0xC8, 0x38, 0xFF, 0x8F, 0xE0, 0x00, 0x70, 0x0F, 0x01, 0xE0,
  0x1E, 0x03, 0x60, 0x6E, 0x0E, 0xE0, 0xCC, 0x18, 0xC3, 0x9C, 0x31, 0xC6,
  0x1C, 0xE1, 0x8F, 0xFE, 0xFF, 0xE0, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x0F, 0xF0, 0xFF, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0xF8,
  0x3F, 0xC1, 0x3C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x83, 0x8F, 0xF8, 0xFE, 0x00, 0x00, 0xD0, 0x3E, 0x0F, 0xE0, 0xE0, 0x1C,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x6F, 0x87, 0xFC, 0xF1, 0xCE, 0x1C, 0xE1,
  0xCE, 0x1C, 0xE1, 0xCC, 0x1C, 0xE3, 0x8E, 0x38, 0x7F, 0x03, 0xE0, 0x3F,
  0xF3, 0xFF, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x07, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x7E, 0x0F, 0xF1, 0xC7, 0x1C, 0x31,
  0x83, 0x18, 0x71, 0xCE, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xDC, 0x71, 0xC6,
  0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xCF, 0x1C, 0x7F, 0x83, 0xF0, 0x01, 0x00,
  0x7E, 0x0F, 0xE1, 0xC7, 0x38, 0x73, 0x87, 0x38, 0x73, 0x07, 0x30, 0x73,
  0x0E, 0x39, 0xE3, 0xFE, 0x1E, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x70, 0xFE, 0x0F, 0xC0, 0x08, 0x71, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x73, 0xCE, 0x00, 0x04, 0x1C, 0x38, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x86, 0x1C, 0x30, 0xE1, 0x83, 0x00, 0x00, 0x20, 0x1C,
  0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x30, 0x02, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x80, 0x1C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x38, 0x1F,
  0x0F, 0x87, 0xC3, 0xE0, 0x70, 0x08, 0x00, 0x04, 0x1F, 0x9F, 0xE4, 0x70,
  0x18, 0x0C, 0x0E, 0x0E, 0x0E, 0x06, 0x06, 0x07, 0x03, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x38, 0x1C, 0x00, 0x01, 0xFC, 0x03, 0xC7, 0x03, 0x80,
  0xC3, 0x80, 0x61, 0x80, 0x19, 0x87, 0xCD, 0xCF, 0xE6, 0xC6, 0x63, 0x66,
  0x31, 0xE3, 0x18, 0xF3, 0x0C, 0xD9, 0x8C, 0x6C, 0xC6, 0x36, 0x67, 0x33,
  0x3E, 0xF1, 0x8E, 0x70, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x07, 0xBC,
  0x01, 0xFE, 0x00, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1B, 0x81,
  0xDC, 0x0C, 0xE0, 0x67, 0x07, 0x38, 0x31, 0xC3, 0x8E, 0x1F, 0xF1, 0xFF,
  0x8E, 0x1C, 0xE0, 0xE7, 0x07, 0x70, 0x3B, 0x81, 0xF8, 0x0E, 0x0F, 0xF0,
  0x7F, 0xC3, 0x0E, 0x18, 0x71, 0xC1, 0x8E, 0x1C, 0x70, 0xE3, 0x1E, 0x3F,
  0xE1, 0xFF, 0x0E, 0x38, 0x70, 0xE3, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x1C,
  0x61, 0xE3, 0xFE, 0x3F, 0xC0, 0x00, 0x40, 0x1F, 0xC3, 0xFE, 0x3C, 0x21,
  0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC4, 0x1F, 0xE0,
  0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0xC3, 0x83, 0x07, 0x1C, 0x1C, 0x70,
  0x71, 0xC1, 0xC6, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0x8E, 0x0E, 0x30,
  0x39, 0xC1, 0xC7, 0x07, 0x1C, 0x38, 0x63, 0xC1, 0xFE, 0x0F, 0xE0, 0x00,
  0x0F, 0xF8, 0x7F, 0x83, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x3F, 0xC1, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0x83, 0x00,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xFE, 0x0F,
  0xF0, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x38, 0x00, 0x00, 0x40, 0x0F, 0xF0, 0xFF, 0xC7, 0x82, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x1F, 0xB8, 0x7E, 0xE0,
  0x33, 0x80, 0xCE, 0x07, 0x38, 0x1C, 0x70, 0x71, 0xE1, 0x83, 0xFE, 0x07,
  0xF0, 0x0E, 0x06, 0x1C, 0x1C, 0x30, 0x38, 0x60, 0x71, 0xC0, 0xC3, 0x81,
  0x87, 0x07, 0x0C, 0x0E, 0x1F, 0xFC, 0x7F, 0xF0, 0xE0, 0xE1, 0xC1, 0xC3,
  0x03, 0x8E, 0x07, 0x1C, 0x0C, 0x38, 0x38, 0x70, 0x70, 0xC0, 0xE3, 0x81,
  0x80, 0x0F, 0xE0, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18,
  0x1F, 0xC3, 0xF8, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x3F, 0x07,
  0xC0, 0x0E, 0x1E, 0x1C, 0x38, 0x30, 0xE0, 0x63, 0x81, 0xCE, 0x03, 0x9C,
  0x07, 0x70, 0x0D, 0xC0, 0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xDC, 0x03,
  0x18, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x60, 0xC0, 0xC1, 0xC3, 0x83,
  0x80, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x3F, 0xFF, 0xE0, 0x0F,
  0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0xF0, 0x3E, 0x1F, 0x03, 0xE1,
  0xF0, 0x7E, 0x1B, 0x06, 0xC1, 0xB0, 0xEC, 0x3B, 0x0D, 0xC3, 0xB9, 0xDC,
  0x3B, 0x99, 0xC3, 0x3B, 0x98, 0x33, 0xB1, 0x87, 0x3B, 0x38, 0x71, 0xE3,
  0x87, 0x1E, 0x38, 0x61, 0xC3, 0x06, 0x1C, 0x30, 0xE1, 0x87, 0x00, 0x0F,
  0x03, 0x0F, 0x07, 0x0F, 0x07, 0x0F, 0x07, 0x1F, 0x06, 0x1F, 0x86, 0x1B,
  0x8E, 0x19, 0x8E, 0x39, 0x8C, 0x39, 0xCC, 0x39, 0xCC, 0x30, 0xDC, 0x30,
  0xDC, 0x70, 0xD8, 0x70, 0xF8, 0x70, 0xF8, 0x60, 0x78, 0x60, 0x78, 0xE0,
  0x70, 0x00, 0x80, 0x1F, 0xC0, 0xFF, 0x87, 0x8F, 0x1C, 0x1C, 0xE0, 0x73,
  0x81, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x7E, 0x01, 0xF8, 0x06, 0xE0, 0x3B,
  0x80, 0xEE, 0x03, 0x38, 0x1C, 0xE0, 0xE1, 0xC7, 0x87, 0xFC, 0x0F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x83, 0x1E, 0x18, 0x71, 0xC3, 0x8E, 0x1C, 0x70, 0xE3,
  0x07, 0x38, 0x71, 0xFF, 0x0F, 0xF0, 0x7E, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x00, 0x00, 0x80, 0x1F, 0xC0, 0xFF,
  0x87, 0x8F, 0x1C, 0x1C, 0xE0, 0x73, 0x81, 0xDC, 0x07, 0x70, 0x1D, 0xC0,
  0x7E, 0x01, 0xF8, 0x06, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0x38, 0x1C, 0xE0,
  0xE1, 0xC7, 0x87, 0xFC, 0x0F, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0xE0, 0x7F, 0x83, 0x1E, 0x18, 0x71, 0xC3, 0x8E,
  0x1C, 0x70, 0xE3, 0x0E, 0x18, 0xF1, 0xFF, 0x0F, 0xE0, 0x77, 0x03, 0x18,
  0x38, 0xE1, 0xC7, 0x0E, 0x38, 0x60, 0xC3, 0x07, 0x38, 0x38, 0x01, 0x80,
  0x7F, 0x1F, 0xF1, 0xC2, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xCC,
  0x78, 0xFF, 0x0F, 0xE0, 0x7F, 0xFF, 0xFC, 0x38, 0x06, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x00, 0x1C, 0x1C, 0x70, 0x71, 0x81,
  0xCE, 0x07, 0x38, 0x18, 0xE0, 0xE3, 0x03, 0x8C, 0x0E, 0x70, 0x31, 0xC0,
  0xC7, 0x07, 0x18, 0x1C, 0xE0, 0x73, 0x81, 0x8E, 0x0E, 0x38, 0x38, 0xF1,
  0xC1, 0xFE, 0x03, 0xF0, 0x00, 0xE0, 0x3F, 0x03, 0xB8, 0x1C, 0xC1, 0xC6,
  0x0E, 0x30, 0xE1, 0x87, 0x0C, 0x30, 0x63, 0x83, 0x18, 0x19, 0xC0, 0xCC,
  0x06, 0xE0, 0x37, 0x01, 0xB0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x60, 0x7E, 0x0E, 0x0E, 0xE0, 0xE0, 0xEE, 0x1E, 0x0C, 0xE1, 0xE1,
  0xCE, 0x1E, 0x1C, 0xE3, 0x63, 0x8E, 0x36, 0x38, 0xE7, 0x63, 0x0E, 0x66,
  0x70, 0xE6, 0x66, 0x0E, 0xC6, 0xE0, 0xEC, 0x6E, 0x0F, 0xC6, 0xC0, 0xF8,
  0x7C, 0x0F, 0x87, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x00,
  0x07, 0x07, 0x07, 0x0E, 0x03, 0x1C, 0x03, 0x18, 0x03, 0xB8, 0x03, 0xB0,
  0x03, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x06, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x18, 0x60, 0x38, 0x70, 0x70, 0x70,
  0xF0, 0x70, 0x60, 0xF6, 0x0E, 0x61, 0xC7, 0x1C, 0x73, 0x87, 0x30, 0x77,
  0x03, 0x60, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xE0, 0xF8, 0x18, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xF8, 0x3F,
  0x00, 0xC6, 0x31, 0xCE, 0x31, 0x8C, 0x63, 0x1C, 0xE7, 0x18, 0xC6, 0x31,
  0x8E, 0x07, 0xE0, 0xF8, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC1, 0xF8, 0x3F, 0x00, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x7C, 0x0C, 0xC1, 0xCC, 0x18, 0xE3, 0x86, 0x30, 0x67, 0x07,
  0xE0, 0x30, 0xFF, 0xFF, 0xC0, 0xEE, 0x73, 0x30, 0x0E, 0x31, 0xF7, 0x3D,
  0xE3, 0x8E, 0x70, 0xE6, 0x0E, 0xE0, 0xCE, 0x0C, 0xE1, 0xCE, 0x1C, 0xE1,
  0xCE, 0x38, 0xE7, 0x8F, 0xD8, 0x79, 0x80, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x1D, 0xC1, 0xFE, 0x1F, 0xF1, 0xC7, 0x38, 0x73,
  0x87, 0x38, 0x73, 0x07, 0x30, 0x77, 0x06, 0x70, 0xE7, 0x0E, 0x71, 0xCF,
  0xF8, 0xCF, 0x00, 0x07, 0x87, 0xF3, 0xD8, 0xE0, 0x70, 0x18, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0C, 0x03, 0x80, 0xE2, 0x1F, 0x87, 0xE0, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x39, 0xC3, 0xEE, 0x3D,
  0xE1, 0xC7, 0x1C, 0x38, 0xC1, 0xCE, 0x0C, 0x70, 0x63, 0x87, 0x1C, 0x38,
  0xC1, 0xC7, 0x1C, 0x39, 0xE1, 0xFB, 0x07, 0x98, 0x00, 0x07, 0x07, 0xF3,
  0x9C, 0xC3, 0x70, 0xD8, 0x7E, 0x7B, 0xFC, 0xF0, 0x30, 0x0C, 0x03, 0x80,
  0xE1, 0x1F, 0xC3, 0xF0, 0x00, 0x34, 0x03, 0xE0, 0x0F, 0x80, 0x70, 0x01,
  0xC0, 0x06, 0x00, 0x3E, 0x03, 0xF8, 0x0F, 0xE0, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x03,
  0xE0, 0x0F, 0x00, 0x00, 0x07, 0x18, 0x7D, 0xC7, 0xBC, 0x38, 0xE3, 0x87,
  0x18, 0x39, 0xC1, 0x8E, 0x0C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE3, 0x87,
  0x3C, 0x3F, 0xE0, 0xF7, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x20, 0xE1, 0xFE,
  0x0F, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x1D, 0xC1, 0xFE, 0x1F, 0xF1, 0xC7, 0x38, 0x73, 0x87, 0x38, 0x63, 0x06,
  0x30, 0xE7, 0x0E, 0x70, 0xE7, 0x0C, 0x60, 0xCE, 0x1C, 0xE1, 0xC0, 0x0E,
  0x1C, 0x38, 0x00, 0x03, 0x87, 0x0C, 0x18, 0x70, 0xE1, 0xC3, 0x06, 0x1C,
  0x38, 0x70, 0xC3, 0x87, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0xF0,
  0x3C, 0x00, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0xE3, 0x8E, 0x18, 0xE0, 0xCE, 0x0E, 0xE0, 0x76, 0x03, 0x70, 0x1F,
  0x80, 0xFC, 0x0E, 0x60, 0x73, 0x83, 0x1C, 0x18, 0xE1, 0xC3, 0x0E, 0x1C,
  0x00, 0x06, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0xE1, 0xC3,
  0x86, 0x0C, 0x38, 0x70, 0xE1, 0x87, 0x0E, 0x00, 0x19, 0xC3, 0x86, 0xFB,
  0xF1, 0xFF, 0xFC, 0x71, 0xC7, 0x38, 0x71, 0xCE, 0x18, 0x73, 0x86, 0x1C,
  0xC3, 0x86, 0x30, 0xE1, 0x9C, 0x38, 0xE7, 0x0C, 0x39, 0x83, 0x0E, 0x61,
  0xC3, 0x38, 0x70, 0xCE, 0x18, 0x70, 0x19, 0xC1, 0xBE, 0x1F, 0xF1, 0xC7,
  0x38, 0x73, 0x87, 0x38, 0x63, 0x06, 0x30, 0xE7, 0x0E, 0x70, 0xE7, 0x0C,
  0x61, 0xCE, 0x1C, 0xE1, 0xC0, 0x07, 0x03, 0xF8, 0xF7, 0x38, 0x77, 0x0E,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xD8, 0x3B, 0x07, 0x71, 0xCE, 0x38, 0xFE,
  0x0F, 0x80, 0x0C, 0xE0, 0x6F, 0x83, 0xEE, 0x1C, 0x71, 0xC3, 0x8E, 0x1C,
  0x70, 0xE3, 0x07, 0x18, 0x39, 0xC1, 0x8E, 0x1C, 0x70, 0xE3, 0x8E, 0x3F,
  0xE1, 0xDE, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x0E, 0x31, 0xFF, 0x3D, 0xE3, 0x8E, 0x70, 0xE6, 0x0E, 0xE0, 0xCE,
  0x0C, 0xE1, 0xCE, 0x1C, 0xC1, 0xCE, 0x38, 0xE7, 0x8F, 0xF8, 0x7B, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x19, 0xC6, 0xF1,
  0xF8, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0,
  0x60, 0x38, 0x0E, 0x00, 0x0F, 0x07, 0xF3, 0x98, 0xC0, 0x30, 0x0E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x87, 0x3F, 0x8F, 0xC0, 0x0C,
  0x30, 0x61, 0xF7, 0xFF, 0xCC, 0x38, 0x70, 0xE1, 0x83, 0x0E, 0x1C, 0x38,
  0x70, 0xF8, 0xF0, 0x38, 0x73, 0x86, 0x30, 0x63, 0x0E, 0x70, 0xE7, 0x0C,
  0x60, 0xC6, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0x8E, 0x38, 0xE7, 0x8F, 0xD8,
  0x7B, 0x80, 0xC1, 0xF0, 0x7C, 0x3B, 0x0E, 0xC7, 0x31, 0xCC, 0x63, 0x38,
  0xCC, 0x37, 0x0D, 0x83, 0xE0, 0xF0, 0x3C, 0x0E, 0x00, 0xC3, 0x87, 0xC3,
  0x87, 0xC7, 0x86, 0xC7, 0x8E, 0xC7, 0x8C, 0xCD, 0x9C, 0xCD, 0x98, 0xDD,
  0x98, 0xD9, 0xB8, 0xD9, 0xB0, 0xF1, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xE1,
  0xC0, 0xE1, 0xC0, 0x1C, 0x38, 0xE3, 0x83, 0x1C, 0x19, 0xC0, 0xFC, 0x07,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xE0, 0x77, 0x07, 0x18,
  0x38, 0xE3, 0x87, 0x00, 0x0C, 0x1C, 0x30, 0x70, 0xC3, 0x83, 0x0E, 0x0C,
  0x30, 0x31, 0xC0, 0xC6, 0x03, 0x38, 0x0C, 0xC0, 0x37, 0x00, 0xD8, 0x03,
  0x60, 0x0F, 0x00, 0x3C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01,
  0x80, 0x3E, 0x00, 0xF0, 0x00, 0x0F, 0xE3, 0xFC, 0x7F, 0x00, 0xE0, 0x38,
  0x06, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xFE,
  0x3F, 0xC0, 0x01, 0xE0, 0x78, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80,
  0x70, 0x0E, 0x03, 0x81, 0xE0, 0x30, 0x0F, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x78, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x03, 0xC0, 0x70, 0x0C, 0x03, 0x01,
  0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x7C, 0x06, 0x07, 0x83, 0x81, 0xC0,
  0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x3C, 0x0E, 0x00, 0x7C, 0x3F,
  0xFE, 0x1F, 0x80,
};

const GFXglyph NotoSans_Condensed_MediumItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 19, 7, 0, -19 },
  { 18, 8, 7, 10, 3, -19 },
  { 25, 14, 19, 14, 0, -19 },
  { 59, 12, 23, 12, 0, -21 },
  { 94, 16, 20, 19, 2, -20 },
  { 134, 14, 20, 14, 0, -20 },
  { 169, 4, 7, 6, 3, -19 },
  { 173, 8, 23, 7, 1, -19 },
  { 196, 9, 23, 7, -2, -19 },
  { 222, 9, 11, 12, 3, -21 },
  { 235, 11, 13, 13, 1, -16 },
  { 253, 5, 7, 6, -1, -3 },
  { 258, 7, 2, 8, 0, -8 },
  { 260, 4, 3, 6, 0, -3 },
  { 262, 13, 19, 10, -1, -19 },
  { 293, 11, 20, 12, 1, -20 },
  { 321, 8, 19, 12, 3, -19 },
  { 340, 13, 20, 12, -1, -20 },
  { 373, 12, 20, 12, 0, -20 },
  { 403, 12, 19, 12, 0, -19 },
  { 432, 12, 19, 12, 0, -19 },
  { 461, 12, 20, 12, 1, -20 },
  { 491, 12, 19, 12, 1, -19 },
  { 520, 12, 20, 12, 0, -20 },
  { 550, 12, 20, 12, 0, -20 },
  { 580, 6, 15, 6, 0, -15 },
  { 592, 7, 19, 6, -1, -15 },
  { 609, 11, 13, 13, 1, -16 },
  { 627, 11, 7, 13, 1, -13 },
  { 637, 11, 13, 13, 1, -16 },
  { 655, 9, 20, 9, 1, -20 },
  { 678, 17, 21, 18, 1, -19 },
  { 723, 13, 19, 13, -2, -19 },
  { 754, 13, 19, 13, 0, -19 },
  { 785, 13, 20, 12, 1, -20 },
  { 818, 14, 19, 14, 0, -19 },
  { 852, 13, 19, 11, 0, -19 },
  { 883, 13, 19, 11, 0, -19 },
  { 914, 14, 20, 15, 1, -20 },
  { 949, 15, 19, 15, 0, -19 },
  { 985, 11, 19, 8, -1, -19 },
  { 1012, 11, 24, 6, -4, -19 },
  { 1045, 15, 19, 13, 0, -19 },
  { 1081, 9, 19, 11, 0, -19 },
  { 1103, 20, 19, 19, 0, -19 },
  { 1151, 16, 19, 16, 0, -19 },
  { 1189, 14, 20, 16, 1, -20 },
  { 1224, 13, 19, 13, 0, -19 },
  { 1255, 14, 25, 16, 1, -20 },
  { 1299, 13, 19, 13, 0, -19 },
  { 1330, 12, 20, 11, 0, -20 },
  { 1360, 11, 19, 11, 2, -19 },
  { 1387, 14, 19, 15, 1, -19 },
  { 1421, 13, 19, 13, 2, -19 },
  { 1452, 20, 19, 20, 2, -19 },
  { 1500, 16, 19, 12, -2, -19 },
  { 1538, 12, 19, 11, 2, -19 },
  { 1567, 14, 19, 11, -1, -19 },
  { 1601, 11, 23, 8, -1, -19 },
  { 1633, 5, 19, 10, 3, -19 },
  { 1645, 11, 23, 8, -2, -19 },
  { 1677, 12, 11, 12, 0, -19 },
  { 1694, 9, 2, 9, -2, 2 },
  { 1697, 4, 5, 7, 4, -21 },
  { 1700, 12, 15, 13, 1, -15 },
  { 1723, 12, 21, 13, 0, -21 },
  { 1755, 10, 15, 10, 1, -15 },
  { 1774, 13, 21, 13, 1, -21 },
  { 1809, 10, 15, 12, 1, -15 },
  { 1828, 14, 27, 7, -3, -21 },
  { 1876, 13, 21, 13, 0, -15 },
  { 1911, 12, 21, 13, 0, -21 },
  { 1943, 7, 20, 6, 0, -20 },
  { 1961, 10, 26, 6, -3, -20 },
  { 1994, 13, 21, 11, 0, -21 },
  { 2029, 7, 21, 6, 0, -21 },
  { 2048, 18, 15, 19, 0, -15 },
  { 2082, 12, 15, 13, 0, -15 },
  { 2105, 11, 15, 13, 1, -15 },
  { 2126, 13, 21, 13, -1, -15 },
  { 2161, 12, 21, 13, 1, -15 },
  { 2193, 10, 15, 9, 0, -15 },
  { 2212, 10, 15, 10, 0, -15 },
  { 2231, 7, 18, 8, 1, -18 },
  { 2247, 12, 15, 13, 1, -15 },
  { 2270, 10, 15, 11, 2, -15 },
  { 2289, 16, 15, 17, 2, -15 },
  { 2319, 13, 15, 11, -1, -15 },
  { 2344, 14, 21, 11, -2, -15 },
  { 2381, 11, 15, 9, -1, -15 },
  { 2402, 11, 23, 9, 0, -19 },
  { 2434, 2, 27, 11, 5, -21 },
  { 2441, 10, 23, 9, -1, -19 },
  { 2470, 11, 3, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_MediumItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC27PT7B_H_
