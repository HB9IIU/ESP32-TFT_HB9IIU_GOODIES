#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC60PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0x00, 0x00,
  0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3E, 0x0F, 0x8F,
  0x87, 0xE7, 0xE1, 0xF9, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1,
  0xF1, 0xE0, 0x78, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xC3, 0xC0, 0xF0,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00,
  0xF0, 0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x3C, 0x0F, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x81,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xDD, 0xF8, 0x0F, 0xC6, 0x0C, 0x07, 0xE3, 0x80,
  0x01, 0xF0, 0xE0, 0x00, 0x7C, 0x38, 0x00, 0x1F, 0x0E, 0x00, 0x07, 0xC3,
  0x00, 0x01, 0xF1, 0xC0, 0x00, 0x7E, 0x70, 0x00, 0x1F, 0xDC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1D, 0xFC, 0x00, 0x07, 0x3F, 0x00, 0x01, 0x8F, 0xC0, 0x00,
  0xE1, 0xF0, 0x00, 0x38, 0x7C, 0x00, 0x0E, 0x1F, 0x00, 0x03, 0x8F, 0xC2,
  0x01, 0xC3, 0xF0, 0xC0, 0x71, 0xF8, 0x3E, 0x1C, 0xFE, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x3F, 0xE0, 0x00, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0x00,
  0x7F, 0xF0, 0x01, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x01, 0xF0, 0xF8, 0x07,
  0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0xF0, 0x03, 0xC0, 0xF8, 0x1F, 0x00, 0x3C, 0x0F, 0x83, 0xE0, 0x07,
  0xC0, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x07, 0xC0, 0x07, 0x80, 0xF0, 0x78,
  0x00, 0x78, 0x1F, 0x0F, 0x80, 0x07, 0x81, 0xF0, 0xF0, 0x00, 0xF8, 0x1E,
  0x1F, 0x00, 0x0F, 0x81, 0xE3, 0xE1, 0xFC, 0xF8, 0x3E, 0x3C, 0x3F, 0xEF,
  0x83, 0xC7, 0xC7, 0xFE, 0xF8, 0x7C, 0x78, 0xFF, 0xF7, 0x8F, 0x8F, 0x9F,
  0x1F, 0x7F, 0xF9, 0xF1, 0xF0, 0xF7, 0xFF, 0x1E, 0x3E, 0x0F, 0x3F, 0xE3,
  0xE3, 0xC0, 0xF1, 0xFC, 0x3C, 0x7C, 0x0F, 0x00, 0x07, 0xC7, 0xC0, 0xF0,
  0x00, 0xF8, 0x78, 0x0F, 0x00, 0x0F, 0x87, 0x81, 0xF0, 0x01, 0xF0, 0xF8,
  0x1F, 0x00, 0x1E, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xF8, 0x1E, 0x00, 0x7C,
  0x0F, 0x01, 0xE0, 0x07, 0xC0, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x03, 0xE0,
  0x0F, 0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x0F, 0x07, 0xC0, 0x3E, 0x00, 0xF0,
  0x78, 0x03, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x00, 0xFF, 0xF0, 0x07, 0x80,
  0x07, 0xFE, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x7C, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F,
  0x1F, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0x83, 0xFF, 0xE0,
  0x7E, 0x0F, 0xEF, 0xE0, 0xFC, 0x3F, 0x8F, 0xC1, 0xF0, 0x7E, 0x1F, 0xC7,
  0xE1, 0xF8, 0x1F, 0x8F, 0x83, 0xE0, 0x3F, 0x3F, 0x0F, 0xC0, 0x3F, 0x7C,
  0x1F, 0x80, 0x7F, 0xF8, 0x3E, 0x00, 0x7F, 0xE0, 0xFC, 0x00, 0xFF, 0xC1,
  0xF8, 0x00, 0xFF, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF8, 0x0F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xC0, 0x7F, 0xF0, 0x1F, 0xE3, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xCF, 0xC0, 0x3F, 0xFE, 0x1F, 0xC0, 0x3F,
  0xF8, 0x1F, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3,
  0xE1, 0xF0, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0x87, 0xC3, 0xE1,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0x01,
  0xF0, 0x07, 0x07, 0xC0, 0x1F, 0x1E, 0x00, 0xFF, 0x78, 0x0B, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xE0, 0x30,
  0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0x9E, 0x00, 0xFC, 0x7C, 0x07, 0xF1,
  0xF0, 0x0F, 0x83, 0xE0, 0x1C, 0x0F, 0x80, 0x20, 0x3F, 0x00, 0x00, 0xE0,
  0x00, 0x02, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC,
  0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0xF8, 0x00, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF,
  0xFF, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x20, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xE1, 0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0x3E, 0x07,
  0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0x83, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF1,
  0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x3E,
  0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xF9, 0xF8, 0x00,
  0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x07, 0xE1, 0xF0,
  0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x1F,
  0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xBE, 0x7F,
  0xBF, 0x3F, 0x1F, 0x8F, 0x0F, 0x87, 0x0F, 0xC1, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xE0,
  0x0F, 0xC0, 0x06, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xE0, 0x3F, 0x80, 0x30, 0x03, 0xF8,
  0x04, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x08, 0x00, 0x3F, 0x81, 0xC0, 0x0F, 0xF0, 0x3F, 0x9F, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3C, 0xF8, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF1,
  0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x3F, 0x00,
  0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xE0,
  0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE2, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xDF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x08, 0x00, 0x3F, 0x81, 0xC0, 0x0F, 0xF0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x0F, 0xE0,
  0x0F, 0xCF, 0xFC, 0x03, 0xF7, 0xFF, 0x80, 0xFB, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xF0, 0x7F, 0x07, 0xF8, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x7E,
  0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF8,
  0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0,
  0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xF3, 0xFE, 0x01,
  0xF8, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x03,
  0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F,
  0x00, 0x7E, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC1, 0xFC,
  0x00, 0xFC, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xDF, 0xC0, 0x0F, 0xF1, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x07,
  0xE3, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0xFE,
  0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F,
  0x0F, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xE3, 0xF0, 0x03,
  0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00,
  0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0,
  0x0F, 0xF1, 0xF8, 0x0F, 0xF0, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xBE, 0x03, 0xFF, 0xBF, 0x00, 0x7F, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0F,
  0x80, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7C, 0x00, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x3F,
  0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0x01, 0xFC,
  0x20, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x80,
  0x1F, 0x07, 0xC0, 0x3F, 0xF0, 0x7C, 0x3E, 0x03, 0xFF, 0xE0, 0xF0, 0xF0,
  0x1F, 0xFF, 0x83, 0xC7, 0xC0, 0xFC, 0x3C, 0x0F, 0x1E, 0x03, 0xE0, 0xF0,
  0x3C, 0x78, 0x1F, 0x07, 0xC0, 0xF3, 0xE0, 0xF8, 0x1F, 0x07, 0xCF, 0x03,
  0xC0, 0x78, 0x1F, 0x3C, 0x1F, 0x01, 0xE0, 0x79, 0xF0, 0x78, 0x0F, 0x81,
  0xE7, 0x81, 0xE0, 0x3E, 0x07, 0x9E, 0x0F, 0x80, 0xF0, 0x1E, 0x78, 0x3E,
  0x07, 0xC0, 0xFB, 0xE0, 0xF0, 0x1F, 0x03, 0xCF, 0x83, 0xC0, 0x7C, 0x0F,
  0x3C, 0x0F, 0x03, 0xE0, 0x7C, 0xF0, 0x3C, 0x0F, 0x81, 0xE3, 0xC0, 0xF0,
  0x3E, 0x0F, 0x8F, 0x03, 0xC1, 0xF8, 0x3C, 0x3C, 0x0F, 0x0F, 0xE1, 0xE0,
  0xF0, 0x3F, 0x7B, 0xDF, 0x83, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F, 0x01, 0xFE,
  0x3F, 0xE0, 0x3E, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x08, 0x00, 0x03, 0xF8, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00,
  0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE0,
  0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x7E,
  0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFE, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x7F, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7C,
  0x07, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x01, 0xF8, 0x03,
  0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0,
  0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0xC0, 0xFC,
  0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xF8, 0x1F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01,
  0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0,
  0x3F, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFC,
  0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x01, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0x01, 0xC0, 0x1F, 0xE0, 0x04, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x70, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xF1, 0xFF, 0xC0, 0x1F, 0x80, 0x7F, 0x80, 0x7E, 0x00, 0xFE,
  0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x01,
  0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E,
  0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0xC0, 0x7E, 0x03, 0xFE,
  0x01, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x1E, 0x00, 0xFF, 0x00, 0x0C, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x1F, 0xFE, 0x3F, 0x80, 0x3F, 0xFC, 0x7E, 0x00, 0x7F,
  0xF8, 0xFC, 0x00, 0xFF, 0xE1, 0xF8, 0x03, 0xFF, 0xC3, 0xF0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x07,
  0xE0, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0x0F, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x7E, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0x80,
  0x07, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F,
  0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x33, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x01, 0xF8,
  0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xF8,
  0x3F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x07, 0xDF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xF7,
  0xE0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x3E, 0xF8, 0x00, 0x7D, 0xF8, 0x07, 0xDF, 0x00, 0x1F, 0xBE,
  0x00, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x3F, 0x3E, 0x00, 0xFD, 0xF8, 0x07,
  0xE7, 0xC0, 0x1F, 0x3F, 0x00, 0xF8, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0x7C, 0x07,
  0xC7, 0xE0, 0x1F, 0x8F, 0x80, 0xF8, 0xFC, 0x03, 0xE1, 0xF0, 0x3E, 0x1F,
  0x80, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xC1, 0xF0, 0xFC, 0x03,
  0xF0, 0xF8, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x0F, 0x83, 0xF0, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x7C, 0x0F, 0x80, 0x7E, 0x0F, 0x8F,
  0x83, 0xF0, 0x0F, 0xC1, 0xF3, 0xE0, 0x7E, 0x01, 0xF8, 0x3E, 0x7C, 0x0F,
  0xC0, 0x3E, 0x03, 0xDF, 0x01, 0xF0, 0x07, 0xC0, 0x7F, 0xE0, 0x7E, 0x01,
  0xF8, 0x0F, 0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xFF, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFF,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0x00, 0xFC, 0x03, 0xFC,
  0x00, 0x1F, 0x80, 0x7F, 0x80, 0x03, 0xF0, 0x0F, 0xF0, 0x00, 0x7C, 0x01,
  0xFF, 0x00, 0x0F, 0x80, 0x7F, 0xE0, 0x03, 0xF0, 0x0F, 0xFC, 0x00, 0x7E,
  0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x3F, 0xF0, 0x01, 0xF0, 0x0F, 0xFF, 0x00,
  0x3E, 0x01, 0xFB, 0xE0, 0x0F, 0xC0, 0x3E, 0x7C, 0x01, 0xF8, 0x07, 0xCF,
  0x80, 0x3E, 0x00, 0xF9, 0xF8, 0x07, 0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0x07,
  0xE3, 0xE0, 0x3F, 0x00, 0xFC, 0x7C, 0x07, 0xE0, 0x1F, 0x0F, 0x80, 0xF8,
  0x03, 0xE1, 0xF8, 0x1F, 0x00, 0xFC, 0x1F, 0x07, 0xE0, 0x1F, 0x83, 0xE0,
  0xFC, 0x03, 0xE0, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0xC3, 0xE0, 0x1F, 0x81,
  0xF8, 0x7C, 0x03, 0xF0, 0x1F, 0x1F, 0x80, 0x7E, 0x03, 0xE3, 0xF0, 0x0F,
  0x80, 0x7E, 0x7C, 0x01, 0xF0, 0x0F, 0xCF, 0x80, 0x7E, 0x00, 0xF9, 0xF0,
  0x0F, 0xC0, 0x1F, 0x7E, 0x01, 0xF8, 0x03, 0xEF, 0xC0, 0x3E, 0x00, 0x7F,
  0xF0, 0x07, 0xC0, 0x0F, 0xFE, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0x00,
  0x1F, 0xF8, 0x07, 0xE0, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x1F,
  0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xE0,
  0x1F, 0x00, 0x03, 0xFC, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x80, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF0,
  0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0xFC, 0x7E,
  0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0xFD, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x3F, 0x7E, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xEF,
  0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F,
  0xC0, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0x83, 0xFE, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0x7F, 0x01,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00,
  0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0,
  0x0F, 0xC0, 0x7C, 0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0x80, 0xFC, 0x7F, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x1F,
  0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC,
  0x1F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x1F,
  0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x07, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0x83, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x03, 0xF0,
  0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0,
  0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0xC0, 0x7C, 0x07, 0xF8, 0x0F, 0xC3, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x1F,
  0x83, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F,
  0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x00,
  0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0,
  0x3E, 0x01, 0xFE, 0x00, 0x40, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x04, 0x00, 0x0F, 0xC0, 0x60, 0x01,
  0xFC, 0x07, 0x80, 0x7F, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xF8,
  0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x0F,
  0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF0,
  0x01, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xE0,
  0x7F, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0x7C,
  0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF8, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03,
  0xF0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x07,
  0xC0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x3F, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xEF, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xCF, 0xC0, 0x07, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0x8F,
  0xC0, 0x0F, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0x0F, 0xC0,
  0x0F, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xFF, 0x80, 0x7E, 0x0F, 0xC0, 0x1F,
  0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xEF, 0x80, 0x7E, 0x0F, 0xC0, 0x3E, 0xF8,
  0x0F, 0xC0, 0xFC, 0x07, 0xCF, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xCF, 0x81, 0xF8, 0x0F, 0xC0, 0xF8, 0xF8, 0x1F, 0x00,
  0xFC, 0x0F, 0x8F, 0x83, 0xF0, 0x0F, 0xC1, 0xF0, 0xF0, 0x3F, 0x00, 0xFC,
  0x1F, 0x0F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0xF0, 0x7E, 0x00, 0xFC, 0x3E,
  0x0F, 0x07, 0xC0, 0x0F, 0xC3, 0xE0, 0xF0, 0xFC, 0x00, 0xFC, 0x7C, 0x0F,
  0x0F, 0xC0, 0x0F, 0xC7, 0xC0, 0xF1, 0xF8, 0x00, 0xFC, 0x7C, 0x0F, 0x1F,
  0x80, 0x0F, 0xCF, 0x80, 0xF1, 0xF0, 0x00, 0xFC, 0xF8, 0x0F, 0x3F, 0x00,
  0x0F, 0xDF, 0x00, 0xF3, 0xF0, 0x00, 0xFD, 0xF0, 0x0F, 0x3E, 0x00, 0x0F,
  0xDF, 0x00, 0xF7, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x00, 0x0F, 0xBE,
  0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x03,
  0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xE7, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xFC, 0x7E, 0x00,
  0x7E, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x3E,
  0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x7E,
  0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7C,
  0x0F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x01,
  0xF0, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE7, 0xE0,
  0x00, 0xF9, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0xFC, 0x7F, 0x1F, 0x8F,
  0xC3, 0xF1, 0xF8, 0x7C, 0x1F, 0x07, 0x83, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xF1, 0xF0, 0x1F, 0xFE, 0x7C, 0x0F, 0xFF, 0xBF, 0x03, 0xFF, 0xFF,
  0xC1, 0xFE, 0x3F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0xC0,
  0x3F, 0x87, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0,
  0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x7F, 0x83,
  0xF8, 0x3F, 0xE0, 0xFF, 0x3F, 0xF0, 0x1F, 0xFF, 0x7C, 0x07, 0xFF, 0x9F,
  0x00, 0xFF, 0xC7, 0xC0, 0x1F, 0xE1, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x7E,
  0x7F, 0xC0, 0x0F, 0x9F, 0xFC, 0x01, 0xF7, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFC, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xF0,
  0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0xFC, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0xC3, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0x81, 0xFC,
  0x07, 0xF0, 0x7F, 0xC1, 0xFC, 0x0F, 0xFC, 0x7F, 0x01, 0xF7, 0xFF, 0xE0,
  0x3E, 0xFF, 0xF8, 0x07, 0x8F, 0xFE, 0x01, 0xF0, 0xFF, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xE0, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x40, 0x7F, 0x8F, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0x83, 0xE0, 0x01, 0xFF, 0x3F, 0x00, 0x3F, 0xFD, 0xF8, 0x03, 0xFF,
  0xEF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFC, 0x3F, 0xE0, 0x1F, 0xC0, 0xFF,
  0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x07,
  0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80,
  0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F,
  0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x07,
  0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xC0,
  0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0xFF,
  0x00, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xFF, 0x7C, 0x00,
  0xFF, 0xF3, 0xE0, 0x03, 0xFF, 0x1F, 0x00, 0x0F, 0xF0, 0xF8, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0x0F, 0x83, 0xF8, 0x1F, 0x87,
  0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF8,
  0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0xFF, 0x1F, 0xBF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x02, 0x07,
  0xF0, 0x3C, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFC, 0x20, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xC7, 0xC0, 0x07, 0xFF,
  0x3E, 0x00, 0xFF, 0xF9, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0x8F, 0xF8,
  0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0x80, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x01, 0xF8,
  0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00,
  0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x3F, 0xC0, 0x3F, 0x83, 0xFE, 0x01, 0xFE, 0x7F, 0xE0, 0x07,
  0xFF, 0xDF, 0x00, 0x3F, 0xFD, 0xF8, 0x00, 0xFF, 0xCF, 0xC0, 0x03, 0xFC,
  0x7E, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x80, 0x03, 0xF0, 0x07, 0x00, 0x7F, 0x80, 0x3F, 0xDF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x1F, 0x00, 0x1F, 0x9F, 0xF0, 0x07, 0xCF, 0xFE, 0x01, 0xF7, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xF1, 0xFC, 0x0F, 0xF0, 0x3F, 0x03, 0xF8,
  0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07,
  0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0x7C, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7C,
  0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0,
  0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F,
  0xC1, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x00, 0x00,
  0x1C, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x01, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x01, 0xF0,
  0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xE0,
  0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x7E,
  0x7F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xC0, 0x01, 0xFC, 0xFC,
  0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x03,
  0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7C, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF1, 0xFF, 0x07,
  0xFC, 0x01, 0xF3, 0xFF, 0x8F, 0xFE, 0x01, 0xE7, 0xFF, 0x9F, 0xFF, 0x03,
  0xEF, 0xFF, 0xBF, 0xFF, 0x03, 0xFE, 0x1F, 0xFC, 0x7F, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x03, 0xF0, 0x0F, 0xE0, 0x3F,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x00, 0xFC,
  0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x01,
  0xF8, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xF8,
  0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x7C, 0x7F, 0xC0, 0x1F, 0x3F, 0xF8, 0x07, 0x9F,
  0xFF, 0x03, 0xEF, 0xFF, 0xC0, 0xFF, 0xC7, 0xF0, 0x3F, 0xC0, 0xFC, 0x0F,
  0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xE1, 0xF8,
  0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1,
  0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC,
  0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xF0,
  0x7F, 0xBF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0xFF, 0x80, 0x03, 0xE7, 0xFF, 0x00, 0x0F, 0xBF, 0xFE, 0x00, 0x7D, 0xFF,
  0xF8, 0x01, 0xF7, 0x8F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xC0,
  0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xF8,
  0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x01,
  0xFE, 0x0F, 0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xF9,
  0xFF, 0xE0, 0x03, 0xE7, 0xFF, 0x00, 0x0F, 0x8F, 0xF0, 0x00, 0x7E, 0x06,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF1, 0xF0, 0x0F, 0xFE,
  0x7C, 0x07, 0xFF, 0x9F, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x3F, 0xE0, 0xFE,
  0x07, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xC3,
  0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F,
  0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF8,
  0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x7F, 0x83, 0xF8, 0x3F, 0xE0, 0xFF, 0x3F,
  0xF0, 0x1F, 0xFF, 0x7C, 0x07, 0xFF, 0xBF, 0x00, 0xFF, 0xCF, 0xC0, 0x1F,
  0xE3, 0xF0, 0x00, 0xC0, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x07, 0xC7, 0xF0, 0x1F, 0x3F, 0x80, 0x79, 0xFE, 0x03,
  0xEF, 0xF8, 0x0F, 0xBF, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x81, 0xC0,
  0xFC, 0x01, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x08, 0x00, 0xFC, 0x30, 0x07, 0xF0,
  0xF8, 0x7F, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0x04, 0x00, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0xFF,
  0x9F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC4, 0x0F, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x06, 0x00, 0x00, 0x07, 0xE0, 0x0F,
  0xC1, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xF8,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xF8, 0x01,
  0xF8, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83,
  0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0xFF,
  0x03, 0xFD, 0xFF, 0xC0, 0xFF, 0xFD, 0xF0, 0x1F, 0xFE, 0x7C, 0x07, 0xFF,
  0x1E, 0x00, 0x7F, 0x87, 0x80, 0x03, 0x02, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7C, 0x01, 0xF8,
  0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0,
  0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0,
  0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x3F, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xFC, 0x00,
  0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x3D, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x03, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0x80, 0x7E, 0xF8, 0x07, 0xF8, 0x07, 0xEF, 0x80,
  0x7F, 0x80, 0x7C, 0xF8, 0x0F, 0xF8, 0x0F, 0xCF, 0x80, 0xFF, 0x80, 0xF8,
  0xF8, 0x0F, 0xF8, 0x1F, 0x8F, 0x81, 0xFF, 0x81, 0xF8, 0xF8, 0x1E, 0xF8,
  0x1F, 0x0F, 0x83, 0xEF, 0x83, 0xF0, 0xF8, 0x3E, 0xF8, 0x3E, 0x0F, 0x83,
  0xCF, 0x87, 0xE0, 0xF8, 0x7C, 0xF8, 0x7C, 0x0F, 0x87, 0xCF, 0x87, 0xC0,
  0xF8, 0xF8, 0xF8, 0xFC, 0x0F, 0x8F, 0x8F, 0x8F, 0x80, 0xF8, 0xF0, 0xF9,
  0xF8, 0x0F, 0x9F, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0xF9, 0xF0, 0x0F, 0xBE,
  0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0xF3, 0xE0, 0x0F, 0xBC, 0x0F, 0x7E, 0x00,
  0xFF, 0xC0, 0xF7, 0xC0, 0x0F, 0xFC, 0x0F, 0x7C, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xFC, 0x00, 0xF8, 0x0F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0x3F, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x3F,
  0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x01,
  0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x3F,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0xBF, 0xFC, 0x00, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFA, 0x00,
  0x3F, 0xF9, 0x00, 0x03, 0xF0,
};

const GFXglyph NotoSans_Condensed_MediumItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 15, 44, 15, 1, -43 },
  { 84, 18, 16, 22, 6, -43 },
  { 120, 30, 43, 30, 1, -43 },
  { 282, 26, 49, 27, 1, -46 },
  { 442, 36, 44, 41, 3, -43 },
  { 640, 31, 44, 31, 0, -43 },
  { 811, 9, 16, 13, 6, -43 },
  { 829, 20, 52, 16, 1, -43 },
  { 959, 20, 52, 17, -5, -43 },
  { 1089, 22, 24, 26, 6, -46 },
  { 1155, 24, 28, 29, 3, -35 },
  { 1239, 12, 15, 14, -3, -7 },
  { 1262, 15, 6, 17, 1, -19 },
  { 1274, 7, 9, 14, 1, -8 },
  { 1282, 29, 43, 21, -3, -43 },
  { 1438, 25, 44, 27, 2, -43 },
  { 1576, 17, 43, 27, 7, -43 },
  { 1668, 29, 43, 27, -2, -43 },
  { 1824, 27, 44, 27, 0, -43 },
  { 1973, 28, 43, 27, -1, -43 },
  { 2124, 27, 44, 27, 0, -43 },
  { 2273, 26, 44, 27, 2, -43 },
  { 2416, 27, 43, 27, 2, -43 },
  { 2562, 27, 44, 27, 0, -43 },
  { 2711, 25, 44, 27, 1, -43 },
  { 2849, 13, 34, 14, 0, -33 },
  { 2905, 16, 41, 14, -3, -33 },
  { 2987, 24, 29, 29, 3, -36 },
  { 3074, 24, 17, 29, 3, -30 },
  { 3125, 24, 29, 29, 3, -36 },
  { 3212, 21, 44, 21, 2, -43 },
  { 3328, 38, 48, 41, 2, -43 },
  { 3556, 29, 43, 28, -4, -43 },
  { 3712, 29, 43, 30, 1, -43 },
  { 3868, 28, 45, 28, 3, -44 },
  { 4026, 30, 43, 32, 1, -43 },
  { 4188, 27, 43, 25, 1, -43 },
  { 4334, 27, 43, 24, 1, -43 },
  { 4480, 31, 45, 33, 3, -44 },
  { 4655, 33, 43, 33, 1, -43 },
  { 4833, 24, 43, 18, -2, -43 },
  { 4962, 25, 55, 14, -9, -43 },
  { 5134, 32, 43, 28, 1, -43 },
  { 5306, 19, 43, 24, 1, -43 },
  { 5409, 43, 43, 43, 1, -43 },
  { 5641, 35, 43, 35, 1, -43 },
  { 5830, 30, 44, 34, 3, -43 },
  { 5995, 28, 43, 28, 1, -43 },
  { 6146, 30, 53, 34, 3, -43 },
  { 6345, 28, 43, 29, 1, -43 },
  { 6496, 28, 44, 25, -1, -43 },
  { 6650, 24, 43, 24, 5, -43 },
  { 6779, 31, 44, 33, 3, -43 },
  { 6950, 28, 43, 28, 5, -43 },
  { 7101, 44, 43, 44, 5, -43 },
  { 7338, 34, 43, 26, -3, -43 },
  { 7521, 26, 43, 25, 5, -43 },
  { 7661, 30, 43, 24, -2, -43 },
  { 7823, 24, 53, 17, -2, -43 },
  { 7982, 11, 43, 21, 6, -43 },
  { 8042, 23, 53, 17, -4, -43 },
  { 8195, 26, 25, 27, 1, -43 },
  { 8277, 21, 4, 20, -5, 5 },
  { 8288, 9, 10, 16, 9, -46 },
  { 8300, 26, 34, 29, 2, -33 },
  { 8411, 27, 47, 29, 0, -46 },
  { 8570, 22, 34, 22, 2, -33 },
  { 8664, 29, 47, 29, 2, -46 },
  { 8835, 23, 34, 26, 2, -33 },
  { 8933, 30, 60, 16, -7, -46 },
  { 9158, 29, 47, 29, -1, -33 },
  { 9329, 26, 46, 28, 0, -46 },
  { 9479, 15, 45, 13, 0, -45 },
  { 9564, 23, 59, 13, -8, -45 },
  { 9734, 28, 46, 25, 0, -46 },
  { 9895, 16, 46, 13, 0, -46 },
  { 9987, 40, 33, 42, 0, -33 },
  { 10152, 26, 33, 28, 0, -33 },
  { 10260, 24, 34, 28, 2, -33 },
  { 10362, 30, 47, 29, -3, -33 },
  { 10539, 26, 47, 29, 2, -33 },
  { 10692, 22, 33, 19, 0, -33 },
  { 10783, 22, 34, 22, 0, -33 },
  { 10877, 17, 41, 17, 2, -40 },
  { 10965, 26, 33, 28, 2, -32 },
  { 11073, 24, 32, 24, 3, -32 },
  { 11169, 36, 32, 37, 4, -32 },
  { 11313, 29, 32, 24, -3, -32 },
  { 11429, 32, 46, 24, -5, -32 },
  { 11613, 24, 32, 21, -2, -32 },
  { 11709, 23, 52, 20, 1, -43 },
  { 11859, 5, 60, 25, 10, -46 },
  { 11897, 22, 52, 20, -3, -43 },
  { 12040, 25, 8, 29, 3, -25 },
};

const GFXfont NotoSans_Condensed_MediumItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC60PT7B_H_
