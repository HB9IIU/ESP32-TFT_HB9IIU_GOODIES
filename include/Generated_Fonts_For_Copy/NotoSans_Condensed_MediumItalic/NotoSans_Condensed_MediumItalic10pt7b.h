#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC10PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x24, 0x20, 0xB4, 0x29, 0x5E, 0xAF, 0xB2, 0x80, 0x11, 0xD8,
  0xC2, 0x1B, 0x4C, 0x40, 0xCB, 0x4D, 0xBD, 0x55, 0x69, 0x80, 0x32, 0x94,
  0xCA, 0xCB, 0xE0, 0xC0, 0x29, 0x29, 0x24, 0x40, 0x24, 0x92, 0x4A, 0x80,
  0x2C, 0x7A, 0x21, 0x3E, 0x42, 0x00, 0xC0, 0xE0, 0x80, 0x12, 0x24, 0x48,
  0x80, 0x35, 0x59, 0x99, 0x60, 0x75, 0x24, 0xB0, 0x71, 0x12, 0x24, 0xF0,
  0x71, 0x16, 0x11, 0xE0, 0x13, 0x55, 0x96, 0x20, 0x7A, 0x10, 0xE1, 0x0B,
  0x80, 0x3A, 0x18, 0xA9, 0x49, 0x80, 0x78, 0x84, 0x42, 0x23, 0x00, 0x72,
  0x54, 0xC9, 0x4B, 0x80, 0x75, 0x57, 0x12, 0xE0, 0x40, 0x80, 0x20, 0x05,
  0x80, 0x09, 0xB0, 0x60, 0x80, 0xF8, 0x3E, 0x83, 0x06, 0xC8, 0x00, 0x71,
  0x24, 0x40, 0xC0, 0x3C, 0x85, 0x6D, 0x5A, 0xD7, 0xA0, 0x38, 0x18, 0xCA,
  0x53, 0xA7, 0x20, 0x7A, 0x52, 0xE5, 0x4B, 0xC0, 0x3A, 0x10, 0x88, 0x21,
  0xC0, 0x7A, 0x52, 0x94, 0xCB, 0x80, 0x7A, 0x10, 0xE4, 0x43, 0x80, 0x7A,
  0x10, 0xE4, 0x42, 0x00, 0x3D, 0x04, 0x16, 0x89, 0x27, 0x00, 0x65, 0x24,
  0x9E, 0x4A, 0x29, 0x00, 0x72, 0x44, 0x44, 0xC0, 0x18, 0x84, 0x21, 0x10,
  0x84, 0xC0, 0x6D, 0x47, 0x18, 0x62, 0x49, 0x00, 0x69, 0x25, 0x38, 0x62,
  0xCD, 0x9B, 0x56, 0xD6, 0xAD, 0x00, 0x65, 0x96, 0x56, 0x5A, 0x69, 0x80,
  0x39, 0x34, 0x52, 0x89, 0x27, 0x00, 0x7A, 0x52, 0xE4, 0x42, 0x00, 0x39,
  0x34, 0x52, 0x89, 0x27, 0x04, 0x10, 0x7A, 0x52, 0xE6, 0x4A, 0x40, 0x7A,
  0x10, 0x41, 0x0B, 0x80, 0xF4, 0x44, 0x88, 0x80, 0x65, 0x24, 0x92, 0x4A,
  0x47, 0x00, 0x9C, 0xA9, 0x4C, 0x62, 0x00, 0x93, 0x6A, 0xD6, 0xAD, 0x9B,
  0x24, 0x00, 0x24, 0xA1, 0x04, 0x31, 0x4C, 0x80, 0x9A, 0xAC, 0x88, 0x80,
  0x78, 0x88, 0x44, 0x43, 0x80, 0x74, 0x44, 0x48, 0x88, 0xC0, 0xAA, 0x54,
  0x31, 0x12, 0x22, 0x22, 0xC0, 0x25, 0x59, 0xF0, 0xD0, 0x7A, 0xA5, 0x27,
  0x00, 0x24, 0x47, 0x55, 0x9E, 0x74, 0x88, 0x60, 0x08, 0x4A, 0xB5, 0x4A,
  0x4E, 0x75, 0xE8, 0x60, 0x18, 0x88, 0xE2, 0x11, 0x08, 0x46, 0x00, 0x7A,
  0xA5, 0x2F, 0x13, 0x80, 0x24, 0x47, 0x55, 0x99, 0x61, 0x25, 0x20, 0x30,
  0x22, 0x24, 0x44, 0xC0, 0x22, 0x12, 0xA6, 0x32, 0x96, 0x29, 0x24, 0xA4,
  0x7E, 0xA5, 0x54, 0xA9, 0x40, 0x75, 0x59, 0x90, 0x75, 0x99, 0x60, 0x75,
  0x59, 0xE8, 0x80, 0x7A, 0xA5, 0x2F, 0x10, 0x80, 0x74, 0x48, 0x80, 0x74,
  0x62, 0xE0, 0x2B, 0xA5, 0x30, 0x5A, 0x95, 0x2F, 0x00, 0xB7, 0x68, 0xAF,
  0xAF, 0x2C, 0xB0, 0x56, 0x66, 0xA0, 0x29, 0x4C, 0x62, 0x13, 0x00, 0x72,
  0x48, 0xE0, 0x32, 0x24, 0xC4, 0x44, 0x40, 0xFF, 0xC0, 0x31, 0x22, 0x32,
  0x24, 0x80, 0xF8,
};

const GFXglyph NotoSans_Condensed_MediumItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 2, 0, -7 },
  { 4, 3, 2, 4, 1, -7 },
  { 5, 5, 7, 5, 0, -7 },
  { 10, 5, 9, 4, 0, -8 },
  { 16, 6, 7, 7, 1, -7 },
  { 22, 5, 7, 5, 0, -7 },
  { 27, 1, 2, 2, 1, -7 },
  { 28, 3, 9, 3, 0, -7 },
  { 32, 3, 9, 3, -1, -7 },
  { 36, 4, 4, 4, 1, -8 },
  { 38, 5, 5, 5, 0, -6 },
  { 42, 1, 2, 2, 0, -1 },
  { 43, 3, 1, 3, 0, -3 },
  { 44, 1, 1, 2, 0, -1 },
  { 45, 4, 7, 4, 0, -7 },
  { 49, 4, 7, 4, 0, -7 },
  { 53, 3, 7, 4, 1, -7 },
  { 56, 4, 7, 4, 0, -7 },
  { 60, 4, 7, 4, 0, -7 },
  { 64, 4, 7, 4, 0, -7 },
  { 68, 5, 7, 4, 0, -7 },
  { 73, 5, 7, 4, 0, -7 },
  { 78, 5, 7, 4, 0, -7 },
  { 83, 5, 7, 4, 0, -7 },
  { 88, 4, 7, 4, 0, -7 },
  { 92, 2, 5, 2, 0, -5 },
  { 94, 3, 6, 2, -1, -5 },
  { 97, 5, 5, 5, 0, -6 },
  { 101, 5, 3, 5, 0, -5 },
  { 103, 5, 5, 5, 0, -6 },
  { 107, 4, 7, 3, 0, -7 },
  { 111, 7, 8, 7, 0, -7 },
  { 118, 5, 7, 5, -1, -7 },
  { 123, 5, 7, 5, 0, -7 },
  { 128, 5, 7, 5, 0, -7 },
  { 133, 5, 7, 5, 0, -7 },
  { 138, 5, 7, 4, 0, -7 },
  { 143, 5, 7, 4, 0, -7 },
  { 148, 6, 7, 6, 0, -7 },
  { 154, 6, 7, 6, 0, -7 },
  { 160, 4, 7, 3, 0, -7 },
  { 164, 5, 9, 2, -2, -7 },
  { 170, 6, 7, 5, 0, -7 },
  { 176, 3, 7, 4, 0, -7 },
  { 179, 7, 7, 7, 0, -7 },
  { 186, 6, 7, 6, 0, -7 },
  { 192, 6, 7, 6, 0, -7 },
  { 198, 5, 7, 5, 0, -7 },
  { 203, 6, 9, 6, 0, -7 },
  { 210, 5, 7, 5, 0, -7 },
  { 215, 5, 7, 4, 0, -7 },
  { 220, 4, 7, 4, 1, -7 },
  { 224, 6, 7, 5, 0, -7 },
  { 230, 5, 7, 5, 1, -7 },
  { 235, 7, 7, 7, 1, -7 },
  { 242, 6, 7, 4, -1, -7 },
  { 248, 4, 7, 4, 1, -7 },
  { 252, 5, 7, 4, 0, -7 },
  { 257, 4, 9, 3, 0, -7 },
  { 262, 2, 7, 4, 1, -7 },
  { 264, 4, 9, 3, -1, -7 },
  { 269, 4, 4, 5, 0, -7 },
  { 271, 4, 1, 3, -1, 1 },
  { 272, 2, 2, 3, 1, -8 },
  { 273, 5, 5, 5, 0, -5 },
  { 277, 4, 8, 5, 0, -8 },
  { 281, 4, 5, 4, 0, -5 },
  { 284, 5, 8, 5, 0, -8 },
  { 289, 4, 5, 4, 0, -5 },
  { 292, 5, 10, 3, -1, -8 },
  { 299, 5, 7, 5, 0, -5 },
  { 304, 4, 8, 5, 0, -8 },
  { 308, 3, 7, 2, 0, -7 },
  { 311, 4, 9, 2, -1, -7 },
  { 316, 5, 8, 4, 0, -8 },
  { 321, 3, 8, 2, 0, -8 },
  { 324, 7, 5, 7, 0, -5 },
  { 329, 4, 5, 5, 0, -5 },
  { 332, 4, 5, 5, 0, -5 },
  { 335, 4, 7, 5, 0, -5 },
  { 339, 5, 7, 5, 0, -5 },
  { 344, 4, 5, 3, 0, -5 },
  { 347, 4, 5, 4, 0, -5 },
  { 350, 3, 7, 3, 0, -7 },
  { 353, 5, 5, 5, 0, -5 },
  { 357, 3, 5, 4, 1, -5 },
  { 359, 6, 5, 6, 1, -5 },
  { 363, 4, 5, 4, 0, -5 },
  { 366, 5, 7, 4, -1, -5 },
  { 371, 4, 5, 3, 0, -5 },
  { 374, 4, 9, 3, 0, -7 },
  { 379, 1, 10, 4, 2, -8 },
  { 381, 4, 9, 3, -1, -7 },
  { 386, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_MediumItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC10PT7B_H_
