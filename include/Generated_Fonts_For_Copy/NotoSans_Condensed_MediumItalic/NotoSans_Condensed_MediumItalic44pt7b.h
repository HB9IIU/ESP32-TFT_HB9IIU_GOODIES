#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC44PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x78, 0x00,
  0x3E, 0x7C, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x78, 0x79, 0xE1, 0xC7, 0x8F,
  0x1C, 0x3C, 0x70, 0xE1, 0xC3, 0x8F, 0x0E, 0x00, 0x00, 0x1C, 0x3C, 0x00,
  0x78, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x87, 0x00, 0x0E,
  0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x70, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x1C, 0x1C, 0x00, 0x38, 0x70,
  0x00, 0xF0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x80, 0x0F, 0x0E, 0x00,
  0x1C, 0x1C, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x03,
  0x83, 0x80, 0x07, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70,
  0xF0, 0x01, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x0F, 0x00, 0x1E, 0x1C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x7D, 0xCE, 0x07, 0x98,
  0x00, 0xF1, 0x80, 0x0F, 0x18, 0x00, 0xF1, 0x80, 0x0F, 0xB8, 0x00, 0xFB,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x6F, 0x80, 0x06, 0x78, 0x00, 0xC7, 0x80,
  0x0C, 0x78, 0x00, 0xC7, 0x84, 0x0C, 0xF8, 0x61, 0xDF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x80,
  0xFC, 0x00, 0xE0, 0x3F, 0xC0, 0x38, 0x0F, 0x38, 0x0F, 0x01, 0xC7, 0x81,
  0xC0, 0x78, 0xF0, 0x78, 0x0E, 0x1E, 0x0E, 0x01, 0xC3, 0xC3, 0xC0, 0x78,
  0x70, 0xF0, 0x0E, 0x0E, 0x1C, 0x01, 0xC1, 0xC7, 0x80, 0x38, 0x78, 0xE0,
  0x07, 0x0F, 0x3C, 0x01, 0xE1, 0xC7, 0x1F, 0x3C, 0x79, 0xC7, 0xF3, 0x8E,
  0x79, 0xFE, 0x73, 0xCE, 0x79, 0xEF, 0xF3, 0xCE, 0x3C, 0xFC, 0x73, 0xC7,
  0x8F, 0x1C, 0x70, 0xF0, 0x07, 0x8E, 0x1E, 0x00, 0xE3, 0xC3, 0xC0, 0x3C,
  0x70, 0x70, 0x07, 0x0E, 0x0E, 0x01, 0xC1, 0xC1, 0xC0, 0x78, 0x38, 0x78,
  0x0E, 0x07, 0x0E, 0x03, 0xC0, 0xE3, 0xC0, 0x70, 0x1C, 0x70, 0x1E, 0x03,
  0xFE, 0x07, 0x80, 0x7F, 0x80, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xE1, 0xE0, 0x07, 0x87,
  0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00,
  0x3C, 0x78, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0xF1, 0xF7, 0xC3,
  0xCF, 0x8F, 0x1E, 0x3C, 0x3E, 0x79, 0xE0, 0x7B, 0xC7, 0x81, 0xFF, 0x3E,
  0x07, 0xF8, 0xF8, 0x0F, 0xE3, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E, 0x07,
  0xF0, 0x7E, 0x7F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0x1F, 0x07, 0xF8, 0x7C,
  0x7D, 0xE7, 0x9E, 0xF3, 0xCF, 0x3C, 0xE3, 0x8E, 0x00, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x01, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x41,
  0xE0, 0x71, 0xC0, 0x7D, 0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0x03, 0xFF, 0x07,
  0xC0, 0x0F, 0xE0, 0x1E, 0xF0, 0x3C, 0xF0, 0x7C, 0x78, 0x18, 0x78, 0x10,
  0x70, 0x00, 0x40, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x0F, 0x87, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0,
  0x78, 0x78, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x11, 0xF7, 0xDF,
  0xFD, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0x07,
  0xC7, 0xC1, 0xE0, 0xF0, 0xF8, 0x3C, 0x3C, 0x0F, 0x1F, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0xC0, 0x3D,
  0xF0, 0x0F, 0x78, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0xF8,
  0x0F, 0xBE, 0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x7C, 0xF0, 0x1E, 0x3E, 0x0F,
  0x8F, 0x83, 0xC1, 0xE1, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xE1, 0xFE, 0x3F, 0xF3,
  0xF7, 0x9E, 0x3C, 0x63, 0xE2, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0xE0, 0x3F, 0xFF, 0x03, 0xE1, 0xF0, 0x18, 0x0F, 0x01, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0x83, 0xE0, 0x20, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x03, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x08, 0x03, 0xF0, 0xF1,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7B, 0xC0, 0x07, 0x3C, 0x00, 0xF7,
  0xC0, 0x1E, 0x78, 0x01, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0x87, 0x80, 0x70,
  0xF0, 0x0E, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xF0, 0x78,
  0x1E, 0x0F, 0x01, 0xE2, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xC1, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x80, 0x3F,
  0x0F, 0x0F, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x7C, 0x03, 0xCF, 0xE0, 0x3D, 0xFF,
  0x03, 0xFF, 0xF8, 0x7F, 0x0F, 0x87, 0xE0, 0x78, 0x7C, 0x07, 0x87, 0x80,
  0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x0F, 0x8F, 0x80, 0xF8, 0x78,
  0x0F, 0x07, 0x81, 0xF0, 0x78, 0x1F, 0x07, 0x83, 0xE0, 0x7E, 0x7C, 0x03,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xC1, 0xF0, 0x78, 0x0F,
  0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x1F, 0x07, 0x81,
  0xE0, 0x7C, 0x3C, 0x03, 0xC7, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0x1F, 0x03, 0xE0, 0xF8, 0x3C,
  0x0F, 0x87, 0x80, 0x78, 0x78, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x07, 0x8F,
  0x80, 0x78, 0xF8, 0x0F, 0x87, 0x80, 0xF0, 0x7E, 0x3F, 0x07, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0xF8,
  0x1F, 0xFE, 0x0F, 0x87, 0xC3, 0xC0, 0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x3E,
  0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x01,
  0xF3, 0xC0, 0xFC, 0xF8, 0x3F, 0x3E, 0x3F, 0x8F, 0xFF, 0xE1, 0xFF, 0x78,
  0x3F, 0xBE, 0x01, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0xC3, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0x81, 0xF0, 0xFC, 0x3E, 0x0F, 0x81,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x01, 0xF0, 0x7C, 0x3F, 0x0F, 0x81, 0xE0, 0x00,
  0xE0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE3, 0x83, 0xE4,
  0x07, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70, 0xF0, 0x3F,
  0x87, 0x0E, 0x0F, 0xFC, 0x71, 0xC1, 0xFF, 0x87, 0x1C, 0x3C, 0x38, 0x73,
  0x83, 0x87, 0x87, 0x38, 0x78, 0x78, 0x73, 0x87, 0x07, 0x07, 0x78, 0xF0,
  0x70, 0x77, 0x0E, 0x0F, 0x0F, 0x70, 0xE0, 0xF0, 0xE7, 0x0E, 0x0E, 0x0E,
  0x70, 0xE0, 0xE1, 0xEF, 0x1E, 0x1E, 0x1C, 0xF1, 0xE1, 0xE3, 0xCF, 0x0E,
  0x3E, 0x38, 0xF0, 0xFF, 0xFF, 0x0F, 0x0F, 0xE7, 0xE0, 0x70, 0x7C, 0x7C,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x02, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x80, 0x0F,
  0x3C, 0x00, 0x79, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xC3, 0xC0,
  0x1E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0xF8, 0x3E, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xF0, 0x1F, 0x0F,
  0x00, 0xF8, 0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xF3, 0xC0, 0x07,
  0xBE, 0x00, 0x3D, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xF8, 0x7E, 0x03, 0xC0, 0x7C, 0x0F, 0x01,
  0xF0, 0x3C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x78, 0x1E, 0x01, 0xE0,
  0x78, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x3F, 0xFF, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0x0F, 0xC0, 0x7C, 0x0F, 0x81, 0xE0, 0x1E,
  0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0xF8, 0x07, 0x83, 0xE0, 0x1E, 0x0F,
  0x00, 0xF8, 0x3C, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x07, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x04, 0x07,
  0xFB, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0x3F, 0xC0, 0x3C, 0x0F,
  0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E,
  0x0F, 0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0xF8, 0x03, 0xE1,
  0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x78, 0x01, 0xF0, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x87, 0xC0,
  0x1E, 0x0F, 0x80, 0x7C, 0x1E, 0x01, 0xF0, 0x3C, 0x07, 0xE0, 0x78, 0x1F,
  0x81, 0xF0, 0x7E, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x83, 0xC0, 0xFC, 0x01, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x07, 0xFC, 0xF8, 0x0F, 0xF9, 0xF0, 0x1F, 0xE3, 0xE0, 0x7F, 0xC7, 0xC0,
  0x07, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x7C, 0x00,
  0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x03, 0xF0, 0x1E,
  0x03, 0xFD, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x01, 0xE0, 0x07, 0x80, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01,
  0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x7C, 0x0F, 0x80,
  0x3E, 0x07, 0xC0, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0,
  0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0x80, 0x3C, 0x07, 0x80, 0x1E, 0x03,
  0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xC0,
  0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xF8, 0x1F, 0x00, 0x78,
  0x0F, 0x80, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x1F, 0x03, 0xE0, 0x0F,
  0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x23, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x78, 0x03, 0xC0,
  0xF8, 0x03, 0xC1, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0xC7, 0xC0, 0x07, 0xC7,
  0xC0, 0x07, 0x8F, 0x80, 0x07, 0x9F, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0xBE,
  0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xBC, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x1E,
  0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x0F,
  0x00, 0x3C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0xFF, 0x7F, 0xFD, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xFE, 0x03, 0xB8, 0x01, 0xFE, 0x07, 0xB8, 0x03, 0xDE, 0x07, 0xB8,
  0x03, 0xFE, 0x07, 0xBC, 0x07, 0xBC, 0x07, 0xBC, 0x07, 0xBC, 0x07, 0xBC,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x7C, 0x0F, 0x3C,
  0x1E, 0x78, 0x0F, 0x3C, 0x1C, 0x78, 0x1F, 0x3C, 0x3C, 0x78, 0x1E, 0x3C,
  0x38, 0xF8, 0x1E, 0x3C, 0x78, 0xF0, 0x1E, 0x3C, 0x78, 0xF0, 0x1E, 0x3C,
  0xF0, 0xF0, 0x3E, 0x1C, 0xF0, 0xF0, 0x3C, 0x1D, 0xE1, 0xF0, 0x3C, 0x1D,
  0xE1, 0xE0, 0x3C, 0x1F, 0xC1, 0xE0, 0x3C, 0x1F, 0xC1, 0xE0, 0x78, 0x1F,
  0x81, 0xE0, 0x78, 0x1F, 0x83, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00,
  0x78, 0x0F, 0xE0, 0x0F, 0x01, 0xFC, 0x01, 0xE0, 0x3F, 0x80, 0x7C, 0x07,
  0xF0, 0x0F, 0x00, 0xEF, 0x01, 0xE0, 0x3D, 0xE0, 0x3C, 0x07, 0xBC, 0x07,
  0x80, 0xF7, 0x81, 0xF0, 0x1E, 0x70, 0x3C, 0x03, 0xCF, 0x07, 0x80, 0xF1,
  0xE0, 0xF0, 0x1E, 0x3C, 0x1E, 0x03, 0xC7, 0x87, 0x80, 0x78, 0x78, 0xF0,
  0x1F, 0x0F, 0x1E, 0x03, 0xC1, 0xE3, 0xC0, 0x78, 0x3C, 0x78, 0x0F, 0x03,
  0x9E, 0x01, 0xE0, 0x7B, 0xC0, 0x7C, 0x0F, 0x78, 0x0F, 0x01, 0xEF, 0x01,
  0xE0, 0x3D, 0xE0, 0x3C, 0x03, 0xF8, 0x07, 0x80, 0x7F, 0x01, 0xE0, 0x0F,
  0xE0, 0x3C, 0x01, 0xFC, 0x07, 0x80, 0x1F, 0x00, 0xF0, 0x03, 0xE0, 0x3E,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0xFF, 0xFE, 0x03, 0xE0, 0xF8, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xC0,
  0x0F, 0x1F, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x00, 0x0F,
  0x7C, 0x00, 0x3D, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xDE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xBE, 0x00, 0x1E, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xE3,
  0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x1F, 0x03, 0xE0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0xFF, 0xFC, 0x07, 0xC7, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F,
  0x01, 0xE0, 0xF8, 0x0F, 0x07, 0xC0, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x3E,
  0x0F, 0x01, 0xF0, 0xF8, 0x0F, 0x07, 0x80, 0xF8, 0x3C, 0x1F, 0x81, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xE0, 0xF8, 0x1F, 0x01, 0xF0, 0xF8, 0x07,
  0xC7, 0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xE0, 0x03, 0xCF,
  0x00, 0x0F, 0x7C, 0x00, 0x3D, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xDE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xBE, 0x00, 0x1E,
  0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8,
  0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x1F, 0x03, 0xE0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF,
  0xFC, 0x07, 0xC7, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xE0,
  0xF8, 0x0F, 0x07, 0xC0, 0x78, 0x3C, 0x07, 0xC1, 0xE0, 0x3E, 0x0F, 0x01,
  0xE0, 0xF8, 0x1F, 0x07, 0x81, 0xF0, 0x3C, 0x7F, 0x81, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x07, 0x8F, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0,
  0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0,
  0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xE3,
  0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xE1, 0xE0, 0xFC, 0x02, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x80, 0x1F, 0x0C, 0x03,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x87, 0xC0,
  0x1E, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0x78, 0x03,
  0xE1, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x7C,
  0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83,
  0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78,
  0x03, 0xE0, 0xF0, 0x07, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xF0,
  0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0xCF,
  0x00, 0x7C, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x0F, 0x01, 0xF0,
  0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC0, 0xF0, 0x78,
  0x0F, 0x87, 0x80, 0xF8, 0xF0, 0x07, 0x8F, 0x00, 0x79, 0xF0, 0x07, 0x9E,
  0x00, 0x7B, 0xE0, 0x07, 0xBC, 0x00, 0x7B, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0x70, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0xF0, 0x07, 0xC0,
  0x3E, 0xF0, 0x07, 0xC0, 0x3C, 0xF0, 0x0F, 0xC0, 0x3C, 0xF0, 0x0F, 0xC0,
  0x7C, 0xF0, 0x1F, 0xC0, 0x78, 0xF0, 0x1F, 0xC0, 0xF8, 0xF0, 0x1F, 0xC0,
  0xF0, 0xF0, 0x3F, 0xC0, 0xF0, 0xF0, 0x3B, 0xC1, 0xF0, 0xF0, 0x7B, 0xC1,
  0xE0, 0xF0, 0x7B, 0xC3, 0xE0, 0xF0, 0x73, 0xC3, 0xC0, 0xF0, 0xF3, 0xC3,
  0xC0, 0xF0, 0xE3, 0xC7, 0xC0, 0xF1, 0xE3, 0xC7, 0x80, 0xF1, 0xE3, 0xCF,
  0x80, 0xF3, 0xC3, 0xCF, 0x00, 0xF3, 0xC3, 0xCF, 0x00, 0xF3, 0x83, 0xDE,
  0x00, 0xF7, 0x83, 0xDE, 0x00, 0xF7, 0x83, 0x9E, 0x00, 0xFF, 0x03, 0xBC,
  0x00, 0xFF, 0x03, 0xBC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x0F,
  0xC0, 0x3E, 0x03, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x78,
  0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0x87, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0x3C, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0x7C, 0x00,
  0x1F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0x3C,
  0x00, 0x78, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x0F, 0x80,
  0x1E, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x80, 0xFB, 0xE0, 0x3C, 0x78,
  0x1F, 0x1E, 0x07, 0x87, 0x83, 0xC1, 0xE1, 0xF0, 0x78, 0x78, 0x1E, 0x3E,
  0x03, 0xCF, 0x00, 0xF7, 0xC0, 0x3D, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xE0, 0xE0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x0F, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xBC, 0x00, 0xF7, 0x80, 0x1C, 0x70, 0x07,
  0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x1C, 0x0F, 0x03, 0xC1, 0xC0, 0x78, 0x78,
  0x07, 0x1E, 0x00, 0xF3, 0xC0, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF1, 0xF1, 0xE1, 0xC3, 0xC3, 0x80,
  0x00, 0xF8, 0xF0, 0x3F, 0xCF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x87,
  0xE1, 0xF0, 0x3E, 0x1E, 0x03, 0xC3, 0xE0, 0x3C, 0x3C, 0x03, 0xC7, 0xC0,
  0x3C, 0x7C, 0x07, 0xC7, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0xF8,
  0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0x83, 0xF0, 0x7C, 0xFF, 0x07, 0xFE, 0xE0, 0x3F, 0xDE, 0x01, 0xF9, 0xE0,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0xF8, 0x07, 0xBF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFC, 0x1E, 0x0F,
  0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xF1,
  0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x3E, 0x03, 0xE3, 0xC0, 0x3E,
  0x3C, 0x03, 0xC3, 0xC0, 0x7C, 0x3C, 0x07, 0xC7, 0xC0, 0xF8, 0x7E, 0x0F,
  0x87, 0xF3, 0xF0, 0x7F, 0xFE, 0x07, 0x3F, 0xC0, 0xF1, 0xF8, 0x00, 0x00,
  0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0x80, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x78, 0x08, 0x7E, 0x30, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x03, 0xE3, 0xC0, 0x3F, 0xDE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3E,
  0x1F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x03, 0xC0, 0xF0, 0x0F,
  0x07, 0xC0, 0x3C, 0x1F, 0x01, 0xF0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x07,
  0x80, 0x78, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x01, 0xF1, 0xF8, 0x07, 0xFE, 0xE0,
  0x0F, 0xF7, 0x80, 0x1F, 0x9E, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x81, 0xFF,
  0xE1, 0xF9, 0xF0, 0xF0, 0x78, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x3C,
  0x0F, 0x3E, 0x0F, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x07, 0xF8, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x87, 0xC1, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x7C, 0x78, 0x0F, 0xF3, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7C, 0x3F, 0x07, 0xC0, 0xF8, 0x3C, 0x07, 0x83, 0xE0, 0x3C, 0x1E, 0x01,
  0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E,
  0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0x83, 0xE0, 0x7C,
  0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x03, 0xE7, 0xF0, 0x1F, 0xFF, 0x80, 0x7F,
  0xBC, 0x03, 0xF9, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x40, 0x3E, 0x03, 0x83, 0xF0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF1, 0xF0, 0x1E, 0xFF, 0x03,
  0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xC3, 0xC3, 0xF0, 0x78, 0x7C, 0x0F, 0x0F,
  0x01, 0xE1, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C,
  0x07, 0x8F, 0x80, 0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0,
  0x1E, 0x3E, 0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0,
  0x78, 0xF8, 0x1F, 0x00, 0x00, 0xC0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0xF8, 0x00, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x04, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x0F, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x07, 0x87, 0xC0, 0xF8, 0xF8, 0x0F,
  0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xF7, 0x80,
  0x3E, 0x7C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0xC3, 0xC0, 0x78, 0x3E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x00, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8,
  0x00, 0x07, 0x8F, 0x83, 0xF0, 0x1C, 0xFF, 0x1F, 0xE0, 0x77, 0xFC, 0xFF,
  0x81, 0xDF, 0xFF, 0xFE, 0x0F, 0xC3, 0xF8, 0x7C, 0x3E, 0x07, 0xC1, 0xF0,
  0xF8, 0x1E, 0x07, 0x83, 0xC0, 0xF8, 0x1E, 0x0F, 0x03, 0xE0, 0x78, 0x7C,
  0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0x3C, 0x1E, 0x07,
  0xC0, 0xF0, 0xF8, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x0F, 0x0F, 0x01, 0xE0,
  0x7C, 0x3C, 0x07, 0x81, 0xE0, 0xF0, 0x3E, 0x07, 0x87, 0xC0, 0xF0, 0x1E,
  0x1E, 0x03, 0xC0, 0x78, 0x78, 0x0F, 0x03, 0xE1, 0xE0, 0x3C, 0x0F, 0x07,
  0x81, 0xF0, 0x3C, 0x3E, 0x07, 0x80, 0xF0, 0x07, 0x8F, 0x80, 0xF7, 0xF8,
  0x1D, 0xFF, 0x83, 0xBF, 0xF0, 0xFE, 0x1E, 0x1F, 0x83, 0xC3, 0xE0, 0x78,
  0x78, 0x0F, 0x0F, 0x01, 0xE3, 0xE0, 0x7C, 0x78, 0x0F, 0x0F, 0x01, 0xE1,
  0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x81, 0xF1, 0xE0, 0x3C, 0x3C, 0x07, 0x87,
  0x80, 0xF1, 0xF0, 0x1E, 0x3C, 0x07, 0xC7, 0x80, 0xF0, 0xF0, 0x1E, 0x1E,
  0x03, 0xC7, 0xC0, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x0F, 0x87, 0xC7, 0xC1, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03,
  0xDF, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1F, 0x78, 0x07, 0xDE, 0x01, 0xEF,
  0x80, 0x7B, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xCF, 0x81, 0xF1, 0xE0,
  0xF8, 0x7C, 0x7C, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x01, 0xE3,
  0xE0, 0x07, 0xBF, 0xC0, 0x1D, 0xFF, 0x80, 0x77, 0x7E, 0x03, 0xF0, 0x78,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1F, 0x03, 0xC0, 0x7C, 0x1F,
  0x01, 0xF0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x01,
  0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3C, 0x0F, 0x01, 0xF0, 0x3C, 0x07, 0xC1,
  0xF0, 0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0xCF, 0xC0, 0x7F, 0xFE, 0x01, 0xEF,
  0xF0, 0x0F, 0x9F, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0xF0, 0x3F,
  0xCE, 0x07, 0xFE, 0xE0, 0xFF, 0xFE, 0x0F, 0x87, 0xE1, 0xF0, 0x3E, 0x1E,
  0x03, 0xC3, 0xE0, 0x3C, 0x3C, 0x03, 0xC7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7,
  0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF8,
  0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0x7C, 0x7E,
  0x07, 0xFF, 0xE0, 0x3F, 0xDE, 0x03, 0xF9, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x07, 0x8F, 0x07, 0x3F, 0x07, 0x7F, 0x07, 0x7E, 0x0F, 0xF0, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x9E, 0x1E, 0x02, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x80, 0xF8, 0xE1, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0,
  0x03, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x01, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xE1, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x10, 0xFF, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0x01, 0xE1, 0xE0,
  0x3C, 0x3C, 0x07, 0x8F, 0x80, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x87, 0x80,
  0xF0, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03,
  0xC3, 0xC0, 0x78, 0xF8, 0x1F, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x1F,
  0x0F, 0x03, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x07, 0xCF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xF7, 0x81, 0xFC, 0xF0, 0xF8, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0xF1,
  0xE0, 0x3C, 0x78, 0x1F, 0x1E, 0x07, 0x87, 0x83, 0xE1, 0xE0, 0xF0, 0x78,
  0x7C, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x78,
  0x07, 0x9E, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF0,
  0x3E, 0x03, 0xFC, 0x0F, 0x81, 0xFF, 0x03, 0xE0, 0x7B, 0xC1, 0xF8, 0x1E,
  0xF0, 0x7E, 0x0F, 0x3C, 0x3F, 0x83, 0xCF, 0x0E, 0xE0, 0xF3, 0xC3, 0xB8,
  0x78, 0xF1, 0xEE, 0x1E, 0x3C, 0x73, 0x8F, 0x0F, 0x3C, 0xE3, 0xC3, 0xCE,
  0x38, 0xF0, 0xF3, 0x8E, 0x78, 0x3D, 0xE3, 0x9E, 0x0E, 0x70, 0xEF, 0x03,
  0xBC, 0x3B, 0xC0, 0xEE, 0x0E, 0xE0, 0x3B, 0x83, 0xF8, 0x0F, 0xE0, 0xFE,
  0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0x81,
  0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x78, 0x1E, 0x07, 0xC0, 0xF0,
  0x7C, 0x07, 0x83, 0xC0, 0x3E, 0x3C, 0x00, 0xF3, 0xE0, 0x07, 0x9E, 0x00,
  0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xBE, 0x00, 0x7C, 0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x03, 0xE1, 0xF0,
  0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x1F, 0x01, 0xF0, 0x01, 0xE0, 0x1F, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x7C, 0x01,
  0xE0, 0x78, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01,
  0xE1, 0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xE3, 0xC0, 0x01, 0xE3, 0xC0, 0x01,
  0xE7, 0x80, 0x00, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1,
  0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x1F,
  0x00, 0x7F, 0x00, 0xFE, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xF0, 0x00, 0x08, 0x00, 0x5F, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xE0, 0x1F, 0xE8, 0x00, 0x40,
};

const GFXglyph NotoSans_Condensed_MediumItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 12, 31, 11, 0, -31 },
  { 48, 14, 11, 16, 4, -31 },
  { 68, 23, 31, 22, 0, -31 },
  { 158, 20, 36, 20, 0, -33 },
  { 248, 27, 32, 30, 2, -32 },
  { 356, 22, 32, 23, 0, -32 },
  { 444, 6, 11, 9, 5, -31 },
  { 453, 14, 39, 12, 1, -32 },
  { 522, 14, 39, 12, -3, -32 },
  { 591, 16, 18, 19, 4, -34 },
  { 627, 18, 21, 21, 2, -26 },
  { 675, 9, 11, 10, -2, -5 },
  { 688, 10, 4, 12, 1, -14 },
  { 693, 6, 6, 10, 0, -6 },
  { 698, 21, 32, 16, -2, -32 },
  { 782, 18, 32, 20, 1, -32 },
  { 854, 13, 31, 20, 5, -31 },
  { 905, 20, 32, 20, -1, -32 },
  { 985, 20, 32, 20, 0, -32 },
  { 1065, 20, 32, 20, 0, -32 },
  { 1145, 20, 31, 20, 0, -31 },
  { 1223, 20, 32, 20, 1, -32 },
  { 1303, 19, 31, 20, 2, -31 },
  { 1377, 20, 32, 20, 0, -32 },
  { 1457, 18, 32, 20, 1, -32 },
  { 1529, 10, 24, 10, 0, -24 },
  { 1559, 12, 30, 10, -2, -24 },
  { 1604, 18, 21, 21, 2, -26 },
  { 1652, 18, 13, 21, 2, -22 },
  { 1682, 18, 21, 21, 2, -26 },
  { 1730, 15, 32, 15, 2, -32 },
  { 1790, 28, 36, 30, 1, -32 },
  { 1916, 21, 32, 21, -3, -32 },
  { 2000, 22, 31, 22, 0, -31 },
  { 2086, 21, 32, 20, 2, -32 },
  { 2170, 23, 31, 24, 0, -31 },
  { 2260, 20, 31, 18, 0, -31 },
  { 2338, 20, 31, 17, 0, -31 },
  { 2416, 23, 32, 24, 2, -32 },
  { 2508, 25, 31, 24, 0, -31 },
  { 2605, 18, 31, 13, -2, -31 },
  { 2675, 19, 40, 10, -7, -31 },
  { 2770, 24, 31, 21, 0, -31 },
  { 2863, 14, 31, 17, 0, -31 },
  { 2918, 32, 31, 32, 0, -31 },
  { 3042, 27, 31, 26, 0, -31 },
  { 3147, 22, 32, 25, 2, -32 },
  { 3235, 21, 31, 21, 0, -31 },
  { 3317, 22, 39, 25, 2, -32 },
  { 3425, 21, 31, 21, 0, -31 },
  { 3507, 20, 32, 19, 0, -32 },
  { 3587, 17, 31, 18, 4, -31 },
  { 3653, 23, 31, 24, 2, -31 },
  { 3743, 20, 31, 20, 4, -31 },
  { 3821, 32, 31, 32, 4, -31 },
  { 3945, 26, 31, 19, -3, -31 },
  { 4046, 18, 31, 19, 4, -31 },
  { 4116, 21, 31, 18, -1, -31 },
  { 4198, 17, 39, 13, -1, -32 },
  { 4281, 8, 32, 16, 5, -32 },
  { 4313, 17, 39, 13, -3, -32 },
  { 4396, 19, 18, 20, 1, -31 },
  { 4439, 15, 3, 15, -4, 4 },
  { 4445, 7, 7, 12, 6, -34 },
  { 4452, 20, 24, 21, 1, -24 },
  { 4512, 20, 33, 21, 0, -33 },
  { 4595, 16, 24, 16, 1, -24 },
  { 4643, 22, 33, 21, 1, -33 },
  { 4734, 17, 24, 19, 1, -24 },
  { 4785, 22, 45, 12, -5, -34 },
  { 4909, 21, 35, 21, 0, -24 },
  { 5001, 19, 33, 21, 0, -33 },
  { 5080, 11, 33, 10, 0, -33 },
  { 5126, 17, 44, 10, -6, -33 },
  { 5220, 20, 33, 19, 0, -33 },
  { 5303, 12, 33, 10, 0, -33 },
  { 5353, 30, 24, 31, 0, -24 },
  { 5443, 19, 24, 21, 0, -24 },
  { 5500, 18, 24, 20, 1, -24 },
  { 5554, 22, 34, 21, -2, -24 },
  { 5648, 20, 35, 21, 1, -24 },
  { 5736, 16, 24, 14, 0, -24 },
  { 5784, 16, 24, 16, 0, -24 },
  { 5832, 12, 29, 13, 2, -29 },
  { 5876, 19, 24, 21, 1, -24 },
  { 5933, 18, 24, 17, 2, -24 },
  { 5987, 26, 24, 27, 3, -24 },
  { 6065, 21, 24, 18, -2, -24 },
  { 6128, 24, 35, 17, -4, -24 },
  { 6233, 17, 24, 15, -1, -24 },
  { 6284, 17, 38, 15, 1, -31 },
  { 6365, 3, 44, 19, 8, -34 },
  { 6382, 16, 38, 15, -2, -31 },
  { 6458, 18, 7, 21, 2, -19 },
};

const GFXfont NotoSans_Condensed_MediumItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC44PT7B_H_
