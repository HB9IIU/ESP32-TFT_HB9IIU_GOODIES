#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC11PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0x24, 0x86, 0xF6, 0x80, 0x18, 0xA7, 0xCA, 0x53, 0xE5, 0x28,
  0x13, 0x58, 0xC3, 0x1A, 0xC8, 0x40, 0x4E, 0xAB, 0x37, 0xEC, 0xD5, 0x66,
  0x30, 0xA3, 0x0C, 0x6E, 0x69, 0x3A, 0xE8, 0x32, 0x44, 0x48, 0x88, 0x84,
  0x21, 0x11, 0x12, 0x22, 0x48, 0x2F, 0x6A, 0x44, 0x4F, 0x44, 0x78, 0xE0,
  0xC0, 0x04, 0x21, 0x04, 0x20, 0x84, 0x30, 0x33, 0x52, 0x9C, 0xCA, 0x4C,
  0x2E, 0x94, 0x92, 0x32, 0x42, 0x23, 0x31, 0x1E, 0x32, 0x42, 0x67, 0x08,
  0x5C, 0x08, 0xCC, 0xA5, 0x7C, 0x44, 0x3A, 0x10, 0xE1, 0x08, 0x5C, 0x19,
  0x10, 0xE5, 0xCA, 0x4E, 0x78, 0x44, 0x22, 0x11, 0x18, 0x3A, 0x52, 0x65,
  0x4A, 0x5E, 0x32, 0x52, 0xB7, 0x88, 0x5C, 0x50, 0x20, 0x24, 0x02, 0xB0,
  0x08, 0xD9, 0xC1, 0x84, 0xF0, 0xF0, 0x8C, 0x23, 0xC8, 0x71, 0x12, 0x44,
  0x0C, 0x1C, 0x45, 0x3A, 0xDA, 0xB5, 0x6F, 0x20, 0x78, 0x08, 0x61, 0x8A,
  0x29, 0xE4, 0xB3, 0x3B, 0x52, 0xF5, 0xA6, 0x7E, 0x1C, 0x84, 0x10, 0x43,
  0x04, 0x1C, 0x39, 0xB4, 0x51, 0x49, 0x2D, 0xBC, 0x3B, 0x10, 0xE4, 0x23,
  0x1E, 0x3B, 0x10, 0x87, 0x23, 0x10, 0x1C, 0x84, 0x10, 0x5F, 0x24, 0x9E,
  0x25, 0x94, 0x5F, 0x49, 0x2C, 0xA2, 0x72, 0x24, 0x44, 0x4C, 0x08, 0x44,
  0x21, 0x08, 0xC4, 0x27, 0x00, 0x25, 0xA5, 0x1C, 0x71, 0x4D, 0x26, 0x26,
  0x44, 0x44, 0xCF, 0x23, 0x63, 0x65, 0x66, 0x5A, 0x5A, 0x92, 0x96, 0x22,
  0xC9, 0x52, 0xA5, 0x4A, 0xA6, 0x44, 0x18, 0x94, 0x51, 0x47, 0x34, 0x9C,
  0x3B, 0x52, 0x97, 0x23, 0x10, 0x18, 0x94, 0x51, 0x47, 0x34, 0x9C, 0x10,
  0x60, 0x3B, 0x52, 0x97, 0x2B, 0x53, 0x3A, 0x10, 0xC3, 0x08, 0x5C, 0xF4,
  0x44, 0x44, 0x88, 0x25, 0x94, 0x53, 0x49, 0x2C, 0x9C, 0x8C, 0xA5, 0x6A,
  0x53, 0x18, 0x91, 0x92, 0xB2, 0xB6, 0xB4, 0xD4, 0xD8, 0x98, 0x26, 0x68,
  0x60, 0xC1, 0x05, 0x12, 0x64, 0x9C, 0xA9, 0x44, 0x22, 0x10, 0x78, 0xC4,
  0x42, 0x22, 0x1E, 0x34, 0x44, 0x44, 0x88, 0x8C, 0xA9, 0x55, 0x31, 0x11,
  0x12, 0x22, 0x2C, 0x11, 0x94, 0x98, 0x80, 0xF0, 0x80, 0x3A, 0x53, 0x29,
  0x38, 0x22, 0x1E, 0x94, 0xA7, 0x5E, 0x34, 0x48, 0x86, 0x0C, 0x23, 0x92,
  0x4A, 0x49, 0x1C, 0x32, 0x5D, 0x08, 0x38, 0x18, 0x8C, 0x42, 0x11, 0x88,
  0x42, 0x20, 0x3A, 0x53, 0x29, 0x38, 0x54, 0xC0, 0x22, 0x1E, 0x94, 0xAA,
  0x52, 0x21, 0x24, 0xA4, 0x10, 0x22, 0x22, 0x44, 0x44, 0x80, 0x22, 0x12,
  0xA6, 0x32, 0xD2, 0x2D, 0x24, 0xA4, 0x7E, 0x95, 0x2A, 0x99, 0x32, 0xC0,
  0x7A, 0x52, 0xA9, 0x48, 0x32, 0x53, 0x39, 0x38, 0x7A, 0x52, 0x9D, 0x7A,
  0x10, 0x80, 0x3A, 0x53, 0x29, 0x38, 0x42, 0x20, 0x74, 0x44, 0x88, 0x74,
  0x42, 0x2E, 0x2D, 0x25, 0x30, 0x4A, 0x52, 0xA9, 0x78, 0x9A, 0xAC, 0xC8,
  0xB6, 0xDD, 0xB6, 0x92, 0x40, 0x2C, 0xA3, 0x0C, 0x33, 0x60, 0x24, 0xA2,
  0x8C, 0x30, 0x82, 0x10, 0x80, 0x72, 0x24, 0x8E, 0x12, 0x22, 0xC4, 0x44,
  0x64, 0xFF, 0xE0, 0x30, 0x84, 0x21, 0x98, 0x84, 0x66, 0x00, 0x4D, 0xC0,
};

const GFXglyph NotoSans_Condensed_MediumItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 3, 3, 4, 1, -8 },
  { 6, 6, 8, 6, 0, -8 },
  { 12, 5, 9, 5, 0, -8 },
  { 18, 6, 8, 8, 1, -8 },
  { 24, 6, 8, 6, 0, -8 },
  { 30, 2, 3, 2, 1, -8 },
  { 31, 4, 10, 3, 0, -8 },
  { 36, 4, 10, 3, -1, -8 },
  { 41, 4, 4, 5, 1, -8 },
  { 43, 4, 6, 5, 1, -7 },
  { 46, 3, 2, 3, -1, -1 },
  { 47, 3, 1, 3, 0, -3 },
  { 48, 2, 1, 3, 0, -1 },
  { 49, 6, 8, 4, -1, -8 },
  { 55, 5, 8, 5, 0, -8 },
  { 60, 3, 8, 5, 1, -8 },
  { 63, 5, 8, 5, 0, -8 },
  { 68, 5, 8, 5, 0, -8 },
  { 73, 5, 8, 5, 0, -8 },
  { 78, 5, 8, 5, 0, -8 },
  { 83, 5, 8, 5, 0, -8 },
  { 88, 5, 8, 5, 0, -8 },
  { 93, 5, 8, 5, 0, -8 },
  { 98, 5, 8, 5, 0, -8 },
  { 103, 2, 6, 3, 0, -6 },
  { 105, 3, 7, 3, -1, -6 },
  { 108, 5, 6, 5, 0, -7 },
  { 112, 4, 3, 5, 1, -5 },
  { 114, 4, 6, 5, 1, -7 },
  { 117, 4, 8, 4, 0, -8 },
  { 121, 7, 9, 7, 0, -8 },
  { 129, 6, 8, 5, -1, -8 },
  { 135, 5, 8, 5, 0, -8 },
  { 140, 6, 8, 5, 0, -8 },
  { 146, 6, 8, 6, 0, -8 },
  { 152, 5, 8, 5, 0, -8 },
  { 157, 5, 8, 4, 0, -8 },
  { 162, 6, 8, 6, 0, -8 },
  { 168, 6, 8, 6, 0, -8 },
  { 174, 4, 8, 3, 0, -8 },
  { 178, 5, 10, 3, -2, -8 },
  { 185, 6, 8, 5, 0, -8 },
  { 191, 4, 8, 4, 0, -8 },
  { 195, 8, 8, 8, 0, -8 },
  { 203, 7, 8, 6, 0, -8 },
  { 210, 6, 8, 6, 0, -8 },
  { 216, 5, 8, 5, 0, -8 },
  { 221, 6, 10, 6, 0, -8 },
  { 229, 5, 8, 5, 0, -8 },
  { 234, 5, 8, 5, 0, -8 },
  { 239, 4, 8, 4, 1, -8 },
  { 243, 6, 8, 6, 0, -8 },
  { 249, 5, 8, 5, 1, -8 },
  { 254, 8, 8, 8, 1, -8 },
  { 262, 7, 8, 5, -1, -8 },
  { 269, 5, 8, 5, 1, -8 },
  { 274, 5, 8, 4, 0, -8 },
  { 279, 4, 10, 3, 0, -8 },
  { 284, 2, 8, 4, 1, -8 },
  { 286, 4, 10, 3, -1, -8 },
  { 291, 5, 5, 5, 0, -8 },
  { 295, 4, 1, 4, -1, 1 },
  { 296, 1, 1, 3, 2, -8 },
  { 297, 5, 6, 5, 0, -6 },
  { 301, 5, 8, 5, 0, -8 },
  { 306, 4, 6, 4, 0, -6 },
  { 309, 6, 8, 5, 0, -8 },
  { 315, 5, 6, 5, 0, -6 },
  { 319, 5, 11, 3, -1, -8 },
  { 326, 5, 9, 5, 0, -6 },
  { 332, 5, 8, 5, 0, -8 },
  { 337, 3, 8, 2, 0, -8 },
  { 340, 4, 11, 2, -1, -8 },
  { 346, 5, 8, 5, 0, -8 },
  { 351, 3, 8, 2, 0, -8 },
  { 354, 7, 6, 8, 0, -6 },
  { 360, 5, 6, 5, 0, -6 },
  { 364, 5, 6, 5, 0, -6 },
  { 368, 5, 9, 5, 0, -6 },
  { 374, 5, 9, 5, 0, -6 },
  { 380, 4, 6, 4, 0, -6 },
  { 383, 4, 6, 4, 0, -6 },
  { 386, 3, 7, 3, 0, -7 },
  { 389, 5, 6, 5, 0, -6 },
  { 393, 4, 6, 4, 1, -6 },
  { 396, 6, 6, 7, 1, -6 },
  { 401, 6, 6, 4, -1, -6 },
  { 406, 6, 9, 4, -1, -6 },
  { 413, 4, 6, 4, 0, -6 },
  { 416, 4, 10, 4, 0, -8 },
  { 421, 1, 11, 5, 2, -8 },
  { 423, 5, 10, 4, -1, -8 },
  { 430, 5, 2, 5, 0, -5 },
};

const GFXfont NotoSans_Condensed_MediumItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC11PT7B_H_
