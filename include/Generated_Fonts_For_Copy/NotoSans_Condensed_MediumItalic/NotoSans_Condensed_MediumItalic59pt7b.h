#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC59PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x80, 0x00, 0x3F, 0x0F,
  0xCF, 0xC3, 0xF3, 0xE0, 0xF8, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xC7,
  0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0x87, 0x83, 0xE3, 0xE0,
  0xF8, 0xF8, 0x3E, 0x3C, 0x0F, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x0F, 0x83, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78,
  0x1E, 0x00, 0x03, 0xE0, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x07, 0x80,
  0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xB8, 0xF0, 0x1F, 0x8E,
  0x0C, 0x07, 0xC3, 0x80, 0x01, 0xF0, 0xE0, 0x00, 0x7C, 0x30, 0x00, 0x1F,
  0x1C, 0x00, 0x07, 0xC7, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x7E, 0x70, 0x00,
  0x1F, 0xD8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x19, 0xFC, 0x00, 0x0E, 0x3F, 0x00,
  0x03, 0x8F, 0xC0, 0x00, 0xE3, 0xF0, 0x00, 0x38, 0xFC, 0x00, 0x0C, 0x3F,
  0x08, 0x07, 0x0F, 0x83, 0x01, 0xC7, 0xE0, 0xF0, 0x73, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x80, 0x1F, 0xC0, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0x00,
  0x7F, 0xF0, 0x01, 0xE0, 0x0F, 0xDF, 0x00, 0x3E, 0x00, 0xF0, 0xF0, 0x07,
  0xC0, 0x1F, 0x0F, 0x80, 0x78, 0x01, 0xE0, 0xF8, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0xF0, 0x03, 0xC0, 0xF8, 0x1F, 0x00, 0x3C, 0x0F, 0x03, 0xE0, 0x07,
  0xC0, 0xF0, 0x3C, 0x00, 0x7C, 0x0F, 0x07, 0xC0, 0x07, 0x80, 0xF0, 0x78,
  0x00, 0x78, 0x1F, 0x0F, 0x80, 0x07, 0x81, 0xF1, 0xF0, 0x00, 0xF8, 0x1E,
  0x1E, 0x00, 0x0F, 0x83, 0xE3, 0xE0, 0xF0, 0xF8, 0x3E, 0x3C, 0x3F, 0xCF,
  0x83, 0xC7, 0xC7, 0xFE, 0xF8, 0x7C, 0xF8, 0xFF, 0xEF, 0x8F, 0x8F, 0x1F,
  0x3E, 0x7D, 0xF9, 0xF1, 0xE1, 0xF7, 0xFF, 0x1E, 0x3E, 0x1F, 0x3F, 0xE3,
  0xE3, 0xC1, 0xF3, 0xFC, 0x7C, 0x7C, 0x1F, 0x06, 0x07, 0xC7, 0x81, 0xF0,
  0x00, 0xF8, 0x78, 0x1F, 0x00, 0x0F, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0xF8,
  0x1E, 0x00, 0x1E, 0x0F, 0x03, 0xE0, 0x03, 0xE0, 0xF0, 0x3E, 0x00, 0x7C,
  0x0F, 0x03, 0xE0, 0x07, 0x81, 0xF0, 0x3C, 0x00, 0xF8, 0x1F, 0x07, 0xC0,
  0x0F, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x1F, 0x07, 0x80, 0x3E, 0x01, 0xF0,
  0xF8, 0x03, 0xC0, 0x0F, 0x1F, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x07, 0x80,
  0x0F, 0xFE, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xF8, 0x7E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C,
  0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7D, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xC1, 0xFF, 0xF0, 0x3F, 0x0F, 0xEF,
  0xC0, 0xF8, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC1, 0xFC,
  0xFC, 0x3E, 0x03, 0xF3, 0xF1, 0xF8, 0x0F, 0xDF, 0x87, 0xE0, 0x1F, 0xFC,
  0x1F, 0x00, 0x7F, 0xF0, 0xFC, 0x00, 0xFF, 0x83, 0xF0, 0x03, 0xFE, 0x0F,
  0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x80, 0xFE, 0x01, 0xFF, 0x01, 0xF8,
  0x0F, 0xFC, 0x07, 0xF8, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0x8F, 0xC0, 0x7F, 0xFC, 0x3F, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0x30, 0x00,
  0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78,
  0x78, 0xF8, 0xF8, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x30, 0x3C, 0x01,
  0xE1, 0xE0, 0x1F, 0x8F, 0x00, 0xFF, 0x78, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFC, 0x00, 0x1F, 0xF0, 0x01,
  0xF7, 0x80, 0x1F, 0x3E, 0x03, 0xF8, 0xF8, 0x1F, 0x87, 0xC0, 0x78, 0x3F,
  0x01, 0xC0, 0xF8, 0x04, 0x07, 0x80, 0x00, 0x30, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x00, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x08, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x20, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xF8, 0x3F, 0x03, 0xF0, 0x3F,
  0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7E, 0x00, 0x3E,
  0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0,
  0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xBF, 0x7F, 0x9F, 0x1F, 0x8F, 0x87,
  0x0F, 0xC1, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xF9, 0xFE, 0x00, 0x7C, 0x07, 0xF0, 0x03, 0x80, 0x3F, 0x00, 0x20,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x1F, 0xF0, 0x0E, 0x01, 0xFC,
  0x03, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x80, 0x03,
  0xF8, 0x30, 0x01, 0xFC, 0x0F, 0xC3, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x0F,
  0x3E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x1E, 0x3E, 0x00,
  0x07, 0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x3F, 0x00, 0x0F, 0x87,
  0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x07,
  0xC0, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x3C, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x80, 0x78, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x04, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x40, 0x01, 0xFC, 0x0E,
  0x00, 0x7F, 0x01, 0xFC, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x40, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xF0, 0x40, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0xCF, 0xF8, 0x03, 0xF7,
  0xFF, 0x00, 0xFB, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xF8, 0x7F, 0x07,
  0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x1F,
  0x0F, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xF0,
  0x1F, 0x83, 0xF8, 0x07, 0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F,
  0x01, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x07, 0xE0,
  0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF3, 0xF8, 0x01, 0xF8, 0x3F,
  0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0,
  0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xE3, 0xF8, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07,
  0xE1, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x1F, 0x87, 0xC0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x0F, 0xF0, 0xFC, 0x0F, 0xF8, 0x7F,
  0x8F, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xBE, 0x03, 0xFF, 0xBF, 0x00,
  0xFF, 0x1F, 0x80, 0x0E, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x03, 0xC7, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xC0,
  0xFE, 0x07, 0xF0, 0x7F, 0x81, 0xF8, 0x0F, 0xC0, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0x80,
  0x10, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0xF8, 0x7F, 0x0E, 0x03, 0xF0, 0x80, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x3F, 0x80, 0xF0, 0x78,
  0x07, 0xFF, 0x07, 0x87, 0x80, 0xFF, 0xF8, 0x3C, 0x3C, 0x0F, 0xFF, 0xC1,
  0xE3, 0xC0, 0x7C, 0x3E, 0x0F, 0x1E, 0x07, 0xC1, 0xE0, 0x79, 0xF0, 0x7C,
  0x0F, 0x03, 0xCF, 0x03, 0xC0, 0xF8, 0x1E, 0x78, 0x3E, 0x07, 0xC0, 0xF7,
  0xC1, 0xE0, 0x3C, 0x0F, 0xBC, 0x0F, 0x01, 0xE0, 0x79, 0xE0, 0xF8, 0x1F,
  0x03, 0xCF, 0x07, 0x80, 0xF8, 0x1E, 0xF8, 0x3C, 0x07, 0x80, 0xF7, 0xC1,
  0xE0, 0x3C, 0x0F, 0x3C, 0x1F, 0x03, 0xE0, 0x79, 0xE0, 0xF8, 0x1F, 0x07,
  0xCF, 0x07, 0xC1, 0xF8, 0x3C, 0x78, 0x3E, 0x0F, 0x83, 0xE3, 0xC1, 0xF0,
  0xFE, 0x1E, 0x1E, 0x07, 0xCF, 0xF3, 0xE0, 0xF0, 0x3F, 0xF7, 0xFE, 0x07,
  0x80, 0xFF, 0x1F, 0xE0, 0x3C, 0x07, 0xF0, 0x7E, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x08, 0x00, 0x07, 0xF0, 0x03, 0xC0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x3E, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xFC,
  0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x83, 0xE0,
  0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x7E,
  0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F,
  0x80, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0x80, 0xFF, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x3F,
  0x01, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x0F, 0xF8, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0x83, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x01,
  0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x3F, 0x00,
  0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8,
  0x3E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0,
  0x0F, 0xE0, 0x7E, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFE, 0xFC, 0x01, 0xFE, 0x00, 0xC0,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x06, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x7F, 0xC0, 0x1F, 0x80, 0x7F, 0x00,
  0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xC0,
  0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01,
  0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x3F, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x3E, 0x00, 0x3F,
  0x81, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0xFF, 0x80,
  0x7E, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1E,
  0x01, 0xFE, 0x00, 0x08, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0x1F, 0xC0, 0x1F, 0xFC, 0x3F, 0x00,
  0x7F, 0xF8, 0x7E, 0x00, 0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0xE1, 0xF8, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xF0, 0x07, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80,
  0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07,
  0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xE0,
  0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8,
  0x00, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xE0,
  0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07, 0xDF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xE7, 0xC0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x03, 0xEF,
  0x80, 0x0F, 0xBF, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0xC0, 0x7E, 0xF8, 0x01,
  0xF3, 0xE0, 0x1F, 0xBE, 0x00, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7E,
  0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x80, 0x7C, 0xF8, 0x07, 0xC7, 0xE0, 0x3F,
  0x1E, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x03, 0xE1, 0xF0,
  0x3E, 0x3F, 0x00, 0xF8, 0x7C, 0x1F, 0x0F, 0xC0, 0x7E, 0x1F, 0x07, 0xC3,
  0xF0, 0x1F, 0x87, 0xC3, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0xF8, 0x7E, 0x01,
  0xF0, 0x7C, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x1F, 0x07, 0xE0, 0x3F, 0x07,
  0xCF, 0xC1, 0xF0, 0x0F, 0xC1, 0xF3, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0xF8,
  0x3F, 0x00, 0xF8, 0x1F, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xDF, 0x03, 0xF0,
  0x1F, 0x81, 0xFF, 0x80, 0xF8, 0x07, 0xE0, 0x7F, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFE,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0xF8, 0x03, 0xFC, 0x00,
  0x1F, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x0F, 0xF0, 0x00, 0xFC, 0x03, 0xFE,
  0x00, 0x1F, 0x00, 0x7F, 0xE0, 0x03, 0xE0, 0x0F, 0xFC, 0x00, 0x7C, 0x01,
  0xFF, 0x80, 0x1F, 0x80, 0x7F, 0xF0, 0x03, 0xF0, 0x0F, 0xBF, 0x00, 0x7C,
  0x01, 0xF7, 0xE0, 0x0F, 0x80, 0x3E, 0x7C, 0x03, 0xF0, 0x07, 0xCF, 0x80,
  0x7E, 0x01, 0xF9, 0xF0, 0x0F, 0xC0, 0x3F, 0x3F, 0x01, 0xF0, 0x07, 0xC3,
  0xE0, 0x3E, 0x00, 0xF8, 0x7C, 0x0F, 0xC0, 0x1F, 0x0F, 0x81, 0xF8, 0x07,
  0xE1, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0xF8,
  0x03, 0xE0, 0x7C, 0x3F, 0x00, 0xFC, 0x0F, 0x87, 0xE0, 0x1F, 0x81, 0xF8,
  0xF8, 0x03, 0xF0, 0x1F, 0x1F, 0x00, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x80,
  0x7C, 0xFC, 0x03, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0x01, 0xFB, 0xE0, 0x0F,
  0x80, 0x1F, 0x7C, 0x01, 0xF0, 0x03, 0xEF, 0x80, 0x3E, 0x00, 0x7F, 0xF0,
  0x0F, 0xC0, 0x0F, 0xFE, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x3E, 0x00, 0x1F,
  0xF0, 0x07, 0xC0, 0x03, 0xFE, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0x00,
  0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x1F,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFE, 0x7F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x00, 0xFE, 0x07, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFE,
  0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0xFE, 0x01, 0xFE,
  0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0x81, 0xFE, 0x01, 0xF8,
  0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x3F,
  0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x3E,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F,
  0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0xC0, 0xFC, 0x07, 0xF8, 0x0F,
  0xC1, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFE, 0x7F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x00, 0xFE, 0x07, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFE,
  0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0xFE, 0x01, 0xFE,
  0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xF0, 0x3F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F,
  0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC1, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF8,
  0x1F, 0x00, 0xFE, 0x07, 0xE0, 0x7F, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFE, 0x01, 0xC0, 0x1F, 0xC0,
  0x04, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x60, 0x01, 0xFC, 0x07, 0x80, 0x7F, 0x80, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xE0,
  0x7E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01,
  0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7C,
  0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF9,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0x7C, 0x00,
  0x7F, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x07,
  0xC0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x1F, 0x80, 0x3E,
  0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x07, 0xE0,
  0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF8,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xFD, 0xF8, 0x00,
  0x1F, 0xBE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xF8, 0x01, 0xF8,
  0xFC, 0x01, 0xFF, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xFC, 0x01, 0xF0, 0x7E, 0x01, 0xFF, 0x80, 0x7E, 0x0F, 0xC0, 0x3F,
  0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xBE, 0x03, 0xF0, 0x3F, 0x01, 0xF7, 0xC0,
  0x7E, 0x07, 0xE0, 0x3C, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0x9F, 0x03, 0xF0,
  0x1F, 0x81, 0xF3, 0xE0, 0x7E, 0x03, 0xF0, 0x7C, 0x7C, 0x1F, 0x80, 0x7E,
  0x0F, 0x8F, 0x83, 0xF0, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x01, 0xF8, 0x7C,
  0x3E, 0x1F, 0x80, 0x3F, 0x0F, 0x87, 0xC3, 0xF0, 0x07, 0xE3, 0xE0, 0xF8,
  0xFC, 0x00, 0xFC, 0x7C, 0x1F, 0x1F, 0x80, 0x1F, 0x9F, 0x03, 0xE3, 0xE0,
  0x03, 0xF3, 0xE0, 0x7C, 0xFC, 0x00, 0x7E, 0x7C, 0x0F, 0x9F, 0x00, 0x0F,
  0xDF, 0x01, 0xF3, 0xE0, 0x01, 0xF3, 0xE0, 0x3E, 0xFC, 0x00, 0x3E, 0xF8,
  0x07, 0xDF, 0x00, 0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x00, 0xFB, 0xE0, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03,
  0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x01,
  0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0x9F, 0x00, 0x1F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x3E, 0x03,
  0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x81, 0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x1F,
  0x3E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x00, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0,
  0x7C, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x7C, 0x78, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F,
  0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF3, 0xF0, 0x00,
  0xF9, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xE1, 0xF8,
  0x7C, 0x1F, 0x07, 0x80, 0x00, 0x3F, 0x87, 0xC0, 0x3F, 0xF1, 0xF0, 0x1F,
  0xFE, 0xF8, 0x0F, 0xFF, 0xBE, 0x07, 0xFF, 0xFF, 0x83, 0xFC, 0x3F, 0xE0,
  0xFE, 0x07, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x80,
  0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x3F,
  0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x03,
  0xF8, 0x3F, 0x01, 0xFE, 0x0F, 0xC0, 0xFF, 0x03, 0xFC, 0xFF, 0xC0, 0x7F,
  0xFD, 0xF0, 0x1F, 0xFE, 0x7C, 0x03, 0xFF, 0x1E, 0x00, 0x7F, 0x87, 0x80,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x3F, 0x80, 0x1F, 0x3F, 0xF0, 0x07, 0xDF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x0F,
  0xC1, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x07, 0xE0,
  0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F,
  0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7E,
  0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x0F, 0xC1, 0xFE,
  0x07, 0xF0, 0x7F, 0xE3, 0xF8, 0x1F, 0x7F, 0xFC, 0x07, 0xDF, 0xFF, 0x01,
  0xE3, 0xFF, 0x00, 0xF8, 0x7F, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xF8, 0x10, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x40, 0xFF, 0x1E, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x3F, 0xC7, 0xE0, 0x03, 0xFF, 0x3F, 0x00, 0x3F, 0xFD, 0xF0, 0x03,
  0xFF, 0xEF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0x80,
  0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0xFC,
  0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x1F,
  0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00,
  0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC,
  0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x81,
  0xFE, 0x00, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0xEF, 0x80, 0x1F, 0xFE, 0x7C,
  0x00, 0x7F, 0xE3, 0xC0, 0x01, 0xFE, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x07,
  0xF0, 0xFC, 0x3F, 0x81, 0xF0, 0xFC, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x80,
  0x7C, 0xFC, 0x01, 0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0x7E, 0x03, 0xF9,
  0xF8, 0x7F, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x04, 0x1F, 0xC0, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0xFF, 0xC7, 0xC0, 0x0F, 0xFF, 0x7C,
  0x00, 0xFF, 0xFB, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x07,
  0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x80,
  0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0xFC,
  0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x1F,
  0x80, 0x0F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00,
  0x3F, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0xFF, 0x00, 0xFC, 0x07, 0xF0, 0x07,
  0xE0, 0x7F, 0x80, 0x3F, 0xCF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xBF, 0x00, 0x1F, 0xF9, 0xF0, 0x00, 0x7F, 0x8F, 0x80, 0x00, 0x60, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x10, 0x00,
  0xFE, 0x00, 0xF0, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x3F,
  0xF0, 0x07, 0xDF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFB, 0xFF, 0xF0, 0x3F,
  0xE1, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xF0,
  0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x03, 0xE0,
  0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07,
  0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x7E, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xFC,
  0x01, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7E,
  0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x1F, 0x80,
  0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xCF,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x7E,
  0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x80, 0xFC,
  0x01, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0,
  0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0xFE, 0x03, 0xF8, 0x01, 0xE3, 0xFF, 0x0F,
  0xFC, 0x01, 0xE7, 0xFF, 0x1F, 0xFE, 0x03, 0xEF, 0xFF, 0xBF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x1F, 0xF8, 0x7F, 0x03, 0xF8, 0x1F,
  0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x1F, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x00,
  0x7E, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x0F,
  0x80, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x3E,
  0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x7E, 0x00, 0xF8,
  0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x3F, 0x00,
  0x7C, 0x01, 0xF0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x03,
  0xF0, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x7E,
  0x00, 0xF8, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF8,
  0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x01, 0xF0, 0xFE, 0x00, 0x78,
  0xFF, 0xC0, 0x1E, 0x7F, 0xF8, 0x0F, 0xBF, 0xFE, 0x03, 0xEF, 0xFF, 0xC0,
  0xFF, 0x87, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x0F,
  0xC1, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x0F, 0xC0,
  0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x0F,
  0x80, 0x1F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC,
  0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x83,
  0xF0, 0x07, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x7E,
  0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xE0,
  0x7F, 0x9F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x1F, 0xC0, 0x01, 0xF3,
  0xFF, 0x00, 0x0F, 0x3F, 0xFC, 0x00, 0xFB, 0xFF, 0xE0, 0x07, 0xDF, 0x7F,
  0x80, 0x3F, 0xE0, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00,
  0xFE, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x3E, 0x01, 0xF8,
  0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07,
  0xE0, 0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x80,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF0,
  0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xF9, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xDF, 0xFF, 0x00, 0x3E, 0x7F, 0xE0, 0x01, 0xF1,
  0xFE, 0x00, 0x1F, 0x81, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xC0, 0x3F, 0xF1, 0xF0,
  0x1F, 0xFE, 0xF8, 0x0F, 0xFF, 0xBE, 0x07, 0xFF, 0xFF, 0x83, 0xF8, 0x1F,
  0xE0, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7C,
  0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC,
  0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0xFF, 0x03, 0xFC, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFE, 0xFC, 0x03, 0xFF, 0x3E, 0x00, 0x7F, 0x8F,
  0x80, 0x03, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0xFC, 0x07, 0x8F, 0xE0, 0x1E, 0x7F, 0x80, 0xFB, 0xFE, 0x03, 0xEF,
  0xF0, 0x0F, 0xFE, 0x40, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFE, 0x0F, 0xF1, 0xF0, 0x3F, 0x00, 0xC0, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC2,
  0x00, 0x7F, 0x0C, 0x01, 0xF8, 0x3E, 0x1F, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x88,
  0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1E, 0x00, 0x07,
  0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0x7E,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8,
  0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x03, 0xFC, 0x1F,
  0xCF, 0xBE, 0x0F, 0xFF, 0xDE, 0x03, 0xFF, 0xDF, 0x01, 0xFF, 0xCF, 0x80,
  0x7F, 0x87, 0xC0, 0x02, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0x8F, 0x80, 0x3F,
  0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0xC1,
  0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xF0, 0x1F,
  0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF1,
  0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x7E,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0x7E, 0x00, 0xFF,
  0xE0, 0x1F, 0xC0, 0x1F, 0x7C, 0x03, 0xF8, 0x07, 0xEF, 0x80, 0xFF, 0x00,
  0xF9, 0xF0, 0x1F, 0xE0, 0x3F, 0x3E, 0x03, 0xFC, 0x07, 0xE7, 0xC0, 0xFF,
  0x80, 0xF8, 0xF8, 0x1E, 0xF0, 0x3F, 0x1F, 0x07, 0xDE, 0x07, 0xC3, 0xE0,
  0xFB, 0xC1, 0xF8, 0x7C, 0x1E, 0x78, 0x3E, 0x0F, 0x87, 0xCF, 0x07, 0xC1,
  0xF0, 0xF1, 0xE1, 0xF8, 0x3E, 0x3E, 0x3C, 0x3E, 0x07, 0xC7, 0xC7, 0x8F,
  0xC0, 0xF8, 0xF0, 0xF1, 0xF0, 0x1F, 0x3E, 0x1E, 0x3E, 0x03, 0xE7, 0x83,
  0xCF, 0x80, 0x7D, 0xF0, 0x79, 0xF0, 0x0F, 0xBE, 0x0F, 0x7E, 0x01, 0xF7,
  0x81, 0xEF, 0x80, 0x3F, 0xF0, 0x3D, 0xF0, 0x07, 0xBC, 0x07, 0xFC, 0x00,
  0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x03, 0xFC, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x01, 0xFC, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF8,
  0x0F, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E,
  0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x7E,
  0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01,
  0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF0,
  0x1F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x3F,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0x80, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x01, 0x3F, 0xF0,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x80, 0x03, 0xF8,
};

const GFXglyph NotoSans_Condensed_MediumItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 15, 43, 15, 1, -42 },
  { 82, 18, 15, 22, 6, -42 },
  { 116, 30, 42, 30, 1, -42 },
  { 274, 26, 48, 26, 1, -45 },
  { 430, 36, 44, 41, 3, -43 },
  { 628, 30, 44, 31, 0, -43 },
  { 793, 8, 15, 13, 6, -42 },
  { 808, 19, 51, 16, 1, -42 },
  { 930, 19, 51, 16, -4, -42 },
  { 1052, 21, 23, 25, 6, -45 },
  { 1113, 24, 28, 28, 3, -35 },
  { 1197, 12, 15, 13, -3, -7 },
  { 1220, 14, 6, 17, 1, -19 },
  { 1231, 7, 9, 13, 1, -8 },
  { 1239, 29, 42, 21, -3, -42 },
  { 1392, 24, 44, 26, 2, -43 },
  { 1524, 17, 42, 26, 6, -42 },
  { 1614, 28, 43, 26, -2, -43 },
  { 1765, 26, 44, 26, 0, -43 },
  { 1908, 27, 42, 26, -1, -42 },
  { 2050, 27, 43, 26, 0, -42 },
  { 2196, 26, 44, 26, 2, -43 },
  { 2339, 27, 42, 26, 2, -42 },
  { 2481, 27, 44, 26, 0, -43 },
  { 2630, 25, 44, 26, 1, -43 },
  { 2768, 13, 33, 14, 0, -32 },
  { 2822, 16, 40, 14, -3, -32 },
  { 2902, 24, 28, 28, 3, -35 },
  { 2986, 24, 17, 28, 3, -29 },
  { 3037, 24, 28, 28, 3, -35 },
  { 3121, 20, 44, 20, 2, -43 },
  { 3231, 37, 47, 40, 2, -42 },
  { 3449, 28, 42, 28, -4, -42 },
  { 3596, 28, 42, 29, 1, -42 },
  { 3743, 28, 44, 27, 3, -43 },
  { 3897, 30, 42, 32, 1, -42 },
  { 4055, 26, 42, 25, 1, -42 },
  { 4192, 26, 42, 23, 1, -42 },
  { 4329, 31, 44, 33, 3, -43 },
  { 4500, 33, 42, 33, 1, -42 },
  { 4674, 23, 42, 17, -2, -42 },
  { 4795, 25, 54, 14, -9, -42 },
  { 4964, 32, 42, 28, 1, -42 },
  { 5132, 18, 42, 23, 1, -42 },
  { 5227, 42, 42, 42, 1, -42 },
  { 5448, 35, 42, 35, 1, -42 },
  { 5632, 30, 44, 34, 3, -43 },
  { 5797, 28, 42, 28, 1, -42 },
  { 5944, 30, 53, 34, 3, -43 },
  { 6143, 27, 42, 28, 1, -42 },
  { 6285, 28, 44, 25, -1, -43 },
  { 6439, 24, 42, 24, 5, -42 },
  { 6565, 30, 43, 32, 3, -42 },
  { 6727, 27, 42, 27, 5, -42 },
  { 6869, 43, 42, 43, 5, -42 },
  { 7095, 33, 42, 26, -3, -42 },
  { 7269, 25, 42, 25, 5, -42 },
  { 7401, 29, 42, 24, -2, -42 },
  { 7554, 22, 51, 17, -1, -42 },
  { 7695, 11, 42, 21, 6, -42 },
  { 7753, 23, 51, 17, -4, -42 },
  { 7900, 25, 24, 27, 1, -42 },
  { 7975, 20, 4, 20, -5, 5 },
  { 7985, 9, 9, 16, 9, -45 },
  { 7996, 26, 33, 28, 2, -32 },
  { 8104, 26, 46, 28, 0, -45 },
  { 8254, 21, 33, 22, 2, -32 },
  { 8341, 29, 46, 28, 2, -45 },
  { 8508, 22, 33, 25, 2, -32 },
  { 8599, 30, 59, 16, -7, -45 },
  { 8821, 29, 46, 28, -1, -32 },
  { 8988, 26, 45, 28, 0, -45 },
  { 9135, 15, 44, 13, 0, -44 },
  { 9218, 23, 58, 13, -8, -44 },
  { 9385, 27, 45, 25, 0, -45 },
  { 9537, 16, 45, 13, 0, -45 },
  { 9627, 40, 32, 42, 0, -32 },
  { 9787, 26, 32, 28, 0, -32 },
  { 9891, 24, 33, 27, 2, -32 },
  { 9990, 29, 46, 28, -3, -32 },
  { 10157, 26, 46, 28, 2, -32 },
  { 10307, 22, 32, 19, 0, -32 },
  { 10395, 22, 33, 21, 0, -32 },
  { 10486, 17, 40, 17, 2, -39 },
  { 10571, 25, 33, 28, 2, -32 },
  { 10675, 23, 32, 23, 3, -32 },
  { 10767, 35, 32, 36, 4, -32 },
  { 10907, 29, 32, 24, -3, -32 },
  { 11023, 31, 46, 23, -5, -32 },
  { 11202, 24, 32, 20, -2, -32 },
  { 11298, 23, 51, 20, 1, -42 },
  { 11445, 5, 59, 25, 10, -45 },
  { 11482, 22, 51, 20, -3, -42 },
  { 11623, 24, 8, 28, 3, -25 },
};

const GFXfont NotoSans_Condensed_MediumItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC59PT7B_H_
