#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC21PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0x30, 0x86, 0x00, 0x43, 0x8E,
  0x00, 0x6E, 0xD9, 0x36, 0x6C, 0x80, 0x06, 0x40, 0x98, 0x33, 0x06, 0x43,
  0xFE, 0x7F, 0xC6, 0x40, 0x88, 0x13, 0x1F, 0xFB, 0xFE, 0x13, 0x06, 0x60,
  0xC8, 0x13, 0x00, 0x02, 0x00, 0x80, 0xFC, 0x7E, 0x34, 0x0D, 0x03, 0x40,
  0x70, 0x0E, 0x03, 0xC0, 0xB0, 0x2C, 0x8B, 0x3F, 0x87, 0xC0, 0x40, 0x10,
  0x00, 0x38, 0x33, 0x63, 0x1B, 0x10, 0x99, 0x8C, 0xD8, 0x66, 0x83, 0x2D,
  0xDB, 0x5B, 0x76, 0x98, 0x6C, 0xC2, 0x66, 0x33, 0x21, 0x1B, 0x18, 0xD1,
  0x87, 0x80, 0x0F, 0x03, 0xB0, 0x66, 0x0C, 0xC1, 0xB0, 0x36, 0x07, 0x80,
  0xE1, 0x7E, 0xCC, 0xDB, 0x1E, 0x61, 0xCC, 0x31, 0xFF, 0x1F, 0x70, 0x6D,
  0x6C, 0x06, 0x18, 0x20, 0xC3, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x82, 0x0C,
  0x08, 0x10, 0x30, 0x60, 0xC0, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x10, 0x60, 0xC3, 0x06, 0x18, 0x31, 0xC0, 0x18, 0x18, 0xD8,
  0xFF, 0x3F, 0x68, 0xEC, 0x4C, 0x18, 0x0C, 0x06, 0x03, 0x0F, 0xF8, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x00, 0x36, 0x64, 0xC0, 0x7F, 0xC0, 0x5F, 0x80,
  0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x08, 0x06,
  0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0x1E, 0x3F, 0x33, 0x63, 0x63,
  0xE3, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6, 0xC6, 0xCC, 0xFC, 0x78, 0x0C, 0x77,
  0xFB, 0x58, 0x61, 0x86, 0x18, 0xC3, 0x0C, 0x31, 0x86, 0x00, 0x0F, 0x87,
  0xF0, 0x8C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x80, 0xC0,
  0x60, 0x30, 0x1F, 0xCF, 0xF0, 0x1F, 0x1F, 0xC4, 0x60, 0x30, 0x18, 0x1C,
  0x7C, 0x3C, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x77, 0xF3, 0xF0, 0x01, 0x81,
  0xC1, 0xE0, 0xB0, 0xF0, 0xD8, 0x4C, 0x66, 0x63, 0x23, 0x3F, 0xFF, 0xF0,
  0x60, 0x20, 0x30, 0x1F, 0x8F, 0xC6, 0x02, 0x03, 0x01, 0x80, 0xF8, 0x4E,
  0x03, 0x01, 0x80, 0xC0, 0x68, 0x77, 0xF3, 0xF0, 0x0F, 0x8F, 0x8C, 0x06,
  0x06, 0x03, 0x23, 0x79, 0xCC, 0xC3, 0x61, 0xB1, 0x98, 0xCC, 0x67, 0xE1,
  0xE0, 0x7F, 0xBF, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C,
  0x0C, 0x06, 0x06, 0x03, 0x03, 0x00, 0x0F, 0x87, 0xE3, 0x1C, 0xC3, 0x31,
  0x86, 0xE1, 0xF0, 0x78, 0x37, 0x18, 0xCC, 0x33, 0x0C, 0xC3, 0x1F, 0x87,
  0xC0, 0x0F, 0x0F, 0xCC, 0x66, 0x36, 0x1B, 0x0D, 0x8E, 0xE7, 0x3D, 0x89,
  0x80, 0xC0, 0xC0, 0x67, 0xE3, 0xE0, 0x39, 0x80, 0x00, 0x00, 0x00, 0x47,
  0x30, 0x1C, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x18, 0xC3, 0x00,
  0x01, 0x83, 0x87, 0x0E, 0x0C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0x80, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38,
  0x78, 0xF1, 0xE0, 0xC0, 0x00, 0x7C, 0xFC, 0x18, 0x30, 0x61, 0x86, 0x18,
  0x60, 0xC1, 0x00, 0x04, 0x18, 0x30, 0x00, 0x07, 0xE0, 0x63, 0x86, 0x04,
  0x60, 0x36, 0x3D, 0xA2, 0x6F, 0x32, 0x79, 0x33, 0x99, 0x9C, 0xCC, 0xA6,
  0xCD, 0x3F, 0xC8, 0xCC, 0x60, 0x03, 0x00, 0x0F, 0xE0, 0x1E, 0x00, 0x03,
  0x80, 0xE0, 0x78, 0x1E, 0x0D, 0x83, 0x60, 0xD8, 0x66, 0x19, 0x8F, 0xE3,
  0xF9, 0x86, 0x61, 0xF8, 0x7C, 0x0C, 0x1F, 0x87, 0xF1, 0x8C, 0x63, 0x30,
  0xCC, 0x73, 0xF8, 0xFC, 0x31, 0x98, 0x66, 0x19, 0x86, 0x63, 0x9F, 0xCF,
  0xE0, 0x0F, 0xC7, 0xE3, 0x80, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xE0, 0x1F, 0x83, 0xE0, 0x1F, 0x83, 0xF8, 0x63,
  0x8C, 0x73, 0x86, 0x60, 0xCC, 0x19, 0x87, 0x30, 0xCC, 0x19, 0x87, 0x30,
  0xC6, 0x38, 0xFE, 0x3F, 0x00, 0x1F, 0xC7, 0xE1, 0x80, 0x60, 0x38, 0x0C,
  0x03, 0xF0, 0xFC, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1F, 0x8F, 0xE0,
  0x1F, 0xC7, 0xE1, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xFC, 0x3F, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x00, 0x0F, 0xE3, 0xFC, 0xE1, 0x18,
  0x06, 0x00, 0xC0, 0x38, 0x06, 0x1E, 0xC7, 0xD8, 0x33, 0x06, 0x60, 0xCE,
  0x18, 0xFE, 0x0F, 0xC0, 0x18, 0x31, 0x83, 0x18, 0x71, 0x86, 0x38, 0x63,
  0x06, 0x3F, 0xE3, 0xFC, 0x30, 0xC6, 0x0C, 0x60, 0xC6, 0x0C, 0x61, 0x86,
  0x18, 0xC1, 0x80, 0x1F, 0x87, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x83, 0xF0, 0x03, 0x81, 0x80, 0xC0,
  0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x60, 0x30, 0x18, 0x78, 0x3C, 0x00, 0x18, 0x71, 0x8C, 0x19, 0xC1, 0x98,
  0x33, 0x03, 0x60, 0x3E, 0x03, 0xE0, 0x36, 0x06, 0x60, 0x66, 0x06, 0x30,
  0x63, 0x06, 0x30, 0xC3, 0x80, 0x18, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x18,
  0x30, 0xC1, 0x83, 0x06, 0x0F, 0xFF, 0x80, 0x1C, 0x0E, 0x38, 0x1C, 0x70,
  0x78, 0xA0, 0xF3, 0x43, 0x66, 0x87, 0x8D, 0x9B, 0x1B, 0x36, 0x36, 0xCC,
  0xCD, 0xB1, 0x9A, 0x63, 0x3C, 0xC6, 0x71, 0x88, 0xE3, 0x31, 0x8C, 0x00,
  0x1C, 0x18, 0xE1, 0x87, 0x0C, 0x2C, 0x63, 0x63, 0x1B, 0x18, 0xD9, 0x86,
  0x4C, 0x33, 0x63, 0x1B, 0x18, 0xD0, 0xC7, 0x86, 0x1C, 0x20, 0xE3, 0x07,
  0x00, 0x0F, 0x83, 0xF8, 0xE3, 0x18, 0x76, 0x06, 0xC1, 0xF8, 0x3E, 0x06,
  0xC0, 0xD8, 0x1B, 0x07, 0x60, 0xCE, 0x38, 0xFE, 0x0F, 0x80, 0x1F, 0x87,
  0xF1, 0x8C, 0x63, 0x38, 0xCC, 0x33, 0x1C, 0xFE, 0x3F, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x0C, 0x00, 0x0F, 0x83, 0xF8, 0xE3, 0x18, 0x76, 0x06,
  0xC1, 0xF8, 0x3E, 0x06, 0xC0, 0xD8, 0x1B, 0x07, 0x60, 0xCE, 0x38, 0xFE,
  0x0F, 0x80, 0x60, 0x06, 0x00, 0xC0, 0x1C, 0x00, 0x1F, 0x07, 0xF1, 0x8C,
  0x63, 0x30, 0xCC, 0x33, 0x18, 0xFE, 0x3E, 0x19, 0x86, 0x61, 0x8C, 0x63,
  0x18, 0xCC, 0x38, 0x0F, 0xC7, 0xE3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80,
  0x78, 0x0E, 0x01, 0xC0, 0x30, 0x0C, 0x86, 0x3F, 0x8F, 0xC0, 0xFF, 0xFF,
  0x18, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xC0,
  0xC0, 0x30, 0x66, 0x0C, 0xC3, 0x18, 0x66, 0x0C, 0xC1, 0x98, 0x73, 0x0C,
  0xE1, 0x98, 0x33, 0x06, 0x61, 0x8C, 0x31, 0xFC, 0x1F, 0x00, 0xC1, 0xF0,
  0x6C, 0x33, 0x0C, 0xC6, 0x31, 0x8C, 0x63, 0x30, 0xCC, 0x36, 0x0D, 0x83,
  0xC0, 0xF0, 0x38, 0x0E, 0x00, 0xC3, 0x07, 0x86, 0x1B, 0x0C, 0x36, 0x38,
  0x6C, 0x51, 0x99, 0xA3, 0x33, 0x4C, 0x6C, 0x98, 0xD9, 0x31, 0xA2, 0xC3,
  0xC5, 0x87, 0x8E, 0x0E, 0x1C, 0x1C, 0x30, 0x30, 0x60, 0x00, 0x18, 0x70,
  0xC6, 0x0C, 0xC0, 0xDC, 0x0D, 0x80, 0xF0, 0x07, 0x00, 0x60, 0x0E, 0x01,
  0xB0, 0x1B, 0x03, 0x30, 0x73, 0x06, 0x38, 0xC1, 0x80, 0xC3, 0xE1, 0xB1,
  0x98, 0xC6, 0xC3, 0xE1, 0xE0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x06,
  0x03, 0x00, 0x0F, 0xE3, 0xF8, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80,
  0x70, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x00, 0xFE, 0x3F, 0xC0, 0x0F,
  0x87, 0x83, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x7C, 0x00, 0xCC, 0xC4, 0x66, 0x66,
  0x66, 0x23, 0x33, 0x30, 0x1F, 0x1E, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C,
  0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0xF0, 0x06, 0x07,
  0x03, 0x83, 0x61, 0x31, 0x88, 0x86, 0xC3, 0xC0, 0x80, 0xFE, 0xCD, 0x80,
  0x08, 0x1E, 0xDC, 0xEC, 0x6E, 0x36, 0x1B, 0x0D, 0x8C, 0xC6, 0x67, 0x3F,
  0x9E, 0xC0, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0xA1, 0xBC, 0xE6, 0x63, 0x31,
  0xB0, 0xD8, 0x6C, 0x36, 0x3B, 0x1B, 0xF9, 0xBC, 0x0C, 0x7D, 0xCB, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0xE3, 0xC0, 0x00, 0xC0, 0x30, 0x18, 0x06,
  0x09, 0x8F, 0x67, 0x39, 0x8C, 0xC3, 0x30, 0xCC, 0x33, 0x18, 0xC6, 0x33,
  0x8F, 0xE3, 0xD8, 0x08, 0x3E, 0x73, 0x63, 0xC6, 0xDE, 0xF8, 0xC0, 0xC0,
  0xC0, 0xEC, 0x7C, 0x03, 0xC0, 0xF0, 0x60, 0x18, 0x06, 0x87, 0xC0, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30,
  0x0C, 0x03, 0x03, 0x80, 0xE0, 0x00, 0x04, 0x07, 0xB3, 0x9C, 0xC6, 0x71,
  0x98, 0x66, 0x19, 0x8C, 0x63, 0x19, 0xC7, 0xF1, 0xEC, 0x06, 0x01, 0x88,
  0x63, 0xF0, 0xF8, 0x00, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0xA1, 0xBC, 0xE6,
  0x63, 0x31, 0xB8, 0xD8, 0x6C, 0x66, 0x33, 0x1B, 0x0D, 0x8E, 0x08, 0xC6,
  0x00, 0x98, 0xC6, 0x33, 0x98, 0xC6, 0x33, 0x18, 0x01, 0x03, 0x03, 0x00,
  0x01, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18,
  0x18, 0x18, 0x38, 0xF0, 0xE0, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x4C,
  0x63, 0x30, 0xD8, 0x3E, 0x0B, 0x07, 0xC1, 0xF0, 0x66, 0x19, 0x8C, 0x63,
  0x1C, 0x1C, 0x61, 0x86, 0x18, 0xC3, 0x0C, 0x30, 0xC6, 0x18, 0x61, 0x8C,
  0x30, 0x02, 0x10, 0xDE, 0xF3, 0x9C, 0xCC, 0x63, 0x31, 0x8D, 0xC6, 0x36,
  0x30, 0x98, 0xC6, 0x63, 0x19, 0x8C, 0x6C, 0x31, 0xB1, 0x8C, 0x02, 0x1B,
  0xCE, 0x66, 0x33, 0x1B, 0x8D, 0x86, 0xC6, 0x63, 0x31, 0xB0, 0xD8, 0xE0,
  0x08, 0x3E, 0x73, 0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6, 0xFC, 0x78,
  0x01, 0x06, 0xF1, 0xCC, 0x63, 0x18, 0xC6, 0x33, 0x0C, 0xC3, 0x31, 0xCC,
  0x67, 0xF1, 0xBC, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x00, 0x08, 0x1E,
  0xDC, 0xEC, 0x6C, 0x36, 0x1B, 0x0D, 0x8C, 0xC6, 0x67, 0x3F, 0x9E, 0xC0,
  0xC0, 0x60, 0x30, 0x18, 0x1C, 0x00, 0x03, 0x36, 0x3E, 0x38, 0x30, 0x70,
  0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0x08, 0x3F, 0x72, 0x60, 0x70, 0x38,
  0x1C, 0x0C, 0x0C, 0x0C, 0xFC, 0xF8, 0x10, 0xC3, 0x7E, 0x61, 0x86, 0x18,
  0xC3, 0x0C, 0x30, 0xF3, 0xC0, 0x61, 0xB1, 0x98, 0xCC, 0x6C, 0x36, 0x1B,
  0x19, 0x8C, 0xCE, 0x7F, 0x3D, 0x00, 0xC3, 0xC6, 0xC6, 0xC6, 0xCC, 0xCC,
  0x58, 0x58, 0x70, 0x70, 0x60, 0xC7, 0x1E, 0x39, 0xB3, 0xCD, 0x9E, 0xCC,
  0xB6, 0x6D, 0xA3, 0x4F, 0x1E, 0x78, 0xF3, 0x87, 0x1C, 0x38, 0xC0, 0x18,
  0xC6, 0x61, 0xB0, 0x3C, 0x0E, 0x03, 0x01, 0xE0, 0xD8, 0x36, 0x18, 0xCE,
  0x30, 0x18, 0x63, 0x1C, 0x63, 0x0C, 0x60, 0x98, 0x13, 0x02, 0xC0, 0x58,
  0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x3C, 0x07, 0x00, 0x1F,
  0x81, 0x81, 0x80, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x70, 0x3F, 0x3F, 0x80,
  0x03, 0x07, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x70, 0xE0, 0x30, 0x30,
  0x30, 0x30, 0x20, 0x60, 0x70, 0x38, 0xFF, 0xFF, 0xF8, 0x1C, 0x1E, 0x06,
  0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0F, 0x06, 0x1C, 0x18, 0x18, 0x10, 0x30,
  0x30, 0x70, 0xE0, 0x70, 0xFF, 0xE3, 0xC0,
};

const GFXglyph NotoSans_Condensed_MediumItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 15, 5, 0, -15 },
  { 13, 7, 5, 8, 2, -15 },
  { 18, 11, 15, 11, 0, -15 },
  { 39, 10, 17, 9, 0, -16 },
  { 61, 13, 15, 14, 1, -15 },
  { 86, 11, 15, 11, 0, -15 },
  { 107, 3, 5, 4, 2, -15 },
  { 109, 7, 18, 6, 0, -15 },
  { 125, 7, 18, 6, -2, -15 },
  { 141, 8, 8, 9, 2, -16 },
  { 149, 9, 10, 10, 1, -12 },
  { 161, 4, 5, 5, -1, -2 },
  { 164, 5, 2, 6, 0, -7 },
  { 166, 3, 3, 5, 0, -3 },
  { 168, 10, 15, 7, -1, -15 },
  { 187, 8, 15, 9, 1, -15 },
  { 202, 6, 15, 9, 2, -15 },
  { 214, 10, 15, 9, -1, -15 },
  { 233, 9, 15, 9, 0, -15 },
  { 250, 9, 15, 9, 0, -15 },
  { 267, 9, 15, 9, 0, -15 },
  { 284, 9, 15, 9, 1, -15 },
  { 301, 9, 15, 9, 1, -15 },
  { 318, 10, 15, 9, 0, -15 },
  { 337, 9, 15, 9, 0, -15 },
  { 354, 5, 11, 5, 0, -11 },
  { 361, 6, 14, 5, -1, -11 },
  { 372, 9, 9, 10, 1, -12 },
  { 383, 9, 6, 10, 1, -10 },
  { 390, 9, 9, 10, 1, -12 },
  { 401, 7, 15, 7, 1, -15 },
  { 415, 13, 17, 14, 1, -15 },
  { 443, 10, 15, 10, -1, -15 },
  { 462, 10, 15, 10, 0, -15 },
  { 481, 10, 15, 10, 1, -15 },
  { 500, 11, 15, 11, 0, -15 },
  { 521, 10, 15, 9, 0, -15 },
  { 540, 10, 15, 8, 0, -15 },
  { 559, 11, 15, 12, 1, -15 },
  { 580, 12, 15, 12, 0, -15 },
  { 603, 9, 15, 6, -1, -15 },
  { 620, 9, 19, 5, -3, -15 },
  { 642, 12, 15, 10, 0, -15 },
  { 665, 7, 15, 8, 0, -15 },
  { 679, 15, 15, 15, 0, -15 },
  { 708, 13, 15, 12, 0, -15 },
  { 733, 11, 15, 12, 1, -15 },
  { 754, 10, 15, 10, 0, -15 },
  { 773, 11, 19, 12, 1, -15 },
  { 800, 10, 15, 10, 0, -15 },
  { 819, 10, 15, 9, 0, -15 },
  { 838, 8, 15, 9, 2, -15 },
  { 853, 11, 15, 11, 1, -15 },
  { 874, 10, 15, 10, 2, -15 },
  { 893, 15, 15, 15, 2, -15 },
  { 922, 12, 15, 9, -1, -15 },
  { 945, 9, 15, 9, 2, -15 },
  { 962, 11, 15, 9, -1, -15 },
  { 983, 9, 18, 6, -1, -15 },
  { 1004, 4, 15, 8, 2, -15 },
  { 1012, 8, 18, 6, -1, -15 },
  { 1030, 9, 9, 10, 0, -15 },
  { 1041, 7, 1, 7, -2, 2 },
  { 1042, 3, 3, 6, 3, -16 },
  { 1044, 9, 12, 10, 1, -12 },
  { 1058, 9, 16, 10, 0, -16 },
  { 1076, 7, 12, 8, 1, -12 },
  { 1087, 10, 16, 10, 1, -16 },
  { 1107, 8, 12, 9, 1, -12 },
  { 1119, 10, 21, 6, -2, -16 },
  { 1146, 10, 17, 10, 0, -12 },
  { 1168, 9, 16, 10, 0, -16 },
  { 1186, 5, 16, 5, 0, -16 },
  { 1196, 8, 21, 5, -3, -16 },
  { 1217, 10, 16, 9, 0, -16 },
  { 1237, 6, 16, 5, 0, -16 },
  { 1249, 14, 12, 15, 0, -12 },
  { 1270, 9, 12, 10, 0, -12 },
  { 1284, 8, 12, 10, 1, -12 },
  { 1296, 10, 17, 10, -1, -12 },
  { 1318, 9, 17, 10, 1, -12 },
  { 1338, 8, 12, 7, 0, -12 },
  { 1350, 8, 12, 8, 0, -12 },
  { 1362, 6, 14, 6, 1, -14 },
  { 1373, 9, 11, 10, 1, -11 },
  { 1386, 8, 11, 8, 1, -11 },
  { 1397, 13, 11, 13, 1, -11 },
  { 1415, 10, 11, 8, -1, -11 },
  { 1429, 11, 16, 8, -2, -11 },
  { 1451, 9, 11, 7, -1, -11 },
  { 1464, 8, 18, 7, 0, -15 },
  { 1482, 1, 21, 9, 4, -16 },
  { 1485, 8, 18, 7, -1, -15 },
  { 1503, 9, 3, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_MediumItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC21PT7B_H_
