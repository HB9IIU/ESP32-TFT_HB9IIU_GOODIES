#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC57PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x00, 0x80, 0x00, 0x3F, 0x1F, 0x9F, 0x0F, 0xCF, 0x87, 0xEF, 0xC3, 0xE7,
  0xE1, 0xF3, 0xE0, 0xF9, 0xF0, 0xFC, 0xF8, 0x7C, 0x78, 0x3E, 0x3C, 0x1F,
  0x3E, 0x0F, 0x1F, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE3, 0xC1, 0xE0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x7C, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x78,
  0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0x81, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF0,
  0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xF9, 0xCF, 0x01,
  0xF8, 0xC1, 0x80, 0xF8, 0x60, 0x00, 0x7C, 0x70, 0x00, 0x7E, 0x38, 0x00,
  0x3E, 0x1C, 0x00, 0x1F, 0x8C, 0x00, 0x07, 0xC6, 0x00, 0x03, 0xF7, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x0E, 0xFE, 0x00, 0x07, 0x3F, 0x00, 0x03, 0x8F, 0x80, 0x01,
  0x87, 0xC0, 0x00, 0xC3, 0xE0, 0x00, 0xE1, 0xF0, 0x00, 0x71, 0xF8, 0x40,
  0x38, 0xFC, 0x38, 0x18, 0xFC, 0x1F, 0xDF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0xFF, 0x00, 0x0F,
  0x80, 0x7F, 0xE0, 0x03, 0xC0, 0x3F, 0xFC, 0x01, 0xF0, 0x0F, 0x1F, 0x00,
  0x78, 0x07, 0xC3, 0xC0, 0x3C, 0x01, 0xE0, 0xF0, 0x1F, 0x00, 0xF8, 0x3C,
  0x07, 0x80, 0x3C, 0x0F, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0xF0, 0x07, 0xC1,
  0xF0, 0x78, 0x01, 0xE0, 0x7C, 0x3E, 0x00, 0x78, 0x1E, 0x0F, 0x00, 0x1E,
  0x07, 0x87, 0xC0, 0x0F, 0x81, 0xE1, 0xE0, 0x03, 0xE0, 0xF8, 0xF0, 0x00,
  0xF8, 0x3C, 0x7C, 0x3E, 0x3C, 0x0F, 0x1E, 0x1F, 0xEF, 0x07, 0xCF, 0x8F,
  0xFB, 0xE1, 0xE3, 0xC7, 0xFF, 0xF8, 0xF9, 0xF3, 0xE7, 0xDF, 0xFC, 0xF8,
  0xF0, 0xF7, 0xFE, 0x3C, 0x78, 0x3C, 0xFF, 0x1F, 0x1E, 0x0F, 0x1F, 0x87,
  0x8F, 0x83, 0xC0, 0x03, 0xE3, 0xC0, 0xF0, 0x01, 0xF0, 0xF0, 0x3C, 0x00,
  0x78, 0x7C, 0x0F, 0x00, 0x3E, 0x1F, 0x07, 0xC0, 0x0F, 0x07, 0x81, 0xF0,
  0x07, 0xC1, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x1E, 0x00, 0xF0, 0x1E, 0x0F,
  0x80, 0x7C, 0x07, 0x83, 0xC0, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x80, 0x78,
  0x7C, 0x03, 0xC0, 0x1E, 0x3E, 0x01, 0xF0, 0x07, 0xDF, 0x80, 0xF8, 0x01,
  0xFF, 0xC0, 0x3C, 0x00, 0x3F, 0xE0, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3E, 0x0F,
  0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0xFC, 0x1F,
  0xFE, 0x07, 0xE1, 0xF9, 0xF8, 0x3E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x3F,
  0x1F, 0x0F, 0x81, 0xF9, 0xF8, 0xFC, 0x07, 0xEF, 0x87, 0xE0, 0x3F, 0xFC,
  0x3E, 0x00, 0xFF, 0xC3, 0xF0, 0x07, 0xFE, 0x1F, 0x80, 0x3F, 0xE0, 0xFC,
  0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x80, 0xFC, 0x07,
  0xFE, 0x07, 0xF0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x7E,
  0x03, 0xFF, 0xC3, 0xF8, 0x0F, 0xFC, 0x0F, 0xC0, 0x04, 0x00, 0x00, 0x00,
  0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8,
  0xF8, 0xF0, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x10, 0x1E, 0x00, 0xE1,
  0xF0, 0x0F, 0xCF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFB,
  0xC0, 0x1F, 0x9E, 0x01, 0xF8, 0xF8, 0x1F, 0x83, 0xC0, 0x3C, 0x1F, 0x00,
  0xC0, 0xFC, 0x02, 0x07, 0x80, 0x00, 0x10, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F,
  0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8,
  0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBE, 0x10, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x0F, 0xC0, 0xFC,
  0x1F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x00,
  0xF8, 0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0xC0, 0x0F,
  0x9F, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E,
  0x00, 0x7E, 0xFC, 0x00, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xE7, 0xC0,
  0x0F, 0xCF, 0x80, 0x1F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7C, 0x03,
  0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0xFC,
  0x07, 0xF7, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xBE, 0x7F, 0x3F, 0x1F, 0x1F, 0x87, 0x0F, 0x83, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x3E, 0x07, 0xF0, 0x0F, 0x00, 0xFC, 0x01, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0x01, 0xFC, 0x03, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x20, 0x00,
  0xFC, 0x18, 0x00, 0xFE, 0x0F, 0x83, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7D, 0xF0,
  0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xE3,
  0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x0F,
  0x07, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF0, 0x1F, 0x00,
  0x7C, 0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x0F, 0x81, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x08, 0x00, 0x3F, 0x83, 0x00, 0x3F, 0xC0, 0xF8,
  0x3F, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x3F, 0xE0,
  0x1F, 0x3F, 0xF8, 0x0F, 0xBF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFC, 0x3F,
  0x83, 0xF8, 0x0F, 0xC1, 0xF8, 0x03, 0xE1, 0xFC, 0x01, 0xF0, 0xFC, 0x00,
  0xF8, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0xC0,
  0x1F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xE0, 0xF8,
  0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xC1, 0xFC, 0x07,
  0xF3, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFE,
  0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03,
  0xF0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x07, 0xE1,
  0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0x8F, 0xE0, 0x1F, 0xC1, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F,
  0xC1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x87, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x07,
  0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x7F, 0x87, 0xF8, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0x07,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x1F,
  0x00, 0x3F, 0x1F, 0x00, 0x7F, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0xFE, 0x1F,
  0x80, 0xFE, 0x1F, 0x83, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0x7C, 0x07, 0xFE, 0x7C, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0xE1, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF0, 0x3F, 0x03,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x7F,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7C, 0x01, 0x00, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xE0, 0x7F, 0x08, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x3E, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x78,
  0x03, 0xF8, 0x0F, 0x0F, 0x80, 0xFF, 0xE0, 0xF0, 0xF0, 0x1F, 0xFE, 0x0F,
  0x1F, 0x03, 0xFF, 0xE0, 0xF1, 0xE0, 0x7C, 0x3E, 0x0F, 0x3E, 0x0F, 0x83,
  0xC0, 0xF3, 0xC0, 0xF0, 0x3C, 0x0F, 0x3C, 0x1F, 0x03, 0xC0, 0xF7, 0xC1,
  0xE0, 0x7C, 0x1F, 0x78, 0x3E, 0x07, 0x81, 0xE7, 0x83, 0xC0, 0x78, 0x1E,
  0x78, 0x3C, 0x07, 0x81, 0xEF, 0x87, 0xC0, 0xF8, 0x1E, 0xF0, 0x78, 0x0F,
  0x03, 0xCF, 0x07, 0x80, 0xF0, 0x3C, 0xF0, 0x78, 0x1F, 0x03, 0xCF, 0x07,
  0x81, 0xF0, 0x78, 0xF0, 0x78, 0x3F, 0x07, 0x8F, 0x07, 0x83, 0xF0, 0xF0,
  0xF0, 0x7C, 0x7F, 0x1E, 0x0F, 0x07, 0xFE, 0xFF, 0xE0, 0xF0, 0x3F, 0xE7,
  0xFC, 0x0F, 0x01, 0xF8, 0x3F, 0x00, 0xF0, 0x06, 0x01, 0xC0, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x02,
  0x00, 0x01, 0xFC, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0x7E, 0x00,
  0xFC, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x8F, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xFB,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xF0, 0x3F, 0xC0, 0x7C, 0x03, 0xF8, 0x0F, 0x80, 0x3F, 0x03, 0xF0,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x03, 0xF0,
  0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00,
  0xFC, 0x07, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xE0, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0x7C,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3E, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFC, 0x07, 0x00, 0xFF,
  0x00, 0x20, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x30, 0x07, 0xFE, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFC, 0x3F, 0xF0, 0x07, 0xE0,
  0x3F, 0x80, 0x3E, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x1F,
  0x80, 0xFC, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xC0,
  0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07,
  0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xC0,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F,
  0xC0, 0xF8, 0x00, 0xFE, 0x07, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x03,
  0xF0, 0x0F, 0xF0, 0x1F, 0x80, 0xFF, 0x00, 0xF8, 0x1F, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x78, 0x0F, 0xF0, 0x00,
  0x80, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0xCF,
  0xC0, 0x1F, 0xFC, 0x7E, 0x00, 0xFF, 0xE3, 0xF0, 0x07, 0xFF, 0x1F, 0x80,
  0x7F, 0xF8, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0x7F,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF8,
  0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF0,
  0x07, 0xC0, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0,
  0x1F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x3F,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xF9, 0xFC, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07,
  0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x01, 0xF7, 0x80, 0x03, 0xFF, 0x00, 0xFB, 0xC0, 0x03, 0xEF, 0x80, 0x7D,
  0xE0, 0x01, 0xFF, 0xC0, 0x3E, 0xF0, 0x01, 0xF7, 0xC0, 0x3F, 0x7C, 0x00,
  0xFB, 0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0x7D, 0xF8,
  0x07, 0xCF, 0x80, 0x7C, 0xFC, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xF3,
  0xE0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x1F,
  0x1F, 0x80, 0x7C, 0x7C, 0x0F, 0x8F, 0xC0, 0x7E, 0x3E, 0x0F, 0x87, 0xC0,
  0x3F, 0x1F, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x87, 0xC3, 0xF0, 0x0F, 0x87,
  0xC3, 0xE1, 0xF8, 0x07, 0xC1, 0xE3, 0xE0, 0xF8, 0x07, 0xE0, 0xF1, 0xF0,
  0x7C, 0x03, 0xE0, 0x78, 0xF0, 0x3E, 0x01, 0xF0, 0x3C, 0xF8, 0x3F, 0x00,
  0xF8, 0x1E, 0x78, 0x1F, 0x80, 0x7C, 0x0F, 0xFC, 0x0F, 0x80, 0x7E, 0x07,
  0xFE, 0x07, 0xC0, 0x3E, 0x03, 0xFE, 0x03, 0xE0, 0x1F, 0x01, 0xFF, 0x03,
  0xF0, 0x0F, 0x80, 0xFF, 0x01, 0xF8, 0x07, 0xC0, 0x7F, 0x80, 0xF8, 0x07,
  0xE0, 0x3F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x7F, 0x00, 0x07, 0xC0, 0x3F, 0x80, 0x03, 0xE0, 0x3F, 0xC0,
  0x03, 0xF0, 0x1F, 0xF0, 0x01, 0xF8, 0x0F, 0xF8, 0x00, 0xF8, 0x07, 0xFC,
  0x00, 0x7C, 0x03, 0xFE, 0x00, 0x3E, 0x03, 0xFF, 0x00, 0x3F, 0x01, 0xF7,
  0xC0, 0x1F, 0x80, 0xFB, 0xE0, 0x0F, 0x80, 0x7D, 0xF0, 0x07, 0xC0, 0x3E,
  0xF8, 0x03, 0xE0, 0x3F, 0x7E, 0x03, 0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0x0F,
  0x8F, 0x80, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x03, 0xE3, 0xE0, 0x7E, 0x03,
  0xF0, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x0F, 0x80,
  0x7C, 0x1F, 0x07, 0xC0, 0x7E, 0x0F, 0xC7, 0xE0, 0x3F, 0x03, 0xE3, 0xF0,
  0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xC0, 0x7C, 0x7C,
  0x07, 0xE0, 0x1F, 0x3E, 0x03, 0xE0, 0x0F, 0xBE, 0x01, 0xF0, 0x07, 0xDF,
  0x00, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0x01, 0xFF, 0xC0, 0x7E, 0x00, 0x7F,
  0xE0, 0x3E, 0x00, 0x3F, 0xE0, 0x1F, 0x00, 0x1F, 0xF0, 0x0F, 0x80, 0x0F,
  0xF8, 0x07, 0xC0, 0x03, 0xFC, 0x07, 0xE0, 0x01, 0xFE, 0x03, 0xE0, 0x00,
  0xFE, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x87,
  0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0xFC, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFD, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x03,
  0xF9, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xE0,
  0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xF0, 0x7F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0x80, 0x7E, 0x03,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x03,
  0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x3F,
  0x00, 0x7E, 0x07, 0xC0, 0x1F, 0xC0, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFE,
  0x07, 0xE0, 0x7F, 0x80, 0xFC, 0x7F, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x0F, 0x87, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFD,
  0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x3F, 0x3E, 0x00, 0x03, 0xF9, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFC,
  0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x07,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x7E, 0x0F, 0xF0, 0x1F, 0x01, 0xFC, 0x07, 0xC0, 0x3F, 0x03, 0xF0,
  0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x3F, 0x03,
  0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7E,
  0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x3F, 0x0F,
  0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7E, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x3F,
  0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x1F, 0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFC, 0x0F, 0x00, 0x7F, 0x00, 0x20, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x01, 0x00, 0x0F, 0xE0, 0x38, 0x03, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF8, 0x3F, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F,
  0x03, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF8, 0x3F, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F,
  0x03, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7E,
  0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0,
  0x03, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7C,
  0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x01,
  0xF8, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0x07, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x7C, 0xF8,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7D,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0xDF, 0x80, 0x0F, 0xC0,
  0x07, 0xEF, 0xC0, 0x0F, 0xE0, 0x03, 0xE7, 0xE0, 0x07, 0xF0, 0x03, 0xF3,
  0xF0, 0x03, 0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xFC, 0x00, 0xF8, 0xFC, 0x01,
  0xFE, 0x00, 0xFC, 0x7E, 0x01, 0xFF, 0x00, 0x7C, 0x3F, 0x00, 0xF7, 0x80,
  0x7E, 0x1F, 0x80, 0x7B, 0xC0, 0x3F, 0x0F, 0xC0, 0x7D, 0xE0, 0x1F, 0x07,
  0xC0, 0x3C, 0xF0, 0x1F, 0x83, 0xE0, 0x3E, 0x78, 0x0F, 0x81, 0xF0, 0x1F,
  0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x9F, 0x03,
  0xE0, 0x3E, 0x07, 0x8F, 0x83, 0xF0, 0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0x0F,
  0x83, 0xE3, 0xE1, 0xF8, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x03, 0xE1, 0xF0,
  0xF8, 0x7C, 0x01, 0xF0, 0xF0, 0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x1F, 0x3F, 0x00, 0x3E, 0x7C, 0x0F, 0x9F, 0x00, 0x1F,
  0x3E, 0x07, 0xCF, 0x80, 0x0F, 0x9E, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x01,
  0xF7, 0xC0, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x1F, 0x87, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x0F, 0x9F, 0x80, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x1F, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7C,
  0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x7E,
  0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x3E,
  0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x00, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xF1, 0xF0,
  0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFC, 0x3F, 0x1F, 0x87, 0xC3, 0xF0, 0xF8, 0x3C, 0x1F, 0x07, 0x80,
  0x00, 0x7F, 0x0F, 0x80, 0x7F, 0xC7, 0xC0, 0xFF, 0xF3, 0xC0, 0x7F, 0xFB,
  0xE0, 0x7F, 0xBF, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x01, 0xFC, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xF1, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x1F,
  0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0xC1,
  0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x07, 0xF8, 0x3F, 0x8F, 0xF8,
  0x0F, 0xFF, 0x7C, 0x07, 0xFF, 0xBE, 0x01, 0xFF, 0x9F, 0x00, 0x7F, 0x0F,
  0x80, 0x0E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x7C,
  0xFF, 0x80, 0x3F, 0x7F, 0xF0, 0x0F, 0xBF, 0xFE, 0x03, 0xFF, 0x7F, 0x80,
  0xFF, 0x07, 0xE0, 0x7F, 0x80, 0xF8, 0x1F, 0xC0, 0x3E, 0x07, 0xE0, 0x0F,
  0xC1, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0xC0,
  0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xFC,
  0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0xE0, 0x7E, 0x07, 0xFC, 0x3F, 0x81, 0xFF,
  0xFF, 0xC0, 0x7D, 0xFF, 0xE0, 0x1E, 0x3F, 0xF0, 0x0F, 0x87, 0xF0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xFD, 0xE0, 0xFE, 0x02, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x20, 0x7F, 0x0E, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xF9, 0xF8,
  0x03, 0xFF, 0xDF, 0x00, 0x3F, 0xFD, 0xF0, 0x07, 0xFB, 0xFF, 0x00, 0xFE,
  0x0F, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x7E,
  0x00, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC0, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x0F,
  0x80, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x03,
  0xF0, 0x0F, 0x80, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0xFF, 0x00,
  0xFE, 0x3F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFB, 0xE0, 0x03, 0xFF,
  0x3E, 0x00, 0x1F, 0xC3, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0x1F, 0x87, 0xE0,
  0x7C, 0x3E, 0x03, 0xE3, 0xF0, 0x1F, 0x3F, 0x00, 0xF9, 0xF8, 0x07, 0xCF,
  0x80, 0x7E, 0xFC, 0x07, 0xE7, 0xC0, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x04, 0x1F, 0xC0, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x08, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x08, 0x7E, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE1, 0xF0, 0x01, 0xFF, 0x1F, 0x00,
  0x7F, 0xF9, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0xE0, 0x1F, 0xC1,
  0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0,
  0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8,
  0x1F, 0x80, 0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF0,
  0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0x7E,
  0x01, 0xF0, 0x0F, 0xE0, 0x1F, 0x81, 0xFE, 0x01, 0xF8, 0x3F, 0xE0, 0x1F,
  0xC7, 0xFC, 0x01, 0xFF, 0xF7, 0xC0, 0x0F, 0xFF, 0x7C, 0x00, 0x7F, 0xEF,
  0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x06, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0xC0, 0x07, 0xE0, 0x0F, 0x81, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x1F, 0xC0, 0x0F,
  0x9F, 0xF0, 0x0F, 0xDF, 0xFC, 0x07, 0xDF, 0xFF, 0x03, 0xFF, 0xFF, 0x81,
  0xFE, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7E, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F,
  0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE1, 0xF8, 0x03,
  0xE0, 0xFC, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00,
  0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x83, 0xE0,
  0x0F, 0xC3, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x7C,
  0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x08, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x3F,
  0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF1,
  0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFC, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x3E,
  0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0,
  0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xE1, 0xFC, 0x07, 0xF0,
  0x07, 0x8F, 0xF8, 0x7F, 0xE0, 0x3E, 0x7F, 0xF3, 0xFF, 0x80, 0xFB, 0xFF,
  0xDF, 0xFF, 0x03, 0xFF, 0x7F, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xF0,
  0x3F, 0x81, 0xFC, 0x07, 0xC1, 0xFC, 0x07, 0xF0, 0x1F, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x80, 0x7E, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x07, 0xC1, 0xF0, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0xFC,
  0x03, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0x1F, 0x87, 0xE0,
  0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x07,
  0xC1, 0xF0, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x01,
  0xE1, 0xFC, 0x00, 0xF1, 0xFF, 0x00, 0xF9, 0xFF, 0xC0, 0x7D, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xE0, 0xFC, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x3F,
  0x07, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE1, 0xF8, 0x03,
  0xE0, 0xFC, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00,
  0x7E, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x83, 0xE0,
  0x0F, 0xC1, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x7C,
  0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x0F,
  0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xC0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xBF, 0xC1, 0xFC, 0x1F, 0x87, 0xF0, 0x1F, 0x0F, 0xC0, 0x3E, 0x3F,
  0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0,
  0x07, 0xEF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xFC, 0x00,
  0xFD, 0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x1F,
  0x9F, 0x00, 0x3F, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xFC, 0x07, 0xE1,
  0xF8, 0x1F, 0xC1, 0xF8, 0x7F, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x78, 0x3F, 0x00,
  0x07, 0x8F, 0xF8, 0x00, 0xF9, 0xFF, 0xC0, 0x0F, 0xBF, 0xFE, 0x00, 0xFF,
  0xDF, 0xE0, 0x0F, 0xF0, 0x7E, 0x00, 0xFE, 0x03, 0xE0, 0x1F, 0xC0, 0x3E,
  0x01, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x3E, 0x03, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07,
  0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07,
  0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x01,
  0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFE, 0x07, 0xE0, 0x1F, 0xF1, 0xFE, 0x01, 0xF7, 0xFF, 0xC0, 0x1F, 0x7F,
  0xF8, 0x01, 0xF3, 0xFF, 0x00, 0x3F, 0x1F, 0xE0, 0x03, 0xF0, 0x30, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0x80, 0x7F, 0xC7,
  0xC0, 0x7F, 0xF3, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xBF, 0xF0, 0x7F, 0x07,
  0xF8, 0x3F, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xF0,
  0x03, 0xE1, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x7E,
  0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x87,
  0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xF0,
  0x7E, 0x07, 0xF8, 0x3F, 0x8F, 0xF8, 0x0F, 0xFF, 0x7C, 0x07, 0xFF, 0xBE,
  0x01, 0xFF, 0xBF, 0x00, 0x7F, 0x1F, 0x00, 0x06, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE1, 0xF8, 0x0F, 0x1F, 0xC0, 0xF9, 0xFC, 0x07,
  0xDF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0x88, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFE, 0x1F, 0x07, 0xE0, 0x10, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x84, 0x00, 0xFC, 0x3C, 0x1F, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x20, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x04, 0x00, 0x07, 0xC0, 0x1F, 0x0F, 0xC0,
  0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80,
  0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x00,
  0x7E, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3E, 0x00,
  0xFC, 0x3E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x01,
  0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xF0, 0xF8, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F,
  0xE0, 0xFE, 0x3F, 0xE0, 0xFF, 0xFB, 0xE0, 0x7F, 0xF3, 0xC0, 0x7F, 0xE3,
  0xC0, 0x3F, 0xC3, 0xC0, 0x02, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xF3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x3F, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x81, 0xF0, 0x7C, 0x07, 0xC3, 0xF0,
  0x1F, 0x0F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0xC0, 0x1F,
  0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xF8,
  0x07, 0xEF, 0x80, 0x7F, 0x00, 0xF9, 0xF0, 0x0F, 0xE0, 0x3F, 0x3E, 0x03,
  0xFC, 0x07, 0xE7, 0xC0, 0x7F, 0x80, 0xF8, 0xF8, 0x1F, 0xF0, 0x3F, 0x1F,
  0x03, 0xFE, 0x07, 0xC3, 0xE0, 0x7F, 0xC1, 0xF8, 0x7C, 0x1F, 0xF8, 0x3E,
  0x0F, 0x83, 0xDE, 0x07, 0xC3, 0xF0, 0xFB, 0xC1, 0xF8, 0x7E, 0x1E, 0x78,
  0x3E, 0x0F, 0xC3, 0xCF, 0x07, 0xC1, 0xF8, 0xF9, 0xE1, 0xF0, 0x3F, 0x1E,
  0x3C, 0x3E, 0x07, 0xE7, 0xC7, 0x8F, 0x80, 0xFC, 0xF0, 0xF1, 0xF0, 0x1F,
  0x1E, 0x1E, 0x3E, 0x03, 0xE7, 0xC3, 0xCF, 0x80, 0x7C, 0xF0, 0x79, 0xF0,
  0x0F, 0xBE, 0x0F, 0x7C, 0x01, 0xF7, 0x81, 0xEF, 0x80, 0x3E, 0xF0, 0x3D,
  0xF0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0,
  0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F,
  0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xC1, 0xF8, 0x00, 0x7C,
  0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3E, 0x1F,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x01,
  0xF8, 0x1F, 0x80, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x0F,
  0xC0, 0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xE0,
  0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x7C, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0xF7, 0xC0,
  0x00, 0x03, 0xDF, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x21, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x02, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x07, 0xFE, 0x40, 0x00, 0xF0,
};

const GFXglyph NotoSans_Condensed_MediumItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 14, 42, 14, 1, -41 },
  { 75, 17, 15, 21, 6, -41 },
  { 107, 29, 41, 29, 1, -41 },
  { 256, 25, 46, 25, 1, -43 },
  { 400, 34, 42, 39, 3, -41 },
  { 579, 29, 42, 30, 0, -41 },
  { 732, 8, 15, 12, 6, -41 },
  { 747, 19, 50, 16, 1, -41 },
  { 866, 18, 50, 16, -4, -41 },
  { 979, 21, 23, 24, 5, -44 },
  { 1040, 23, 27, 27, 3, -34 },
  { 1118, 12, 15, 13, -3, -7 },
  { 1141, 14, 5, 16, 1, -18 },
  { 1150, 7, 8, 13, 1, -7 },
  { 1157, 28, 41, 20, -3, -41 },
  { 1301, 23, 42, 25, 2, -41 },
  { 1422, 17, 41, 26, 6, -41 },
  { 1510, 26, 41, 25, -1, -41 },
  { 1644, 25, 42, 25, 0, -41 },
  { 1776, 26, 41, 26, -1, -41 },
  { 1910, 26, 42, 25, 0, -41 },
  { 2047, 25, 42, 25, 2, -41 },
  { 2179, 26, 41, 25, 2, -41 },
  { 2313, 26, 42, 25, 0, -41 },
  { 2450, 24, 42, 25, 1, -41 },
  { 2576, 12, 32, 13, 0, -31 },
  { 2624, 16, 39, 13, -3, -31 },
  { 2702, 23, 27, 27, 3, -34 },
  { 2780, 23, 16, 27, 3, -28 },
  { 2826, 23, 27, 27, 3, -34 },
  { 2904, 20, 42, 20, 2, -41 },
  { 3009, 36, 46, 39, 2, -41 },
  { 3216, 27, 41, 27, -4, -41 },
  { 3355, 27, 41, 28, 1, -41 },
  { 3494, 27, 42, 26, 3, -41 },
  { 3636, 29, 41, 31, 1, -41 },
  { 3785, 25, 41, 24, 1, -41 },
  { 3914, 25, 41, 23, 1, -41 },
  { 4043, 29, 42, 32, 3, -41 },
  { 4196, 32, 41, 32, 1, -41 },
  { 4360, 23, 41, 17, -2, -41 },
  { 4478, 24, 52, 14, -9, -41 },
  { 4634, 31, 41, 27, 1, -41 },
  { 4793, 18, 41, 22, 1, -41 },
  { 4886, 41, 41, 41, 1, -41 },
  { 5097, 33, 41, 33, 1, -41 },
  { 5267, 29, 42, 33, 3, -41 },
  { 5420, 27, 41, 27, 1, -41 },
  { 5559, 29, 51, 33, 3, -41 },
  { 5744, 26, 41, 27, 1, -41 },
  { 5878, 27, 42, 24, -1, -41 },
  { 6020, 23, 41, 23, 5, -41 },
  { 6138, 29, 42, 31, 3, -41 },
  { 6291, 26, 41, 26, 5, -41 },
  { 6425, 41, 41, 41, 5, -41 },
  { 6636, 32, 41, 25, -3, -41 },
  { 6800, 24, 41, 24, 5, -41 },
  { 6923, 28, 41, 23, -2, -41 },
  { 7067, 22, 50, 16, -1, -41 },
  { 7205, 10, 41, 20, 6, -41 },
  { 7257, 22, 50, 16, -4, -41 },
  { 7395, 24, 24, 26, 1, -41 },
  { 7467, 20, 4, 19, -5, 5 },
  { 7477, 9, 9, 16, 8, -44 },
  { 7488, 25, 32, 27, 2, -31 },
  { 7588, 26, 44, 27, 0, -43 },
  { 7731, 20, 32, 21, 2, -31 },
  { 7811, 28, 44, 27, 2, -43 },
  { 7965, 21, 32, 25, 2, -31 },
  { 8049, 29, 58, 15, -7, -44 },
  { 8260, 28, 45, 27, -1, -31 },
  { 8418, 25, 43, 27, 0, -43 },
  { 8553, 15, 42, 13, 0, -42 },
  { 8632, 22, 56, 13, -7, -42 },
  { 8786, 26, 43, 24, 0, -43 },
  { 8926, 15, 43, 13, 0, -43 },
  { 9007, 38, 31, 40, 0, -31 },
  { 9155, 25, 31, 27, 0, -31 },
  { 9252, 23, 32, 26, 2, -31 },
  { 9344, 28, 44, 27, -2, -31 },
  { 9498, 25, 45, 27, 2, -31 },
  { 9639, 21, 31, 18, 0, -31 },
  { 9721, 21, 32, 21, 0, -31 },
  { 9805, 16, 39, 16, 2, -38 },
  { 9883, 24, 32, 27, 2, -31 },
  { 9979, 22, 31, 22, 3, -31 },
  { 10065, 35, 31, 35, 3, -31 },
  { 10201, 28, 31, 23, -3, -31 },
  { 10310, 30, 45, 23, -5, -31 },
  { 10479, 23, 31, 20, -2, -31 },
  { 10569, 22, 50, 19, 1, -41 },
  { 10707, 4, 56, 24, 10, -43 },
  { 10735, 21, 50, 19, -3, -41 },
  { 10867, 23, 8, 27, 3, -24 },
};

const GFXfont NotoSans_Condensed_MediumItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC57PT7B_H_
