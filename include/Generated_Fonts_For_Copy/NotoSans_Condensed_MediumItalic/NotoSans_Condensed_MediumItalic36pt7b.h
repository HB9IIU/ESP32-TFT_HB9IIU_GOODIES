#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC36PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x07, 0x83, 0xE0, 0xF8, 0x1C, 0x00, 0x79, 0xEE,
  0x39, 0xC7, 0x39, 0xEF, 0x3D, 0xC7, 0x38, 0xE7, 0x1C, 0xC3, 0x18, 0x60,
  0x00, 0x71, 0xC0, 0x0C, 0x30, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0C, 0x38,
  0x03, 0x86, 0x00, 0x71, 0xC0, 0x0C, 0x38, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x0E, 0x38, 0x01, 0x86, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0x86, 0x00,
  0x70, 0xC0, 0x7F, 0xFF, 0x1F, 0xFF, 0xE0, 0x70, 0xC0, 0x0E, 0x38, 0x01,
  0x87, 0x00, 0x30, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x30, 0xC0, 0x0E,
  0x38, 0x00, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x01, 0xFF, 0x07, 0xFF,
  0x0F, 0xFF, 0x0F, 0x62, 0x0E, 0x60, 0x1E, 0x60, 0x1E, 0x40, 0x0E, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xBC,
  0x01, 0xBC, 0x01, 0x9C, 0x01, 0x1C, 0x03, 0x3C, 0x43, 0x38, 0x7F, 0xF8,
  0xFF, 0xF0, 0x7F, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0F, 0x00, 0x70, 0x7E, 0x03, 0x83, 0xFC, 0x0C, 0x0E, 0x70, 0x70, 0x71,
  0xC3, 0x81, 0xC7, 0x0E, 0x06, 0x1C, 0x70, 0x38, 0x71, 0xC0, 0xE1, 0xCE,
  0x03, 0x8E, 0x30, 0x0E, 0x39, 0xC7, 0x38, 0xEE, 0x7E, 0xE7, 0x3B, 0xFB,
  0xFD, 0xCC, 0x77, 0xE6, 0x71, 0xCF, 0x39, 0x87, 0x01, 0xCE, 0x18, 0x07,
  0x38, 0x60, 0x38, 0xE3, 0x80, 0xC3, 0x8E, 0x07, 0x0C, 0x38, 0x38, 0x30,
  0xC0, 0xE0, 0xC7, 0x07, 0x03, 0xB8, 0x18, 0x0F, 0xE0, 0xE0, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0E, 0x38, 0x07, 0x8E, 0x01,
  0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x78, 0x07, 0x1C, 0x01, 0xEE, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF8, 0x71, 0xFE, 0x1C, 0xF3, 0x8F,
  0x78, 0xF3, 0x9C, 0x1D, 0xE7, 0x07, 0xF3, 0xC0, 0xF8, 0xF0, 0x3E, 0x3C,
  0x0F, 0x0F, 0x07, 0xE1, 0xFF, 0xF8, 0x7F, 0xEF, 0x0F, 0xE3, 0xE0, 0x7B,
  0x9C, 0xEF, 0x73, 0x9C, 0xE6, 0x00, 0x00, 0xE0, 0x38, 0x0F, 0x01, 0xC0,
  0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0F, 0x00, 0x02, 0x00, 0x0F, 0x00, 0x38, 0x10, 0xE0, 0x63, 0x81, 0xEC,
  0x27, 0xFF, 0x83, 0xFE, 0x0F, 0x8C, 0x7E, 0x03, 0xDC, 0x1E, 0x70, 0x30,
  0xE0, 0x43, 0x80, 0x08, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x3C, 0x71, 0xE3, 0x87, 0x1C, 0x38, 0xE0, 0xFF, 0xFF, 0xFF, 0x33, 0xDF,
  0xF7, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x78, 0xF0, 0xE1, 0xE3, 0xC3,
  0xC7, 0x03, 0x9E, 0x0F, 0x38, 0x1E, 0x70, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7,
  0x01, 0xCE, 0x03, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x73, 0x81,
  0xE7, 0x03, 0xCE, 0x0F, 0x1E, 0x1E, 0x3C, 0x78, 0x3F, 0xE0, 0x7F, 0x80,
  0x7E, 0x00, 0x01, 0xC0, 0xF0, 0xFC, 0x7F, 0x3F, 0x9E, 0xEF, 0x39, 0x9E,
  0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07,
  0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x00, 0x00,
  0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xF1, 0xF0, 0x20, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F,
  0xFE, 0x06, 0x1F, 0x04, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x07, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x80, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x6E, 0x00,
  0xFE, 0x01, 0xDE, 0x01, 0x9C, 0x03, 0x9C, 0x07, 0x1C, 0x0E, 0x3C, 0x0E,
  0x38, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x78, 0x70, 0x78, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1F,
  0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x08, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x80,
  0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0x03,
  0xFE, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x3B, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0x7C, 0x3C, 0x78,
  0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x38, 0xF0,
  0x78, 0xF0, 0x78, 0x70, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0x80, 0x1F,
  0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC4, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFE, 0x07,
  0xFF, 0x07, 0x0F, 0x0F, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E,
  0x0F, 0x0F, 0x1E, 0x07, 0xBC, 0x07, 0xF8, 0x03, 0xE0, 0x0F, 0xF0, 0x1F,
  0x78, 0x3C, 0x78, 0x78, 0x3C, 0x70, 0x3C, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0,
  0x1C, 0xF0, 0x3C, 0x78, 0x78, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x00,
  0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x1E, 0x0E, 0x0F, 0x1E, 0x0F, 0x1C,
  0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x3C,
  0x3E, 0x1E, 0x7E, 0x1F, 0xFE, 0x0F, 0xDC, 0x07, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0x00, 0x02, 0x0F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x78, 0xF8, 0xF8, 0xF0, 0x00,
  0x80, 0xF0, 0x3C, 0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x81, 0xC0, 0xF0,
  0x38, 0x1E, 0x07, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07,
  0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x00, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xC0, 0x03, 0x00,
  0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3C, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0x80,
  0x00, 0x07, 0xC1, 0xFF, 0x8F, 0xFC, 0x30, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x1E, 0x01, 0xC0, 0x78, 0x01, 0xC0, 0xE0,
  0x01, 0x83, 0x80, 0x03, 0x8E, 0x0F, 0x87, 0x18, 0x3F, 0xCE, 0x70, 0xE7,
  0x1C, 0xC3, 0x8E, 0x3B, 0x8E, 0x1C, 0x77, 0x1C, 0x30, 0xEC, 0x30, 0xE1,
  0x98, 0xE1, 0xC3, 0x71, 0xC3, 0x8E, 0xE3, 0x86, 0x1D, 0xC7, 0x1C, 0x33,
  0x8E, 0x38, 0xE7, 0x1C, 0xFB, 0x8E, 0x3F, 0x7E, 0x1C, 0x3C, 0x78, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x04, 0x00, 0xF8,
  0x78, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xB8, 0x01, 0xDC, 0x01,
  0xCE, 0x00, 0xE7, 0x00, 0xF3, 0x80, 0x71, 0xC0, 0x78, 0xE0, 0x38, 0x70,
  0x3C, 0x38, 0x1E, 0x1C, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0x81,
  0xC3, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x1E,
  0x3E, 0x07, 0x03, 0xC1, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03,
  0x83, 0x81, 0xE0, 0xE0, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0x01,
  0xC1, 0xE0, 0x70, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0x80, 0xF0, 0xE0,
  0x3C, 0x38, 0x0E, 0x1E, 0x07, 0x87, 0x87, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC1, 0xF8, 0x60,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x40, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x03, 0xCF, 0xC0, 0x78, 0x7C, 0x0E,
  0x07, 0x83, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xC0, 0x3C, 0x38,
  0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1C, 0x3C, 0x07, 0x87, 0x00, 0xF0, 0xE0,
  0x1E, 0x3C, 0x03, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1C, 0x07, 0x83, 0x81,
  0xF0, 0xF0, 0x7C, 0x1E, 0x3F, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x81,
  0xFF, 0x81, 0xFF, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x7F, 0xFC,
  0x3F, 0x06, 0x0F, 0x00, 0x87, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x7F, 0xBC, 0x1F,
  0xCF, 0x07, 0xF3, 0x80, 0x3C, 0xE0, 0x0F, 0x38, 0x03, 0xCE, 0x00, 0xE3,
  0xC0, 0x38, 0xF0, 0x1E, 0x3C, 0x07, 0x87, 0x81, 0xC1, 0xFF, 0xF0, 0x3F,
  0xFC, 0x07, 0xFE, 0x00, 0x03, 0x80, 0x78, 0x1C, 0x03, 0x81, 0xE0, 0x1C,
  0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0x80, 0x78, 0x1C, 0x03, 0x81, 0xE0,
  0x1C, 0x0F, 0x01, 0xE0, 0x70, 0x0F, 0x03, 0x80, 0x70, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x70, 0x0F, 0x03, 0x80, 0x70, 0x3C, 0x03,
  0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x70, 0x0F, 0x03, 0x80, 0x70, 0x3C,
  0x03, 0x81, 0xE0, 0x3C, 0x0E, 0x01, 0xE0, 0x70, 0x0E, 0x07, 0x80, 0x70,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0xFF, 0x83, 0xFE, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0x80, 0xF0,
  0x38, 0x1E, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x07, 0x80, 0x70, 0xF0,
  0x07, 0x1E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xE7, 0x80, 0x0E, 0xF0,
  0x01, 0xEE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xEF,
  0x00, 0x3C, 0x70, 0x03, 0xC7, 0x00, 0x38, 0x78, 0x03, 0x87, 0x80, 0x38,
  0x38, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x03, 0xC0, 0x70, 0x1C, 0x0F,
  0x01, 0xE0, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78,
  0x07, 0xFF, 0x7F, 0xFF, 0xFE, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xF8,
  0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0,
  0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xDC, 0x0E, 0xE0, 0x7F, 0x81,
  0xDC, 0x0E, 0xF0, 0x3B, 0x81, 0xDC, 0x0F, 0x70, 0x73, 0x81, 0xEE, 0x0E,
  0x70, 0x39, 0xC3, 0x9E, 0x07, 0x38, 0x73, 0xC0, 0xE7, 0x1C, 0x70, 0x3C,
  0x73, 0x8E, 0x07, 0x0E, 0xE3, 0xC0, 0xE1, 0xDC, 0x78, 0x1C, 0x3F, 0x0E,
  0x03, 0x87, 0xE1, 0xC0, 0xF0, 0xF8, 0x38, 0x1C, 0x1F, 0x0F, 0x03, 0x83,
  0xC1, 0xE0, 0x70, 0x78, 0x38, 0x1E, 0x0F, 0x07, 0x00, 0x03, 0xC0, 0x3C,
  0x0F, 0x00, 0xF0, 0x7C, 0x03, 0x81, 0xF8, 0x0E, 0x07, 0xE0, 0x38, 0x1F,
  0x81, 0xE0, 0xFE, 0x07, 0x03, 0xB8, 0x1C, 0x0E, 0xF0, 0x70, 0x39, 0xC3,
  0xC0, 0xE7, 0x0F, 0x07, 0x9C, 0x38, 0x1E, 0x78, 0xE0, 0x70, 0xE3, 0x81,
  0xC3, 0x9E, 0x07, 0x0E, 0x78, 0x3C, 0x39, 0xC0, 0xE0, 0xF7, 0x03, 0x81,
  0xDC, 0x0E, 0x07, 0xF0, 0x38, 0x1F, 0x81, 0xE0, 0x7E, 0x07, 0x00, 0xF8,
  0x1C, 0x03, 0xE0, 0x70, 0x0F, 0x83, 0xC0, 0x3C, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3E, 0x3E, 0x1F, 0x03, 0xC7, 0x80, 0xF3, 0xC0,
  0x3C, 0xF0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xEF, 0x00, 0x7B, 0x80, 0x1E, 0xE0, 0x07, 0xB8,
  0x01, 0xCE, 0x00, 0xF3, 0x80, 0x3C, 0xF0, 0x1E, 0x3C, 0x0F, 0x0F, 0x87,
  0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0x01, 0xFF, 0xC0, 0xF3, 0xF0, 0x70, 0x78, 0x38, 0x1C, 0x3C, 0x0E, 0x1E,
  0x07, 0x0F, 0x03, 0x87, 0x03, 0xC3, 0x81, 0xE3, 0xC1, 0xE1, 0xE1, 0xF0,
  0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3E,
  0x3E, 0x1F, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x78, 0x03,
  0xDE, 0x00, 0xF7, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xEF,
  0x00, 0x7B, 0x80, 0x1E, 0xE0, 0x07, 0xB8, 0x01, 0xCE, 0x00, 0xF3, 0x80,
  0x3C, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x87, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0,
  0x07, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xF1,
  0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x1E, 0x07, 0x0F, 0x07, 0x87,
  0x03, 0xC3, 0x81, 0xC3, 0xC1, 0xE1, 0xE7, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x39, 0xE0, 0x3C, 0x70, 0x1E, 0x38, 0x0F, 0x1E, 0x07, 0x0F, 0x03, 0x83,
  0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0xE0, 0x78, 0x70, 0x1C, 0x78, 0x0F, 0x00,
  0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0x8E, 0x0F, 0x02, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x80, 0x78, 0xC0, 0xF0, 0xFF, 0xF0,
  0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x00, 0x0E, 0x01, 0xC7, 0x80, 0x71, 0xE0, 0x3C, 0x78, 0x0F, 0x1C,
  0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x38, 0xF0, 0x1E, 0x38, 0x07, 0x8E, 0x01,
  0xC7, 0x80, 0x71, 0xE0, 0x3C, 0x78, 0x0F, 0x1C, 0x03, 0xC7, 0x00, 0xE3,
  0xC0, 0x38, 0xF0, 0x1E, 0x3C, 0x07, 0x8E, 0x01, 0xE3, 0x80, 0x70, 0xE0,
  0x3C, 0x38, 0x0E, 0x0F, 0x07, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0,
  0x00, 0xF0, 0x07, 0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xCF, 0x01, 0xE7,
  0x80, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x78, 0x38, 0x3C, 0x1C, 0x1C,
  0x0E, 0x1E, 0x07, 0x0E, 0x03, 0x8F, 0x01, 0xC7, 0x00, 0xE7, 0x80, 0x73,
  0x80, 0x3B, 0xC0, 0x1D, 0xE0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x0E, 0x03,
  0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3B, 0xC0, 0xF8, 0x1E, 0xF0, 0x3E,
  0x07, 0x3C, 0x1F, 0x83, 0xCF, 0x07, 0xE0, 0xF3, 0xC1, 0xF8, 0x38, 0xF0,
  0xEE, 0x1E, 0x3C, 0x3B, 0x87, 0x0F, 0x1C, 0xE3, 0xC3, 0xC7, 0x38, 0xF0,
  0xF1, 0xCE, 0x38, 0x3C, 0xE3, 0x9E, 0x0F, 0x38, 0xE7, 0x03, 0xDC, 0x3B,
  0xC0, 0xE7, 0x0E, 0xF0, 0x39, 0xC3, 0xB8, 0x0E, 0xE0, 0xFE, 0x03, 0xB8,
  0x3F, 0x00, 0xFC, 0x0D, 0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03,
  0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x70, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x1C, 0x1C, 0x01, 0xC3, 0xC0, 0x1C,
  0x38, 0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0x3C, 0x00, 0xF1, 0xC0,
  0x1E, 0x1C, 0x01, 0xE1, 0xC0, 0x3C, 0x1E, 0x03, 0x81, 0xE0, 0x78, 0x1E,
  0x0F, 0x00, 0xE0, 0xF0, 0x1F, 0xE0, 0x3D, 0xC0, 0xF3, 0x81, 0xE7, 0x07,
  0x8E, 0x0E, 0x1E, 0x3C, 0x3C, 0x70, 0x79, 0xE0, 0x73, 0x80, 0xEE, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xE3,
  0x8E, 0x38, 0xE3, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x3C, 0x71, 0xC7, 0x1C, 0x70, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x60, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xB8, 0x03,
  0xB8, 0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x1C, 0x1E, 0x1C, 0x0E, 0x38,
  0x0E, 0x78, 0x0E, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF1, 0xC7, 0x8E, 0x38,
  0x70, 0x01, 0xC0, 0x07, 0xE7, 0x0F, 0xFF, 0x1F, 0x3E, 0x1E, 0x1E, 0x3C,
  0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x70, 0x1C, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x38, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF8, 0xFF,
  0xF0, 0x7F, 0x70, 0x3E, 0x70, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x18, 0x0F, 0x7E, 0x0E,
  0xFE, 0x0F, 0x8F, 0x1F, 0x0F, 0x1E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x1C,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x78,
  0x1C, 0x78, 0x3C, 0x7C, 0x78, 0x7F, 0xF8, 0xEF, 0xF0, 0xE7, 0xE0, 0x01,
  0xE0, 0x3F, 0xC3, 0xFE, 0x3E, 0x23, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x43, 0xFE, 0x1F, 0xF0, 0x7F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x07, 0x1C, 0x07, 0xEF, 0x03, 0xFF, 0xC1, 0xF3, 0xE0, 0x78, 0x78, 0x3C,
  0x1E, 0x0E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x70, 0x70, 0x1C, 0x3C, 0x0F,
  0x0F, 0x03, 0xC3, 0xC0, 0xE0, 0xF0, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC3, 0xE0, 0xFF, 0xF0, 0x1F, 0xDC, 0x03, 0xE7, 0x00, 0x01, 0xE0, 0x1F,
  0xE0, 0xFF, 0x87, 0x8F, 0x1C, 0x1C, 0xE0, 0x77, 0x83, 0xDE, 0x1E, 0x70,
  0xF9, 0xFF, 0xCF, 0xFC, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x21, 0xF7, 0x87, 0xFE, 0x07, 0xF0, 0x00, 0x02, 0x00, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFA, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x2F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xF9,
  0xC1, 0xFF, 0xE1, 0xF3, 0xE0, 0xF0, 0xF0, 0xF0, 0x78, 0x70, 0x3C, 0x78,
  0x1E, 0x3C, 0x0E, 0x1C, 0x07, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xC3,
  0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0xF8, 0x78, 0x7C, 0x3F, 0xFC, 0x0F, 0xEE,
  0x03, 0xE7, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x80,
  0xF0, 0x71, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0F, 0x38, 0x0E, 0x7E, 0x0E, 0xFE, 0x0F, 0xDF, 0x1F, 0x0F, 0x1E, 0x0F,
  0x1E, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x0E, 0x3C, 0x1E, 0x38, 0x1E,
  0x38, 0x1C, 0x38, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x70, 0x3C, 0x70, 0x38,
  0x70, 0x38, 0xF0, 0x78, 0x01, 0x03, 0xC1, 0xE0, 0xF0, 0x20, 0x00, 0x00,
  0x00, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E,
  0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x00, 0x00,
  0x08, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0xBE, 0x03, 0xF8, 0x0F, 0xC0,
  0x1C, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x01, 0x0F, 0x0F, 0x07, 0x0F, 0x03,
  0x87, 0x01, 0xC7, 0x01, 0xE7, 0x80, 0xE7, 0x80, 0x77, 0x80, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x03, 0x8E, 0x03, 0xC7,
  0x81, 0xE3, 0xC0, 0xE1, 0xE0, 0x70, 0x70, 0x38, 0x3C, 0x3C, 0x1E, 0x00,
  0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03,
  0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80,
  0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x00, 0x00, 0x38,
  0x1C, 0x0E, 0xFE, 0x7E, 0x0F, 0xFE, 0xFF, 0x0F, 0x9F, 0xCF, 0x1F, 0x0F,
  0x8F, 0x1E, 0x0F, 0x07, 0x1E, 0x0F, 0x07, 0x1C, 0x0E, 0x0F, 0x1C, 0x1E,
  0x0F, 0x3C, 0x1E, 0x0E, 0x3C, 0x1C, 0x0E, 0x38, 0x1C, 0x0E, 0x38, 0x1C,
  0x1E, 0x38, 0x3C, 0x1E, 0x78, 0x3C, 0x1C, 0x78, 0x38, 0x1C, 0x70, 0x38,
  0x3C, 0x70, 0x38, 0x3C, 0x70, 0x78, 0x38, 0xF0, 0x78, 0x38, 0x00, 0x18,
  0x0E, 0x7E, 0x0E, 0xFE, 0x0F, 0xDF, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F,
  0x1E, 0x0E, 0x1C, 0x0E, 0x3C, 0x0E, 0x3C, 0x1E, 0x38, 0x1E, 0x38, 0x1C,
  0x38, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x70, 0x3C, 0x70, 0x38, 0xF0, 0x38,
  0xF0, 0x78, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0xF9, 0xE3, 0xC1, 0xC7,
  0x83, 0xDE, 0x07, 0xBC, 0x0F, 0x70, 0x1E, 0xE0, 0x3B, 0xC0, 0x77, 0x81,
  0xEF, 0x03, 0xDE, 0x07, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0xF0, 0xFF, 0xC1,
  0xFF, 0x00, 0xFC, 0x00, 0x00, 0x06, 0x00, 0xE7, 0xE0, 0x3B, 0xF8, 0x0F,
  0x8F, 0x03, 0xC3, 0xC1, 0xE0, 0x70, 0x78, 0x1C, 0x1C, 0x07, 0x07, 0x03,
  0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x38, 0x0E, 0x0E, 0x03, 0x83, 0x81, 0xE1,
  0xE0, 0x70, 0x78, 0x3C, 0x1F, 0x1E, 0x07, 0xFF, 0x81, 0xDF, 0xC0, 0xF7,
  0xE0, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x07, 0xE7, 0x0F, 0xFF, 0x1F, 0x3E, 0x1C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E,
  0x78, 0x1E, 0x78, 0x1C, 0x70, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x38,
  0xF0, 0x38, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF8, 0xFF, 0xF0, 0x7F, 0x70,
  0x3E, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x77, 0xC3,
  0xBE, 0x1F, 0xE1, 0xF8, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x7F, 0xC7, 0xFE, 0x3C, 0x63,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x81, 0xE7, 0xFE, 0x3F, 0xE1,
  0xFE, 0x00, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x1F, 0xF7, 0xFC, 0x70,
  0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C,
  0x07, 0x03, 0xC0, 0xF0, 0x3F, 0x87, 0xE1, 0xF8, 0x1E, 0x0F, 0x1C, 0x0E,
  0x1C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C,
  0x78, 0x3C, 0x78, 0x3C, 0x70, 0x38, 0x70, 0x38, 0xF0, 0x78, 0xF0, 0x78,
  0xF0, 0xF8, 0xF1, 0xF0, 0xFF, 0xF0, 0x7F, 0x70, 0x7E, 0x70, 0xE0, 0x3F,
  0x80, 0xEE, 0x07, 0xB8, 0x1C, 0xF0, 0xF3, 0xC3, 0x8F, 0x1E, 0x3C, 0x70,
  0xF3, 0xC3, 0xCE, 0x07, 0x38, 0x1D, 0xC0, 0x77, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x3F, 0xC3,
  0xE0, 0xEE, 0x0F, 0x87, 0xB8, 0x7E, 0x1C, 0xE1, 0xF8, 0xF3, 0x86, 0xE3,
  0x8E, 0x3B, 0x8E, 0x38, 0xEE, 0x78, 0xE7, 0x39, 0xC3, 0x9C, 0xEF, 0x0E,
  0x63, 0xB8, 0x3B, 0x8E, 0xE0, 0xEE, 0x3F, 0x03, 0xB0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF0, 0x0F, 0x03, 0xC0,
  0x00, 0x07, 0x87, 0xC1, 0xE1, 0xE0, 0x78, 0xF0, 0x0E, 0x38, 0x03, 0x9C,
  0x00, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0x70, 0x03, 0xDC, 0x01, 0xE7, 0x80, 0x70,
  0xE0, 0x3C, 0x38, 0x1E, 0x0F, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0xF0,
  0x38, 0x1E, 0x0F, 0x03, 0xC1, 0xC0, 0x78, 0x78, 0x07, 0x0E, 0x00, 0xE3,
  0xC0, 0x1C, 0x70, 0x03, 0x9E, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xDC,
  0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x9E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x7F, 0xE3, 0xFF, 0x8F, 0xFC,
  0x00, 0x00, 0x18, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x03,
  0xF0, 0x1F, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x40, 0x1E, 0x00,
  0xF8, 0x07, 0xE0, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3E, 0x03, 0xF0, 0x0F,
  0x80, 0x30, 0x00, 0x7E, 0x03, 0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xE8, 0x07,
  0x00,
};

const GFXglyph NotoSans_Condensed_MediumItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 26, 9, 0, -26 },
  { 34, 11, 10, 13, 4, -26 },
  { 48, 19, 26, 18, 0, -26 },
  { 110, 16, 29, 16, 0, -27 },
  { 168, 22, 26, 25, 2, -26 },
  { 240, 18, 26, 19, 0, -26 },
  { 299, 5, 10, 8, 4, -26 },
  { 306, 11, 32, 10, 1, -26 },
  { 350, 12, 32, 10, -3, -26 },
  { 398, 14, 15, 15, 3, -28 },
  { 425, 14, 17, 17, 2, -21 },
  { 455, 7, 9, 8, -2, -4 },
  { 463, 8, 3, 10, 1, -11 },
  { 466, 5, 5, 8, 0, -5 },
  { 470, 18, 26, 13, -2, -26 },
  { 529, 15, 26, 16, 1, -26 },
  { 578, 10, 26, 16, 4, -26 },
  { 611, 17, 26, 16, -1, -26 },
  { 667, 16, 26, 16, 0, -26 },
  { 719, 16, 26, 16, 0, -26 },
  { 771, 16, 26, 16, 0, -26 },
  { 823, 16, 26, 16, 1, -26 },
  { 875, 17, 26, 16, 1, -26 },
  { 931, 16, 26, 16, 0, -26 },
  { 983, 16, 26, 16, 0, -26 },
  { 1035, 8, 20, 8, 0, -20 },
  { 1055, 10, 25, 8, -2, -20 },
  { 1087, 14, 17, 17, 2, -21 },
  { 1117, 14, 10, 17, 2, -18 },
  { 1135, 14, 17, 17, 2, -21 },
  { 1165, 13, 26, 12, 1, -26 },
  { 1208, 23, 29, 24, 1, -26 },
  { 1292, 17, 26, 17, -2, -26 },
  { 1348, 18, 26, 18, 0, -26 },
  { 1407, 17, 26, 17, 2, -26 },
  { 1463, 19, 26, 19, 0, -26 },
  { 1525, 17, 26, 15, 0, -26 },
  { 1581, 17, 26, 14, 0, -26 },
  { 1637, 18, 26, 20, 2, -26 },
  { 1696, 21, 26, 20, 0, -26 },
  { 1765, 14, 26, 11, -1, -26 },
  { 1811, 14, 33, 9, -5, -26 },
  { 1869, 20, 26, 17, 0, -26 },
  { 1934, 12, 26, 14, 0, -26 },
  { 1973, 27, 26, 26, 0, -26 },
  { 2061, 22, 26, 21, 0, -26 },
  { 2133, 18, 26, 21, 2, -26 },
  { 2192, 17, 26, 17, 0, -26 },
  { 2248, 18, 32, 21, 2, -26 },
  { 2320, 17, 26, 17, 0, -26 },
  { 2376, 16, 26, 15, 0, -26 },
  { 2428, 14, 26, 15, 3, -26 },
  { 2474, 18, 26, 20, 2, -26 },
  { 2533, 17, 26, 17, 3, -26 },
  { 2589, 26, 26, 26, 3, -26 },
  { 2674, 20, 26, 16, -2, -26 },
  { 2739, 15, 26, 15, 3, -26 },
  { 2788, 18, 26, 15, -1, -26 },
  { 2847, 14, 32, 10, -1, -26 },
  { 2903, 6, 26, 13, 4, -26 },
  { 2923, 13, 32, 10, -2, -26 },
  { 2975, 16, 15, 16, 0, -26 },
  { 3005, 12, 2, 12, -3, 3 },
  { 3008, 6, 6, 10, 5, -28 },
  { 3013, 16, 20, 17, 1, -20 },
  { 3053, 16, 27, 17, 0, -27 },
  { 3107, 13, 20, 13, 1, -20 },
  { 3140, 18, 27, 17, 1, -27 },
  { 3201, 14, 20, 15, 1, -20 },
  { 3236, 18, 37, 10, -4, -28 },
  { 3320, 17, 29, 17, 0, -20 },
  { 3382, 16, 27, 17, 0, -27 },
  { 3436, 9, 27, 8, 0, -27 },
  { 3467, 14, 36, 8, -5, -27 },
  { 3530, 17, 27, 15, 0, -27 },
  { 3588, 10, 27, 8, 0, -27 },
  { 3622, 24, 20, 25, 0, -20 },
  { 3682, 16, 20, 17, 0, -20 },
  { 3722, 15, 20, 17, 1, -20 },
  { 3760, 18, 29, 17, -2, -20 },
  { 3826, 16, 29, 17, 1, -20 },
  { 3884, 13, 20, 12, 0, -20 },
  { 3917, 13, 20, 13, 0, -20 },
  { 3950, 10, 24, 10, 1, -24 },
  { 3980, 16, 19, 17, 1, -19 },
  { 4018, 14, 19, 14, 2, -19 },
  { 4052, 22, 19, 22, 2, -19 },
  { 4105, 18, 19, 15, -2, -19 },
  { 4148, 19, 28, 14, -3, -19 },
  { 4215, 14, 19, 12, -1, -19 },
  { 4249, 13, 32, 12, 1, -26 },
  { 4301, 3, 35, 15, 6, -27 },
  { 4315, 14, 32, 12, -2, -26 },
  { 4371, 15, 5, 17, 2, -15 },
};

const GFXfont NotoSans_Condensed_MediumItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC36PT7B_H_
