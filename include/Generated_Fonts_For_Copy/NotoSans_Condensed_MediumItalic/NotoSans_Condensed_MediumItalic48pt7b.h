#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC48PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x3E, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x03, 0xC0, 0x00, 0x3E, 0x3E, 0xF8,
  0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x78, 0x78,
  0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x07, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x38,
  0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF8, 0x07, 0x07, 0x80, 0x07, 0x83, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xC1,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x78, 0x07, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0x0F,
  0x07, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0xC0, 0x03, 0xC1, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFD, 0xFE, 0x07, 0xCE, 0x10, 0x1E, 0x38, 0x00, 0x78,
  0xC0, 0x01, 0xE3, 0x00, 0x07, 0x8C, 0x00, 0x1E, 0x70, 0x00, 0x7D, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0x7C, 0x00, 0x1C,
  0xF8, 0x00, 0x63, 0xE0, 0x01, 0x8F, 0x80, 0x06, 0x3E, 0x20, 0x38, 0xF0,
  0x60, 0xE7, 0xC1, 0xE3, 0x7E, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x3C, 0x0F, 0xF0, 0x07, 0x81, 0xFF, 0x80, 0x70, 0x3C, 0x78, 0x0F,
  0x03, 0xC7, 0x81, 0xE0, 0x78, 0x78, 0x1E, 0x07, 0x87, 0x83, 0xC0, 0x70,
  0x78, 0x38, 0x0F, 0x07, 0x87, 0x80, 0xF0, 0x78, 0xF0, 0x0F, 0x07, 0x0F,
  0x00, 0xF0, 0xF1, 0xE0, 0x0E, 0x0F, 0x1C, 0x00, 0xE0, 0xF3, 0xC7, 0xCE,
  0x1E, 0x38, 0xFE, 0xE1, 0xE7, 0x9F, 0xFF, 0x3C, 0xF3, 0xEF, 0xFF, 0xCF,
  0x3C, 0x7F, 0xF9, 0xE7, 0x87, 0x7F, 0x1C, 0x70, 0x71, 0xC3, 0xCF, 0x07,
  0x00, 0x78, 0xF0, 0x70, 0x07, 0x8F, 0x0F, 0x00, 0xF0, 0xE0, 0xF0, 0x0E,
  0x1E, 0x0F, 0x01, 0xE1, 0xE0, 0xF0, 0x3C, 0x1E, 0x0E, 0x03, 0xC1, 0xE1,
  0xE0, 0x78, 0x1E, 0x1E, 0x07, 0x01, 0xE3, 0xC0, 0xF0, 0x1E, 0x3C, 0x1E,
  0x00, 0xFF, 0x81, 0xE0, 0x0F, 0xF0, 0x3C, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xF0,
  0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE1, 0xF0, 0x01, 0xE3, 0xE0, 0x01, 0xE7,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0x0F, 0xBE, 0x1F, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1F, 0x1E, 0x3C, 0x1F, 0x3E, 0x7C, 0x1F, 0x3C, 0x78, 0x0F,
  0xFC, 0x78, 0x0F, 0xF8, 0xF8, 0x07, 0xF8, 0xF8, 0x07, 0xF0, 0xF8, 0x03,
  0xE0, 0xF8, 0x07, 0xE0, 0x7C, 0x1F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFE,
  0xF8, 0x3F, 0xF8, 0xF8, 0x1F, 0xF0, 0x7C, 0x3E, 0xF9, 0xF3, 0xE7, 0x8F,
  0x1E, 0x3C, 0xF1, 0xE3, 0xC7, 0x00, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x04, 0x1E, 0x03, 0x0F, 0x03, 0xE7, 0x01, 0xFF,
  0x9F, 0xFF, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xE1, 0xFC, 0x01, 0xFE, 0x01,
  0xF7, 0x81, 0xF1, 0xC1, 0xF8, 0xF0, 0x38, 0x7C, 0x08, 0x1E, 0x00, 0x08,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x87, 0xC3, 0xC3,
  0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x1C, 0x1E, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xEF, 0xFE, 0xFB, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0,
  0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F,
  0x1F, 0x00, 0xF1, 0xF0, 0x0F, 0x1E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01,
  0xF3, 0xE0, 0x1F, 0x3C, 0x01, 0xF7, 0xC0, 0x1E, 0x7C, 0x01, 0xE7, 0xC0,
  0x3E, 0x7C, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xC7, 0x80, 0x7C, 0xF8,
  0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF0, 0x78, 0x1F, 0x07,
  0x83, 0xF0, 0x7C, 0x3E, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8,
  0x7F, 0xE7, 0xFF, 0xBF, 0x3C, 0x78, 0xF0, 0xC7, 0xC2, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x7F, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0x81, 0xF0, 0x08, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3E, 0x3F, 0x81, 0xC0, 0x7C, 0x04, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x40, 0x07, 0xC3, 0x00,
  0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x77, 0x80, 0x03, 0xFE, 0x00, 0x1E,
  0xF8, 0x00, 0x73, 0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x7C, 0x00, 0xF1, 0xF0,
  0x03, 0xC7, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xE0, 0x1E,
  0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1F,
  0x07, 0x80, 0x7C, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x10, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x80, 0x0F, 0x83, 0x00, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x01,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFC, 0x20, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC3, 0xC0, 0x7C, 0xFF, 0x07, 0xDF, 0xF0,
  0x7B, 0xFF, 0x87, 0xF1, 0xF8, 0xFE, 0x0F, 0xCF, 0xC0, 0x7C, 0xF8, 0x07,
  0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0x8F, 0x00,
  0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0xF8,
  0x3E, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xF0, 0xF8, 0x0F, 0x81, 0xF0, 0x7C,
  0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07,
  0x81, 0xF0, 0x3E, 0x03, 0xC1, 0xF0, 0x0F, 0x8F, 0x80, 0x3F, 0x7C, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xF7,
  0xE0, 0x1F, 0x8F, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x3C, 0x1F, 0x00, 0xF8,
  0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8,
  0x03, 0xE1, 0xF0, 0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0xCF, 0xE0, 0x3F, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xE7, 0xE0, 0xFC, 0x1F, 0x0F, 0x81,
  0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0,
  0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x03, 0xF3, 0xE0, 0x3F, 0x3E,
  0x07, 0xE3, 0xF0, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFB, 0xC0,
  0x7F, 0x3C, 0x01, 0x87, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xC0, 0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x0F, 0x00, 0x00,
  0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF,
  0x1E, 0x3F, 0x18, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x01,
  0xE0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x3C,
  0x38, 0x0F, 0xF0, 0xF1, 0xE0, 0x7F, 0xE3, 0xC7, 0x03, 0xFF, 0x07, 0x3C,
  0x1E, 0x1C, 0x1C, 0xE0, 0xF0, 0xF0, 0xF7, 0x87, 0x83, 0xC3, 0xDE, 0x1E,
  0x0E, 0x0F, 0x70, 0xF0, 0x78, 0x3B, 0xC3, 0xC1, 0xE0, 0xEF, 0x0E, 0x07,
  0x83, 0xBC, 0x38, 0x1C, 0x1E, 0xE1, 0xE0, 0xF0, 0x73, 0x87, 0x83, 0xC1,
  0xCE, 0x1E, 0x0F, 0x0F, 0x38, 0x78, 0x7C, 0x38, 0xE1, 0xE3, 0xF1, 0xE3,
  0x87, 0xDD, 0xEF, 0x0E, 0x0F, 0xF7, 0xF8, 0x38, 0x1F, 0x8F, 0xC0, 0xE0,
  0x18, 0x08, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x40, 0x03, 0xF0, 0x0E,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07, 0x9E,
  0x00, 0x0F, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xF1, 0xE0,
  0x03, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1E, 0x0F, 0x00, 0x7C, 0x1E, 0x00,
  0xF8, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0x80,
  0x3C, 0x1F, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF8, 0x01, 0xE1, 0xF0, 0x03,
  0xC7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3F,
  0xF0, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x3F, 0x03, 0xE0, 0x1F,
  0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xC0, 0x1E, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0x03, 0xF0,
  0x0F, 0x01, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x1E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF8,
  0x3E, 0x01, 0xF0, 0x3C, 0x03, 0xF0, 0x7C, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x7F, 0x01, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0x07, 0xF0, 0x0F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0x81, 0xE0, 0x07, 0xC1, 0xF0, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1E, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x07, 0xC1, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x0F,
  0x80, 0x7E, 0x07, 0xC0, 0x7E, 0x03, 0xC0, 0x7E, 0x03, 0xE1, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xC0, 0x38, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x03, 0xFF, 0x1F, 0x01, 0xFF, 0x9F, 0x00, 0xFF, 0x8F,
  0x80, 0x7F, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF0,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F,
  0x07, 0xC0, 0x0F, 0x03, 0xF0, 0x0F, 0x81, 0xFC, 0x07, 0xC0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03,
  0xE0, 0x3E, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x01, 0xF0, 0x03, 0xE0, 0x3E,
  0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x7C,
  0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7C, 0x00, 0xF8, 0x0F, 0x00, 0x1E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00,
  0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0xF8, 0x0F,
  0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0x80, 0x0F,
  0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8,
  0x01, 0xF0, 0x1E, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x03,
  0xF0, 0x0F, 0x81, 0xF8, 0x03, 0xC0, 0x7C, 0x00, 0xF0, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xE1, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0xF7, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x1F, 0x00,
  0x1F, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x78, 0x0F,
  0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3C, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE,
  0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1E, 0xF0, 0x03,
  0xFE, 0x03, 0xDE, 0x00, 0xFF, 0xC0, 0x7B, 0xC0, 0x1E, 0xF0, 0x1F, 0x78,
  0x07, 0xDE, 0x03, 0xEF, 0x00, 0xF7, 0xC0, 0x79, 0xE0, 0x3E, 0xF8, 0x0F,
  0x3C, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x7C, 0xF0, 0x3C, 0xF8,
  0x0F, 0x9E, 0x07, 0x9F, 0x01, 0xE3, 0xC1, 0xE3, 0xE0, 0x3C, 0x78, 0x3C,
  0x78, 0x07, 0x8F, 0x0F, 0x0F, 0x01, 0xF1, 0xE1, 0xE3, 0xE0, 0x3E, 0x3C,
  0x78, 0x7C, 0x07, 0x87, 0x8F, 0x0F, 0x80, 0xF0, 0xF3, 0xC1, 0xE0, 0x3E,
  0x0F, 0x78, 0x3C, 0x07, 0xC1, 0xFE, 0x0F, 0x80, 0xF0, 0x3F, 0xC1, 0xF0,
  0x1E, 0x07, 0xF0, 0x3E, 0x03, 0xC0, 0xFE, 0x07, 0x80, 0xF8, 0x1F, 0xC0,
  0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xC0, 0x7E, 0x07, 0xC0, 0x78, 0x0F,
  0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x0F,
  0xE0, 0x07, 0xC0, 0x7F, 0x00, 0x3C, 0x03, 0xF8, 0x01, 0xE0, 0x1F, 0xC0,
  0x0F, 0x00, 0xFE, 0x00, 0xF8, 0x0F, 0xF8, 0x07, 0xC0, 0x7B, 0xC0, 0x3C,
  0x03, 0xDE, 0x01, 0xE0, 0x1E, 0xF0, 0x1F, 0x01, 0xF7, 0xC0, 0xF8, 0x0F,
  0xBE, 0x07, 0xC0, 0x78, 0xF0, 0x3C, 0x03, 0xC7, 0x81, 0xE0, 0x1E, 0x3C,
  0x1F, 0x01, 0xF1, 0xF0, 0xF8, 0x0F, 0x87, 0x87, 0x80, 0x78, 0x3C, 0x3C,
  0x03, 0xC1, 0xE1, 0xE0, 0x1E, 0x0F, 0x9F, 0x01, 0xF0, 0x7C, 0xF8, 0x0F,
  0x81, 0xE7, 0x80, 0x78, 0x0F, 0x3C, 0x03, 0xC0, 0x79, 0xE0, 0x3E, 0x03,
  0xFF, 0x01, 0xF0, 0x0F, 0xF8, 0x0F, 0x80, 0x7F, 0x80, 0x78, 0x03, 0xFC,
  0x03, 0xC0, 0x1F, 0xE0, 0x3E, 0x00, 0xFF, 0x01, 0xF0, 0x03, 0xF8, 0x0F,
  0x00, 0x1F, 0x80, 0x78, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x3E,
  0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE7, 0xE0, 0x01,
  0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xDF, 0x80,
  0x03, 0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0,
  0x00, 0xFC, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x1F,
  0x00, 0x3F, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x1F, 0x81, 0xF8, 0x3F, 0x80,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1E, 0x07, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x07, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xE0, 0x3F, 0x07, 0xC0, 0xFC, 0x0F,
  0x87, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF,
  0xE0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0x81, 0xF8, 0x1F, 0x80,
  0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x07, 0xC7, 0xC0,
  0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7D, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F,
  0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xF3,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x1F,
  0x81, 0xF8, 0x3F, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xC1, 0xF8, 0x0F, 0x03, 0xF0, 0x7C,
  0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1E, 0x01, 0xF0, 0xF8, 0x07,
  0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF0, 0x1F, 0x07,
  0xC1, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3E, 0x3E, 0x00, 0xF8, 0x78, 0x03, 0xE1, 0xF0, 0x0F, 0x07, 0xC0,
  0x3C, 0x1F, 0x01, 0xF0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78,
  0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07,
  0xC3, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0x80, 0xC0, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x82,
  0x00, 0x7E, 0x0E, 0x03, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0,
  0xF8, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F,
  0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xE0, 0xF8, 0x01,
  0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3C, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xE0,
  0x03, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x7E, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x3E,
  0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x1E, 0x00, 0xF8, 0x78,
  0x03, 0xC1, 0xE0, 0x1F, 0x07, 0x80, 0x7C, 0x1E, 0x03, 0xE0, 0x78, 0x0F,
  0x81, 0xE0, 0x7C, 0x07, 0x81, 0xF0, 0x1E, 0x0F, 0x80, 0x78, 0x3E, 0x01,
  0xE0, 0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0xF8, 0x01, 0xE3,
  0xC0, 0x07, 0x9F, 0x00, 0x1E, 0x7C, 0x00, 0x79, 0xE0, 0x01, 0xEF, 0x80,
  0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xFF, 0x00, 0x3E, 0x00, 0xFB, 0xE0, 0x0F, 0xC0, 0x1F,
  0x7C, 0x01, 0xF8, 0x03, 0xCF, 0x80, 0x3F, 0x00, 0xF9, 0xF0, 0x0F, 0xE0,
  0x1F, 0x3E, 0x01, 0xFC, 0x07, 0xC7, 0xC0, 0x7F, 0x80, 0xF8, 0xF8, 0x0F,
  0xF0, 0x1E, 0x1F, 0x03, 0xDE, 0x07, 0xC3, 0xE0, 0x7B, 0xC0, 0xF0, 0x7C,
  0x0F, 0x78, 0x3E, 0x0F, 0x83, 0xCF, 0x07, 0xC1, 0xF0, 0x79, 0xE0, 0xF0,
  0x3E, 0x1E, 0x3C, 0x3E, 0x07, 0xC3, 0xC7, 0x87, 0x80, 0xF8, 0x78, 0xF1,
  0xF0, 0x1F, 0x1E, 0x1E, 0x3E, 0x03, 0xE3, 0xC3, 0xC7, 0x80, 0x7C, 0xF0,
  0x79, 0xF0, 0x0F, 0x9E, 0x0F, 0x3C, 0x01, 0xF3, 0xC1, 0xCF, 0x80, 0x3E,
  0xF0, 0x39, 0xF0, 0x07, 0xDE, 0x07, 0x3C, 0x00, 0xF7, 0x80, 0xEF, 0x80,
  0x1E, 0xF0, 0x1D, 0xE0, 0x03, 0xDE, 0x03, 0xBC, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0x7C, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC1,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x1F,
  0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x0F,
  0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x78, 0x03, 0xE7, 0x80,
  0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC1, 0xF0, 0x3C,
  0x1E, 0x03, 0xC3, 0xE0, 0x3C, 0x7C, 0x03, 0xC7, 0xC0, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xF0, 0x78, 0x3C,
  0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC0,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xC7, 0x80, 0x7C, 0x78,
  0x07, 0x87, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x01,
  0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xE7, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x7C, 0x7C, 0x3C,
  0x1E, 0x1E, 0x0F, 0x00, 0xFC, 0x3C, 0x07, 0xF9, 0xE0, 0x3F, 0xF7, 0x81,
  0xFF, 0xDE, 0x0F, 0xC3, 0xF8, 0x3E, 0x07, 0xE1, 0xF0, 0x1F, 0x07, 0xC0,
  0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1E, 0x1F, 0x00, 0x78,
  0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1E, 0x00, 0xF0, 0x78,
  0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0x78, 0x1F,
  0x81, 0xF0, 0xFE, 0x07, 0xFF, 0x78, 0x1F, 0xFD, 0xE0, 0x3F, 0xE7, 0x80,
  0x7E, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x7E, 0x01, 0xF7, 0xFC,
  0x07, 0xFF, 0xF0, 0x1E, 0xFF, 0xE0, 0x7F, 0x0F, 0x81, 0xF8, 0x3E, 0x0F,
  0xC0, 0x78, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0x83, 0xE0, 0x1E, 0x0F, 0x00,
  0x78, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF8,
  0xF8, 0x03, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xE0, 0xF8,
  0x0F, 0x87, 0xE0, 0x7C, 0x1F, 0xC3, 0xF0, 0x7F, 0xBF, 0x81, 0xEF, 0xFC,
  0x07, 0x3F, 0xE0, 0x3C, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFE, 0x0F, 0xC0, 0x83, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x01, 0x07, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0xFC, 0x7C, 0x01, 0xFE, 0x78, 0x03, 0xFF, 0x78, 0x07, 0xFF, 0xF8, 0x0F,
  0xC3, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E,
  0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x7C, 0x01, 0xE0, 0x7C,
  0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0xF8,
  0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0x78,
  0x1F, 0x80, 0x7C, 0x3F, 0x80, 0x7E, 0xFF, 0x80, 0x7F, 0xF7, 0x80, 0x3F,
  0xE7, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0x03, 0xF3, 0xE0, 0xF8, 0x3E, 0x1E, 0x07, 0xC7, 0xC0, 0xF8, 0xF0, 0x1F,
  0x3E, 0x03, 0xC7, 0x80, 0xF9, 0xF0, 0x7E, 0x3F, 0xFF, 0x87, 0xFF, 0xE0,
  0xFF, 0xF0, 0x1F, 0xE0, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x04, 0x1F, 0xC7, 0x81,
  0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x20, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x0D, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x1E, 0x01, 0xFF, 0x78, 0x07,
  0xFE, 0xF0, 0x1F, 0xFF, 0xE0, 0x7E, 0x1F, 0xC0, 0xF8, 0x1F, 0x83, 0xE0,
  0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x78, 0x03,
  0xC1, 0xF0, 0x07, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C,
  0x1E, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x83,
  0xE0, 0x3F, 0x07, 0xC0, 0xFC, 0x07, 0xC3, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xF7, 0xC0, 0x1F, 0x8F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x80, 0x3E, 0x01, 0xF3, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF1, 0xF8,
  0x0F, 0xBF, 0xE0, 0x7F, 0xFF, 0x83, 0xDF, 0xFC, 0x1F, 0xC3, 0xE0, 0xFC,
  0x1F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0,
  0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1E, 0x01,
  0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xC0, 0x3E, 0x1E,
  0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xC0, 0x3E,
  0x1E, 0x01, 0xE1, 0xF0, 0x1F, 0x00, 0x00, 0x60, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0,
  0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF0,
  0x1F, 0x0F, 0x80, 0x78, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E,
  0x7C, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x80, 0x0F, 0x7C, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xBC, 0x00, 0x7C, 0xF8, 0x03,
  0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x7C, 0x07, 0xC1,
  0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0x80, 0xF8,
  0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x00, 0x03, 0x8F, 0xE0, 0xFC, 0x07, 0x9F, 0xF1, 0xFE, 0x07, 0xBF,
  0xF7, 0xFF, 0x07, 0xFF, 0xF7, 0xFF, 0x07, 0xF0, 0xFE, 0x1F, 0x07, 0xE0,
  0xFC, 0x0F, 0x0F, 0xC0, 0xF8, 0x0F, 0x0F, 0x80, 0xF8, 0x1F, 0x0F, 0x80,
  0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0x1E, 0x1F, 0x01,
  0xF0, 0x1E, 0x1F, 0x01, 0xE0, 0x1E, 0x1F, 0x01, 0xE0, 0x3E, 0x1E, 0x03,
  0xE0, 0x3E, 0x3E, 0x03, 0xE0, 0x3C, 0x3E, 0x03, 0xE0, 0x3C, 0x3E, 0x03,
  0xC0, 0x7C, 0x3C, 0x03, 0xC0, 0x7C, 0x3C, 0x07, 0xC0, 0x7C, 0x7C, 0x07,
  0xC0, 0x78, 0x7C, 0x07, 0xC0, 0x78, 0x7C, 0x07, 0x80, 0xF8, 0x78, 0x07,
  0x80, 0xF8, 0x78, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x80, 0xF0, 0x03, 0x87,
  0xE0, 0x3C, 0xFF, 0x81, 0xEF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x0F, 0x83,
  0xF0, 0x7C, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07,
  0xC3, 0xC0, 0x3C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x78,
  0x07, 0xC7, 0xC0, 0x3C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0x78, 0x07, 0x87, 0xC0, 0x3C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x00,
  0xF8, 0x78, 0x07, 0x87, 0xC0, 0x7C, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xC3, 0xE1, 0xF8, 0x1E, 0x1F, 0x01,
  0xF1, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0,
  0x1F, 0x7C, 0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0x78,
  0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xC7, 0x80, 0xF8, 0x7C, 0x0F, 0x87,
  0xC1, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0xE1, 0xF8, 0x00, 0xE7, 0xFC, 0x01, 0xEF, 0xFE, 0x01, 0xEF, 0xFE,
  0x01, 0xFC, 0x3E, 0x01, 0xF8, 0x1E, 0x03, 0xF0, 0x1E, 0x03, 0xE0, 0x1F,
  0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x1E, 0x03, 0xC0, 0x1E, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x3E, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x3C,
  0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x1F, 0x81, 0xF0, 0x1F, 0xC3, 0xF0, 0x1F, 0xFF, 0xE0, 0x1E, 0xFF, 0xC0,
  0x1E, 0xFF, 0x80, 0x3E, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x3C, 0x07, 0xFD, 0xE0, 0x3F, 0xF7, 0x81,
  0xFF, 0xFE, 0x0F, 0xC3, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0,
  0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1E, 0x1F, 0x00, 0x78,
  0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF0, 0x78,
  0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0x78, 0x1F,
  0x81, 0xF0, 0xFE, 0x07, 0xFF, 0x78, 0x1F, 0xFF, 0xE0, 0x3F, 0xEF, 0x00,
  0x7E, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0x8F, 0xC1,
  0xE7, 0xE0, 0x7B, 0xF8, 0x1E, 0xFE, 0x07, 0xF8, 0x81, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF,
  0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0x01, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x20, 0x1F, 0x0F, 0xBF, 0xC3,
  0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x7F, 0xEF, 0xFF, 0x7F, 0xFF, 0xFF, 0x87,
  0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x0F,
  0x00, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xE3,
  0xE0, 0x1E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C,
  0x7C, 0x03, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0x80, 0x78, 0x78, 0x07,
  0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF0, 0x1F, 0x0F, 0x01,
  0xF0, 0xF0, 0x3F, 0x0F, 0x87, 0xF0, 0xFF, 0xEF, 0x0F, 0xFD, 0xE0, 0x7F,
  0xDE, 0x07, 0xF1, 0xE0, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFB, 0xC0,
  0x3E, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0xF8, 0xF0, 0x3C,
  0x3C, 0x1F, 0x0F, 0x07, 0x83, 0xC3, 0xE0, 0xF8, 0xF0, 0x3E, 0x3C, 0x0F,
  0x9F, 0x03, 0xE7, 0x80, 0xFB, 0xE0, 0x1E, 0xF0, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0xFF, 0x80, 0xFC, 0x07, 0xBC, 0x07,
  0xE0, 0x7D, 0xE0, 0x7F, 0x03, 0xCF, 0x03, 0xF8, 0x1E, 0x78, 0x1F, 0xC1,
  0xF3, 0xC1, 0xFE, 0x0F, 0x1E, 0x0E, 0xF0, 0xF8, 0xF0, 0xF7, 0x87, 0x87,
  0x87, 0xBC, 0x3C, 0x3C, 0x39, 0xE3, 0xE1, 0xE3, 0xCF, 0x1E, 0x0F, 0x1E,
  0x79, 0xF0, 0x79, 0xE3, 0xCF, 0x03, 0xCF, 0x1E, 0x78, 0x1E, 0x70, 0xF7,
  0x80, 0xF7, 0x87, 0xBC, 0x07, 0xB8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFE, 0x01,
  0xFE, 0x0E, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x0F,
  0x07, 0xC0, 0x1E, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0xF8, 0x00, 0x7B,
  0xE0, 0x00, 0xF7, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x7C, 0x78, 0x00,
  0xF0, 0xF0, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x1E, 0x03, 0xC0, 0x7C,
  0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x07, 0xC0,
  0x78, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xE0, 0x0F, 0x81, 0xF0,
  0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x7C,
  0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F,
  0x00, 0x03, 0xCF, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7B,
  0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x6F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x30, 0x00, 0x00, 0x3F, 0x80, 0x17, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xE8, 0x01, 0xFC,
};

const GFXglyph NotoSans_Condensed_MediumItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 13, 34, 12, 0, -34 },
  { 57, 15, 12, 18, 5, -34 },
  { 80, 25, 34, 24, 0, -34 },
  { 187, 22, 39, 21, 0, -36 },
  { 295, 28, 35, 33, 3, -35 },
  { 418, 24, 35, 25, 0, -35 },
  { 523, 7, 12, 10, 5, -34 },
  { 534, 16, 42, 13, 1, -34 },
  { 618, 16, 43, 13, -4, -35 },
  { 704, 17, 19, 21, 5, -37 },
  { 745, 20, 22, 23, 2, -28 },
  { 800, 9, 12, 11, -2, -6 },
  { 814, 11, 4, 14, 1, -15 },
  { 820, 6, 6, 11, 1, -6 },
  { 825, 23, 34, 17, -2, -34 },
  { 923, 20, 35, 21, 1, -35 },
  { 1011, 14, 34, 22, 5, -34 },
  { 1071, 22, 35, 21, -1, -35 },
  { 1168, 21, 35, 21, 0, -35 },
  { 1260, 22, 34, 22, -1, -34 },
  { 1354, 22, 34, 21, 0, -34 },
  { 1448, 20, 35, 21, 2, -35 },
  { 1536, 21, 34, 21, 2, -34 },
  { 1626, 22, 35, 21, 0, -35 },
  { 1723, 20, 35, 21, 1, -35 },
  { 1811, 11, 26, 11, 0, -26 },
  { 1847, 13, 32, 11, -2, -26 },
  { 1899, 20, 22, 23, 2, -28 },
  { 1954, 20, 14, 23, 2, -24 },
  { 1989, 20, 22, 23, 2, -28 },
  { 2044, 16, 35, 16, 2, -35 },
  { 2114, 30, 38, 33, 2, -34 },
  { 2257, 23, 34, 23, -3, -34 },
  { 2355, 24, 34, 24, 0, -34 },
  { 2457, 23, 35, 22, 2, -35 },
  { 2558, 25, 34, 26, 0, -34 },
  { 2665, 22, 34, 20, 0, -34 },
  { 2759, 22, 34, 19, 0, -34 },
  { 2853, 25, 35, 27, 2, -35 },
  { 2963, 27, 34, 27, 1, -34 },
  { 3078, 19, 34, 14, -2, -34 },
  { 3159, 20, 43, 11, -7, -34 },
  { 3267, 26, 34, 22, 1, -34 },
  { 3378, 16, 34, 19, 0, -34 },
  { 3446, 35, 34, 35, 0, -34 },
  { 3595, 29, 34, 28, 0, -34 },
  { 3719, 25, 35, 28, 2, -35 },
  { 3829, 23, 34, 22, 0, -34 },
  { 3927, 25, 43, 28, 2, -35 },
  { 4062, 22, 34, 23, 1, -34 },
  { 4156, 22, 35, 20, 0, -35 },
  { 4253, 19, 34, 19, 4, -34 },
  { 4334, 25, 34, 26, 2, -34 },
  { 4441, 22, 34, 22, 4, -34 },
  { 4535, 35, 34, 35, 4, -34 },
  { 4684, 28, 34, 21, -3, -34 },
  { 4803, 20, 34, 20, 4, -34 },
  { 4888, 24, 34, 19, -2, -34 },
  { 4990, 18, 42, 14, -1, -34 },
  { 5085, 9, 34, 17, 5, -34 },
  { 5124, 18, 42, 14, -3, -34 },
  { 5219, 20, 20, 22, 1, -34 },
  { 5269, 16, 3, 16, -4, 4 },
  { 5275, 8, 8, 13, 7, -37 },
  { 5283, 22, 26, 23, 1, -26 },
  { 5355, 22, 36, 23, 0, -36 },
  { 5454, 18, 26, 18, 1, -26 },
  { 5513, 24, 36, 23, 1, -36 },
  { 5621, 19, 26, 21, 1, -26 },
  { 5683, 25, 49, 13, -6, -37 },
  { 5837, 23, 38, 23, 0, -26 },
  { 5947, 21, 36, 23, 0, -36 },
  { 6042, 12, 36, 11, 0, -36 },
  { 6096, 18, 48, 11, -6, -36 },
  { 6204, 22, 36, 20, 0, -36 },
  { 6303, 13, 36, 11, 0, -36 },
  { 6362, 32, 26, 34, 0, -26 },
  { 6466, 21, 26, 23, 0, -26 },
  { 6535, 20, 26, 22, 1, -26 },
  { 6600, 24, 37, 23, -2, -26 },
  { 6711, 22, 37, 23, 1, -26 },
  { 6813, 18, 26, 16, 0, -26 },
  { 6872, 18, 26, 17, 0, -26 },
  { 6931, 13, 32, 14, 2, -32 },
  { 6983, 20, 26, 23, 2, -26 },
  { 7048, 18, 26, 19, 3, -26 },
  { 7107, 29, 26, 30, 3, -26 },
  { 7202, 23, 26, 19, -2, -26 },
  { 7277, 25, 38, 19, -4, -26 },
  { 7396, 19, 26, 17, -1, -26 },
  { 7458, 18, 42, 16, 1, -34 },
  { 7553, 4, 48, 20, 8, -37 },
  { 7577, 18, 42, 16, -3, -34 },
  { 7672, 20, 6, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_MediumItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC48PT7B_H_
