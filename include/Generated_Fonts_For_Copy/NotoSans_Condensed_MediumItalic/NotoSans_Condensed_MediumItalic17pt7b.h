#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC17PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0x8C, 0x62, 0x11, 0x8C, 0x00, 0x31, 0x80, 0xDE, 0xA5, 0x20,
  0x09, 0x04, 0x86, 0xCF, 0xF7, 0xF8, 0xB0, 0x91, 0xFE, 0x24, 0x34, 0x12,
  0x0B, 0x00, 0x04, 0x0C, 0x3F, 0x2A, 0x28, 0x38, 0x38, 0x0C, 0x16, 0x16,
  0x9C, 0xF8, 0x20, 0x20, 0x70, 0x96, 0x4D, 0xB2, 0x48, 0x96, 0x25, 0x7E,
  0xA4, 0x69, 0x12, 0x4D, 0xB2, 0x69, 0x0E, 0x1E, 0x09, 0x0C, 0x86, 0xC1,
  0xC0, 0xC1, 0xE6, 0x9E, 0xCF, 0x63, 0x33, 0x8F, 0x60, 0xFA, 0x0C, 0x63,
  0x0C, 0x21, 0x84, 0x10, 0xC3, 0x0C, 0x30, 0x41, 0x06, 0x00, 0x18, 0xC2,
  0x10, 0x84, 0x63, 0x18, 0x8C, 0x46, 0x22, 0x00, 0x32, 0xCE, 0x4F, 0x53,
  0x61, 0x00, 0x10, 0x20, 0x47, 0xFF, 0xE2, 0x04, 0x08, 0x36, 0x4C, 0xF0,
  0xF0, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60,
  0xC0, 0x3C, 0xC9, 0x9E, 0x3C, 0x58, 0xA3, 0x46, 0x8D, 0x33, 0x67, 0x80,
  0x3B, 0xB5, 0x63, 0x18, 0x84, 0x63, 0x18, 0x80, 0x3E, 0x26, 0x03, 0x02,
  0x06, 0x04, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0xFC, 0x3E, 0x23, 0x03, 0x02,
  0x06, 0x38, 0x0C, 0x04, 0x06, 0x04, 0x8C, 0xF8, 0x07, 0x06, 0x0A, 0x1E,
  0x16, 0x24, 0x64, 0xCC, 0xFE, 0x0C, 0x08, 0x18, 0x1F, 0x30, 0x30, 0x20,
  0x28, 0x7C, 0x06, 0x06, 0x06, 0x04, 0x9C, 0xF8, 0x1E, 0x61, 0x82, 0x0D,
  0x9F, 0xB3, 0x46, 0x8D, 0x1B, 0x67, 0x80, 0x7E, 0x0C, 0x10, 0x60, 0x83,
  0x04, 0x18, 0x20, 0xC3, 0x06, 0x00, 0x1E, 0x33, 0x23, 0x22, 0x36, 0x18,
  0x3C, 0x46, 0xC6, 0xC6, 0xCC, 0x78, 0x1E, 0x6D, 0x8B, 0x16, 0x2C, 0xDF,
  0x8B, 0x04, 0x1A, 0x67, 0x80, 0x32, 0x00, 0x00, 0x0C, 0xC0, 0x18, 0xC0,
  0x00, 0x00, 0x04, 0x62, 0x30, 0x02, 0x1C, 0xE7, 0x0E, 0x07, 0x03, 0x81,
  0xFE, 0x00, 0x07, 0xF0, 0x81, 0xC0, 0xE0, 0x70, 0xE7, 0x38, 0x40, 0xFA,
  0x42, 0x11, 0x19, 0x88, 0x80, 0x31, 0x80, 0x0F, 0x8C, 0x32, 0x05, 0x3D,
  0xDB, 0x64, 0x9B, 0x26, 0xDB, 0xB6, 0xA6, 0xC8, 0x03, 0x00, 0x7E, 0x00,
  0x07, 0x07, 0x0F, 0x0B, 0x1B, 0x1B, 0x33, 0x3F, 0x23, 0x63, 0x43, 0xC3,
  0x1F, 0x33, 0x31, 0x31, 0x23, 0x3C, 0x66, 0x62, 0x62, 0x46, 0xCE, 0xFC,
  0x1F, 0x32, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE8, 0x78,
  0x1E, 0x19, 0x8C, 0x66, 0x32, 0x19, 0x0D, 0x86, 0xC6, 0x63, 0x23, 0x3F,
  0x1F, 0x00, 0x1F, 0x30, 0x30, 0x30, 0x20, 0x3E, 0x60, 0x60, 0x60, 0x40,
  0xFC, 0xF8, 0x1F, 0x30, 0x30, 0x30, 0x20, 0x3C, 0x7C, 0x60, 0x60, 0x40,
  0xC0, 0xC0, 0x1F, 0x98, 0x98, 0x0C, 0x0C, 0x06, 0x7B, 0x3D, 0x84, 0xC2,
  0x63, 0x39, 0x8F, 0xC0, 0x10, 0xCC, 0x23, 0x18, 0xC6, 0x21, 0x8F, 0xE6,
  0x11, 0x8C, 0x63, 0x10, 0xC4, 0x23, 0x18, 0x1E, 0x18, 0x20, 0xC1, 0x83,
  0x04, 0x08, 0x30, 0x60, 0xC7, 0xC0, 0x02, 0x0C, 0x18, 0x30, 0x40, 0x83,
  0x06, 0x0C, 0x10, 0x20, 0xC1, 0x82, 0x3C, 0x00, 0x11, 0x99, 0x8C, 0x86,
  0xC2, 0xC1, 0xC1, 0xE0, 0xD8, 0x6C, 0x22, 0x11, 0x98, 0xC0, 0x10, 0xC3,
  0x0C, 0x20, 0x86, 0x18, 0x61, 0x0C, 0x7E, 0x18, 0x39, 0xC3, 0x8E, 0x1C,
  0x71, 0xE2, 0x8B, 0x14, 0xD1, 0xA4, 0x8D, 0x6C, 0x4A, 0x62, 0x72, 0x33,
  0x91, 0x99, 0x80, 0x18, 0x4E, 0x33, 0x8C, 0xA3, 0x2C, 0x8B, 0x66, 0x59,
  0x96, 0x47, 0x11, 0xCC, 0x33, 0x0C, 0x1E, 0x33, 0x61, 0x61, 0xC1, 0xC1,
  0xC3, 0xC3, 0xC3, 0xC6, 0xCC, 0x78, 0x1E, 0x33, 0x31, 0x33, 0x23, 0x27,
  0x7E, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0x1E, 0x33, 0x61, 0x41, 0xC1, 0xC1,
  0xC3, 0xC3, 0xC3, 0xC6, 0xCC, 0x78, 0x18, 0x0C, 0x0C, 0x1E, 0x33, 0x33,
  0x33, 0x23, 0x26, 0x7C, 0x6C, 0x6C, 0x44, 0x46, 0xC6, 0x1F, 0x32, 0x20,
  0x60, 0x30, 0x38, 0x1C, 0x0C, 0x04, 0x0C, 0x9C, 0xF8, 0x7F, 0x20, 0x41,
  0x83, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x82, 0x00, 0x21, 0xB0, 0x98, 0xCC,
  0x64, 0x36, 0x13, 0x09, 0x8C, 0xC6, 0x62, 0x33, 0x0F, 0x00, 0xC3, 0x43,
  0x46, 0x46, 0x44, 0x4C, 0x48, 0x58, 0x50, 0x70, 0x60, 0x60, 0x42, 0x1A,
  0x31, 0x91, 0x8C, 0x9C, 0x44, 0xA6, 0x25, 0x21, 0x6B, 0x0A, 0x58, 0x72,
  0x83, 0x1C, 0x38, 0xC1, 0xC6, 0x00, 0x18, 0xC6, 0x61, 0xB0, 0x28, 0x0E,
  0x03, 0x00, 0xC0, 0x70, 0x36, 0x09, 0x86, 0x63, 0x18, 0xC3, 0x46, 0x6C,
  0x6C, 0x78, 0x70, 0x30, 0x20, 0x60, 0x60, 0x60, 0x40, 0x1F, 0x80, 0x80,
  0xC0, 0xC0, 0x40, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x1F, 0xC0, 0x1C,
  0xC3, 0x08, 0x20, 0x86, 0x18, 0x41, 0x0C, 0x30, 0xC3, 0x8E, 0x00, 0x93,
  0x6D, 0x92, 0x4D, 0xB0, 0x1C, 0x10, 0xC3, 0x08, 0x21, 0x86, 0x18, 0x41,
  0x0C, 0x33, 0x8E, 0x00, 0x08, 0x1C, 0x14, 0x34, 0x26, 0x62, 0xC3, 0x7F,
  0xF0, 0xCC, 0x80, 0x3E, 0xDF, 0x16, 0x28, 0xD1, 0xA3, 0x4C, 0xE8, 0x10,
  0x10, 0x30, 0x30, 0x2E, 0x33, 0x63, 0x63, 0x62, 0x46, 0x46, 0xEC, 0xF8,
  0x3D, 0x8C, 0x30, 0x82, 0x08, 0x34, 0xF0, 0x03, 0x03, 0x02, 0x06, 0x3E,
  0x6E, 0xC4, 0xC4, 0x8C, 0x8C, 0x8C, 0x98, 0xE8, 0x3D, 0xBC, 0xF6, 0xF2,
  0x08, 0x32, 0xF8, 0x03, 0x83, 0x81, 0x01, 0x81, 0xE0, 0x60, 0x20, 0x30,
  0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0xE0, 0x00, 0x1F,
  0x37, 0x62, 0x62, 0x46, 0x46, 0xC6, 0x4C, 0x74, 0x0C, 0x0C, 0x98, 0xF0,
  0x10, 0x20, 0xC1, 0x82, 0xE6, 0x58, 0xB1, 0x66, 0x8D, 0x1E, 0x2C, 0xC0,
  0x13, 0x00, 0x32, 0x66, 0x64, 0x4C, 0xC0, 0x04, 0x30, 0x00, 0x0C, 0x21,
  0x86, 0x18, 0x41, 0x0C, 0x30, 0xC2, 0x18, 0xC0, 0x10, 0x10, 0x30, 0x30,
  0x33, 0x26, 0x6C, 0x78, 0x78, 0x68, 0x48, 0xCC, 0xCC, 0x11, 0x33, 0x32,
  0x66, 0x64, 0x4C, 0xC0, 0x2E, 0xE6, 0x65, 0x88, 0xB3, 0x16, 0x66, 0x8C,
  0xD1, 0x1E, 0x22, 0xCC, 0xC0, 0x2E, 0x65, 0x8B, 0x16, 0x68, 0xD1, 0xE2,
  0xCC, 0x3D, 0xBC, 0x71, 0x86, 0x38, 0xF6, 0xF0, 0x17, 0x0C, 0xCC, 0x66,
  0x33, 0x11, 0x18, 0x8C, 0xEC, 0x7C, 0x30, 0x10, 0x08, 0x0C, 0x00, 0x3E,
  0xDF, 0x16, 0x28, 0xD1, 0xA3, 0x4C, 0xE8, 0x30, 0x60, 0xC1, 0x00, 0x2C,
  0xC6, 0x18, 0x61, 0x04, 0x30, 0xC0, 0x3D, 0x96, 0x18, 0x38, 0x61, 0xA6,
  0xF0, 0x26, 0xF4, 0x4C, 0xCC, 0x88, 0xE0, 0x66, 0x8F, 0x16, 0x2C, 0xD1,
  0xA2, 0x4C, 0xE8, 0xC7, 0x9B, 0x26, 0xCD, 0x1E, 0x38, 0x70, 0xC0, 0xCC,
  0xF3, 0x3D, 0x4B, 0x56, 0xF5, 0x39, 0xCA, 0x63, 0x18, 0xC6, 0x00, 0x33,
  0x89, 0x07, 0x83, 0x81, 0x80, 0xE0, 0xF0, 0xC8, 0xC6, 0x00, 0x18, 0xC6,
  0x61, 0x90, 0x6C, 0x1A, 0x07, 0x81, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0xE0, 0x00, 0x3E, 0x0C, 0x30, 0x41, 0x86, 0x08, 0x30, 0xFC, 0x0E,
  0x30, 0x60, 0xC1, 0x06, 0x1C, 0x70, 0x20, 0x41, 0x83, 0x06, 0x0E, 0x0C,
  0x00, 0xFF, 0xFF, 0x80, 0x18, 0x30, 0xC2, 0x08, 0x60, 0xC3, 0x18, 0xC3,
  0x0C, 0x23, 0x8C, 0x00, 0xF3, 0x3C,
};

const GFXglyph NotoSans_Condensed_MediumItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 12, 4, 0, -12 },
  { 9, 5, 4, 6, 2, -12 },
  { 12, 9, 12, 9, 0, -12 },
  { 26, 8, 14, 8, 0, -13 },
  { 40, 10, 12, 12, 1, -12 },
  { 55, 9, 12, 9, 0, -12 },
  { 69, 2, 4, 4, 2, -12 },
  { 70, 6, 15, 5, 0, -12 },
  { 82, 5, 15, 5, -1, -12 },
  { 92, 6, 7, 7, 2, -13 },
  { 98, 7, 8, 8, 1, -10 },
  { 105, 4, 4, 4, -1, -2 },
  { 107, 4, 1, 5, 0, -5 },
  { 108, 2, 2, 4, 0, -2 },
  { 109, 8, 12, 6, -1, -12 },
  { 121, 7, 12, 8, 1, -12 },
  { 132, 5, 12, 8, 2, -12 },
  { 140, 8, 12, 8, 0, -12 },
  { 152, 8, 12, 8, 0, -12 },
  { 164, 8, 12, 8, 0, -12 },
  { 176, 8, 12, 8, 0, -12 },
  { 188, 7, 12, 8, 1, -12 },
  { 199, 7, 12, 8, 1, -12 },
  { 210, 8, 12, 8, 0, -12 },
  { 222, 7, 12, 8, 0, -12 },
  { 233, 4, 9, 4, 0, -9 },
  { 238, 5, 11, 4, -1, -9 },
  { 245, 7, 8, 8, 1, -10 },
  { 252, 7, 4, 8, 1, -8 },
  { 256, 7, 8, 8, 1, -10 },
  { 263, 5, 12, 6, 1, -12 },
  { 271, 10, 13, 12, 1, -12 },
  { 288, 8, 12, 8, -1, -12 },
  { 300, 8, 12, 8, 0, -12 },
  { 312, 8, 12, 8, 1, -12 },
  { 324, 9, 12, 9, 0, -12 },
  { 338, 8, 12, 7, 0, -12 },
  { 350, 8, 12, 7, 0, -12 },
  { 362, 9, 12, 9, 1, -12 },
  { 376, 10, 12, 9, 0, -12 },
  { 391, 7, 12, 5, -1, -12 },
  { 402, 7, 15, 4, -3, -12 },
  { 416, 9, 12, 8, 0, -12 },
  { 430, 6, 12, 7, 0, -12 },
  { 439, 13, 12, 12, 0, -12 },
  { 459, 10, 12, 10, 0, -12 },
  { 474, 8, 12, 10, 1, -12 },
  { 486, 8, 12, 8, 0, -12 },
  { 498, 8, 15, 10, 1, -12 },
  { 513, 8, 12, 8, 0, -12 },
  { 525, 8, 12, 7, 0, -12 },
  { 537, 7, 12, 7, 1, -12 },
  { 548, 9, 12, 9, 1, -12 },
  { 562, 8, 12, 8, 1, -12 },
  { 574, 13, 12, 12, 1, -12 },
  { 594, 10, 12, 7, -1, -12 },
  { 609, 8, 12, 7, 1, -12 },
  { 621, 9, 12, 7, -1, -12 },
  { 635, 6, 15, 5, 0, -12 },
  { 647, 3, 12, 6, 2, -12 },
  { 652, 6, 15, 5, -1, -12 },
  { 664, 8, 7, 8, 0, -12 },
  { 671, 6, 2, 6, -2, 1 },
  { 673, 3, 3, 5, 2, -13 },
  { 675, 7, 9, 8, 1, -9 },
  { 683, 8, 13, 8, 0, -13 },
  { 696, 6, 9, 6, 1, -9 },
  { 703, 8, 13, 8, 1, -13 },
  { 716, 6, 9, 7, 1, -9 },
  { 723, 9, 17, 5, -2, -13 },
  { 743, 8, 13, 8, 0, -9 },
  { 756, 7, 13, 8, 0, -13 },
  { 768, 4, 13, 4, 0, -13 },
  { 775, 6, 17, 4, -2, -13 },
  { 788, 8, 13, 7, 0, -13 },
  { 801, 4, 13, 4, 0, -13 },
  { 808, 11, 9, 12, 0, -9 },
  { 821, 7, 9, 8, 0, -9 },
  { 829, 6, 9, 8, 1, -9 },
  { 836, 9, 13, 8, -1, -9 },
  { 851, 7, 13, 8, 1, -9 },
  { 863, 6, 9, 6, 0, -9 },
  { 870, 6, 9, 6, 0, -9 },
  { 877, 4, 11, 5, 1, -11 },
  { 883, 7, 9, 8, 1, -9 },
  { 891, 7, 9, 7, 1, -9 },
  { 899, 10, 9, 10, 1, -9 },
  { 911, 9, 9, 7, -1, -9 },
  { 922, 10, 13, 7, -2, -9 },
  { 939, 7, 9, 6, -1, -9 },
  { 947, 7, 15, 6, 0, -12 },
  { 961, 1, 17, 7, 3, -13 },
  { 964, 6, 15, 6, -1, -12 },
  { 976, 7, 2, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_MediumItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC17PT7B_H_
