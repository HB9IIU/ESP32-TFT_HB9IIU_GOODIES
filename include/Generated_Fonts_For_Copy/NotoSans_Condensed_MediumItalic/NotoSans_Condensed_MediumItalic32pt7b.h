#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC32PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x07,
  0x07, 0x83, 0xC0, 0x79, 0xDC, 0x77, 0x39, 0xCE, 0x73, 0x98, 0xEE, 0x33,
  0x8C, 0x00, 0xC7, 0x00, 0x63, 0x00, 0x71, 0x80, 0x31, 0xC0, 0x18, 0xC0,
  0x1C, 0x60, 0x0C, 0x30, 0x3F, 0xFF, 0x3F, 0xFF, 0x03, 0x0C, 0x01, 0x8E,
  0x00, 0xC6, 0x00, 0xE3, 0x00, 0x63, 0x81, 0xFF, 0xF9, 0xFF, 0xF8, 0x18,
  0xE0, 0x0C, 0x70, 0x0E, 0x30, 0x06, 0x18, 0x03, 0x1C, 0x03, 0x8C, 0x01,
  0xCE, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x03, 0xC0, 0x3F, 0xF0, 0xFF, 0xC1,
  0xD9, 0x87, 0x30, 0x0E, 0x40, 0x1C, 0x80, 0x39, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xB8, 0x03, 0x70, 0x04, 0xE2,
  0x09, 0xC7, 0x37, 0x8F, 0xFE, 0x0F, 0xF8, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x1E, 0x01, 0x87, 0xE0, 0x70, 0xCE, 0x1C, 0x39, 0xC3,
  0x06, 0x38, 0xE1, 0xC7, 0x18, 0x38, 0xC7, 0x06, 0x19, 0xC0, 0xC7, 0x30,
  0x18, 0xEE, 0x7B, 0x19, 0x9F, 0x67, 0x77, 0x7F, 0xCC, 0xC6, 0xF3, 0x38,
  0xC0, 0xE6, 0x38, 0x18, 0xC7, 0x07, 0x38, 0xE0, 0xC7, 0x18, 0x38, 0xE3,
  0x0E, 0x1C, 0xE1, 0x83, 0x98, 0x70, 0x7E, 0x1C, 0x07, 0xC0, 0x01, 0xF0,
  0x03, 0xF8, 0x07, 0xBC, 0x07, 0x1C, 0x06, 0x1C, 0x0E, 0x18, 0x0E, 0x38,
  0x07, 0x78, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xC7,
  0x39, 0xC7, 0x71, 0xEE, 0x70, 0xEE, 0xE0, 0xFC, 0xE0, 0x7C, 0xE0, 0x78,
  0xF0, 0xF8, 0xFB, 0xFC, 0x7F, 0xDC, 0x3F, 0x1E, 0x7B, 0x9C, 0xE7, 0x31,
  0x9C, 0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x0E, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0,
  0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x07, 0x03, 0x80, 0x07,
  0x00, 0x70, 0x47, 0x0E, 0x60, 0xFF, 0xF3, 0xFF, 0x0F, 0xF1, 0xF0, 0x3B,
  0x07, 0x38, 0x21, 0xC0, 0x10, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x1E, 0x38, 0x71, 0xC3, 0x86, 0x1C,
  0x70, 0xFF, 0xFF, 0xF8, 0x77, 0xF7, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0xFE, 0x3C, 0x71, 0xC3,
  0x9E, 0x1C, 0xE0, 0xE7, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0xFE,
  0x07, 0x70, 0x3B, 0x81, 0xDC, 0x1E, 0xE0, 0xE7, 0x07, 0x38, 0x71, 0xC3,
  0x8F, 0xF8, 0x3F, 0x80, 0xF8, 0x00, 0x01, 0xC1, 0xE0, 0xF8, 0x7E, 0x3F,
  0xBC, 0xE6, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0x01,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x30, 0x70, 0x40, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0xE0, 0xFF,
  0xC3, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x03,
  0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x20, 0x38, 0xF7, 0xE3, 0xFF, 0x0F, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xD8, 0x07, 0xE0, 0x3B,
  0x80, 0xCE, 0x07, 0x38, 0x39, 0xC0, 0xC7, 0x07, 0x1C, 0x38, 0x70, 0xC3,
  0x87, 0x0E, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x20, 0x38, 0xF7, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0xFC,
  0x0F, 0xF0, 0x7F, 0x83, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x81, 0xDF, 0x87, 0xFF, 0x1F, 0x3C, 0xF0, 0x73, 0xC1, 0xCE, 0x07,
  0x38, 0x1C, 0xE0, 0x73, 0x83, 0xCE, 0x0E, 0x3C, 0x78, 0x7B, 0xC1, 0xFE,
  0x03, 0xF0, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0xFF, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x0F, 0xF8, 0x3E, 0xF0, 0x70, 0xE1, 0xE1, 0xE3, 0x83, 0x87, 0x07,
  0x07, 0x0E, 0x0E, 0x38, 0x1F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFE, 0x07,
  0x9E, 0x1E, 0x1C, 0x38, 0x3C, 0xF0, 0x39, 0xC0, 0xF3, 0x81, 0xC7, 0x83,
  0x87, 0x9F, 0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xFF,
  0x87, 0x8F, 0x1C, 0x1C, 0x70, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0,
  0xF3, 0x83, 0xCF, 0x1E, 0x1F, 0xF8, 0x7E, 0xE0, 0x63, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0xC7, 0x83, 0xFC, 0x0F, 0xE0, 0x00,
  0x1E, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x3C, 0x78, 0xF0, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x70, 0x38, 0x38, 0x1C, 0x1C,
  0x0E, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x3C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x80, 0x06, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x01, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x80, 0x70, 0x02, 0x00, 0x00, 0x1F, 0x87,
  0xF8, 0xFF, 0x90, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC0, 0xF0,
  0x3C, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x0F, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x03,
  0xC1, 0xE0, 0x70, 0x06, 0x0E, 0x00, 0x71, 0xC0, 0x03, 0x18, 0x3D, 0x33,
  0x87, 0xE3, 0x30, 0xC6, 0x37, 0x18, 0xE3, 0x63, 0x8E, 0x36, 0x30, 0xC3,
  0xE3, 0x0C, 0x7E, 0x71, 0xC6, 0xC7, 0x1C, 0x6C, 0x71, 0x8E, 0xC7, 0x38,
  0xCC, 0x7E, 0xF8, 0xC3, 0xCF, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xE3, 0x80, 0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0E, 0xC0, 0x1D, 0x80, 0x33,
  0x00, 0xE7, 0x01, 0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x38, 0x70, 0x70, 0xE1,
  0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x1C, 0x0E, 0x38, 0x1C, 0xE0, 0x39, 0xC0,
  0x77, 0x80, 0xEE, 0x01, 0xFC, 0x03, 0x80, 0x07, 0xF0, 0x07, 0xFC, 0x07,
  0xFE, 0x0F, 0x0F, 0x0E, 0x0F, 0x0E, 0x07, 0x0E, 0x0F, 0x0E, 0x0E, 0x1E,
  0x1E, 0x1C, 0x3C, 0x1F, 0xF8, 0x1F, 0xF0, 0x1C, 0x78, 0x38, 0x3C, 0x38,
  0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x78, 0x3C, 0x70, 0x3C, 0x70, 0x78, 0x7F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x0F,
  0x02, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x7F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xE3, 0xE0,
  0xE0, 0xF0, 0x70, 0x38, 0x38, 0x1E, 0x1C, 0x0F, 0x1E, 0x07, 0x8E, 0x03,
  0xC7, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x71, 0xE0, 0x78, 0xE0, 0x3C, 0x70,
  0x1C, 0x38, 0x1E, 0x3C, 0x1E, 0x1C, 0x0F, 0x0E, 0x1F, 0x07, 0xFF, 0x03,
  0xFE, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x7F,
  0xC0, 0xFF, 0x81, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0x81, 0xFF,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFF,
  0xC1, 0xFF, 0xE1, 0xF0, 0x20, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x4E, 0x0F, 0xC7, 0x07, 0xE3,
  0x80, 0x73, 0xC0, 0x39, 0xE0, 0x3C, 0xF0, 0x1C, 0x38, 0x0E, 0x1C, 0x07,
  0x0F, 0x03, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0x01, 0xC1,
  0xC0, 0x70, 0x70, 0x1C, 0x3C, 0x0F, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0xE0,
  0x38, 0x38, 0x0E, 0x1E, 0x07, 0x87, 0x01, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1C, 0x07, 0x0F, 0x03, 0xC3, 0x80, 0xE0, 0xE0, 0x38, 0x38, 0x0E, 0x0E,
  0x07, 0x87, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x07, 0x0F, 0x03,
  0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x7F,
  0x83, 0xFC, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x1F, 0x81, 0xFC,
  0x0F, 0xC0, 0x00, 0x07, 0x03, 0xC1, 0xC1, 0xE0, 0x70, 0xF0, 0x3C, 0x38,
  0x0E, 0x1C, 0x03, 0x8F, 0x00, 0xE7, 0x80, 0x39, 0xC0, 0x1E, 0xE0, 0x07,
  0x78, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0x78, 0x03, 0x8E,
  0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x3C, 0x07, 0x07, 0x01, 0xC1, 0xC0,
  0x70, 0x70, 0x1C, 0x1E, 0x0F, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0xFE,
  0xFF, 0xBF, 0xF0, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xEC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xDC, 0x1D, 0xC1, 0xDC, 0x1D, 0xC1, 0x9C, 0x1D, 0xC3, 0xB8,
  0x1D, 0xC3, 0x38, 0x19, 0xC7, 0x38, 0x38, 0xC6, 0x38, 0x38, 0xCE, 0x38,
  0x38, 0xCE, 0x70, 0x38, 0xDC, 0x70, 0x70, 0xDC, 0x70, 0x70, 0xF8, 0x70,
  0x70, 0xF8, 0xE0, 0x70, 0xF0, 0xE0, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x07, 0x80, 0xE0, 0xF0, 0x1C, 0x1E, 0x03, 0x87, 0xC0, 0x70, 0xFC, 0x1C,
  0x1F, 0x83, 0x83, 0xF0, 0x70, 0x66, 0x0E, 0x1C, 0xE1, 0xC3, 0x9C, 0x70,
  0x73, 0x8E, 0x0E, 0x71, 0xC1, 0xC7, 0x38, 0x70, 0xE7, 0x0E, 0x1D, 0xC1,
  0xC3, 0xB8, 0x38, 0x37, 0x0E, 0x07, 0xE1, 0xC0, 0xF8, 0x38, 0x1F, 0x07,
  0x03, 0xE0, 0xE0, 0x3C, 0x38, 0x07, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0xC1, 0xE1, 0xE1, 0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x0F,
  0x38, 0x07, 0xBC, 0x03, 0xDC, 0x01, 0xEE, 0x00, 0xE7, 0x00, 0x73, 0x80,
  0x3B, 0xC0, 0x3D, 0xE0, 0x1C, 0xF0, 0x1E, 0x38, 0x0E, 0x1C, 0x0F, 0x0F,
  0x0F, 0x07, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xFC,
  0x07, 0xFE, 0x0F, 0x1E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E,
  0x1E, 0x0E, 0x1C, 0x1E, 0x1C, 0x3C, 0x1C, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0xC1, 0xE1, 0xE1, 0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x0F, 0x38,
  0x07, 0xBC, 0x03, 0xDC, 0x01, 0xEE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x3B,
  0xC0, 0x3D, 0xE0, 0x1C, 0xF0, 0x1E, 0x38, 0x0F, 0x1C, 0x0F, 0x0F, 0x0F,
  0x07, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8,
  0x78, 0xF0, 0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x87, 0x07, 0x1E, 0x0E, 0x38,
  0x38, 0x70, 0xF0, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x0E, 0x38, 0x1C, 0x70,
  0x38, 0xE0, 0x71, 0xE1, 0xC1, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x0F, 0x3C,
  0x0E, 0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0xF0, 0x41, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC4, 0x0F, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x87,
  0x01, 0xC7, 0x81, 0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x1C,
  0x78, 0x1E, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x01, 0xC7, 0x81,
  0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x3C, 0x78, 0x1C, 0x3C,
  0x0E, 0x0E, 0x0F, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0xE0, 0x1F,
  0xC0, 0x3B, 0x80, 0xF7, 0x01, 0xCE, 0x07, 0x9C, 0x0E, 0x38, 0x3C, 0x70,
  0x70, 0xE0, 0xE1, 0xC3, 0x83, 0x87, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0xF0,
  0x39, 0xC0, 0x73, 0x80, 0xEE, 0x01, 0xDC, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x0F, 0xC0, 0xF0, 0x3B,
  0x81, 0xE0, 0x77, 0x03, 0xC1, 0xEE, 0x0F, 0x83, 0x9C, 0x1F, 0x07, 0x38,
  0x7E, 0x1C, 0x70, 0xFC, 0x38, 0xE1, 0xB8, 0xF1, 0xC7, 0x71, 0xC3, 0x8C,
  0xE3, 0x87, 0x39, 0xCE, 0x0E, 0x73, 0x9C, 0x1D, 0xC7, 0x70, 0x3B, 0x8E,
  0xE0, 0x76, 0x1D, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0xF8,
  0x07, 0xC1, 0xF0, 0x0F, 0x03, 0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00,
  0x00, 0x07, 0x81, 0xC0, 0xE0, 0xF0, 0x38, 0x38, 0x0E, 0x1C, 0x03, 0x8F,
  0x00, 0x73, 0x80, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1D,
  0xC0, 0x0F, 0x78, 0x03, 0x8E, 0x01, 0xC3, 0x80, 0xF0, 0xE0, 0x38, 0x38,
  0x1C, 0x0F, 0x0F, 0x01, 0xC0, 0xE0, 0x3F, 0x03, 0xF8, 0x1D, 0xC1, 0xCF,
  0x0E, 0x38, 0xE1, 0xCF, 0x0E, 0x70, 0x77, 0x03, 0xB8, 0x1F, 0x80, 0x7C,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x0F,
  0xFE, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x7F,
  0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F,
  0x81, 0xFC, 0x00, 0xE3, 0x86, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0xC3, 0x0E,
  0x38, 0xE3, 0x8E, 0x38, 0x61, 0xC7, 0x1C, 0x71, 0xC0, 0x03, 0xF0, 0x7F,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0xFC, 0x0F, 0xC0, 0x00, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0xF8, 0x03, 0x60,
  0x1D, 0xC0, 0xE7, 0x03, 0x8C, 0x1C, 0x38, 0x60, 0xE3, 0x81, 0x8C, 0x07,
  0xF0, 0x1C, 0xFF, 0xFF, 0xFC, 0xE3, 0x9C, 0x61, 0x80, 0x01, 0x00, 0x3F,
  0x71, 0xFD, 0xC7, 0x9F, 0x3C, 0x38, 0xE0, 0xE7, 0x03, 0x9C, 0x0E, 0x70,
  0x73, 0xC1, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0xF3, 0x83, 0x8E, 0x1E, 0x3C,
  0xF8, 0x7E, 0xE1, 0xF3, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE2, 0x03, 0xBE, 0x1D, 0xFC, 0x7C, 0x71, 0xE1,
  0xC7, 0x07, 0x1C, 0x1C, 0xF0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x3C, 0xE0,
  0xE7, 0x83, 0x9E, 0x1E, 0x78, 0x71, 0xF3, 0xCE, 0xFE, 0x39, 0xF0, 0x00,
  0x80, 0x7F, 0x1F, 0xE1, 0xE2, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0xB8, 0x7F,
  0x83, 0xF0, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x03, 0x1C, 0x0F, 0xDC, 0x1F, 0xDC, 0x1C, 0x7C, 0x38, 0x38,
  0x78, 0x38, 0x70, 0x38, 0x70, 0x38, 0xF0, 0x70, 0xE0, 0x70, 0xE0, 0x70,
  0xE0, 0x70, 0xE0, 0xF0, 0xE0, 0xE0, 0xE1, 0xE0, 0xF3, 0xE0, 0x7E, 0xE0,
  0x7C, 0xE0, 0x00, 0x80, 0x7E, 0x1F, 0xF1, 0xC7, 0x38, 0x77, 0x87, 0x70,
  0x77, 0x1E, 0xFF, 0xCF, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0x0C, 0x7F, 0xC3, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x79, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x80, 0x0F,
  0xDC, 0x3F, 0xB8, 0x79, 0xF1, 0xC1, 0xC7, 0x83, 0x8E, 0x07, 0x1C, 0x0E,
  0x38, 0x38, 0xF0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x07, 0x8E, 0x0E, 0x1C,
  0x3C, 0x3D, 0xF8, 0x3F, 0x70, 0x7D, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x20, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE2, 0x03, 0xBE,
  0x1D, 0xFC, 0x7C, 0xF1, 0xE1, 0xC7, 0x07, 0x1C, 0x1C, 0xF0, 0xF3, 0x83,
  0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xE7, 0x07, 0x9C, 0x1C, 0x70, 0x71, 0xC1,
  0xCF, 0x07, 0x38, 0x38, 0x03, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70,
  0x70, 0x70, 0xF0, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x0F,
  0xC0, 0xF8, 0x0E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x87, 0x0E, 0x1E, 0x38, 0x38, 0xF0, 0x73,
  0xC0, 0xE7, 0x01, 0xDC, 0x07, 0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x73, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1E, 0x0E, 0x1C, 0x3C, 0x38, 0x70,
  0x78, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C,
  0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0xF0,
  0xE0, 0x00, 0x20, 0x60, 0x33, 0xE7, 0xE1, 0xDF, 0xBF, 0x87, 0xCF, 0xCE,
  0x1E, 0x1E, 0x3C, 0x70, 0x70, 0xE1, 0xC3, 0xC3, 0x8F, 0x0E, 0x0E, 0x38,
  0x38, 0x38, 0xE0, 0xE0, 0xE3, 0x83, 0x87, 0x0E, 0x1C, 0x1C, 0x70, 0x70,
  0x71, 0xC1, 0xC1, 0xC7, 0x07, 0x07, 0x1C, 0x1C, 0x38, 0xF0, 0xE0, 0xE3,
  0x83, 0x83, 0x80, 0x00, 0x20, 0x33, 0xE1, 0xDF, 0xC7, 0xCF, 0x1E, 0x1C,
  0x70, 0x71, 0xC1, 0xCF, 0x0F, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x0E,
  0x70, 0x79, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0xF0, 0x73, 0x83, 0x80, 0x01,
  0x00, 0x7F, 0x07, 0xFC, 0x38, 0xE3, 0x83, 0xBC, 0x1D, 0xC0, 0xEE, 0x07,
  0xF0, 0x3F, 0x03, 0xF8, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x73, 0x87, 0x8F,
  0x78, 0x7F, 0x81, 0xF8, 0x00, 0x00, 0x10, 0x0C, 0xF8, 0x3B, 0xF8, 0x7C,
  0x70, 0xF0, 0xE1, 0xC1, 0xC3, 0x83, 0x8F, 0x07, 0x1C, 0x0E, 0x38, 0x1C,
  0x70, 0x38, 0xE0, 0xE3, 0xC1, 0xC7, 0x87, 0x8F, 0x0E, 0x1F, 0x7C, 0x37,
  0xF0, 0xE7, 0xC1, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x3F, 0x71, 0xFF, 0xC7,
  0x1F, 0x38, 0x38, 0xE0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x73, 0x81, 0xCE,
  0x07, 0x38, 0x1C, 0xE0, 0xF3, 0x83, 0x8E, 0x1E, 0x3C, 0xF8, 0x7E, 0xE1,
  0xF7, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x20, 0xCF, 0x1D, 0xE1, 0xFE, 0x1E, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0x00, 0xFF, 0x1F, 0xE3,
  0xC2, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x3C, 0x83, 0xCE, 0x78, 0xFF, 0x8F, 0xE0, 0x0E, 0x06,
  0x03, 0x03, 0x87, 0xFB, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07,
  0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x3D, 0x1F, 0x87, 0xC0, 0x1C, 0x1C,
  0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xE7, 0x07, 0x1C, 0x1C,
  0x70, 0x71, 0xC1, 0xCF, 0x0F, 0x38, 0x38, 0xE0, 0xE3, 0x87, 0x8F, 0x3E,
  0x3F, 0xB8, 0x7C, 0xC0, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1, 0xCE,
  0x38, 0xE3, 0x8E, 0x38, 0xE7, 0x0E, 0x70, 0xEE, 0x0E, 0xE0, 0xFC, 0x0F,
  0xC0, 0xF8, 0x07, 0x80, 0x70, 0x00, 0xE0, 0xE0, 0xFC, 0x3C, 0x3F, 0x87,
  0x87, 0x71, 0xF0, 0xEE, 0x36, 0x39, 0xC6, 0xC7, 0x39, 0xD9, 0xC7, 0x33,
  0x38, 0xEE, 0x67, 0x1D, 0x8D, 0xC3, 0xF1, 0xB8, 0x7E, 0x36, 0x0F, 0x87,
  0xC1, 0xF0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0xF0, 0x00, 0x1E,
  0x1E, 0x1C, 0x38, 0x38, 0xE0, 0x73, 0xC0, 0x77, 0x00, 0xFC, 0x01, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0xEE, 0x01, 0xDC, 0x07,
  0x1C, 0x1E, 0x38, 0x38, 0x70, 0xE0, 0xF0, 0x07, 0x03, 0x83, 0x83, 0x81,
  0xC1, 0xC0, 0xE1, 0xE0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x70, 0x0E, 0x38,
  0x07, 0x38, 0x01, 0x9C, 0x00, 0xDC, 0x00, 0x6E, 0x00, 0x36, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x7F, 0x84, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01,
  0xFF, 0x1F, 0xF8, 0xFF, 0x80, 0x00, 0x70, 0x1E, 0x03, 0xE0, 0x78, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C,
  0x0F, 0x80, 0xF0, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xC0, 0x3C, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0x80, 0x3C, 0x07, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x3F, 0x07,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C,
  0x0F, 0xC0, 0xF8, 0x0F, 0x00, 0x10, 0x05, 0xFC, 0x1F, 0xFF, 0xF0, 0xFE,
  0x80, 0xF0,
};

const GFXglyph NotoSans_Condensed_MediumItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 23, 8, 0, -23 },
  { 27, 10, 8, 12, 3, -23 },
  { 37, 17, 23, 16, 0, -23 },
  { 86, 15, 26, 14, 0, -24 },
  { 135, 19, 23, 22, 2, -23 },
  { 190, 16, 23, 17, 0, -23 },
  { 236, 5, 8, 7, 3, -23 },
  { 241, 10, 28, 9, 1, -23 },
  { 276, 10, 28, 9, -2, -23 },
  { 311, 12, 12, 14, 3, -24 },
  { 329, 13, 15, 15, 2, -19 },
  { 354, 7, 8, 7, -2, -4 },
  { 361, 7, 3, 9, 1, -10 },
  { 364, 4, 4, 7, 0, -4 },
  { 366, 16, 23, 11, -2, -23 },
  { 412, 13, 23, 14, 1, -23 },
  { 450, 10, 23, 14, 3, -23 },
  { 479, 15, 23, 14, -1, -23 },
  { 523, 14, 23, 14, 0, -23 },
  { 564, 14, 23, 14, 0, -23 },
  { 605, 14, 23, 14, 0, -23 },
  { 646, 14, 23, 14, 1, -23 },
  { 687, 15, 23, 14, 1, -23 },
  { 731, 15, 23, 14, 0, -23 },
  { 775, 14, 23, 14, 0, -23 },
  { 816, 7, 17, 7, 0, -17 },
  { 831, 9, 21, 7, -2, -17 },
  { 855, 14, 15, 15, 1, -19 },
  { 882, 13, 9, 15, 2, -16 },
  { 897, 13, 15, 15, 2, -19 },
  { 922, 11, 23, 11, 1, -23 },
  { 954, 20, 26, 22, 1, -23 },
  { 1019, 15, 23, 15, -2, -23 },
  { 1063, 16, 23, 16, 0, -23 },
  { 1109, 16, 23, 15, 1, -23 },
  { 1155, 17, 23, 17, 0, -23 },
  { 1204, 15, 23, 13, 0, -23 },
  { 1248, 15, 23, 13, 0, -23 },
  { 1292, 17, 23, 18, 1, -23 },
  { 1341, 18, 23, 18, 0, -23 },
  { 1393, 13, 23, 9, -1, -23 },
  { 1431, 13, 29, 8, -5, -23 },
  { 1479, 18, 23, 15, 0, -23 },
  { 1531, 11, 23, 13, 0, -23 },
  { 1563, 24, 23, 23, 0, -23 },
  { 1632, 19, 23, 19, 0, -23 },
  { 1687, 17, 23, 18, 1, -23 },
  { 1736, 16, 23, 15, 0, -23 },
  { 1782, 17, 28, 18, 1, -23 },
  { 1842, 15, 23, 15, 0, -23 },
  { 1886, 15, 23, 14, 0, -23 },
  { 1930, 12, 23, 13, 3, -23 },
  { 1965, 17, 23, 17, 1, -23 },
  { 2014, 15, 23, 15, 3, -23 },
  { 2058, 23, 23, 23, 3, -23 },
  { 2125, 18, 23, 14, -2, -23 },
  { 2177, 13, 23, 13, 3, -23 },
  { 2215, 16, 23, 13, -1, -23 },
  { 2261, 13, 28, 9, -1, -23 },
  { 2307, 6, 23, 11, 3, -23 },
  { 2325, 12, 28, 9, -2, -23 },
  { 2367, 14, 13, 15, 0, -23 },
  { 2390, 11, 2, 11, -3, 3 },
  { 2393, 5, 5, 9, 5, -24 },
  { 2397, 14, 18, 15, 1, -18 },
  { 2429, 14, 24, 15, 0, -24 },
  { 2471, 12, 18, 12, 1, -18 },
  { 2498, 16, 24, 15, 1, -24 },
  { 2546, 12, 18, 14, 1, -18 },
  { 2573, 16, 32, 9, -4, -24 },
  { 2637, 15, 26, 15, 0, -18 },
  { 2686, 14, 24, 15, 0, -24 },
  { 2728, 8, 24, 7, 0, -24 },
  { 2752, 12, 32, 7, -4, -24 },
  { 2800, 15, 24, 13, 0, -24 },
  { 2845, 8, 24, 7, 0, -24 },
  { 2869, 22, 18, 23, 0, -18 },
  { 2919, 14, 18, 15, 0, -18 },
  { 2951, 13, 18, 15, 1, -18 },
  { 2981, 15, 26, 15, -1, -18 },
  { 3030, 14, 26, 15, 1, -18 },
  { 3076, 12, 18, 10, 0, -18 },
  { 3103, 12, 18, 12, 0, -18 },
  { 3130, 9, 21, 9, 1, -21 },
  { 3154, 14, 17, 15, 1, -17 },
  { 3184, 12, 17, 13, 2, -17 },
  { 3210, 19, 17, 20, 2, -17 },
  { 3251, 15, 17, 13, -1, -17 },
  { 3283, 17, 25, 13, -3, -17 },
  { 3337, 13, 17, 11, -1, -17 },
  { 3365, 12, 28, 11, 1, -23 },
  { 3407, 3, 32, 14, 5, -24 },
  { 3419, 12, 28, 11, -2, -23 },
  { 3461, 14, 5, 15, 1, -14 },
};

const GFXfont NotoSans_Condensed_MediumItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC32PT7B_H_
