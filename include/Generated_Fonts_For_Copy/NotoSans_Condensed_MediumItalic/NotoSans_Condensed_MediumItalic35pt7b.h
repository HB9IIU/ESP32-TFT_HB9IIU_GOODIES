#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC35PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x07,
  0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x38, 0xE7, 0x3D, 0xE7, 0xB8, 0xE7,
  0x1C, 0xE3, 0x9C, 0x63, 0x0C, 0xE3, 0x80, 0x00, 0x61, 0x80, 0x38, 0xE0,
  0x0E, 0x38, 0x03, 0x0C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x18, 0x60, 0x7F,
  0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x30, 0xC0, 0x1C, 0x70, 0x06, 0x18,
  0x01, 0x86, 0x00, 0xE3, 0x81, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC1,
  0xC7, 0x00, 0x61, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x0C, 0x00, 0xC3,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0xF8,
  0x03, 0xFF, 0x07, 0xFE, 0x0F, 0x6E, 0x0E, 0x60, 0x1E, 0x40, 0x1C, 0x40,
  0x1E, 0xC0, 0x0E, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xBC, 0x01, 0x3C, 0x03, 0x3C, 0x03, 0x38, 0x43, 0x78,
  0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0F, 0x00, 0xE0, 0xFC, 0x06, 0x0E, 0x70, 0x70, 0x63, 0x87,
  0x07, 0x1C, 0x38, 0x30, 0xE3, 0x81, 0x86, 0x18, 0x1C, 0x31, 0xC0, 0xE3,
  0x9C, 0x07, 0x1C, 0xE0, 0x38, 0xCE, 0x7D, 0xCE, 0x67, 0xEE, 0x77, 0x73,
  0xFF, 0x73, 0x9D, 0xF3, 0xB8, 0xE0, 0x39, 0xC7, 0x01, 0x8C, 0x38, 0x1C,
  0x61, 0xC1, 0xC7, 0x0C, 0x0E, 0x38, 0xE0, 0xE1, 0xC7, 0x06, 0x0E, 0x30,
  0x70, 0x73, 0x83, 0x01, 0xF8, 0x38, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x39, 0xE0, 0x1E, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x71, 0xE0,
  0x1C, 0x70, 0x07, 0x38, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x0F,
  0xC0, 0x07, 0xF8, 0xF3, 0xDE, 0x39, 0xE3, 0x9E, 0x70, 0xF7, 0x1C, 0x1F,
  0xCF, 0x07, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1F, 0x07, 0xFF, 0xE1,
  0xFF, 0x38, 0x3F, 0x8F, 0x00, 0x7B, 0x9D, 0xEE, 0x73, 0x9C, 0xC0, 0x00,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x87, 0x07,
  0x30, 0x7F, 0x9C, 0xFF, 0xE0, 0xFF, 0x0F, 0x80, 0xEC, 0x0E, 0x70, 0xF3,
  0x83, 0x0E, 0x00, 0x40, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x3C,
  0x71, 0xE3, 0x87, 0x1C, 0x38, 0xE0, 0xFF, 0xFF, 0xFF, 0x7B, 0xFE, 0xE0,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xE0, 0x7F, 0xC3,
  0xC7, 0x1E, 0x1C, 0x70, 0x73, 0xC1, 0xCE, 0x07, 0x38, 0x1D, 0xE0, 0x77,
  0x81, 0xDC, 0x07, 0x70, 0x3F, 0xC0, 0xFF, 0x03, 0xBC, 0x0E, 0xE0, 0x7B,
  0x81, 0xEE, 0x07, 0x38, 0x3C, 0xE0, 0xE3, 0xC7, 0x87, 0xFC, 0x1F, 0xE0,
  0x3F, 0x00, 0x03, 0xC1, 0xF0, 0xF8, 0x7E, 0x7F, 0xBD, 0xEE, 0x79, 0x1C,
  0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07,
  0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xE1, 0xE0, 0x20, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xFF, 0xE1, 0xFF,
  0xF0, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x04, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x80, 0xF0,
  0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x6E, 0x00, 0xFC, 0x01, 0xDC, 0x01, 0x9C, 0x03, 0x9C,
  0x07, 0x3C, 0x06, 0x38, 0x0E, 0x38, 0x1C, 0x38, 0x38, 0x78, 0x38, 0x78,
  0x70, 0x70, 0xE0, 0x70, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xFF, 0x07, 0xFF,
  0x07, 0xFE, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x1D, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x80, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x7E,
  0x03, 0xFC, 0x0F, 0xF8, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x73, 0xC1, 0xEF, 0xC3, 0xBF, 0xC7, 0xC7, 0x8F, 0x07,
  0x3C, 0x0E, 0x78, 0x1C, 0xF0, 0x39, 0xE0, 0x73, 0xC1, 0xE7, 0x83, 0xCF,
  0x07, 0x0E, 0x1E, 0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0x80, 0x1F, 0xFF, 0x1F,
  0xFF, 0x3F, 0xFF, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x01,
  0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0x0F, 0x0E, 0x0F, 0x0E, 0x07, 0x0E,
  0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x0F, 0x3C, 0x07, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0xF0, 0x3C, 0x78, 0x78, 0x38, 0x70, 0x3C, 0x70, 0x3C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0x70, 0x78, 0x7D, 0xF0, 0x3F, 0xF0, 0x1F,
  0xC0, 0x01, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x78, 0xF1, 0xE0, 0xE3, 0x81,
  0xC7, 0x03, 0x9E, 0x07, 0x3C, 0x0E, 0x78, 0x3C, 0xF0, 0x79, 0xE1, 0xF3,
  0xC7, 0xE3, 0xFF, 0x87, 0xF7, 0x03, 0xCE, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x3F, 0xF0, 0x7F, 0xC0, 0xFE, 0x00,
  0x0E, 0x0F, 0x1F, 0x1E, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0xF8, 0xF0, 0xF0, 0x03, 0x80, 0xF0, 0x7C, 0x1E,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x07, 0x03,
  0x80, 0x00, 0x04, 0x00, 0x30, 0x03, 0xC0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xC0, 0x03, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3C, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x0F, 0x00, 0x30, 0x00, 0x80, 0x00, 0x0F, 0xE3, 0xFF, 0x3F, 0xF1,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x03, 0xFF, 0x80, 0x1E, 0x0F, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x1C, 0x38,
  0x00, 0x71, 0xC0, 0x00, 0xC7, 0x0F, 0xE3, 0x38, 0x7F, 0x8C, 0xE3, 0x8E,
  0x33, 0x1C, 0x30, 0xDC, 0x71, 0xC3, 0x61, 0x87, 0x1D, 0x8E, 0x1C, 0x7E,
  0x38, 0x61, 0xB8, 0xC3, 0x86, 0xE3, 0x0E, 0x3B, 0x8C, 0x78, 0xCE, 0x39,
  0xE7, 0x38, 0xFD, 0xF8, 0xE1, 0xE3, 0xC3, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x02, 0x00, 0xF8, 0x78, 0x00, 0xFF, 0xE0, 0x01,
  0xFC, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x37, 0x00, 0x77,
  0x00, 0x77, 0x00, 0xE7, 0x00, 0xE7, 0x01, 0xE7, 0x01, 0xC7, 0x03, 0xC7,
  0x03, 0x87, 0x07, 0x87, 0x07, 0x07, 0x07, 0x07, 0x0F, 0xFF, 0x0F, 0xFF,
  0x1F, 0xFF, 0x1C, 0x07, 0x3C, 0x07, 0x3C, 0x07, 0x78, 0x07, 0x78, 0x07,
  0x70, 0x07, 0xF0, 0x07, 0x03, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xE0,
  0xF0, 0x70, 0x38, 0x78, 0x1C, 0x3C, 0x0E, 0x1C, 0x0F, 0x0E, 0x07, 0x87,
  0x07, 0x87, 0x8F, 0x83, 0xFF, 0x81, 0xFF, 0x80, 0xE3, 0xE0, 0x70, 0x78,
  0x78, 0x1C, 0x3C, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x8F, 0x03, 0xC7, 0x81,
  0xE3, 0xC3, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x01, 0xFE,
  0x03, 0xFF, 0x07, 0xFE, 0x0F, 0x82, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x20, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1C, 0x3E, 0x07, 0x07, 0xC3,
  0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0E, 0x03, 0xC3, 0x80, 0xF1, 0xE0,
  0x3C, 0x78, 0x0F, 0x1C, 0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x38, 0xF0, 0x1E,
  0x3C, 0x07, 0x8E, 0x03, 0xC3, 0x80, 0xF1, 0xE0, 0x78, 0x78, 0x3E, 0x1E,
  0x3F, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0x03,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3E, 0x06, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x7F, 0x38, 0x1F, 0xCE, 0x07, 0xF3, 0x80,
  0x38, 0xE0, 0x0E, 0x38, 0x07, 0x8E, 0x01, 0xE3, 0xC0, 0x70, 0xF0, 0x1C,
  0x3E, 0x07, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x03, 0x80,
  0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70,
  0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1C, 0x0E, 0x01, 0xC0, 0xE0, 0x1C, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xC0, 0x38, 0x1C, 0x07, 0x83,
  0xC0, 0x78, 0x3C, 0x07, 0x83, 0x80, 0x70, 0x38, 0x07, 0x03, 0x80, 0xF0,
  0x78, 0x0F, 0x07, 0x80, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0xF0, 0x1E,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x9F, 0x03,
  0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0x81, 0xE0, 0xF0, 0x78, 0x1E, 0x0F,
  0x03, 0x83, 0xC0, 0x70, 0xF0, 0x0E, 0x3C, 0x03, 0xC7, 0x00, 0x71, 0xE0,
  0x0E, 0x78, 0x01, 0xDE, 0x00, 0x7B, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xBC, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x0E, 0x00,
  0xE1, 0xE0, 0x1C, 0x3C, 0x07, 0x83, 0x80, 0xF0, 0x70, 0x1C, 0x0F, 0x03,
  0x81, 0xE0, 0xF0, 0x1C, 0x00, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78,
  0x07, 0x81, 0x7F, 0xE7, 0xFE, 0xFF, 0xE0, 0x03, 0xC0, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x83,
  0xF8, 0x0F, 0xE0, 0xEE, 0x03, 0xF0, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77,
  0x03, 0xB8, 0x3B, 0xC1, 0xEE, 0x0E, 0xF0, 0x73, 0x87, 0x38, 0x1C, 0xE1,
  0xCE, 0x07, 0x38, 0xE3, 0x81, 0xCE, 0x39, 0xE0, 0xF3, 0x9C, 0x78, 0x38,
  0xE7, 0x1C, 0x0E, 0x39, 0xC7, 0x03, 0x8E, 0xE1, 0xC1, 0xE3, 0xB8, 0xF0,
  0x78, 0x7C, 0x38, 0x1C, 0x1F, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC1, 0xE1,
  0xE0, 0xF0, 0x70, 0x78, 0x00, 0x03, 0xC0, 0x38, 0x3E, 0x01, 0xC1, 0xF0,
  0x1E, 0x0F, 0x80, 0xE0, 0x7E, 0x07, 0x07, 0x70, 0x38, 0x3B, 0x81, 0xC1,
  0xDC, 0x1E, 0x0E, 0xE0, 0xE0, 0x73, 0x87, 0x07, 0x9C, 0x38, 0x38, 0xE3,
  0xC1, 0xC7, 0x1E, 0x0E, 0x3C, 0xE0, 0x70, 0xE7, 0x07, 0x87, 0x38, 0x38,
  0x3B, 0xC1, 0xC1, 0xDC, 0x0E, 0x07, 0xE0, 0xF0, 0x3F, 0x07, 0x81, 0xF8,
  0x38, 0x0F, 0xC1, 0xC0, 0x7C, 0x0E, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0x01,
  0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xE0, 0xF1, 0xE0, 0x79, 0xE0, 0x1C,
  0xF0, 0x0E, 0xF0, 0x07, 0x78, 0x03, 0xB8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0E, 0xE0, 0x0F, 0x70,
  0x07, 0xB8, 0x07, 0x9C, 0x03, 0xCF, 0x03, 0xC7, 0xC3, 0xC1, 0xFF, 0xE0,
  0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0xE1, 0xF0, 0x70, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0E, 0x07,
  0x87, 0x03, 0x87, 0x83, 0xC3, 0xC3, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xC0, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xE0, 0xF1, 0xE0, 0x79, 0xE0, 0x1C,
  0xF0, 0x0E, 0xF0, 0x07, 0x78, 0x03, 0xB8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0E, 0xE0, 0x0F, 0x70,
  0x07, 0xB8, 0x07, 0x9C, 0x03, 0xCF, 0x03, 0xC7, 0xC3, 0xC1, 0xFF, 0xE0,
  0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0xE1, 0xE0, 0x70, 0x78, 0x38, 0x3C, 0x3C, 0x1E, 0x1C, 0x0F, 0x0E, 0x07,
  0x07, 0x07, 0x87, 0x83, 0xC3, 0xC7, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xC0, 0x79, 0xE0, 0x3C, 0x70, 0x1C, 0x38, 0x0E, 0x1E, 0x07, 0x0F, 0x07,
  0x83, 0x83, 0xC1, 0xC1, 0xC0, 0xF0, 0xE0, 0x78, 0xF0, 0x3C, 0x00, 0x01,
  0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0x06, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0xC0, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC7,
  0x80, 0xF1, 0xC0, 0x38, 0x70, 0x0E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0,
  0x70, 0xE0, 0x1C, 0x38, 0x07, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x38,
  0x70, 0x0E, 0x1C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xE0, 0x1C, 0x38,
  0x07, 0x0E, 0x03, 0xC3, 0x80, 0xF0, 0xE0, 0x78, 0x3C, 0x3E, 0x0F, 0xFF,
  0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x70,
  0xF0, 0xF0, 0xF0, 0xE0, 0xF0, 0xE0, 0x71, 0xE0, 0x71, 0xC0, 0x73, 0xC0,
  0x73, 0x80, 0x77, 0x80, 0x77, 0x00, 0x77, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x1C, 0x03, 0xF8,
  0x0E, 0x03, 0xFC, 0x0F, 0x01, 0xDE, 0x07, 0x81, 0xEF, 0x07, 0xC0, 0xF7,
  0x03, 0xE0, 0x73, 0x81, 0xB0, 0x79, 0xC1, 0xF8, 0x38, 0xE0, 0xFC, 0x3C,
  0x70, 0xEE, 0x1C, 0x38, 0x77, 0x0E, 0x1C, 0x73, 0x8F, 0x0E, 0x39, 0xC7,
  0x07, 0x1C, 0xE7, 0x83, 0x9C, 0x73, 0x81, 0xCE, 0x39, 0xC0, 0xEE, 0x1D,
  0xE0, 0x77, 0x0E, 0xE0, 0x3B, 0x87, 0x70, 0x1F, 0x83, 0xF0, 0x0F, 0xC1,
  0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x3C, 0x1E, 0x03, 0xC1, 0xC0, 0x1C,
  0x3C, 0x01, 0xC3, 0x80, 0x1C, 0x78, 0x01, 0xEF, 0x00, 0x1E, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xB8, 0x00, 0x73, 0x80,
  0x0F, 0x3C, 0x01, 0xE3, 0xC0, 0x1C, 0x1C, 0x03, 0xC1, 0xC0, 0x38, 0x1E,
  0x07, 0x81, 0xE0, 0xF0, 0x1E, 0x00, 0xF0, 0x1F, 0xE0, 0x7B, 0xC0, 0xE3,
  0x83, 0xC7, 0x07, 0x0E, 0x1E, 0x1C, 0x38, 0x3C, 0xF0, 0x7B, 0xC0, 0x77,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE1, 0xC7,
  0x1C, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xB8, 0x07, 0x38, 0x06, 0x38, 0x0E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x38, 0x0E, 0x38, 0x0E, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF1,
  0xC7, 0x8E, 0x38, 0x70, 0x07, 0xC7, 0x0F, 0xEE, 0x1F, 0xFE, 0x1E, 0x3E,
  0x3C, 0x1E, 0x38, 0x1C, 0x78, 0x1C, 0x78, 0x1C, 0x70, 0x3C, 0xF0, 0x3C,
  0xF0, 0x38, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0,
  0xFF, 0xF0, 0x7F, 0x70, 0x3E, 0x70, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x7C,
  0x0E, 0xFE, 0x0F, 0xFE, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F,
  0x1C, 0x0F, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x38, 0x1C,
  0x78, 0x3C, 0x78, 0x3C, 0x78, 0x78, 0x7F, 0xF0, 0xEF, 0xF0, 0xE7, 0xC0,
  0x03, 0xF8, 0x7F, 0x87, 0xFC, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x08, 0x7F, 0xC3, 0xFE, 0x0F, 0xE0, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x07, 0xCE, 0x07, 0xF7, 0x07, 0xFF, 0x83, 0xC7, 0xC3, 0xC1, 0xE1, 0xC0,
  0xE1, 0xE0, 0x70, 0xE0, 0x38, 0x70, 0x3C, 0x78, 0x1E, 0x3C, 0x0E, 0x1E,
  0x07, 0x0F, 0x07, 0x87, 0x03, 0xC3, 0xC3, 0xC1, 0xE1, 0xE0, 0xFB, 0xF0,
  0x3F, 0xB8, 0x0F, 0x9C, 0x00, 0x03, 0xF0, 0x7F, 0xC7, 0xFE, 0x38, 0x73,
  0xC3, 0x9C, 0x1D, 0xE1, 0xEE, 0x1E, 0x7F, 0xF7, 0xFE, 0x3F, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x04, 0x7D, 0xE3, 0xFF, 0x07, 0xF0,
  0x00, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE3, 0x83, 0xFB, 0x83,
  0xFF, 0xC1, 0xE3, 0xE1, 0xE0, 0xF0, 0xE0, 0x70, 0xF0, 0x38, 0x78, 0x1C,
  0x38, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x0F, 0x03, 0x87, 0x83, 0xC3, 0xC1,
  0xE1, 0xE1, 0xE0, 0xF1, 0xF0, 0x7F, 0xF8, 0x1F, 0xDC, 0x07, 0xDE, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC1, 0x03, 0xC0, 0xF7, 0xE0,
  0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x7C, 0x1D, 0xFC,
  0x3F, 0xF8, 0xF8, 0x71, 0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x0F, 0x3C,
  0x1E, 0x78, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x83, 0xCF, 0x07, 0x9E, 0x0E,
  0x38, 0x1C, 0x70, 0x38, 0xE0, 0xF3, 0xC1, 0xE0, 0x03, 0x83, 0xC1, 0xE0,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0,
  0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0,
  0x78, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x0F, 0x0E, 0x1E, 0x0E, 0x1C, 0x1E, 0x38, 0x1E, 0x78,
  0x1C, 0xF0, 0x1D, 0xE0, 0x1D, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3D, 0xE0, 0x39, 0xE0, 0x78, 0xE0, 0x70, 0xE0, 0x70, 0xF0, 0x70, 0xF0,
  0x70, 0x70, 0xF0, 0x78, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C,
  0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1E,
  0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x00, 0x0E,
  0x7C, 0x7C, 0x0E, 0xFE, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x1F, 0x8F, 0x1E,
  0x0F, 0x0E, 0x1E, 0x0E, 0x0E, 0x1C, 0x1E, 0x0E, 0x1C, 0x1E, 0x0E, 0x3C,
  0x1C, 0x1E, 0x3C, 0x1C, 0x1E, 0x38, 0x1C, 0x1C, 0x38, 0x3C, 0x1C, 0x38,
  0x38, 0x1C, 0x78, 0x38, 0x3C, 0x78, 0x38, 0x3C, 0x70, 0x38, 0x38, 0x70,
  0x78, 0x38, 0x70, 0x70, 0x38, 0xF0, 0x70, 0x78, 0x0E, 0x7C, 0x1D, 0xFC,
  0x3F, 0xF8, 0xF8, 0x71, 0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x0F, 0x3C,
  0x1E, 0x78, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x83, 0xCF, 0x07, 0x9E, 0x0E,
  0x38, 0x1C, 0x70, 0x39, 0xE0, 0xF3, 0xC1, 0xE0, 0x03, 0xF0, 0x3F, 0xE1,
  0xFF, 0x87, 0x8F, 0x3C, 0x1C, 0xE0, 0x77, 0x81, 0xDC, 0x07, 0x70, 0x1F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xE0, 0x3B, 0x81, 0xEF, 0x07, 0x3C, 0x3C,
  0x7F, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0x03, 0x9F, 0x00, 0xEF, 0xE0, 0x3F,
  0xF8, 0x0F, 0x0F, 0x07, 0xC3, 0xC1, 0xE0, 0xF0, 0x70, 0x3C, 0x1C, 0x0F,
  0x0F, 0x03, 0x83, 0xC0, 0xE0, 0xE0, 0x38, 0x38, 0x1E, 0x0E, 0x07, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xDF,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC6, 0x1F, 0xDC, 0x7F,
  0xF8, 0xF1, 0xF3, 0xC1, 0xE7, 0x03, 0x9E, 0x07, 0x38, 0x0E, 0x70, 0x3D,
  0xE0, 0x7B, 0xC0, 0xE7, 0x81, 0xCF, 0x07, 0x9C, 0x0F, 0x3C, 0x3C, 0x78,
  0x78, 0xFF, 0xF0, 0xFE, 0xE0, 0xFB, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x0E, 0x78,
  0x77, 0x83, 0xFC, 0x3F, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x00, 0x07, 0xF0, 0xFF, 0xC7, 0xFC, 0x78, 0x23,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x07, 0x90, 0x38, 0xFF, 0xC7, 0xFC, 0x3F, 0xC0,
  0x07, 0x01, 0x80, 0xE0, 0x38, 0x1F, 0xDF, 0xF7, 0xFC, 0x70, 0x3C, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03,
  0xC0, 0xFE, 0x1F, 0x87, 0xE0, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x79, 0xE0,
  0xF3, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x1E, 0x78, 0x38, 0xE0, 0x71,
  0xC0, 0xE3, 0x83, 0xCF, 0x07, 0x9E, 0x0E, 0x3C, 0x3C, 0x78, 0xF8, 0xFF,
  0xF0, 0xFE, 0xE1, 0xF9, 0x80, 0xE0, 0x3F, 0x81, 0xEE, 0x07, 0x38, 0x1C,
  0xE0, 0xE3, 0x83, 0x8E, 0x1E, 0x38, 0x70, 0xE3, 0xC3, 0x8E, 0x0F, 0x78,
  0x1D, 0xC0, 0x77, 0x01, 0xF8, 0x06, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0xE0, 0x70, 0x3F, 0x07, 0x83, 0xF8, 0x3C, 0x1D, 0xC3,
  0xE0, 0xEE, 0x1F, 0x0E, 0x70, 0xD8, 0x73, 0x8E, 0xC7, 0x9C, 0x76, 0x38,
  0xE7, 0x31, 0xC7, 0x39, 0x9C, 0x39, 0x8C, 0xE1, 0xDC, 0x6E, 0x0E, 0xE3,
  0x70, 0x7E, 0x1B, 0x83, 0xF0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3C, 0x07,
  0x81, 0xE0, 0x3C, 0x1F, 0x00, 0x07, 0x07, 0x83, 0x83, 0xC1, 0xE3, 0xC0,
  0x71, 0xC0, 0x39, 0xC0, 0x1D, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x77, 0x00, 0x7B, 0x80, 0x79,
  0xC0, 0x38, 0xF0, 0x3C, 0x38, 0x3C, 0x1C, 0x3C, 0x0F, 0x00, 0x07, 0x01,
  0xE0, 0xE0, 0x38, 0x1C, 0x0F, 0x03, 0xC1, 0xC0, 0x78, 0x78, 0x0F, 0x0E,
  0x01, 0xE3, 0xC0, 0x1C, 0x70, 0x03, 0x9E, 0x00, 0x73, 0x80, 0x0E, 0xF0,
  0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x7F, 0xE3, 0xFF, 0x0F, 0xFC,
  0x00, 0x00, 0x78, 0x0F, 0xC0, 0x7C, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x1E, 0x03,
  0xE0, 0x1E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x1F, 0x00, 0xF8, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x01, 0xF8, 0x1E, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x80, 0x7C, 0x0F, 0xC0, 0x7C, 0x03, 0x00, 0x00, 0x38, 0x07, 0xFC,
  0x1F, 0xFF, 0xF1, 0xFF, 0x80, 0xF8,
};

const GFXglyph NotoSans_Condensed_MediumItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 25, 9, 0, -25 },
  { 30, 11, 9, 13, 3, -25 },
  { 43, 18, 25, 18, 0, -25 },
  { 100, 16, 29, 16, 0, -27 },
  { 158, 21, 25, 24, 2, -25 },
  { 224, 18, 25, 18, 0, -25 },
  { 281, 5, 9, 7, 4, -25 },
  { 287, 11, 31, 10, 1, -25 },
  { 330, 12, 31, 10, -3, -25 },
  { 377, 13, 14, 15, 3, -27 },
  { 400, 14, 17, 17, 2, -21 },
  { 430, 7, 9, 8, -2, -4 },
  { 438, 8, 3, 10, 1, -11 },
  { 441, 5, 4, 8, 0, -4 },
  { 444, 17, 25, 12, -2, -25 },
  { 498, 14, 25, 16, 1, -25 },
  { 542, 10, 25, 16, 4, -25 },
  { 574, 17, 25, 16, -1, -25 },
  { 628, 16, 25, 16, 0, -25 },
  { 678, 16, 25, 16, 0, -25 },
  { 728, 16, 25, 16, 0, -25 },
  { 778, 15, 25, 16, 1, -25 },
  { 825, 16, 25, 16, 1, -25 },
  { 875, 16, 25, 16, 0, -25 },
  { 925, 15, 25, 16, 0, -25 },
  { 972, 8, 19, 8, 0, -19 },
  { 991, 10, 24, 8, -2, -19 },
  { 1021, 14, 17, 17, 2, -21 },
  { 1051, 14, 10, 17, 2, -17 },
  { 1069, 14, 17, 17, 2, -21 },
  { 1099, 12, 25, 12, 1, -25 },
  { 1137, 22, 28, 24, 1, -25 },
  { 1214, 16, 25, 16, -2, -25 },
  { 1264, 17, 25, 17, 0, -25 },
  { 1318, 16, 25, 16, 2, -25 },
  { 1368, 18, 25, 19, 0, -25 },
  { 1425, 16, 25, 15, 0, -25 },
  { 1475, 16, 25, 14, 0, -25 },
  { 1525, 18, 25, 19, 2, -25 },
  { 1582, 20, 25, 19, 0, -25 },
  { 1645, 14, 25, 10, -1, -25 },
  { 1689, 14, 32, 8, -5, -25 },
  { 1745, 19, 25, 16, 0, -25 },
  { 1805, 12, 25, 14, 0, -25 },
  { 1843, 26, 25, 25, 0, -25 },
  { 1925, 21, 25, 21, 0, -25 },
  { 1991, 17, 25, 20, 2, -25 },
  { 2045, 17, 25, 16, 0, -25 },
  { 2099, 17, 31, 20, 2, -25 },
  { 2165, 17, 25, 17, 0, -25 },
  { 2219, 16, 25, 15, 0, -25 },
  { 2269, 14, 25, 14, 3, -25 },
  { 2313, 18, 25, 19, 2, -25 },
  { 2370, 16, 25, 16, 3, -25 },
  { 2420, 25, 25, 25, 3, -25 },
  { 2499, 20, 25, 15, -2, -25 },
  { 2562, 15, 25, 15, 3, -25 },
  { 2609, 17, 25, 14, -1, -25 },
  { 2663, 14, 31, 10, -1, -25 },
  { 2718, 6, 25, 13, 4, -25 },
  { 2737, 13, 31, 10, -2, -25 },
  { 2788, 16, 14, 16, 0, -25 },
  { 2816, 12, 2, 12, -3, 3 },
  { 2819, 6, 6, 10, 5, -27 },
  { 2824, 16, 19, 17, 1, -19 },
  { 2862, 16, 27, 17, 0, -27 },
  { 2916, 13, 19, 13, 1, -19 },
  { 2947, 17, 27, 17, 1, -27 },
  { 3005, 13, 19, 15, 1, -19 },
  { 3036, 18, 35, 9, -4, -27 },
  { 3115, 17, 27, 17, 0, -19 },
  { 3173, 15, 27, 17, 0, -27 },
  { 3224, 9, 26, 8, 0, -26 },
  { 3254, 13, 34, 8, -4, -26 },
  { 3310, 16, 27, 15, 0, -27 },
  { 3364, 9, 27, 8, 0, -27 },
  { 3395, 24, 19, 25, 0, -19 },
  { 3452, 15, 19, 17, 0, -19 },
  { 3488, 14, 19, 16, 1, -19 },
  { 3522, 18, 27, 17, -2, -19 },
  { 3583, 15, 27, 17, 1, -19 },
  { 3634, 13, 19, 11, 0, -19 },
  { 3665, 13, 19, 13, 0, -19 },
  { 3696, 10, 23, 10, 1, -23 },
  { 3725, 15, 19, 17, 1, -19 },
  { 3761, 14, 19, 14, 2, -19 },
  { 3795, 21, 19, 22, 2, -19 },
  { 3845, 17, 19, 14, -2, -19 },
  { 3886, 19, 27, 14, -3, -19 },
  { 3951, 14, 19, 12, -1, -19 },
  { 3985, 13, 31, 12, 1, -25 },
  { 4036, 3, 35, 15, 6, -27 },
  { 4050, 13, 31, 12, -2, -25 },
  { 4101, 14, 5, 17, 2, -15 },
};

const GFXfont NotoSans_Condensed_MediumItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC35PT7B_H_
