#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC26PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xE1, 0x83,
  0x06, 0x00, 0x00, 0x61, 0xE3, 0x80, 0x67, 0xE6, 0xE6, 0xCE, 0xCC, 0xCC,
  0xCC, 0x03, 0x18, 0x0C, 0x60, 0x33, 0x00, 0x8C, 0x06, 0x30, 0x19, 0x93,
  0xFF, 0x8F, 0xFE, 0x0C, 0xC0, 0x33, 0x01, 0x8C, 0x06, 0x20, 0xFF, 0xF0,
  0xC6, 0x03, 0x18, 0x0C, 0xC0, 0x33, 0x01, 0x8C, 0x06, 0x60, 0x00, 0x00,
  0x80, 0x18, 0x03, 0x80, 0xFF, 0x1F, 0xE1, 0x90, 0x3B, 0x03, 0xA0, 0x1E,
  0x01, 0xE0, 0x0F, 0x80, 0x78, 0x05, 0xC0, 0x4C, 0x04, 0xC8, 0x5C, 0xEF,
  0x8F, 0xF8, 0x3E, 0x00, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x06, 0x1E, 0x0C,
  0x33, 0x1C, 0x63, 0x18, 0x63, 0x30, 0x66, 0x30, 0x66, 0x60, 0xC6, 0x60,
  0xC6, 0xDE, 0x6D, 0x9F, 0x7D, 0xB3, 0x33, 0x33, 0x03, 0x63, 0x06, 0x63,
  0x0C, 0x63, 0x0C, 0x66, 0x18, 0x66, 0x18, 0x7C, 0x30, 0x38, 0x03, 0x80,
  0x3F, 0x03, 0x98, 0x18, 0xC0, 0xC6, 0x06, 0x70, 0x33, 0x01, 0xB0, 0x0F,
  0x00, 0xF0, 0x0F, 0xC6, 0xE6, 0x76, 0x3B, 0x70, 0xFB, 0x87, 0x9C, 0x38,
  0xE3, 0xE3, 0xFF, 0x0F, 0x9C, 0x7F, 0xFD, 0xB0, 0x03, 0x06, 0x0C, 0x1C,
  0x18, 0x38, 0x30, 0x70, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x06, 0x06, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x06, 0x0E, 0x0C,
  0x0C, 0x1C, 0x18, 0x30, 0x70, 0xE0, 0x06, 0x01, 0x84, 0x61, 0xD0, 0xFF,
  0xC3, 0xF1, 0xE0, 0xD8, 0x73, 0x08, 0xC0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE1, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x39, 0x9C, 0xC6, 0x60, 0x7F, 0xF8, 0x6F, 0xE0, 0x00, 0x30, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0,
  0x00, 0x07, 0x83, 0xF1, 0xDC, 0xE3, 0x30, 0xDC, 0x37, 0x0D, 0x83, 0xE0,
  0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xB0, 0xEC, 0x3B, 0x0C, 0xE7, 0x3F, 0x87,
  0xC0, 0x06, 0x1C, 0xFB, 0xFE, 0xD9, 0x83, 0x0E, 0x1C, 0x30, 0x61, 0xC3,
  0x87, 0x0C, 0x18, 0x70, 0xE1, 0xC0, 0x01, 0xC0, 0x3F, 0x83, 0xDC, 0x10,
  0x60, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0xFE, 0x3F,
  0xF0, 0x07, 0x81, 0xFE, 0x1E, 0xE1, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x1C, 0x0F, 0x80, 0xF0, 0x1F, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x83, 0x8F, 0xF0, 0xFE, 0x00, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1E,
  0x03, 0xE0, 0x6E, 0x06, 0xC0, 0xCC, 0x19, 0xC1, 0x9C, 0x31, 0x86, 0x18,
  0xE1, 0x8F, 0xFE, 0xFF, 0xE0, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE1, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x3F,
  0x83, 0xFC, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x83,
  0x8F, 0xF0, 0xFE, 0x00, 0x01, 0xE0, 0xFC, 0x3C, 0x8E, 0x03, 0x80, 0x60,
  0x1C, 0x03, 0x38, 0x6F, 0x9F, 0x73, 0x87, 0x70, 0xEE, 0x1D, 0x83, 0x30,
  0x66, 0x1C, 0xE7, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0xF3, 0xFE, 0x3F, 0xE0,
  0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0xFE, 0x1E, 0xF1, 0xC7, 0x18, 0x71, 0x87, 0x18, 0x61, 0xDC,
  0x0F, 0x80, 0xF0, 0x3F, 0x87, 0x1C, 0x61, 0xCE, 0x0C, 0xE0, 0xCE, 0x1C,
  0xE1, 0xC7, 0xF8, 0x3F, 0x00, 0x03, 0x81, 0xF8, 0x7B, 0x8C, 0x33, 0x86,
  0x60, 0xCC, 0x19, 0x83, 0x30, 0xE7, 0x3C, 0xFF, 0x8F, 0x60, 0x0C, 0x03,
  0x80, 0x60, 0x1C, 0x07, 0x1F, 0xC3, 0xF0, 0x00, 0x1C, 0xF3, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0xE3, 0x80, 0x0E, 0x1C, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x0E, 0x18, 0x70, 0xC0, 0x00, 0x60,
  0x3C, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0x80, 0x10, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xC0, 0x78,
  0x7C, 0x3E, 0x1F, 0x03, 0x80, 0x40, 0x00, 0x1E, 0x3F, 0x8D, 0xE0, 0x70,
  0x38, 0x1C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x06, 0x07, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x70, 0x38, 0x00, 0x00, 0x70, 0x03, 0xFC, 0x07, 0x0E, 0x0C,
  0x03, 0x18, 0x03, 0x30, 0x63, 0x31, 0xF3, 0x63, 0x33, 0x66, 0x33, 0xC6,
  0x33, 0xCC, 0x63, 0xCC, 0x63, 0xCC, 0x66, 0xCC, 0xE6, 0xCF, 0xFC, 0xC7,
  0x38, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3D, 0xE0, 0x1F, 0xC0, 0x00,
  0x70, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1B, 0x00, 0xD8, 0x0C, 0xC0, 0x66,
  0x07, 0x30, 0x31, 0x83, 0x8C, 0x1F, 0xE1, 0xFF, 0x0E, 0x18, 0xE0, 0xC7,
  0x07, 0x30, 0x3B, 0x81, 0xF8, 0x0E, 0x0F, 0x80, 0x7F, 0x83, 0xFC, 0x18,
  0x71, 0xC3, 0x8E, 0x1C, 0x60, 0xC3, 0x0E, 0x3F, 0xE1, 0xFE, 0x0E, 0x78,
  0x60, 0xC3, 0x06, 0x38, 0x31, 0xC1, 0x8E, 0x1C, 0x61, 0xC3, 0xFE, 0x3F,
  0xC0, 0x01, 0xE0, 0x3F, 0xC3, 0xFC, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x83, 0xFC, 0x0F, 0xE0, 0x0F, 0x00, 0x3F, 0x80,
  0xFF, 0x03, 0x0E, 0x1C, 0x38, 0x70, 0x61, 0xC1, 0xC6, 0x06, 0x38, 0x18,
  0xE0, 0xE3, 0x83, 0x8C, 0x0E, 0x30, 0x31, 0xC1, 0xC7, 0x07, 0x1C, 0x38,
  0x63, 0xC1, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x3F, 0xC3, 0xFC, 0x38, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x87, 0xF0, 0xFF, 0x00, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38,
  0x03, 0xFC, 0x3F, 0xC3, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0xF0, 0xFF, 0x87, 0x02, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x87, 0xEE, 0x1F, 0x38,
  0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x06, 0x38, 0x18, 0x70, 0xE1, 0xFF, 0x81,
  0xFC, 0x00, 0x0E, 0x0E, 0x1C, 0x1C, 0x30, 0x30, 0x60, 0x61, 0xC1, 0xC3,
  0x83, 0x87, 0x07, 0x0C, 0x0C, 0x3F, 0xF8, 0x7F, 0xF0, 0xE0, 0xE1, 0x81,
  0xC3, 0x03, 0x0E, 0x06, 0x1C, 0x1C, 0x38, 0x38, 0x60, 0x60, 0xC0, 0xC3,
  0x83, 0x80, 0x0F, 0xC3, 0xF0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38,
  0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x1F,
  0x8F, 0xE0, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x3E, 0x07, 0x80, 0x0E,
  0x1C, 0x38, 0x70, 0xC3, 0x83, 0x1C, 0x1C, 0xE0, 0x73, 0x81, 0x9C, 0x06,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0E, 0xE0, 0x33, 0x81, 0xC6, 0x07,
  0x18, 0x1C, 0x70, 0x61, 0xC1, 0x83, 0x0E, 0x0E, 0x00, 0x0E, 0x07, 0x03,
  0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x03,
  0x81, 0xC0, 0xE0, 0x60, 0xBF, 0xBF, 0xC0, 0x0F, 0x01, 0xE1, 0xE0, 0x3C,
  0x3C, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x3C, 0x36, 0x0D, 0x86, 0xC1, 0xF0,
  0xD8, 0x6E, 0x3B, 0x0D, 0x87, 0x63, 0x30, 0xCC, 0x66, 0x19, 0x99, 0xC3,
  0x33, 0x38, 0xE6, 0xE6, 0x1C, 0xD8, 0xC3, 0x1F, 0x38, 0x63, 0xC7, 0x0C,
  0x78, 0xE3, 0x86, 0x18, 0x00, 0x0E, 0x07, 0x0E, 0x07, 0x0F, 0x06, 0x0F,
  0x06, 0x1F, 0x0E, 0x1B, 0x0E, 0x1B, 0x0C, 0x1B, 0x8C, 0x39, 0x8C, 0x39,
  0x9C, 0x31, 0x9C, 0x31, 0xD8, 0x31, 0xD8, 0x70, 0xD8, 0x70, 0xF8, 0x60,
  0xF8, 0x60, 0xF0, 0x60, 0x70, 0xE0, 0x70, 0x01, 0xC0, 0x3F, 0x83, 0xDE,
  0x38, 0x73, 0x81, 0x9C, 0x0D, 0xC0, 0x6E, 0x03, 0x70, 0x1B, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0x70, 0x3B, 0x81, 0xDC, 0x1C, 0x71, 0xC3, 0xFC,
  0x0F, 0xC0, 0x0F, 0x80, 0x7F, 0x03, 0xFC, 0x18, 0x61, 0xC3, 0x8E, 0x1C,
  0x60, 0xC3, 0x06, 0x38, 0x71, 0xCF, 0x0F, 0xF0, 0x7E, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x3F,
  0x83, 0xDE, 0x38, 0x73, 0x81, 0x9C, 0x0D, 0xC0, 0x6E, 0x03, 0x60, 0x1B,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0x70, 0x3B, 0x81, 0xDC, 0x1C, 0x71,
  0xC3, 0xFE, 0x0F, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x0F,
  0x80, 0xFE, 0x0F, 0xF0, 0xC7, 0x1C, 0x31, 0xC3, 0x18, 0x31, 0x87, 0x38,
  0xF3, 0xFE, 0x3F, 0x83, 0x38, 0x33, 0x87, 0x18, 0x71, 0x87, 0x1C, 0x61,
  0xC6, 0x0C, 0xE0, 0xE0, 0x03, 0xC0, 0xFF, 0x1F, 0xE1, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x38, 0xC7, 0x8F, 0xF0, 0xFE, 0x00, 0x7F, 0xFF, 0xFB,
  0xFF, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x00,
  0x1C, 0x1C, 0x60, 0x71, 0x81, 0x8E, 0x06, 0x38, 0x38, 0xE0, 0xE3, 0x03,
  0x0C, 0x0C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x18, 0x18, 0xE0, 0x63, 0x83,
  0x8E, 0x0E, 0x38, 0x30, 0xF1, 0xC1, 0xFE, 0x03, 0xF0, 0x00, 0xE0, 0x3E,
  0x07, 0xE0, 0x6E, 0x0E, 0xE0, 0xCE, 0x1C, 0x61, 0xC6, 0x38, 0x63, 0x86,
  0x30, 0x67, 0x06, 0x60, 0x6E, 0x06, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x00, 0xE0, 0x60, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0x70, 0xF0,
  0xEE, 0x1E, 0x19, 0xC7, 0xC7, 0x38, 0xD8, 0xE7, 0x1B, 0x18, 0xE6, 0x67,
  0x1C, 0xCC, 0xC3, 0xB9, 0xB8, 0x76, 0x37, 0x0E, 0xC6, 0xC1, 0xF0, 0xF8,
  0x3E, 0x1E, 0x07, 0xC3, 0xC0, 0xF0, 0x70, 0x1E, 0x0E, 0x03, 0x81, 0xC0,
  0x00, 0x0C, 0x0C, 0x38, 0x70, 0xE3, 0x83, 0x8C, 0x06, 0x70, 0x19, 0x80,
  0x7E, 0x01, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x03, 0xE0, 0x0D, 0x80,
  0x77, 0x03, 0x9C, 0x0C, 0x70, 0x70, 0xC3, 0x83, 0x0E, 0x0E, 0x00, 0xE0,
  0xFC, 0x1D, 0x87, 0x30, 0xE6, 0x38, 0xE6, 0x1D, 0xC3, 0xB0, 0x3E, 0x07,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0xFE, 0x3F, 0xE0, 0x07, 0xC1, 0xF0,
  0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60,
  0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x1F,
  0x0F, 0xC0, 0xCC, 0xCC, 0xCE, 0xE6, 0x66, 0x66, 0x77, 0x33, 0x33, 0x30,
  0x07, 0xC1, 0xF0, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0,
  0x30, 0x0C, 0x1F, 0x0F, 0x80, 0x01, 0x00, 0x30, 0x07, 0x80, 0x78, 0x0D,
  0x80, 0xCC, 0x18, 0xC3, 0x8C, 0x30, 0x67, 0x06, 0xE0, 0x70, 0xFF, 0xFF,
  0xC0, 0xEE, 0x63, 0x1F, 0x67, 0xEC, 0xE7, 0xB8, 0x76, 0x0D, 0xC1, 0xB8,
  0x77, 0x0E, 0xC1, 0x98, 0x33, 0x0E, 0x73, 0xCF, 0xF8, 0xF6, 0x00, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1B, 0xE1, 0xFE, 0x1C,
  0x73, 0x87, 0x38, 0x73, 0x07, 0x30, 0x67, 0x06, 0x70, 0xE7, 0x0E, 0x71,
  0xC7, 0x1C, 0xFF, 0x8C, 0xF0, 0x0F, 0x9F, 0xCE, 0x0E, 0x06, 0x07, 0x03,
  0x81, 0xC0, 0xC0, 0x60, 0x30, 0x1C, 0x4F, 0xE3, 0xF0, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x1F, 0x63, 0xF6, 0x39, 0xE7, 0x0E,
  0x60, 0xCE, 0x0C, 0xE1, 0xCE, 0x1C, 0xC1, 0x8C, 0x18, 0xC3, 0x8E, 0x78,
  0xFF, 0x87, 0xB0, 0x0F, 0x87, 0xE3, 0x9D, 0xC7, 0x61, 0xB8, 0xEF, 0xF3,
  0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x84, 0xFF, 0x1F, 0x80, 0x00, 0x78, 0x07,
  0xC0, 0x72, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1F, 0x81, 0xFC, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0xF8, 0x07, 0x80, 0x00, 0x0F, 0xB1, 0xFB, 0x1C, 0xF3, 0x87, 0x30, 0x67,
  0x06, 0x70, 0xE7, 0x0E, 0x60, 0xC6, 0x1C, 0x61, 0xC7, 0x3C, 0x7F, 0xC3,
  0xD8, 0x01, 0x80, 0x38, 0x03, 0x88, 0x70, 0xFF, 0x0F, 0xC0, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0xF8, 0xFF, 0x1C, 0x67, 0x0C,
  0xE1, 0x9C, 0x33, 0x0E, 0x61, 0xDC, 0x33, 0x86, 0x61, 0xCC, 0x3B, 0x87,
  0x70, 0xC0, 0x0E, 0x1C, 0x30, 0x00, 0x03, 0x86, 0x0C, 0x38, 0x70, 0xC1,
  0x83, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x80, 0x01, 0xC0, 0x70, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03,
  0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x83,
  0xC0, 0xF0, 0x00, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x18, 0x71, 0x8E, 0x19, 0xC3, 0xB8, 0x3B, 0x03, 0x70, 0x3E, 0x03, 0xF0,
  0x77, 0x07, 0x30, 0x63, 0x06, 0x38, 0xE3, 0x8E, 0x18, 0x0E, 0x1C, 0x30,
  0x61, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xE1, 0x83, 0x06, 0x1C, 0x38, 0x60,
  0xC3, 0x87, 0x00, 0x1B, 0xCF, 0x8F, 0xFF, 0xC7, 0x3C, 0x67, 0x0E, 0x33,
  0x86, 0x19, 0x87, 0x0C, 0xC3, 0x8E, 0x61, 0x87, 0x70, 0xC3, 0x38, 0xE1,
  0x98, 0x70, 0xCC, 0x38, 0xEE, 0x18, 0x77, 0x0C, 0x30, 0x1B, 0xE3, 0xFC,
  0x71, 0x9C, 0x33, 0x86, 0x70, 0xCC, 0x39, 0x87, 0x70, 0xCE, 0x19, 0x87,
  0x30, 0xEE, 0x1D, 0xC3, 0x00, 0x0F, 0x8F, 0xF3, 0x9D, 0xC3, 0x60, 0xF8,
  0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x6C, 0x3B, 0x9C, 0x7F, 0x1F, 0x80, 0x0D,
  0xF0, 0x7F, 0x83, 0x8E, 0x38, 0x71, 0xC3, 0x8C, 0x1C, 0x60, 0xC3, 0x06,
  0x38, 0x71, 0xC3, 0x8E, 0x38, 0x71, 0xC7, 0xFC, 0x3B, 0xC1, 0xC0, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1F, 0x67, 0xEC, 0xE7,
  0xB8, 0x76, 0x0D, 0xC1, 0xB8, 0x77, 0x0E, 0xC1, 0x98, 0x73, 0x0E, 0x73,
  0xCF, 0xF8, 0xF6, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0x1B, 0xC7, 0xE1, 0xE0, 0xF0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C,
  0x06, 0x01, 0x80, 0xE0, 0x38, 0x00, 0x1F, 0xCF, 0xE3, 0x08, 0xC0, 0x30,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x72, 0x1C, 0xFE, 0x3F, 0x00,
  0x18, 0x30, 0x63, 0xFF, 0xE6, 0x1C, 0x38, 0x70, 0xC1, 0x87, 0x0E, 0x18,
  0x30, 0x7C, 0x78, 0x38, 0x66, 0x1C, 0xC3, 0xB8, 0x67, 0x0C, 0xC3, 0x98,
  0x77, 0x0C, 0xE1, 0x9C, 0x73, 0x0E, 0x73, 0xCF, 0xF0, 0xF6, 0x00, 0xE0,
  0xEC, 0x39, 0x86, 0x31, 0xC6, 0x30, 0xCE, 0x19, 0x83, 0x30, 0x6E, 0x0D,
  0x81, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0xC3, 0x87, 0x8F, 0x1F, 0x1E,
  0x36, 0x3C, 0xEC, 0xD9, 0x99, 0xB3, 0x36, 0x6E, 0x6C, 0xD8, 0xD9, 0xF1,
  0xE3, 0xC3, 0xC7, 0x87, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x00, 0x1C, 0x71,
  0xC6, 0x0C, 0xE0, 0xDC, 0x0F, 0x80, 0xF8, 0x07, 0x00, 0xF0, 0x0F, 0x01,
  0xB0, 0x3B, 0x83, 0x38, 0x71, 0x8E, 0x1C, 0x0C, 0x1C, 0x30, 0xE0, 0xC3,
  0x03, 0x1C, 0x0C, 0x60, 0x31, 0x80, 0xCE, 0x03, 0x30, 0x0D, 0xC0, 0x36,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x0F, 0x80, 0x3C, 0x00, 0x1F, 0xE3, 0xF8, 0x07, 0x01, 0xC0,
  0x30, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0F, 0xF1,
  0xFE, 0x00, 0x00, 0x40, 0xF0, 0x7C, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38,
  0x0C, 0x03, 0x03, 0xC1, 0xC0, 0xF0, 0x0E, 0x01, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x00, 0xC0, 0x30, 0x0F, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x08, 0x07, 0x03, 0xC0, 0x60, 0x30, 0x38,
  0x1C, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0x70, 0x78, 0x70, 0x70, 0x38, 0x18,
  0x0C, 0x06, 0x07, 0x03, 0x87, 0x83, 0x80, 0x78, 0x3F, 0xFF, 0x3F, 0xC0,
  0xC0,
};

const GFXglyph NotoSans_Condensed_MediumItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 19, 6, 0, -19 },
  { 18, 8, 7, 10, 3, -19 },
  { 25, 14, 19, 13, 0, -19 },
  { 59, 12, 22, 12, 0, -20 },
  { 92, 16, 19, 18, 1, -19 },
  { 130, 13, 19, 14, 0, -19 },
  { 161, 3, 7, 6, 3, -19 },
  { 164, 8, 23, 7, 1, -19 },
  { 187, 8, 23, 7, -2, -19 },
  { 210, 10, 10, 11, 2, -20 },
  { 223, 11, 12, 12, 1, -15 },
  { 240, 5, 6, 6, -1, -3 },
  { 244, 7, 2, 7, 0, -8 },
  { 246, 4, 3, 6, 0, -3 },
  { 248, 12, 19, 9, -1, -19 },
  { 277, 10, 19, 12, 1, -19 },
  { 301, 7, 19, 12, 3, -19 },
  { 318, 13, 19, 12, -1, -19 },
  { 349, 12, 19, 12, 0, -19 },
  { 378, 12, 19, 12, 0, -19 },
  { 407, 12, 19, 12, 0, -19 },
  { 436, 11, 19, 12, 1, -19 },
  { 463, 12, 19, 12, 1, -19 },
  { 492, 12, 19, 12, 0, -19 },
  { 521, 11, 19, 12, 0, -19 },
  { 548, 6, 14, 6, 0, -14 },
  { 559, 7, 17, 6, -1, -14 },
  { 574, 11, 12, 12, 1, -15 },
  { 591, 11, 8, 12, 1, -13 },
  { 602, 11, 12, 12, 1, -15 },
  { 619, 9, 19, 9, 1, -19 },
  { 641, 16, 21, 18, 1, -19 },
  { 683, 13, 19, 12, -2, -19 },
  { 714, 13, 19, 13, 0, -19 },
  { 745, 13, 19, 12, 1, -19 },
  { 776, 14, 19, 14, 0, -19 },
  { 810, 12, 19, 11, 0, -19 },
  { 839, 12, 19, 10, 0, -19 },
  { 868, 14, 19, 14, 1, -19 },
  { 902, 15, 19, 14, 0, -19 },
  { 938, 10, 19, 8, -1, -19 },
  { 962, 11, 24, 6, -4, -19 },
  { 995, 14, 19, 12, 0, -19 },
  { 1029, 9, 19, 10, 0, -19 },
  { 1051, 19, 19, 19, 0, -19 },
  { 1097, 16, 19, 15, 0, -19 },
  { 1135, 13, 19, 15, 1, -19 },
  { 1166, 13, 19, 12, 0, -19 },
  { 1197, 13, 23, 15, 1, -19 },
  { 1235, 12, 19, 12, 0, -19 },
  { 1264, 12, 19, 11, 0, -19 },
  { 1293, 11, 19, 11, 2, -19 },
  { 1320, 14, 19, 14, 1, -19 },
  { 1354, 12, 19, 12, 2, -19 },
  { 1383, 19, 19, 19, 2, -19 },
  { 1429, 14, 19, 11, -1, -19 },
  { 1463, 11, 19, 11, 2, -19 },
  { 1490, 13, 19, 11, -1, -19 },
  { 1521, 10, 23, 7, -1, -19 },
  { 1550, 4, 19, 9, 3, -19 },
  { 1560, 10, 23, 7, -2, -19 },
  { 1589, 12, 11, 12, 0, -19 },
  { 1606, 9, 2, 9, -2, 2 },
  { 1609, 4, 4, 7, 4, -20 },
  { 1611, 11, 14, 12, 1, -14 },
  { 1631, 12, 20, 12, 0, -20 },
  { 1661, 9, 14, 10, 1, -14 },
  { 1677, 12, 20, 12, 1, -20 },
  { 1707, 10, 14, 11, 1, -14 },
  { 1725, 13, 26, 7, -3, -20 },
  { 1768, 12, 20, 12, 0, -14 },
  { 1798, 11, 20, 12, 0, -20 },
  { 1826, 7, 19, 6, 0, -19 },
  { 1843, 10, 25, 6, -3, -19 },
  { 1875, 12, 20, 11, 0, -20 },
  { 1905, 7, 20, 6, 0, -20 },
  { 1923, 17, 14, 18, 0, -14 },
  { 1953, 11, 14, 12, 0, -14 },
  { 1973, 10, 14, 12, 1, -14 },
  { 1991, 13, 20, 12, -1, -14 },
  { 2024, 11, 20, 12, 1, -14 },
  { 2052, 10, 14, 8, 0, -14 },
  { 2070, 10, 14, 9, 0, -14 },
  { 2088, 7, 17, 7, 1, -17 },
  { 2103, 11, 14, 12, 1, -14 },
  { 2123, 11, 14, 10, 1, -14 },
  { 2143, 15, 14, 16, 2, -14 },
  { 2170, 12, 14, 10, -1, -14 },
  { 2191, 14, 20, 10, -2, -14 },
  { 2226, 11, 14, 9, -1, -14 },
  { 2246, 10, 23, 9, 0, -19 },
  { 2275, 3, 26, 11, 4, -20 },
  { 2285, 9, 23, 9, -1, -19 },
  { 2311, 11, 4, 12, 1, -11 },
};

const GFXfont NotoSans_Condensed_MediumItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC26PT7B_H_
