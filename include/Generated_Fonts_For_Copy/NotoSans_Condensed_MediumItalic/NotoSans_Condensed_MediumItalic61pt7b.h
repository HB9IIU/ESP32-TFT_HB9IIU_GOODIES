#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC61PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x02,
  0x00, 0x00, 0x3F, 0x87, 0xE7, 0xE1, 0xFC, 0xFC, 0x3F, 0x1F, 0x87, 0xE3,
  0xF0, 0xFC, 0x7C, 0x1F, 0x0F, 0x83, 0xE3, 0xF0, 0x7C, 0x7C, 0x1F, 0x8F,
  0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x3C, 0x3E,
  0x0F, 0x87, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x78, 0x1F, 0x00,
  0x00, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x20, 0xF0,
  0x1E, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x1E,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x81, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xE7, 0x1E, 0x01, 0xF0, 0xE0, 0x80,
  0x7E, 0x18, 0x00, 0x0F, 0x87, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x3E, 0x1C,
  0x00, 0x07, 0xC3, 0x80, 0x00, 0xFC, 0xE0, 0x00, 0x1F, 0xDC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xCF, 0xC0, 0x00, 0x39, 0xFC,
  0x00, 0x07, 0x1F, 0x80, 0x01, 0xC3, 0xF0, 0x00, 0x38, 0x7E, 0x00, 0x07,
  0x0F, 0xC0, 0x00, 0xE1, 0xF0, 0x40, 0x1C, 0x7E, 0x0E, 0x07, 0x1F, 0xC1,
  0xF0, 0xE7, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0xFF, 0xC0, 0x03, 0xE0, 0x0F, 0xFF,
  0x00, 0x3E, 0x00, 0xFC, 0xF8, 0x01, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x00,
  0x7C, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x0F, 0x80, 0x3E, 0x07, 0x80,
  0xF8, 0x01, 0xF0, 0x3C, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x7C, 0x00, 0xF8,
  0x1F, 0x03, 0xC0, 0x07, 0xC0, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xC3, 0xE0,
  0x01, 0xE0, 0x3C, 0x1F, 0x00, 0x0F, 0x01, 0xE1, 0xF0, 0x00, 0x78, 0x1F,
  0x0F, 0x00, 0x07, 0xC0, 0xF8, 0xF8, 0x18, 0x3E, 0x07, 0x8F, 0x87, 0xF9,
  0xF0, 0x7C, 0x7C, 0x7F, 0xEF, 0x83, 0xC7, 0xC7, 0xFF, 0x3C, 0x3E, 0x3C,
  0x7F, 0xFD, 0xF3, 0xE3, 0xE3, 0xE3, 0xEF, 0xFF, 0x3E, 0x3E, 0x1F, 0x7F,
  0xF1, 0xF1, 0xE0, 0xF9, 0xFF, 0x1F, 0x1F, 0x07, 0xC7, 0xE0, 0xF0, 0xF0,
  0x3E, 0x00, 0x0F, 0x8F, 0x81, 0xF0, 0x00, 0x78, 0x7C, 0x0F, 0x80, 0x07,
  0xC3, 0xE0, 0x7C, 0x00, 0x7C, 0x1E, 0x03, 0xC0, 0x03, 0xE0, 0xF0, 0x1E,
  0x00, 0x3E, 0x0F, 0x81, 0xF0, 0x01, 0xE0, 0x7C, 0x0F, 0x80, 0x1F, 0x03,
  0xE0, 0x78, 0x01, 0xF0, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x3E, 0x00,
  0xF8, 0x07, 0xC1, 0xE0, 0x07, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x01, 0xF1,
  0xF0, 0x07, 0xC0, 0x07, 0xFF, 0x80, 0x3E, 0x00, 0x3F, 0xF8, 0x03, 0xE0,
  0x00, 0xFF, 0x80, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0x07, 0xFF,
  0xE0, 0x7C, 0x1F, 0x8F, 0xC1, 0xF8, 0x7F, 0x1F, 0xC3, 0xF1, 0xFC, 0x1F,
  0x8F, 0xC3, 0xF0, 0x3F, 0x1F, 0x8F, 0xC0, 0x3F, 0x7E, 0x1F, 0x80, 0x7E,
  0xFC, 0x3F, 0x00, 0x7F, 0xF0, 0x7C, 0x00, 0xFF, 0xE1, 0xF8, 0x01, 0xFF,
  0x83, 0xF0, 0x01, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0xF0, 0x1F, 0xC0, 0xFF, 0xE0, 0x3F, 0xEF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xEF, 0xC0, 0x7F, 0xFF, 0x9F, 0xC0, 0x7F, 0xFC, 0x1F, 0x80,
  0x3F, 0xF0, 0x3F, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0xCF, 0xC7,
  0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC1,
  0xE1, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0x00, 0xF0,
  0x07, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0xFE, 0x7C, 0x03, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F,
  0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xDE, 0x00, 0x7E, 0x7C, 0x03, 0xF1, 0xF0,
  0x1F, 0xC3, 0xE0, 0x3E, 0x0F, 0x80, 0x70, 0x3F, 0x00, 0x80, 0x78, 0x00,
  0x01, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x7F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x00, 0x7F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x20, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xF3,
  0xF8, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC3, 0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F,
  0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3,
  0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x0F,
  0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xBF, 0x3F, 0x9F,
  0x3F, 0x9F, 0x9F, 0x8F, 0xC7, 0x87, 0xE1, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0xF0, 0x0F, 0xE0, 0x07, 0x00, 0x7F, 0x00, 0x10, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xF0,
  0x3F, 0xC0, 0x38, 0x03, 0xF8, 0x02, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC1, 0x00, 0x07,
  0xF8, 0x38, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x7C, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x1F,
  0x80, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0xF8, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x03,
  0xE0, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x08, 0x00, 0x3F, 0xC0,
  0xE0, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xF0, 0x20, 0x0F, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0x80, 0x07, 0xC7, 0xFC, 0x03,
  0xF3, 0xFF, 0x80, 0xFD, 0xFF, 0xF0, 0x3E, 0xFF, 0xFC, 0x1F, 0xFC, 0xFF,
  0x07, 0xFC, 0x0F, 0xE1, 0xFE, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x03,
  0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x00,
  0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3E, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xFC, 0x01, 0xFC,
  0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE,
  0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0x0F, 0xE0,
  0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87,
  0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x7F,
  0x87, 0xF0, 0x3F, 0xE1, 0xFE, 0x1F, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xEF, 0xC0, 0x3F, 0xF3, 0xE0, 0x07, 0xF1, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7C,
  0x00, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0x81, 0xFC, 0x30, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x7C, 0x01, 0xFE, 0x03, 0xC0, 0xF0, 0x0F, 0xFF, 0x07, 0x83, 0xE0,
  0x3F, 0xFE, 0x0F, 0x87, 0x80, 0xFF, 0xFC, 0x1F, 0x1F, 0x03, 0xF0, 0xF8,
  0x3E, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0xF8, 0x1F, 0x03, 0xC0, 0xF1, 0xF0,
  0x7C, 0x0F, 0x81, 0xE3, 0xC0, 0xF0, 0x1F, 0x03, 0xC7, 0x83, 0xE0, 0x3C,
  0x07, 0x9F, 0x07, 0xC0, 0x78, 0x0F, 0x3C, 0x0F, 0x01, 0xF0, 0x3E, 0x78,
  0x3E, 0x03, 0xE0, 0x78, 0xF0, 0x7C, 0x07, 0x80, 0xF3, 0xE0, 0xF8, 0x1F,
  0x03, 0xE7, 0xC1, 0xE0, 0x3E, 0x07, 0x8F, 0x83, 0xC0, 0x7C, 0x0F, 0x1E,
  0x07, 0x81, 0xF8, 0x3E, 0x3C, 0x0F, 0x03, 0xE0, 0x78, 0x78, 0x1E, 0x0F,
  0xC1, 0xF0, 0xF0, 0x3E, 0x3F, 0xC7, 0xC1, 0xE0, 0x7F, 0xF7, 0xFF, 0x03,
  0xE0, 0x7F, 0xCF, 0xFC, 0x07, 0xC0, 0xFF, 0x0F, 0xF0, 0x0F, 0x80, 0xFC,
  0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x04, 0x00,
  0x00, 0xFE, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x3F,
  0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFC, 0x07,
  0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x01,
  0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xF0, 0x1F, 0xE0, 0x3F, 0x00, 0x7F, 0x01, 0xF8,
  0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0,
  0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x01, 0xF8,
  0x1F, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x7F, 0x80,
  0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01,
  0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x81, 0xF8,
  0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xE1, 0xF0, 0x07, 0xF8, 0x01, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFF, 0x01, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x05, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0x03, 0xFE, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x03, 0xF0,
  0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F,
  0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xFC,
  0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xC0, 0x7F, 0xC0, 0x1F, 0x8F, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x08,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0xFC, 0x01, 0xFF, 0x00, 0x1C, 0x01, 0xFE,
  0x00, 0x08, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x08, 0x7E, 0x00, 0xFF, 0xF0, 0xFE, 0x00,
  0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0xF0, 0xFC, 0x01,
  0xFF, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0x80, 0x7F, 0x80,
  0x1F, 0x80, 0x3F, 0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x11, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x07,
  0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0,
  0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F,
  0x80, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x03, 0xF7, 0xC0, 0x03, 0xEF,
  0x80, 0x3F, 0x7C, 0x00, 0x7D, 0xF8, 0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x80,
  0x3E, 0x7C, 0x00, 0xF9, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0x9F, 0x80, 0x7E,
  0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x3F, 0x00, 0x7C, 0x7C,
  0x03, 0xF3, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x3F, 0x00, 0xFC, 0x7C, 0x07,
  0xE3, 0xF0, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x00, 0xFC, 0x7C, 0x0F, 0xC7,
  0xE0, 0x0F, 0x87, 0xC0, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x1F, 0x87, 0xE0,
  0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x01, 0xF8, 0x7C, 0x3F, 0x0F, 0xC0, 0x1F,
  0x87, 0xE3, 0xE0, 0xFC, 0x01, 0xF0, 0x3E, 0x7E, 0x0F, 0xC0, 0x3F, 0x03,
  0xE7, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x7C, 0x0F, 0x80, 0x3F, 0x03, 0xEF,
  0x81, 0xF8, 0x03, 0xE0, 0x3E, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xFF, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xFE, 0x01, 0xF0,
  0x07, 0xE0, 0x3F, 0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xFC, 0x03, 0xF0, 0x07,
  0xC0, 0x3F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0xFF, 0x00, 0x03, 0xE0, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0x80,
  0x07, 0xE0, 0x0F, 0xF8, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x1F,
  0xF8, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x1F, 0xFC, 0x00, 0xFC,
  0x01, 0xFF, 0xC0, 0x0F, 0xC0, 0x3F, 0x7C, 0x00, 0xFC, 0x03, 0xF7, 0xC0,
  0x0F, 0x80, 0x3F, 0x7E, 0x01, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0x80, 0x3E,
  0x3E, 0x01, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x80, 0x7E, 0x3E, 0x01, 0xF0,
  0x07, 0xE3, 0xF0, 0x3F, 0x00, 0x7C, 0x3F, 0x03, 0xF0, 0x07, 0xC1, 0xF0,
  0x3F, 0x00, 0xFC, 0x1F, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x3E, 0x00, 0xFC,
  0x1F, 0x87, 0xE0, 0x0F, 0x80, 0xF8, 0x7E, 0x00, 0xF8, 0x0F, 0x87, 0xE0,
  0x1F, 0x80, 0xFC, 0x7C, 0x01, 0xF8, 0x0F, 0xC7, 0xC0, 0x1F, 0x80, 0xFC,
  0xFC, 0x01, 0xF0, 0x07, 0xCF, 0xC0, 0x3F, 0x00, 0x7C, 0xFC, 0x03, 0xF0,
  0x07, 0xEF, 0x80, 0x3F, 0x00, 0x7E, 0xF8, 0x03, 0xE0, 0x03, 0xFF, 0x80,
  0x3E, 0x00, 0x3F, 0xF8, 0x07, 0xE0, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x3F,
  0xF0, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x07, 0xC0,
  0x01, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x01, 0xFE, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0x80, 0xFF,
  0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0xBF, 0x80,
  0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0x3F, 0x9F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F,
  0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0,
  0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E,
  0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x03,
  0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x03, 0xFC, 0x07, 0xE0, 0x3F, 0xC0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x01,
  0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x07,
  0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80,
  0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0,
  0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7F, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x01, 0xFC,
  0x07, 0xE0, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0x87, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F,
  0x80, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x07,
  0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xF3, 0xF0, 0x03, 0xF8,
  0x03, 0x80, 0x3F, 0x80, 0x04, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x04, 0x00,
  0x0F, 0xE0, 0x30, 0x00, 0xFE, 0x01, 0xF0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC,
  0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8,
  0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0,
  0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0,
  0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0xFE, 0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03,
  0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0,
  0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E,
  0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x7E,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x7C,
  0x00, 0x1F, 0x80, 0x07, 0xF7, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x7C, 0x00,
  0x3F, 0x80, 0x07, 0xE7, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7F,
  0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xF8, 0x01, 0xFC, 0x7C, 0x00, 0xFF, 0x80,
  0x1F, 0x87, 0xC0, 0x0F, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xFF, 0x80, 0x3F,
  0x07, 0xC0, 0x1F, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xFF, 0x80, 0x7E, 0x07,
  0xC0, 0x3E, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xEF, 0x80, 0x7E, 0x0F, 0xC0,
  0x3E, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xCF, 0x80, 0xFC, 0x0F, 0xC0, 0x7C,
  0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0x8F, 0x81, 0xF8, 0x0F, 0xC0, 0xF8, 0xF8,
  0x1F, 0x80, 0xFC, 0x1F, 0x8F, 0x83, 0xF0, 0x0F, 0xC1, 0xF0, 0xF8, 0x3F,
  0x00, 0xFC, 0x1F, 0x0F, 0x83, 0xE0, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x00,
  0xFC, 0x3E, 0x0F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0xF8, 0xFC, 0x00, 0xFC,
  0x7C, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7, 0xC0, 0xF8, 0xF8, 0x00, 0xFC, 0xF8,
  0x0F, 0x9F, 0x80, 0x0F, 0xCF, 0x80, 0xF9, 0xF8, 0x00, 0xFD, 0xF8, 0x0F,
  0xBF, 0x00, 0x0F, 0xDF, 0x00, 0xFB, 0xF0, 0x00, 0xFD, 0xF0, 0x0F, 0xBE,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x00, 0x7F, 0x7C, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE0,
  0x0F, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x7F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0x3E,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x7E,
  0x00, 0x1F, 0x1F, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFC,
  0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80,
  0x03, 0xE3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07,
  0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0xF8,
  0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE3,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0,
  0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0x81,
  0xF0, 0x00, 0x3F, 0x83, 0xE0, 0x1F, 0xFC, 0xFC, 0x07, 0xFF, 0x9F, 0x01,
  0xFF, 0xFB, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xE0, 0xFF, 0x83, 0xF8, 0x0F,
  0xE0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x80,
  0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE1,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01,
  0xFC, 0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x07, 0xFC, 0x0F,
  0xFB, 0xFF, 0x80, 0xFF, 0xFB, 0xF0, 0x1F, 0xFE, 0x7C, 0x01, 0xFF, 0x8F,
  0x80, 0x1F, 0xE1, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF1, 0xFE, 0x00, 0x7E, 0x7F, 0xE0, 0x0F,
  0x9F, 0xFE, 0x01, 0xF7, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xF8, 0x3F,
  0x81, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC1, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x03,
  0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F,
  0xC1, 0xFC, 0x0F, 0xFE, 0xFF, 0x81, 0xF7, 0xFF, 0xE0, 0x3E, 0xFF, 0xF8,
  0x07, 0x8F, 0xFE, 0x01, 0xF0, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0xC0, 0x40, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x60, 0x7F, 0xDF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x1F, 0x80, 0x0F, 0xFE, 0x7C, 0x00, 0x7F, 0xF9, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0x07, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x0F,
  0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xE0,
  0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00,
  0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F,
  0x01, 0xFE, 0x00, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0xFB, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0x7C, 0x00, 0x3F, 0xF9, 0xF0, 0x00, 0x7F, 0x87,
  0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0x8F, 0xE0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x0F, 0x8F, 0xE0, 0x1F, 0x1F, 0x80, 0x3E, 0x7E, 0x00, 0xFC, 0xFC,
  0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0xFF, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x02, 0x07, 0xF8, 0x3C, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF3, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xDF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x7C, 0x00, 0x7F, 0xF3, 0xF0, 0x03, 0xFF, 0xCF, 0x80, 0x1F, 0xFF, 0xBE,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x3F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00,
  0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F,
  0x00, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0,
  0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x80, 0x7E, 0x01, 0xFC, 0x01, 0xF8,
  0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFE,
  0xFC, 0x00, 0xFF, 0xF3, 0xE0, 0x01, 0xFF, 0x9F, 0x80, 0x03, 0xFC, 0x7E,
  0x00, 0x03, 0x81, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x80, 0x03, 0xF8, 0x03, 0x80, 0x1F, 0xC0, 0x0F, 0xE3,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF1, 0xFE, 0x00, 0x7E, 0x7F, 0xE0,
  0x0F, 0x9F, 0xFE, 0x01, 0xF7, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xF8,
  0x3F, 0x81, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC1,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x1F,
  0x80, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x83, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0,
  0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x3F, 0x00,
  0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x01,
  0xF0, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xE3, 0xF8, 0x00,
  0x7E, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xDF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xC0, 0x01, 0xFC,
  0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xF0,
  0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x3E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0xFF, 0x01, 0xFC, 0x00, 0xF8, 0xFF,
  0xC3, 0xFF, 0x00, 0x7D, 0xFF, 0xE3, 0xFF, 0xC0, 0x3E, 0xFF, 0xFB, 0xFF,
  0xF0, 0x3E, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x7C, 0x00, 0xF8,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0,
  0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0xFF, 0x00, 0x3E, 0x3F,
  0xF0, 0x07, 0xCF, 0xFF, 0x00, 0xFB, 0xFF, 0xE0, 0x3E, 0xFF, 0xFE, 0x07,
  0xFC, 0x1F, 0xC0, 0xFF, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x07,
  0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC1,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x1F,
  0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80,
  0x3F, 0x3F, 0x80, 0x1F, 0x3F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01,
  0xFC, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x3E, 0x1F, 0xE0, 0x00, 0xF8, 0xFF, 0xC0,
  0x03, 0xE7, 0xFF, 0x80, 0x0F, 0xBF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0x7F,
  0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F,
  0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0,
  0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x0F,
  0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x01, 0xFE, 0x0F,
  0xF0, 0x0F, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFD, 0xFF, 0xE0,
  0x03, 0xE7, 0xFF, 0x00, 0x0F, 0x87, 0xF8, 0x00, 0x7E, 0x06, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC3, 0xE0, 0x1F, 0xFC, 0xF8, 0x07, 0xFF, 0x9F, 0x01,
  0xFF, 0xFB, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xE0, 0xFF, 0x83, 0xF8, 0x0F,
  0xE0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0xFC,
  0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x1F, 0x80,
  0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC1,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01,
  0xFC, 0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x07, 0xFC, 0x0F,
  0xFB, 0xFF, 0x80, 0xFF, 0xFB, 0xF0, 0x1F, 0xFE, 0x7C, 0x01, 0xFF, 0x9F,
  0x80, 0x1F, 0xE3, 0xF0, 0x00, 0x60, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x07, 0xC7,
  0xF0, 0x1F, 0x3F, 0xC0, 0x7D, 0xFE, 0x03, 0xEF, 0xF8, 0x0F, 0xBF, 0xE0,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x07, 0xF8, 0xF8, 0x3F, 0x80, 0x60, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x08, 0x00, 0xFC, 0x30, 0x07, 0xF0, 0xFC, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xCF,
  0xFF, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0xCC, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x06, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7C,
  0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x07, 0xE0,
  0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07,
  0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0x83, 0xF0, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC,
  0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x03,
  0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x7F, 0x83, 0xF8, 0x3F, 0xE0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0x7C, 0x07, 0xFF, 0x9F, 0x00, 0xFF, 0xC7, 0xC0,
  0x1F, 0xE1, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0xFE, 0x7C, 0x00, 0xFC, 0x7C, 0x00,
  0xFC, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x7C, 0x03,
  0xF0, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F,
  0xC0, 0x7E, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x01,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xBE, 0x00, 0xFE, 0x00, 0xFD,
  0xF0, 0x0F, 0xF0, 0x0F, 0xCF, 0x80, 0x7F, 0x80, 0x7E, 0x7C, 0x03, 0xFC,
  0x07, 0xE3, 0xE0, 0x3F, 0xE0, 0x3F, 0x1F, 0x01, 0xEF, 0x01, 0xF0, 0xF8,
  0x1F, 0x78, 0x1F, 0x87, 0xC0, 0xFB, 0xC0, 0xFC, 0x3E, 0x07, 0xBE, 0x07,
  0xC1, 0xF0, 0x7D, 0xF0, 0x7E, 0x0F, 0x83, 0xEF, 0x83, 0xE0, 0x7C, 0x3E,
  0x7C, 0x3F, 0x03, 0xE1, 0xF3, 0xE1, 0xF0, 0x1F, 0x0F, 0x1F, 0x0F, 0x80,
  0xF8, 0xF8, 0xF8, 0xFC, 0x07, 0xC7, 0xC7, 0xC7, 0xC0, 0x3E, 0x7C, 0x3E,
  0x7E, 0x01, 0xF3, 0xE1, 0xF3, 0xE0, 0x0F, 0xBE, 0x0F, 0x9F, 0x00, 0x7D,
  0xF0, 0x7D, 0xF8, 0x03, 0xEF, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x7E,
  0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xDF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x20, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF2,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x9F, 0xF8, 0x00, 0x5F, 0xFF, 0x00, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x00, 0x7F, 0xFD, 0x00, 0x0F,
  0xFC, 0x80, 0x00, 0x70, 0x00,
};

const GFXglyph NotoSans_Condensed_MediumItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 15, 45, 15, 1, -44 },
  { 86, 19, 16, 23, 6, -44 },
  { 124, 31, 44, 31, 1, -44 },
  { 295, 27, 50, 27, 1, -46 },
  { 464, 37, 45, 42, 3, -44 },
  { 673, 31, 45, 32, 0, -44 },
  { 848, 9, 16, 13, 6, -44 },
  { 866, 20, 54, 17, 1, -44 },
  { 1001, 20, 54, 17, -5, -44 },
  { 1136, 22, 24, 26, 6, -47 },
  { 1202, 25, 29, 29, 3, -36 },
  { 1293, 12, 15, 14, -3, -7 },
  { 1316, 15, 5, 17, 1, -19 },
  { 1326, 7, 9, 14, 1, -8 },
  { 1334, 29, 44, 22, -3, -44 },
  { 1494, 25, 45, 27, 2, -44 },
  { 1635, 17, 44, 27, 7, -44 },
  { 1729, 29, 44, 27, -2, -44 },
  { 1889, 27, 45, 27, 0, -44 },
  { 2041, 28, 44, 27, -1, -44 },
  { 2195, 28, 45, 27, 0, -44 },
  { 2353, 26, 45, 27, 2, -44 },
  { 2500, 28, 44, 27, 2, -44 },
  { 2654, 28, 45, 27, 0, -44 },
  { 2812, 26, 45, 27, 1, -44 },
  { 2959, 13, 34, 14, 0, -33 },
  { 3015, 17, 41, 14, -3, -33 },
  { 3103, 25, 29, 29, 3, -36 },
  { 3194, 25, 17, 29, 3, -30 },
  { 3248, 25, 29, 29, 3, -36 },
  { 3339, 21, 45, 21, 2, -44 },
  { 3458, 39, 49, 41, 2, -44 },
  { 3697, 29, 44, 29, -4, -44 },
  { 3857, 29, 44, 30, 1, -44 },
  { 4017, 29, 45, 28, 3, -44 },
  { 4181, 31, 44, 33, 1, -44 },
  { 4352, 27, 44, 26, 1, -44 },
  { 4501, 27, 44, 24, 1, -44 },
  { 4650, 32, 45, 34, 3, -44 },
  { 4830, 34, 44, 34, 1, -44 },
  { 5017, 25, 44, 18, -3, -44 },
  { 5155, 25, 56, 15, -9, -44 },
  { 5330, 33, 44, 29, 1, -44 },
  { 5512, 19, 44, 24, 1, -44 },
  { 5617, 44, 44, 44, 1, -44 },
  { 5859, 36, 44, 36, 1, -44 },
  { 6057, 31, 45, 35, 3, -44 },
  { 6232, 29, 44, 29, 1, -44 },
  { 6392, 31, 54, 35, 3, -44 },
  { 6602, 28, 44, 29, 1, -44 },
  { 6756, 29, 45, 26, -1, -44 },
  { 6920, 24, 44, 25, 5, -44 },
  { 7052, 32, 45, 33, 3, -44 },
  { 7232, 29, 44, 28, 5, -44 },
  { 7392, 44, 44, 44, 5, -44 },
  { 7634, 34, 44, 27, -3, -44 },
  { 7821, 26, 44, 26, 5, -44 },
  { 7964, 30, 44, 25, -2, -44 },
  { 8129, 24, 54, 18, -2, -44 },
  { 8291, 11, 44, 22, 6, -44 },
  { 8352, 23, 54, 18, -4, -44 },
  { 8508, 26, 26, 28, 1, -44 },
  { 8593, 21, 4, 20, -5, 5 },
  { 8604, 10, 10, 17, 9, -47 },
  { 8617, 27, 34, 29, 2, -33 },
  { 8732, 27, 47, 29, 0, -46 },
  { 8891, 22, 34, 23, 2, -33 },
  { 8985, 30, 47, 29, 2, -46 },
  { 9162, 23, 34, 26, 2, -33 },
  { 9260, 31, 62, 17, -7, -47 },
  { 9501, 30, 48, 29, -1, -33 },
  { 9681, 27, 46, 29, 0, -46 },
  { 9837, 16, 45, 14, 0, -45 },
  { 9927, 24, 60, 14, -8, -45 },
  { 10107, 28, 46, 26, 0, -46 },
  { 10268, 16, 46, 14, 0, -46 },
  { 10360, 41, 33, 43, 0, -33 },
  { 10530, 27, 33, 29, 0, -33 },
  { 10642, 24, 34, 28, 2, -33 },
  { 10744, 30, 47, 29, -3, -33 },
  { 10921, 27, 48, 29, 2, -33 },
  { 11083, 22, 33, 20, 0, -33 },
  { 11174, 22, 34, 22, 0, -33 },
  { 11268, 17, 41, 17, 2, -40 },
  { 11356, 26, 34, 29, 2, -33 },
  { 11467, 24, 33, 24, 3, -33 },
  { 11566, 37, 33, 38, 4, -33 },
  { 11719, 30, 33, 25, -3, -33 },
  { 11843, 32, 48, 24, -5, -33 },
  { 12035, 24, 33, 21, -2, -33 },
  { 12134, 23, 54, 21, 1, -44 },
  { 12290, 6, 61, 26, 10, -47 },
  { 12336, 23, 54, 21, -3, -44 },
  { 12492, 25, 9, 29, 3, -26 },
};

const GFXfont NotoSans_Condensed_MediumItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC61PT7B_H_
