#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC24PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x71, 0xC7, 0x18, 0x61, 0x8E, 0x30, 0xC3, 0x0C, 0x00, 0x06,
  0x38, 0xE0, 0x77, 0x66, 0x66, 0x66, 0x66, 0xCC, 0x03, 0x30, 0x31, 0x01,
  0x98, 0x0C, 0xC0, 0x44, 0x9F, 0xF8, 0x33, 0x01, 0x18, 0x19, 0x80, 0xCC,
  0x3F, 0xF9, 0xFF, 0xC3, 0x30, 0x19, 0x80, 0x88, 0x0C, 0xC0, 0x66, 0x00,
  0x01, 0x00, 0x20, 0x3F, 0x8F, 0xE1, 0xA4, 0x64, 0x0E, 0x81, 0xD0, 0x1E,
  0x01, 0xE0, 0x1E, 0x02, 0xC0, 0xD8, 0x13, 0x32, 0xE7, 0xF8, 0x7E, 0x03,
  0x00, 0x40, 0x00, 0x1C, 0x1C, 0x6C, 0x31, 0x98, 0xC3, 0x33, 0x06, 0x66,
  0x18, 0xD8, 0x33, 0x32, 0x66, 0xDE, 0xF9, 0x76, 0xF6, 0xCC, 0x19, 0x18,
  0x36, 0x30, 0xCC, 0xC1, 0x19, 0x86, 0x33, 0x18, 0x7C, 0x70, 0x70, 0x07,
  0xC0, 0xFC, 0x0C, 0xC1, 0xCC, 0x1C, 0xC1, 0xD8, 0x0F, 0x00, 0xE0, 0x1E,
  0x03, 0x63, 0x67, 0x7E, 0x36, 0xE3, 0xCC, 0x1C, 0xE3, 0xC7, 0xFC, 0x7C,
  0xE0, 0x76, 0x66, 0x6C, 0x06, 0x18, 0x60, 0xC3, 0x0E, 0x18, 0x30, 0xE1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x06, 0x00, 0x06,
  0x06, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x06, 0x06, 0x06,
  0x0E, 0x0C, 0x0C, 0x18, 0x38, 0x30, 0x60, 0xE0, 0x0C, 0x06, 0x1B, 0x1F,
  0xF1, 0xF9, 0xE1, 0xD8, 0xCC, 0x27, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x3F, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x39, 0x9C, 0xC6,
  0x60, 0x7D, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80,
  0x60, 0x18, 0x03, 0x00, 0xC0, 0x00, 0x0F, 0x87, 0xE3, 0x98, 0xC7, 0x71,
  0xD8, 0x76, 0x1B, 0x86, 0xC1, 0xB0, 0x6C, 0x3B, 0x0C, 0xC3, 0x31, 0xCC,
  0x63, 0xF0, 0x78, 0x00, 0x0E, 0x79, 0xF7, 0x6D, 0xC3, 0x06, 0x0C, 0x38,
  0x70, 0xC1, 0x83, 0x0E, 0x18, 0x30, 0x60, 0x07, 0xC0, 0xFE, 0x08, 0x70,
  0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xC3, 0xF8,
  0x43, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x60, 0xF8, 0x1F, 0x00, 0x70, 0x06,
  0x00, 0xC0, 0x18, 0x07, 0x20, 0xC7, 0xF8, 0xFE, 0x00, 0x00, 0xE0, 0x38,
  0x0F, 0x01, 0x60, 0x6C, 0x1B, 0x83, 0x60, 0xCC, 0x31, 0x8C, 0x71, 0x8C,
  0x7F, 0xEF, 0xFC, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0x0F, 0xE1, 0xFC,
  0x60, 0x0C, 0x01, 0x80, 0x70, 0x0D, 0x81, 0xFC, 0x37, 0x80, 0x30, 0x07,
  0x00, 0xC0, 0x18, 0x07, 0x20, 0xC7, 0xF8, 0xFC, 0x00, 0x07, 0xC3, 0xF1,
  0xC0, 0xE0, 0x30, 0x18, 0x06, 0xE1, 0xFC, 0xF3, 0xB8, 0xEC, 0x1B, 0x0E,
  0xC3, 0xB0, 0xCE, 0x73, 0xF8, 0x7C, 0x00, 0x3F, 0xEF, 0xF8, 0x03, 0x00,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03,
  0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x00, 0x0F, 0xC3, 0xFC, 0x63, 0x8C,
  0x31, 0x8E, 0x31, 0x87, 0x70, 0x78, 0x1F, 0x07, 0x71, 0xC6, 0x70, 0xCE,
  0x19, 0xC3, 0x38, 0xE3, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xF8, 0xE3, 0x18,
  0x63, 0x0E, 0x61, 0x9C, 0x31, 0x8E, 0x3B, 0xC7, 0xD8, 0x77, 0x00, 0xC0,
  0x38, 0x06, 0x01, 0xC7, 0xF0, 0xF8, 0x00, 0x19, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0x19, 0xCE, 0x00, 0x0C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x0C, 0x71, 0x8E, 0x30, 0x00, 0x40, 0x70, 0x78, 0x78, 0x78, 0x38, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x70, 0x04, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x78,
  0x78, 0x78, 0x38, 0x08, 0x00, 0x3E, 0x7F, 0x43, 0x03, 0x03, 0x06, 0x0E,
  0x1C, 0x38, 0x30, 0x60, 0x60, 0x00, 0x00, 0xE0, 0xE0, 0xC0, 0x03, 0xF0,
  0x0E, 0x38, 0x70, 0x30, 0xC0, 0x33, 0x0C, 0x6C, 0x7C, 0xD9, 0x99, 0xA2,
  0x33, 0xCC, 0x67, 0x99, 0x8B, 0x23, 0x36, 0x46, 0x6C, 0xDD, 0x99, 0xEE,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xE0, 0x6C, 0x0D, 0x83, 0xB0, 0x66, 0x1C, 0xE3, 0x1C,
  0xFF, 0x9F, 0xF3, 0x0E, 0xE1, 0xD8, 0x3F, 0x07, 0xC0, 0xE0, 0x0F, 0xC0,
  0xFE, 0x1C, 0x71, 0x87, 0x18, 0x71, 0x86, 0x38, 0xE3, 0xFC, 0x3F, 0x83,
  0x1C, 0x30, 0xC7, 0x0E, 0x70, 0xC6, 0x0C, 0x61, 0xC7, 0xF8, 0xFE, 0x00,
  0x07, 0xF0, 0xFE, 0x1C, 0x23, 0x80, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x87, 0xF0,
  0x3F, 0x00, 0x0F, 0xC0, 0xFE, 0x1C, 0x71, 0xC3, 0x18, 0x31, 0x83, 0x38,
  0x33, 0x83, 0x30, 0x33, 0x07, 0x30, 0x77, 0x06, 0x70, 0xE6, 0x1C, 0x63,
  0x87, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x0E, 0x01, 0xFC, 0x3F, 0x86, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xE1, 0xFC, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x0E, 0x01, 0xC0, 0x3F, 0x87, 0xF0, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x87, 0x04, 0x70, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0xE1, 0xE7, 0x1F, 0x38, 0x39, 0xC1, 0xCE,
  0x0C, 0x70, 0x61, 0xC3, 0x0F, 0xF8, 0x3F, 0x80, 0x0C, 0x1C, 0x30, 0x61,
  0xC1, 0x87, 0x06, 0x18, 0x38, 0x60, 0xE3, 0x83, 0x0F, 0xFC, 0x3F, 0xF0,
  0xC1, 0xC3, 0x07, 0x1C, 0x18, 0x70, 0x61, 0x83, 0x86, 0x0E, 0x18, 0x30,
  0xE0, 0xC0, 0x1F, 0xC1, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30,
  0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x81, 0xF0, 0xFC, 0x00,
  0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00,
  0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC2,
  0xF0, 0x78, 0x38, 0x00, 0x0C, 0x38, 0x63, 0x87, 0x18, 0x31, 0xC1, 0x9C,
  0x0D, 0xC0, 0xEC, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0C, 0xC0, 0xE6, 0x07,
  0x38, 0x31, 0xC1, 0x86, 0x0C, 0x30, 0xE1, 0xC0, 0x0C, 0x0C, 0x1C, 0x18,
  0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x7F,
  0xFF, 0x0E, 0x03, 0xC3, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x0F,
  0x87, 0x83, 0xE3, 0xE1, 0xB0, 0xD8, 0x6C, 0x33, 0x33, 0x0C, 0xCD, 0xC3,
  0x36, 0x61, 0xCD, 0x98, 0x63, 0xC6, 0x18, 0xF1, 0x86, 0x38, 0xE1, 0x8E,
  0x30, 0xE3, 0x0C, 0x00, 0x0E, 0x0E, 0x1C, 0x18, 0x78, 0x30, 0xF0, 0xE1,
  0xF1, 0xC3, 0x63, 0x0E, 0xC6, 0x19, 0x8C, 0x33, 0x38, 0x63, 0x60, 0xC6,
  0xC3, 0x8D, 0x86, 0x1B, 0x0C, 0x3E, 0x18, 0x38, 0x30, 0x70, 0xE0, 0xE0,
  0x07, 0xE0, 0xFF, 0x1C, 0x73, 0x83, 0x30, 0x37, 0x03, 0x60, 0x36, 0x03,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x06, 0xE0, 0xEE, 0x0C, 0xE1, 0xC7, 0xF8,
  0x3E, 0x00, 0x0F, 0xC0, 0xFE, 0x1C, 0x61, 0x87, 0x18, 0x71, 0x86, 0x38,
  0x63, 0x8E, 0x3F, 0xC3, 0xF8, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0xFF, 0x1C, 0x73, 0x83, 0x30, 0x37,
  0x03, 0x60, 0x36, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x06, 0xE0, 0xEE,
  0x0C, 0x61, 0xC7, 0xF8, 0x3F, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x0F, 0xC0, 0xFE, 0x1C, 0x61, 0x87, 0x18, 0x61, 0x86, 0x38, 0xE3, 0x9E,
  0x3F, 0xC3, 0xF0, 0x33, 0x07, 0x30, 0x73, 0x86, 0x38, 0x61, 0x86, 0x18,
  0xE1, 0xC0, 0x0F, 0xE3, 0xF8, 0xE1, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x21, 0xC7, 0xF8,
  0xFC, 0x00, 0xFF, 0xFF, 0xE1, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x00,
  0x18, 0x39, 0xC1, 0x8E, 0x0C, 0x60, 0xE3, 0x07, 0x18, 0x31, 0xC1, 0x8E,
  0x0C, 0x60, 0xE3, 0x07, 0x38, 0x31, 0xC1, 0x8E, 0x1C, 0x70, 0xE3, 0x8E,
  0x0F, 0xE0, 0x3E, 0x00, 0xE0, 0xFC, 0x1B, 0x83, 0x70, 0xEE, 0x19, 0xC7,
  0x38, 0xC7, 0x38, 0xE6, 0x1D, 0xC3, 0xB0, 0x36, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0x70, 0x00, 0xC1, 0xC1, 0xE0, 0xE1, 0xF0, 0x70, 0xD8, 0x78,
  0x6C, 0x3C, 0x76, 0x36, 0x33, 0x1B, 0x39, 0x8D, 0x98, 0xCC, 0xCC, 0x66,
  0x6C, 0x36, 0x36, 0x1B, 0x1F, 0x0D, 0x8F, 0x07, 0x87, 0x83, 0xC3, 0x81,
  0xC1, 0xC0, 0xE0, 0xE0, 0x00, 0x0C, 0x38, 0x61, 0x83, 0x9C, 0x1C, 0xC0,
  0x6C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xE0, 0x3F,
  0x03, 0x98, 0x18, 0xC1, 0xC6, 0x0C, 0x38, 0xC1, 0xC0, 0xE1, 0xF8, 0x66,
  0x39, 0x8C, 0x67, 0x19, 0x86, 0xC1, 0xB0, 0x78, 0x0E, 0x03, 0x00, 0xC0,
  0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x60,
  0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x38, 0x03, 0x00, 0x70, 0x07, 0xF8, 0xFF, 0x80, 0x07, 0xC1, 0xE0,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0xF0, 0xF8, 0x00,
  0xE3, 0x18, 0xC6, 0x31, 0x8E, 0x31, 0x8C, 0x63, 0x18, 0xC3, 0x18, 0x07,
  0xC3, 0xE0, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC1, 0xE0,
  0xF8, 0x00, 0x03, 0x00, 0xE0, 0x1C, 0x06, 0xC1, 0x98, 0x33, 0x0C, 0x31,
  0x86, 0x60, 0xDC, 0x0C, 0xFF, 0xFF, 0xE7, 0x30, 0x1E, 0xCF, 0xF7, 0x1D,
  0x87, 0x61, 0xB8, 0x6C, 0x1B, 0x0E, 0xC3, 0xB0, 0xCC, 0x73, 0xFC, 0x7B,
  0x00, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x37, 0x87, 0xF1, 0xE7,
  0x38, 0xE6, 0x1C, 0xC3, 0xB8, 0x67, 0x0C, 0xC3, 0x98, 0x73, 0x9C, 0xFF,
  0x1B, 0xC0, 0x1F, 0x3F, 0x70, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC2, 0xFC, 0x7C, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x3D, 0x8F,
  0xF3, 0x8E, 0x61, 0xCC, 0x33, 0x86, 0x60, 0xCC, 0x39, 0x87, 0x30, 0xC6,
  0x38, 0xFF, 0x0F, 0x60, 0x1F, 0x1F, 0xDC, 0x6C, 0x3E, 0x3E, 0xFB, 0xF9,
  0x80, 0xC0, 0x60, 0x30, 0x1F, 0xC7, 0xE0, 0x00, 0xF0, 0x1F, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x7E, 0x0F, 0xC0, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x18, 0x03, 0x80, 0xF0, 0x0E, 0x00, 0x0F, 0x63, 0xFC, 0xE3, 0x98,
  0x73, 0x0C, 0xE1, 0x98, 0x33, 0x0E, 0x61, 0xCC, 0x31, 0x8E, 0x3F, 0xC3,
  0xF8, 0x06, 0x00, 0xC0, 0x38, 0x8E, 0x1F, 0xC1, 0xE0, 0x00, 0x0C, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0x80, 0x37, 0x87, 0xF1, 0xE7, 0x38, 0xC6, 0x18,
  0xC3, 0x18, 0x67, 0x1C, 0xC3, 0x18, 0x63, 0x0C, 0xE1, 0x9C, 0x70, 0x0C,
  0x70, 0xC0, 0x00, 0x61, 0x8E, 0x30, 0xC3, 0x1C, 0x71, 0x86, 0x18, 0xE3,
  0x80, 0x01, 0x81, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x0E, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01,
  0x81, 0xC3, 0xC1, 0xC0, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x31,
  0xC6, 0x71, 0xCC, 0x33, 0x06, 0xC0, 0xF8, 0x1F, 0x07, 0x60, 0xCE, 0x19,
  0xC3, 0x18, 0xE3, 0x1C, 0x70, 0x0C, 0x31, 0xC7, 0x18, 0x61, 0x8E, 0x30,
  0xC3, 0x0C, 0x71, 0x86, 0x18, 0xE3, 0x80, 0x1B, 0xCE, 0x1F, 0xDF, 0x3C,
  0xE3, 0x38, 0xE3, 0x30, 0xC3, 0x30, 0xC7, 0x31, 0xC6, 0x71, 0x86, 0x61,
  0x86, 0x61, 0x86, 0x61, 0x8E, 0xE3, 0x8C, 0xE3, 0x0C, 0x1B, 0xC3, 0xF8,
  0xF3, 0x9C, 0x63, 0x0C, 0x61, 0x9C, 0x33, 0x8E, 0x61, 0x8C, 0x31, 0x86,
  0x71, 0xCE, 0x38, 0x1F, 0x1F, 0xDC, 0x6C, 0x3E, 0x1F, 0x0F, 0x07, 0x83,
  0xC3, 0xE1, 0xB1, 0xDF, 0xC7, 0xC0, 0x0D, 0xE0, 0xFE, 0x1E, 0x71, 0xC7,
  0x18, 0x71, 0x87, 0x18, 0x63, 0x86, 0x30, 0xE3, 0x0E, 0x39, 0xC7, 0xF8,
  0x7F, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x00, 0x1E,
  0xCF, 0xF7, 0x1D, 0x87, 0x61, 0xB8, 0x6C, 0x1B, 0x0E, 0xC3, 0xB0, 0xCC,
  0x73, 0xEC, 0x7F, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x1B,
  0x8F, 0x8F, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C,
  0x0E, 0x00, 0x1F, 0x9F, 0x8C, 0x4E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06,
  0x03, 0x21, 0x9F, 0xCF, 0xC0, 0x18, 0x30, 0xC3, 0xFF, 0xCE, 0x1C, 0x30,
  0x60, 0xC3, 0x86, 0x0C, 0x18, 0x3C, 0x78, 0x30, 0xCC, 0x37, 0x1D, 0x86,
  0x61, 0x98, 0x6E, 0x1B, 0x8E, 0xC3, 0x31, 0xCC, 0x73, 0xEC, 0xFB, 0x00,
  0xE1, 0xF8, 0x6E, 0x39, 0x8C, 0x67, 0x19, 0x86, 0xE1, 0xB0, 0x7C, 0x1E,
  0x07, 0x81, 0xC0, 0x70, 0x00, 0xE3, 0x8F, 0xC7, 0x1B, 0x9E, 0x37, 0x3C,
  0xEE, 0x59, 0x9D, 0xB7, 0x3B, 0x6C, 0x7C, 0xD8, 0xF9, 0xE1, 0xA3, 0xC3,
  0xC7, 0x87, 0x8E, 0x0E, 0x1C, 0x00, 0x18, 0x71, 0xCE, 0x1D, 0xC0, 0xD8,
  0x0F, 0x80, 0xF0, 0x0E, 0x00, 0xE0, 0x1B, 0x03, 0xB0, 0x33, 0x06, 0x38,
  0xE3, 0x80, 0x1C, 0x38, 0x61, 0x83, 0x1C, 0x18, 0xC0, 0xCE, 0x06, 0x60,
  0x37, 0x01, 0xB0, 0x0D, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x38, 0x07, 0x80, 0x30, 0x00, 0x1F, 0xC7, 0xF0,
  0x38, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x07, 0x01, 0xFC,
  0xFE, 0x00, 0x03, 0xC1, 0xE0, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30,
  0x1C, 0x1E, 0x0E, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xE0, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E,
  0x0F, 0x01, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x03, 0xC0, 0xC1,
  0xC1, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x1C, 0x1E, 0x0C, 0x00, 0x78,
  0x7F, 0xF8, 0x78,
};

const GFXglyph NotoSans_Condensed_MediumItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 17, 6, 0, -17 },
  { 14, 8, 6, 9, 2, -17 },
  { 20, 13, 17, 12, 0, -17 },
  { 48, 11, 19, 11, 0, -18 },
  { 75, 15, 17, 17, 1, -17 },
  { 107, 12, 17, 13, 0, -17 },
  { 133, 4, 6, 5, 2, -17 },
  { 136, 7, 21, 7, 1, -17 },
  { 155, 8, 21, 7, -2, -17 },
  { 176, 9, 9, 10, 2, -18 },
  { 187, 10, 11, 12, 1, -14 },
  { 201, 5, 6, 5, -1, -3 },
  { 205, 6, 3, 7, 0, -8 },
  { 208, 3, 3, 5, 0, -3 },
  { 210, 11, 17, 9, -1, -17 },
  { 234, 10, 17, 11, 1, -17 },
  { 256, 7, 17, 11, 3, -17 },
  { 271, 12, 17, 11, -1, -17 },
  { 297, 11, 17, 11, 0, -17 },
  { 321, 11, 17, 11, 0, -17 },
  { 345, 11, 17, 11, 0, -17 },
  { 369, 10, 17, 11, 1, -17 },
  { 391, 11, 17, 11, 1, -17 },
  { 415, 11, 17, 11, 0, -17 },
  { 439, 11, 17, 11, 0, -17 },
  { 463, 5, 13, 6, 0, -13 },
  { 472, 6, 16, 6, -1, -13 },
  { 484, 10, 11, 12, 1, -14 },
  { 498, 10, 7, 12, 1, -12 },
  { 507, 10, 11, 12, 1, -14 },
  { 521, 8, 17, 8, 1, -17 },
  { 538, 15, 19, 16, 1, -17 },
  { 574, 11, 17, 11, -1, -17 },
  { 598, 12, 17, 12, 0, -17 },
  { 624, 12, 17, 11, 1, -17 },
  { 650, 12, 17, 13, 0, -17 },
  { 676, 11, 17, 10, 0, -17 },
  { 700, 11, 17, 10, 0, -17 },
  { 724, 13, 17, 13, 1, -17 },
  { 752, 14, 17, 13, 0, -17 },
  { 782, 10, 17, 7, -1, -17 },
  { 804, 10, 22, 6, -4, -17 },
  { 832, 13, 17, 11, 0, -17 },
  { 860, 8, 17, 9, 0, -17 },
  { 877, 18, 17, 17, 0, -17 },
  { 916, 15, 17, 14, 0, -17 },
  { 948, 12, 17, 14, 1, -17 },
  { 974, 12, 17, 11, 0, -17 },
  { 1000, 12, 21, 14, 1, -17 },
  { 1032, 12, 17, 11, 0, -17 },
  { 1058, 11, 17, 10, 0, -17 },
  { 1082, 10, 17, 10, 2, -17 },
  { 1104, 13, 17, 13, 1, -17 },
  { 1132, 11, 17, 11, 2, -17 },
  { 1156, 17, 17, 17, 2, -17 },
  { 1193, 13, 17, 11, -1, -17 },
  { 1221, 10, 17, 10, 2, -17 },
  { 1243, 12, 17, 10, -1, -17 },
  { 1269, 10, 21, 7, -1, -17 },
  { 1296, 5, 17, 9, 2, -17 },
  { 1307, 10, 21, 7, -2, -17 },
  { 1334, 11, 10, 11, 0, -17 },
  { 1348, 8, 2, 8, -2, 2 },
  { 1350, 4, 3, 7, 3, -18 },
  { 1352, 10, 13, 11, 1, -13 },
  { 1369, 11, 18, 11, 0, -18 },
  { 1394, 8, 13, 9, 1, -13 },
  { 1407, 11, 18, 12, 1, -18 },
  { 1432, 9, 13, 10, 1, -13 },
  { 1447, 12, 24, 7, -3, -18 },
  { 1483, 11, 19, 12, 0, -13 },
  { 1510, 11, 18, 11, 0, -18 },
  { 1535, 6, 18, 5, 0, -18 },
  { 1549, 9, 24, 5, -3, -18 },
  { 1576, 11, 18, 10, 0, -18 },
  { 1601, 6, 18, 5, 0, -18 },
  { 1615, 16, 13, 17, 0, -13 },
  { 1641, 11, 13, 11, 0, -13 },
  { 1659, 9, 13, 11, 1, -13 },
  { 1674, 12, 19, 11, -1, -13 },
  { 1703, 10, 19, 11, 1, -13 },
  { 1727, 9, 13, 8, 0, -13 },
  { 1742, 9, 13, 9, 0, -13 },
  { 1757, 7, 16, 7, 1, -16 },
  { 1771, 10, 13, 11, 1, -13 },
  { 1788, 10, 13, 9, 1, -13 },
  { 1805, 15, 13, 15, 1, -13 },
  { 1830, 12, 13, 10, -1, -13 },
  { 1850, 13, 19, 10, -2, -13 },
  { 1881, 10, 13, 8, -1, -13 },
  { 1898, 10, 21, 8, 0, -17 },
  { 1925, 2, 24, 10, 4, -18 },
  { 1931, 9, 21, 8, -1, -17 },
  { 1955, 10, 3, 12, 1, -10 },
};

const GFXfont NotoSans_Condensed_MediumItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC24PT7B_H_
