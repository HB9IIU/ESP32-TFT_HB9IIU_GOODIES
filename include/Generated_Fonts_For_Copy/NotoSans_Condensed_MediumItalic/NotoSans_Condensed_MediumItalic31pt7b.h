#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC31PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x18, 0x18, 0x38, 0x38, 0x30, 0x00, 0x00, 0x70, 0x70, 0xF0, 0xF0, 0x73,
  0xDC, 0xE7, 0x39, 0x8E, 0x63, 0x38, 0xCE, 0x73, 0x1C, 0x00, 0xC6, 0x01,
  0xC6, 0x01, 0x8E, 0x01, 0x8C, 0x03, 0x8C, 0x03, 0x1C, 0x1F, 0xFF, 0x3F,
  0xFF, 0x06, 0x38, 0x06, 0x30, 0x0E, 0x30, 0x0C, 0x70, 0x0C, 0x60, 0x7F,
  0xFC, 0xFF, 0xFC, 0x18, 0xE0, 0x18, 0xC0, 0x38, 0xC0, 0x31, 0xC0, 0x31,
  0x80, 0x71, 0x80, 0x63, 0x80, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0xFE,
  0x07, 0xFC, 0x3F, 0xE1, 0xC8, 0x87, 0x20, 0x1C, 0x80, 0x76, 0x01, 0xF8,
  0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xDC, 0x02, 0x70, 0x09,
  0xC8, 0x67, 0x39, 0xB8, 0xFF, 0xE3, 0xFF, 0x01, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x1E, 0x03, 0x8F, 0xC1, 0xC7, 0x30, 0x61, 0x8C, 0x38,
  0x63, 0x0C, 0x38, 0xC6, 0x0C, 0x33, 0x83, 0x1C, 0xC0, 0xC6, 0x71, 0x31,
  0x99, 0xFC, 0xEC, 0xFF, 0xF7, 0x73, 0x79, 0x98, 0xC0, 0xEE, 0x30, 0x33,
  0x8C, 0x1C, 0xC3, 0x0E, 0x31, 0xC3, 0x0C, 0x61, 0xC3, 0x18, 0x60, 0xCE,
  0x38, 0x3F, 0x1C, 0x07, 0x80, 0x01, 0xF0, 0x03, 0xF8, 0x07, 0x38, 0x06,
  0x18, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x87, 0x3B, 0xCE, 0x79, 0xCE, 0x71, 0xFC, 0xF0,
  0xFC, 0xE0, 0xF8, 0xE0, 0x78, 0xE0, 0xF8, 0xF3, 0xF8, 0x7F, 0xBC, 0x3F,
  0x1C, 0x7B, 0x9C, 0xE6, 0x33, 0x98, 0x03, 0xC0, 0xC0, 0x70, 0x38, 0x0C,
  0x07, 0x01, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x18, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x18,
  0x0E, 0x00, 0x04, 0x00, 0xE0, 0x18, 0x23, 0x0F, 0x63, 0xFF, 0xC7, 0xF8,
  0xF0, 0x3F, 0x0E, 0x61, 0xCE, 0x11, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x83, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x3C, 0xE3, 0x9C, 0x71, 0x8E, 0x30,
  0xFF, 0xFF, 0xF8, 0x77, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x7F, 0x83, 0x9C, 0x38, 0x73, 0xC3, 0x9C, 0x1C, 0xE0, 0xEE, 0x07,
  0x70, 0x3B, 0x83, 0x9C, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x83, 0x9C,
  0x1C, 0xE1, 0xE7, 0x0E, 0x38, 0xF1, 0xEF, 0x07, 0xF0, 0x1F, 0x00, 0x03,
  0x83, 0xC7, 0xE7, 0xFF, 0xF3, 0xB9, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0x03, 0xF8, 0x0F, 0xF8, 0x3C, 0xF0, 0x20, 0xF0, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0xE0, 0xE3, 0xC2,
  0x0F, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x3F, 0x80,
  0xF8, 0x03, 0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0xC8, 0x1E, 0x39, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x06, 0xE0, 0x33, 0x01, 0xDC, 0x06,
  0x70, 0x31, 0xC1, 0xC7, 0x0E, 0x38, 0x30, 0xE1, 0xC3, 0x8E, 0x0E, 0x3F,
  0xFE, 0xFF, 0xF8, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x1F, 0x80, 0x7F, 0x83, 0xFF, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC8, 0x1E, 0x39, 0xF0, 0xFF,
  0xC3, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0xC1, 0xE2, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x73, 0xC3, 0xFF, 0x1F, 0xF8, 0xF1, 0xEF, 0x07,
  0x70, 0x3B, 0x81, 0xDC, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x70, 0xE7, 0x87,
  0xF8, 0x1F, 0x80, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xE3, 0xC3,
  0x87, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC3, 0x8E, 0x0E, 0x70, 0x1F, 0x80,
  0x7C, 0x07, 0xF0, 0x3C, 0xE1, 0xE1, 0xC7, 0x07, 0x38, 0x1C, 0xE0, 0x73,
  0x81, 0xCF, 0x07, 0x1E, 0x78, 0x7F, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x3F,
  0xE0, 0xF3, 0x87, 0x0E, 0x1C, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0E, 0x38,
  0x38, 0xE0, 0xE3, 0x87, 0x8F, 0xFE, 0x1F, 0xB8, 0x3D, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x31, 0xE0, 0xFF, 0x03, 0xF8, 0x00,
  0x0C, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x3C, 0x78, 0xE0, 0x03, 0x03, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x70, 0x38, 0x38, 0x1C, 0x1C,
  0x0E, 0x0E, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0x80, 0x04, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x0F, 0x01, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0x00,
  0x60, 0x00, 0x1F, 0xC7, 0xF8, 0xC7, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xF8, 0x03, 0x81, 0xC0, 0x60, 0x0E, 0x0C, 0x00, 0x61, 0x80, 0x06,
  0x38, 0x7E, 0x73, 0x0F, 0xE7, 0x71, 0x8C, 0x76, 0x38, 0xC6, 0x63, 0x0C,
  0x66, 0x71, 0xC6, 0xE7, 0x18, 0x6C, 0x61, 0x8E, 0xC6, 0x38, 0xCC, 0x63,
  0x9C, 0xC7, 0x7F, 0x8C, 0x3D, 0xF0, 0xC1, 0x04, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x78, 0x01, 0xFF, 0x80, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1B, 0x80,
  0x77, 0x00, 0xEE, 0x03, 0x9C, 0x07, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0xE1,
  0xC1, 0xFF, 0x87, 0xFF, 0x0E, 0x0E, 0x1C, 0x1C, 0x70, 0x1C, 0xE0, 0x3B,
  0x80, 0x77, 0x00, 0xFE, 0x01, 0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x38, 0xF8,
  0x70, 0x70, 0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x8E, 0x0F, 0x1C, 0x3C, 0x3F,
  0xF0, 0x7F, 0x80, 0xFF, 0xC3, 0x83, 0x87, 0x07, 0x8E, 0x07, 0x1C, 0x1E,
  0x78, 0x38, 0xE0, 0x71, 0xC1, 0xE3, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x07, 0xFC, 0x1E, 0x30, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03,
  0xF7, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xFE,
  0x0E, 0x0E, 0x0E, 0x0F, 0x0E, 0x07, 0x0E, 0x07, 0x1C, 0x07, 0x1C, 0x07,
  0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1E,
  0x38, 0x1C, 0x78, 0x3C, 0x70, 0x78, 0x70, 0xF0, 0x7F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1F,
  0xF0, 0x7F, 0xC3, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xFF,
  0x07, 0xF8, 0x3F, 0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0xFF, 0x01, 0xFF,
  0xC1, 0xF1, 0xC1, 0xE0, 0x21, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x1F, 0x8E, 0x0F, 0xC7, 0x0F, 0xE7,
  0x80, 0xE3, 0xC0, 0x71, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x1E, 0x1E, 0x0E,
  0x0F, 0xDF, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0x01, 0xC1, 0xC0, 0xE0,
  0xF0, 0x38, 0x38, 0x0E, 0x0E, 0x03, 0x83, 0x81, 0xE0, 0xE0, 0x70, 0x70,
  0x1C, 0x1C, 0x07, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x38, 0x0E,
  0x0E, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x70, 0x78, 0x1C, 0x1C, 0x07, 0x07,
  0x01, 0xC1, 0xC0, 0x70, 0x70, 0x38, 0x3C, 0x0E, 0x00, 0x0F, 0xF0, 0xFF,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0xFF, 0x0F, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x03, 0xF0,
  0x1F, 0x81, 0xF0, 0x00, 0x07, 0x07, 0x83, 0x87, 0x83, 0x83, 0x81, 0xC3,
  0x80, 0xE3, 0xC0, 0x73, 0xC0, 0x39, 0xC0, 0x39, 0xC0, 0x1D, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xDC, 0x01, 0xCE, 0x00, 0xE3, 0x80,
  0x71, 0xC0, 0x78, 0xE0, 0x38, 0x70, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x07,
  0x07, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78,
  0x1C, 0x07, 0x01, 0xFF, 0x7F, 0xFF, 0xF0, 0x07, 0x80, 0x3E, 0x0F, 0x00,
  0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1B,
  0x83, 0x70, 0x76, 0x0E, 0xE0, 0xFC, 0x1D, 0xC3, 0xB8, 0x3B, 0x87, 0x70,
  0x77, 0x1C, 0xE0, 0xCE, 0x3B, 0x83, 0x9C, 0xE7, 0x07, 0x39, 0xCE, 0x0E,
  0x77, 0x1C, 0x1C, 0xEE, 0x38, 0x71, 0xD8, 0xE0, 0xE1, 0xF1, 0xC1, 0xC3,
  0xC3, 0x83, 0x87, 0x87, 0x06, 0x0E, 0x0C, 0x1C, 0x1C, 0x38, 0x00, 0x07,
  0x80, 0xE0, 0xF0, 0x18, 0x3E, 0x07, 0x07, 0xC0, 0xE0, 0xFC, 0x1C, 0x1F,
  0x83, 0x83, 0x70, 0xE0, 0xEE, 0x1C, 0x1C, 0xC3, 0x83, 0x9C, 0x70, 0x73,
  0x8E, 0x0C, 0x73, 0x83, 0x86, 0x70, 0x70, 0xEE, 0x0E, 0x1D, 0xC1, 0xC3,
  0xB0, 0x70, 0x7E, 0x0E, 0x07, 0xC1, 0xC0, 0xF8, 0x38, 0x1F, 0x06, 0x03,
  0xC1, 0xC0, 0x38, 0x00, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0x9E, 0x0E, 0x0F,
  0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x78, 0x07, 0x70, 0x07,
  0x70, 0x07, 0x70, 0x0F, 0x70, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E,
  0xF0, 0x1C, 0x70, 0x3C, 0x70, 0x78, 0x7D, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0,
  0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x70, 0xF0, 0xE0, 0xE1, 0xC1, 0xC3,
  0x83, 0x8E, 0x07, 0x1C, 0x1E, 0x38, 0x38, 0x71, 0xE0, 0xFF, 0xC3, 0xFE,
  0x07, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0x9E,
  0x0E, 0x0F, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x78, 0x07,
  0x70, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x70, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E,
  0xF0, 0x1E, 0xF0, 0x1C, 0x70, 0x3C, 0x70, 0x78, 0x7D, 0xF0, 0x3F, 0xE0,
  0x1F, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x07, 0xF0, 0x0F, 0xF8, 0x39, 0xF0, 0x70, 0xF0, 0xE0, 0xE1, 0xC1, 0xC3,
  0x83, 0x8E, 0x0F, 0x1C, 0x1C, 0x38, 0x78, 0x7F, 0xE0, 0xFF, 0x83, 0xFC,
  0x07, 0x38, 0x0E, 0x38, 0x1C, 0x70, 0x78, 0xE0, 0xE1, 0xC1, 0xC1, 0xC3,
  0x83, 0x87, 0x07, 0x1C, 0x0F, 0x00, 0x03, 0xFC, 0x3F, 0xF0, 0xFB, 0x87,
  0x82, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x88, 0x1E, 0x3F, 0xF0, 0xFF, 0xC3, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x07, 0x8F, 0x03, 0x87, 0x01,
  0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x70, 0xF0, 0x38, 0x70, 0x1C, 0x38,
  0x0E, 0x1C, 0x0F, 0x0E, 0x07, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xE1,
  0xC0, 0xE0, 0xE0, 0x70, 0xF0, 0x38, 0x78, 0x3C, 0x1C, 0x1C, 0x0F, 0xFE,
  0x07, 0xFE, 0x00, 0xFC, 0x00, 0xE0, 0x1F, 0x80, 0xEE, 0x03, 0xB8, 0x1C,
  0xE0, 0x73, 0x83, 0x8E, 0x0E, 0x38, 0x78, 0xE1, 0xC3, 0x87, 0x0E, 0x38,
  0x38, 0xE0, 0xE7, 0x03, 0x9C, 0x0E, 0xE0, 0x3B, 0x80, 0xEC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x1F, 0x81,
  0xC0, 0xEE, 0x07, 0x03, 0xB8, 0x3C, 0x0E, 0xE0, 0xF0, 0x73, 0x87, 0xC1,
  0xCE, 0x1B, 0x0E, 0x38, 0xEC, 0x38, 0xE3, 0xB0, 0xE3, 0x8C, 0xC7, 0x0E,
  0x73, 0x1C, 0x39, 0x8C, 0xE0, 0xEE, 0x33, 0x83, 0xB8, 0xCE, 0x0E, 0xC3,
  0x70, 0x3F, 0x0D, 0xC0, 0xD8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xC0,
  0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x83, 0xC0,
  0xE0, 0xE0, 0x38, 0x70, 0x0E, 0x3C, 0x03, 0x8E, 0x00, 0x77, 0x00, 0x1D,
  0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x77, 0x00, 0x3D, 0xC0, 0x0E, 0x70, 0x07,
  0x0E, 0x03, 0xC3, 0x80, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x0F, 0x00, 0xE0,
  0x7F, 0x03, 0xB8, 0x39, 0xC1, 0xCE, 0x1C, 0x39, 0xE1, 0xCE, 0x0E, 0xE0,
  0x77, 0x03, 0xF0, 0x1F, 0x80, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x00, 0x07,
  0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x07, 0xE0, 0xFC, 0x00, 0xE3, 0x86,
  0x18, 0x61, 0xC7, 0x1C, 0x71, 0xC3, 0x0C, 0x38, 0xE3, 0x8E, 0x38, 0x61,
  0x86, 0x1C, 0x70, 0x07, 0xF0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x3E, 0x00, 0xF8, 0x07, 0x60, 0x19, 0x80, 0xE7, 0x07, 0x0C, 0x1C, 0x30,
  0xE0, 0xE3, 0x03, 0x9C, 0x06, 0xE0, 0x1C, 0xFF, 0xFF, 0xFC, 0xEE, 0x77,
  0x30, 0x07, 0x9C, 0x3F, 0x61, 0xFF, 0x8F, 0x1E, 0x38, 0x79, 0xC1, 0xE7,
  0x07, 0x1C, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0E, 0x38, 0x38, 0xE0, 0xE3,
  0x87, 0x8F, 0x3E, 0x1F, 0xB0, 0x7C, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xBC, 0x1D, 0xF8, 0x7F,
  0xF1, 0xE1, 0xC7, 0x07, 0x1C, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0F, 0x38,
  0x38, 0xE0, 0xE7, 0x03, 0x9C, 0x1C, 0x78, 0xF1, 0xE7, 0x8E, 0xFC, 0x3B,
  0xE0, 0x07, 0xE1, 0xFC, 0x7F, 0x1E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x43, 0xF8, 0x3F,
  0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x03, 0xCE, 0x0F, 0xF8, 0x3F, 0xF0, 0xF1, 0xE1, 0xC3, 0xC7,
  0x07, 0x8E, 0x0E, 0x1C, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC1, 0xC3, 0x83,
  0x87, 0x07, 0x0E, 0x1E, 0x1E, 0x7C, 0x1F, 0xB0, 0x3E, 0x60, 0x07, 0xC0,
  0xFE, 0x1E, 0xF3, 0x87, 0x38, 0x77, 0x06, 0x70, 0xEF, 0xFC, 0xFF, 0x8F,
  0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x87, 0xF8, 0x3F, 0x80,
  0x00, 0x0E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x03, 0xCE, 0x0F, 0xD8, 0x3F, 0xF0, 0xF1, 0xE1, 0xC3, 0xC7,
  0x07, 0x8E, 0x0E, 0x1C, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC1, 0xC3, 0x83,
  0x87, 0x0F, 0x0E, 0x1E, 0x1E, 0xFC, 0x1F, 0xF0, 0x3E, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x18, 0x78, 0x3F, 0xE0, 0x7F, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xBC, 0x1D, 0xF8, 0x7F, 0xE1, 0xE3, 0xC7, 0x07, 0x1C, 0x38, 0xE0, 0xE3,
  0x83, 0x8E, 0x0E, 0x38, 0x38, 0xE1, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x71,
  0xC1, 0xCE, 0x0E, 0x38, 0x38, 0x07, 0x07, 0x0F, 0x06, 0x00, 0x00, 0x0E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70,
  0x70, 0x70, 0xE0, 0xE0, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0xF8, 0x0F,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x87, 0x1C, 0x38, 0x71, 0xE1, 0xCF, 0x07, 0x38, 0x1D, 0xC0,
  0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xEE, 0x07, 0x1C, 0x1C, 0x70,
  0x71, 0xC1, 0xC7, 0x8E, 0x0E, 0x38, 0x38, 0x07, 0x07, 0x07, 0x07, 0x0E,
  0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0x0C, 0xF0, 0xF0, 0xEF, 0xDF,
  0x87, 0xFF, 0xFE, 0x3C, 0x7C, 0x71, 0xC3, 0xC3, 0x8E, 0x1C, 0x1C, 0xE0,
  0xE1, 0xC7, 0x07, 0x0E, 0x38, 0x38, 0x71, 0xC3, 0x83, 0x8E, 0x1C, 0x1C,
  0xE0, 0xE1, 0xC7, 0x07, 0x0E, 0x38, 0x30, 0x71, 0xC3, 0x83, 0x9C, 0x1C,
  0x1C, 0xE0, 0xE1, 0xC0, 0x0C, 0xF0, 0x77, 0xE1, 0xFF, 0xC7, 0x8F, 0x1C,
  0x1C, 0x70, 0xE3, 0xC3, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x87, 0x1C,
  0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x38, 0x38, 0xE0, 0xE0, 0x07, 0xC0,
  0xFE, 0x1F, 0xF3, 0x87, 0x38, 0x77, 0x07, 0x70, 0x7F, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x1E, 0xF3, 0xC7, 0xF8, 0x3F, 0x00,
  0x06, 0x78, 0x1D, 0xF8, 0x3F, 0xF8, 0x78, 0x70, 0xE0, 0xE1, 0xC1, 0xC7,
  0x83, 0x8E, 0x07, 0x1C, 0x1E, 0x38, 0x38, 0x70, 0x71, 0xC0, 0xE3, 0x83,
  0x87, 0x8F, 0x0F, 0x3C, 0x1B, 0xF0, 0x73, 0xC0, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0x9C, 0x3F,
  0x61, 0xFF, 0x8F, 0x1E, 0x38, 0x79, 0xC1, 0xE7, 0x07, 0x1C, 0x1C, 0xE0,
  0x73, 0x81, 0xCE, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x87, 0x8F, 0x3E, 0x1F,
  0xB0, 0x7D, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x0C, 0xE3, 0xBC, 0x7F, 0x8F, 0x81, 0xE0, 0x38, 0x0F,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x00, 0x07, 0xC3, 0xFC, 0xFF, 0x9C, 0x03, 0x80, 0x70, 0x0F,
  0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x31, 0xE7,
  0xF8, 0xFE, 0x00, 0x0E, 0x06, 0x07, 0x07, 0xF7, 0xF3, 0xF8, 0xE0, 0x70,
  0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x72, 0x3F,
  0x0F, 0x80, 0x1C, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x98, 0x39,
  0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x87, 0x38, 0x39, 0xC1, 0xCE, 0x1E, 0x70,
  0xF3, 0xCF, 0x1F, 0xD8, 0x7C, 0xC0, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x1C,
  0xE1, 0xCE, 0x38, 0xE3, 0x8E, 0x70, 0xE7, 0x0E, 0x60, 0xEE, 0x0E, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0x70, 0x00, 0xE1, 0xE0, 0xFC, 0x3C,
  0x3B, 0x87, 0x87, 0x71, 0xF1, 0xCE, 0x3E, 0x39, 0xCF, 0xC6, 0x39, 0xB9,
  0xC7, 0x37, 0x38, 0xEE, 0xEE, 0x1D, 0x9D, 0xC3, 0xF3, 0xB0, 0x7C, 0x7E,
  0x0D, 0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0x80, 0xE0, 0xF0,
  0x00, 0x1C, 0x1E, 0x1C, 0x38, 0x38, 0xE0, 0x73, 0x80, 0xE7, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3F, 0x00, 0xEE, 0x01,
  0xDC, 0x07, 0x38, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0xE0, 0x07, 0x03, 0x83,
  0x83, 0x81, 0xC1, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0xE0, 0x1C, 0x70,
  0x0E, 0x30, 0x07, 0x38, 0x03, 0x9C, 0x00, 0xDC, 0x00, 0x6E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78,
  0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x4F, 0xF8,
  0xFF, 0x80, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x38, 0x03, 0x80, 0x38, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x7C, 0x07, 0x00, 0xF8,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x3E, 0x01, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x7C, 0x03, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xF0, 0x0F, 0x03, 0xE0, 0x78, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0xFC, 0x0F, 0x80, 0xF0, 0x00,
  0x3C, 0x0F, 0xFC, 0xFB, 0xFF, 0x03, 0xE0,
};

const GFXglyph NotoSans_Condensed_MediumItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 22, 8, 0, -22 },
  { 23, 10, 8, 12, 3, -22 },
  { 33, 16, 22, 16, 0, -22 },
  { 77, 14, 26, 14, 0, -24 },
  { 123, 18, 22, 21, 2, -22 },
  { 173, 16, 22, 16, 0, -22 },
  { 217, 5, 8, 7, 3, -22 },
  { 222, 10, 27, 9, 1, -22 },
  { 256, 10, 27, 9, -2, -22 },
  { 290, 11, 12, 13, 3, -24 },
  { 307, 13, 14, 15, 1, -18 },
  { 330, 6, 8, 7, -1, -4 },
  { 336, 7, 3, 9, 1, -10 },
  { 339, 4, 4, 7, 0, -4 },
  { 341, 15, 22, 11, -2, -22 },
  { 383, 13, 22, 14, 1, -22 },
  { 419, 9, 22, 14, 3, -22 },
  { 444, 15, 22, 14, -1, -22 },
  { 486, 14, 22, 14, 0, -22 },
  { 525, 14, 22, 14, 0, -22 },
  { 564, 14, 22, 14, 0, -22 },
  { 603, 13, 22, 14, 1, -22 },
  { 639, 14, 22, 14, 1, -22 },
  { 678, 14, 22, 14, 0, -22 },
  { 717, 14, 22, 14, 0, -22 },
  { 756, 7, 17, 7, 0, -17 },
  { 771, 9, 21, 7, -2, -17 },
  { 795, 13, 14, 15, 1, -18 },
  { 818, 13, 8, 15, 1, -15 },
  { 831, 13, 14, 15, 1, -18 },
  { 854, 11, 22, 11, 1, -22 },
  { 885, 20, 25, 21, 1, -22 },
  { 948, 15, 22, 15, -2, -22 },
  { 990, 15, 22, 15, 0, -22 },
  { 1032, 15, 22, 14, 1, -22 },
  { 1074, 16, 22, 17, 0, -22 },
  { 1118, 14, 22, 13, 0, -22 },
  { 1157, 14, 22, 12, 0, -22 },
  { 1196, 17, 22, 17, 1, -22 },
  { 1243, 18, 22, 17, 0, -22 },
  { 1293, 12, 22, 9, -1, -22 },
  { 1326, 13, 28, 7, -5, -22 },
  { 1372, 17, 22, 15, 0, -22 },
  { 1419, 10, 22, 12, 0, -22 },
  { 1447, 23, 22, 22, 0, -22 },
  { 1511, 19, 22, 18, 0, -22 },
  { 1564, 16, 22, 18, 1, -22 },
  { 1608, 15, 22, 15, 0, -22 },
  { 1650, 16, 27, 18, 1, -22 },
  { 1704, 15, 22, 15, 0, -22 },
  { 1746, 14, 22, 13, 0, -22 },
  { 1785, 12, 22, 13, 3, -22 },
  { 1818, 17, 22, 17, 1, -22 },
  { 1865, 14, 22, 14, 3, -22 },
  { 1904, 22, 22, 23, 3, -22 },
  { 1965, 18, 22, 14, -2, -22 },
  { 2015, 13, 22, 13, 3, -22 },
  { 2051, 15, 22, 13, -1, -22 },
  { 2093, 12, 27, 9, -1, -22 },
  { 2134, 6, 22, 11, 3, -22 },
  { 2151, 12, 27, 9, -2, -22 },
  { 2192, 14, 13, 14, 0, -22 },
  { 2215, 11, 2, 10, -3, 3 },
  { 2218, 4, 5, 8, 5, -24 },
  { 2221, 14, 17, 15, 1, -17 },
  { 2251, 14, 24, 15, 0, -24 },
  { 2293, 11, 17, 12, 1, -17 },
  { 2317, 15, 24, 15, 1, -24 },
  { 2362, 12, 17, 13, 1, -17 },
  { 2388, 16, 31, 8, -4, -24 },
  { 2450, 15, 24, 15, 0, -17 },
  { 2495, 14, 24, 15, 0, -24 },
  { 2537, 8, 23, 7, 0, -23 },
  { 2560, 12, 30, 7, -4, -23 },
  { 2605, 14, 24, 13, 0, -24 },
  { 2647, 8, 24, 7, 0, -24 },
  { 2671, 21, 17, 22, 0, -17 },
  { 2716, 14, 17, 15, 0, -17 },
  { 2746, 12, 17, 14, 1, -17 },
  { 2772, 15, 24, 15, -1, -17 },
  { 2817, 14, 24, 15, 1, -17 },
  { 2859, 11, 17, 10, 0, -17 },
  { 2883, 11, 17, 11, 0, -17 },
  { 2907, 9, 20, 9, 1, -20 },
  { 2930, 13, 17, 15, 1, -17 },
  { 2958, 12, 17, 12, 2, -17 },
  { 2984, 19, 17, 19, 2, -17 },
  { 3025, 15, 17, 13, -1, -17 },
  { 3057, 17, 24, 12, -3, -17 },
  { 3108, 12, 17, 11, -1, -17 },
  { 3134, 12, 27, 10, 0, -22 },
  { 3175, 3, 31, 13, 5, -24 },
  { 3187, 12, 27, 10, -2, -22 },
  { 3228, 13, 4, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_MediumItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC31PT7B_H_
