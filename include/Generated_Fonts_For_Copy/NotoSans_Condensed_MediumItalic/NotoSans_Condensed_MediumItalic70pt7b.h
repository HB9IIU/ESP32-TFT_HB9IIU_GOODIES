#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC70PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0xFC,
  0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x1F, 0x81, 0xF8,
  0xFC, 0x1F, 0xC7, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81,
  0xF8, 0xFC, 0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x07, 0xE1, 0xF0, 0x3F, 0x1F,
  0x81, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xDF, 0xC0, 0x1F, 0xC7, 0x87, 0x80, 0x7F, 0x0E, 0x02, 0x00,
  0xFE, 0x1C, 0x00, 0x01, 0xF8, 0x38, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x07,
  0xE1, 0xE0, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0x1F, 0x87, 0x00, 0x00, 0x3F,
  0x8E, 0x00, 0x00, 0x7F, 0x3C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0x3F,
  0xC0, 0x00, 0x0E, 0x3F, 0x80, 0x00, 0x1C, 0x7F, 0x00, 0x00, 0x78, 0x7E,
  0x00, 0x00, 0xF0, 0xFC, 0x00, 0x01, 0xC1, 0xF8, 0x00, 0x03, 0x83, 0xF0,
  0x00, 0x07, 0x0F, 0xE0, 0x00, 0x1E, 0x1F, 0xC1, 0x80, 0x38, 0x7F, 0x03,
  0xC0, 0x71, 0xFE, 0x07, 0xF0, 0xEF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xF0,
  0x03, 0xF9, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0xF8,
  0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x00, 0x7E, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0x07,
  0xC0, 0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x83, 0xF0, 0x00, 0x7C, 0x07,
  0xC0, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0x7C, 0x1F,
  0x00, 0x03, 0xE0, 0x3F, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x87, 0xE0, 0x38,
  0x3E, 0x03, 0xE1, 0xF0, 0x7F, 0x8F, 0x81, 0xF8, 0xFC, 0x3F, 0xF3, 0xE0,
  0x7C, 0x3E, 0x3F, 0xFE, 0xF8, 0x3F, 0x1F, 0x0F, 0xFF, 0xBF, 0x0F, 0x8F,
  0xC7, 0xE7, 0xFF, 0xCF, 0xE3, 0xE3, 0xF0, 0xFD, 0xFF, 0xF1, 0xF8, 0xF8,
  0x3F, 0x7F, 0xF8, 0x7C, 0x7E, 0x07, 0xCF, 0xFC, 0x3F, 0x1F, 0x01, 0xF1,
  0xFE, 0x1F, 0x87, 0xC0, 0x7C, 0x1C, 0x07, 0xC3, 0xF0, 0x3F, 0x00, 0x03,
  0xF0, 0xF8, 0x0F, 0xC0, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x00, 0x7E, 0x1F,
  0x80, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x0F,
  0x80, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x00,
  0xFC, 0x07, 0xC0, 0x7C, 0x00, 0x7E, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x00,
  0x7C, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC1,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x3F, 0x00,
  0x3E, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xC0,
  0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xFB, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x10, 0x1F, 0xFF, 0x80,
  0x7E, 0x03, 0xFB, 0xF8, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x0F, 0xE1,
  0xFC, 0x0F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0x83,
  0xF8, 0x0F, 0xF3, 0xF8, 0x3F, 0x00, 0x7F, 0x3F, 0x07, 0xF0, 0x07, 0xFF,
  0xF0, 0x7F, 0x00, 0x3F, 0xFE, 0x07, 0xE0, 0x03, 0xFF, 0xE0, 0x7E, 0x00,
  0x1F, 0xFC, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0xFE, 0x00, 0x0F, 0xF8, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xFF,
  0x80, 0x7F, 0x80, 0xFF, 0xF8, 0x07, 0xFC, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x9F, 0xE0, 0x1F, 0xFF, 0xF1, 0xFE, 0x00,
  0xFF, 0xFC, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xC7, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x3F,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0x00, 0x7C, 0x00, 0xE0, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x8F, 0x00, 0x3F, 0xF7, 0x81, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFB, 0xE0, 0x01,
  0xFD, 0xF8, 0x01, 0xFC, 0x7C, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x1F, 0x80,
  0x7E, 0x07, 0xE0, 0x1E, 0x03, 0xF0, 0x06, 0x01, 0xFC, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xF8, 0x1E, 0x1F, 0x9F,
  0xDF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0xFE, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0x7F, 0xC0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83,
  0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0,
  0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07,
  0xF1, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0,
  0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07,
  0xF1, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xDF,
  0xCF, 0xF1, 0xF8, 0xFE, 0x1F, 0x87, 0xC3, 0xF8, 0x38, 0x3F, 0x82, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0x01, 0xFF, 0x00,
  0x1E, 0x00, 0x7F, 0x80, 0x06, 0x00, 0x1F, 0xC0, 0x02, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xE3, 0xFF,
  0x80, 0x3E, 0x00, 0xFF, 0x00, 0x30, 0x01, 0xFE, 0x00, 0x40, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x04, 0x00, 0x03, 0xFC, 0x0E,
  0x00, 0x1F, 0xF0, 0x1F, 0x81, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xFD, 0xFC, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x07, 0xC3, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0xE0, 0x01,
  0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x1F, 0xC0, 0x1F,
  0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x80, 0x00, 0xFF, 0x80, 0xE0, 0x01, 0xFF, 0x00, 0xFE,
  0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x06, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xFC, 0x7F, 0xE0,
  0x03, 0xF9, 0xFF, 0xE0, 0x07, 0xE7, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0x03,
  0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF3, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x07,
  0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x3F,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0x7F, 0x07, 0xF0,
  0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xFE, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F,
  0x80, 0xFF, 0xC0, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xDF, 0x80, 0x3F, 0xFC, 0x7E, 0x00, 0x7F, 0xE3,
  0xF8, 0x00, 0x3C, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x03, 0xC1, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xF0, 0x0F, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0x87, 0xFC, 0x0E, 0x00, 0xFF, 0x02, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x0F,
  0x80, 0x1F, 0xFE, 0x07, 0xC0, 0xFC, 0x01, 0xFF, 0xF8, 0x1E, 0x07, 0xC0,
  0x3F, 0xFF, 0xC0, 0xF8, 0x7E, 0x03, 0xFF, 0xFC, 0x07, 0xC3, 0xE0, 0x1F,
  0x83, 0xE0, 0x3E, 0x1F, 0x01, 0xF8, 0x1F, 0x01, 0xE1, 0xF0, 0x1F, 0x81,
  0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0xC0, 0x7C,
  0x07, 0xC7, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x3E, 0x07, 0xE0, 0x3F, 0x01,
  0xF1, 0xF0, 0x3E, 0x01, 0xF0, 0x0F, 0x9F, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0x07, 0xE0, 0x3E, 0x3E,
  0x07, 0xC0, 0x3E, 0x01, 0xF1, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x0F, 0x81,
  0xF0, 0x1F, 0x80, 0xF8, 0xFC, 0x1F, 0x80, 0xFC, 0x07, 0xC7, 0xC0, 0xFC,
  0x07, 0xE0, 0x7C, 0x3E, 0x07, 0xE0, 0x7E, 0x03, 0xE1, 0xF0, 0x3F, 0x03,
  0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x3F, 0xC3, 0xE0, 0x7C, 0x07, 0xE7, 0xFE,
  0x3F, 0x03, 0xE0, 0x3F, 0xFC, 0xFF, 0xF0, 0x1F, 0x00, 0xFF, 0xC7, 0xFF,
  0x00, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x7E, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFC, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC,
  0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x03,
  0xF1, 0xFC, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x03,
  0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFF,
  0x01, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xEF,
  0xF0, 0x01, 0xFF, 0x80, 0x38, 0x00, 0xFF, 0x80, 0x02, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x06, 0x00, 0x0F, 0xFF, 0xBF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0xE0, 0x03, 0xF8, 0x07, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xE0,
  0x01, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x0F,
  0xE0, 0x07, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x81, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x00,
  0xC0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x1F, 0xFF, 0x83, 0xF8, 0x00, 0xFF, 0xFC, 0x1F, 0xC0, 0x07, 0xFF, 0xE0,
  0xFE, 0x00, 0x3F, 0xFF, 0x07, 0xF0, 0x01, 0xFF, 0xF0, 0x7F, 0x80, 0x1F,
  0xFF, 0x83, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x00, 0x7E, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00,
  0x7E, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xFF, 0xBF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x03, 0x8F, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x7F,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x03, 0xFB, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0x7C, 0x00,
  0x0F, 0xDF, 0xC0, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8,
  0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xE7,
  0xE0, 0x03, 0xF3, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x07, 0xF3, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x3F, 0x8F, 0xE0,
  0x07, 0xF1, 0xF8, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0xFC, 0x07, 0xE1,
  0xFC, 0x00, 0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0x80, 0x1F, 0x83, 0xF0, 0x3F,
  0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xC1,
  0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xF8, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x1F,
  0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x80, 0x0F, 0xC0,
  0x7E, 0x7E, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xDF, 0x80, 0xFE, 0x00, 0x7F,
  0x01, 0xFB, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0xFC, 0x03, 0xF0, 0x01,
  0xF8, 0x07, 0xFF, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0xFF, 0xE0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x1F, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x7F, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xFC, 0x01,
  0xF8, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x00,
  0x0F, 0xE0, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0xF0,
  0x03, 0xFF, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xC0,
  0x0F, 0xDF, 0x80, 0x0F, 0xE0, 0x0F, 0xEF, 0xC0, 0x07, 0xE0, 0x07, 0xE7,
  0xE0, 0x03, 0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0xFC, 0x01,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x00,
  0x7F, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0x83,
  0xF0, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x07,
  0xE0, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x83, 0xF8, 0x01,
  0xF8, 0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x03,
  0xF8, 0x7E, 0x00, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x3F,
  0x80, 0x1F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xE7, 0xE0, 0x07, 0xE0, 0x03, 0xF3, 0xF0, 0x03, 0xF0, 0x01,
  0xF9, 0xF8, 0x01, 0xF8, 0x00, 0xFD, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0x00, 0x07, 0xFF, 0x80, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0x01,
  0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0xF0,
  0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00,
  0x0F, 0xF3, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xCF, 0xF0,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFC,
  0x0F, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F,
  0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0,
  0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF8,
  0x07, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x0F, 0xF3, 0xF8,
  0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFE,
  0x7F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0x7F, 0x8F, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x0F,
  0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xC0,
  0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xC0, 0x1F, 0xF0, 0x0F, 0xE0, 0x7F, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0,
  0x01, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0xFF, 0x80, 0x04,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x10, 0x00, 0x0F, 0xF0, 0x0C, 0x00, 0x0F, 0xF0,
  0x07, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xC0,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xF9,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xFE, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xF0, 0x7F, 0x00, 0x1F, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xFF,
  0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F,
  0x7C, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0x80, 0xFE, 0x00,
  0xF9, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x3E, 0x00, 0xFE, 0x03, 0xF8,
  0x07, 0xE7, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xF8, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x3F, 0x1F, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xC3, 0xE0, 0x3F, 0x80,
  0x3F, 0x81, 0xF8, 0x7C, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x0F, 0x81, 0xFC,
  0x00, 0xFE, 0x0F, 0xC1, 0xF0, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x3E, 0x07,
  0xE0, 0x03, 0xF8, 0x7E, 0x07, 0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0xF8,
  0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x1F, 0x0F, 0xE0, 0x01, 0xFC, 0x7E, 0x03,
  0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x7C, 0x3F, 0x00, 0x07, 0xF3, 0xF0,
  0x0F, 0x8F, 0xE0, 0x00, 0xFE, 0x7E, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0xCF,
  0xC0, 0x3E, 0x7F, 0x00, 0x03, 0xF3, 0xF0, 0x07, 0xCF, 0xE0, 0x00, 0x7E,
  0x7E, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x1F, 0x7F, 0x00, 0x01,
  0xFB, 0xF0, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x7D, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0xFE, 0x00, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x00, 0x3F, 0xCF, 0xE0,
  0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xE7, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xFC,
  0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFC, 0x1F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x03, 0xF0,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x00,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x3F,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x1F, 0xE1, 0xFC,
  0x3F, 0xC3, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x80,
  0xF0, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x7F, 0xF0, 0xFC, 0x01, 0xFF, 0xF1,
  0xF8, 0x07, 0xFF, 0xF7, 0xE0, 0x1F, 0xFF, 0xEF, 0xC0, 0x7F, 0xF7, 0xFF,
  0x80, 0xFF, 0x03, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xF8,
  0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xC0,
  0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x03,
  0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0xE0, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0x87, 0xFF, 0x00, 0xFF, 0xFF, 0x7E,
  0x00, 0xFF, 0xFC, 0xFC, 0x01, 0xFF, 0xF1, 0xF8, 0x01, 0xFF, 0xC3, 0xE0,
  0x01, 0xFF, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00,
  0xFE, 0x3F, 0xF0, 0x01, 0xF9, 0xFF, 0xF0, 0x03, 0xF7, 0xFF, 0xF0, 0x0F,
  0xEF, 0xFF, 0xE0, 0x1F, 0xFE, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xC0, 0x7F,
  0xC0, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0xFE, 0x07, 0xF8,
  0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07,
  0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8,
  0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xC0, 0x7E, 0xFF, 0xFF, 0x80, 0xFD, 0xFF, 0xFE, 0x01, 0xF9,
  0xFF, 0xF8, 0x03, 0xE1, 0xFF, 0xE0, 0x0F, 0xC1, 0xFF, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xE7, 0xC0, 0x3F,
  0xC0, 0x20, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x80, 0x7F,
  0xC1, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x3F, 0xF8, 0xFE, 0x00, 0x1F,
  0xFF, 0x3F, 0x80, 0x0F, 0xFF, 0xEF, 0xC0, 0x07, 0xFF, 0xFB, 0xF0, 0x03,
  0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07,
  0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xF0,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xC0, 0x3F,
  0x80, 0x03, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xFF,
  0xBF, 0x00, 0x1F, 0xFF, 0xCF, 0xC0, 0x03, 0xFF, 0xE3, 0xF0, 0x00, 0x7F,
  0xF0, 0xF8, 0x00, 0x0F, 0xF8, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFC, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x3F, 0x80, 0x7F, 0x0F, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x00,
  0x3F, 0x8F, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x8F,
  0xE0, 0x1F, 0xE1, 0xF8, 0x0F, 0xF8, 0x7F, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x40,
  0x7F, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x20, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x87, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x0F, 0xC0, 0x01, 0xFF, 0xC3, 0xF0, 0x00, 0xFF, 0xF8, 0xFC,
  0x00, 0x7F, 0xFF, 0x7E, 0x00, 0x3F, 0xFF, 0xDF, 0x80, 0x1F, 0xF9, 0xFF,
  0xE0, 0x07, 0xF8, 0x1F, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0,
  0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x7F,
  0x81, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0xFE, 0x00, 0x1F, 0xFF, 0x3F, 0x80, 0x03, 0xFF, 0x8F, 0xC0,
  0x00, 0x7F, 0xC7, 0xF0, 0x00, 0x03, 0x81, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x08, 0x00, 0x0F, 0xE0, 0x03, 0x80, 0x07, 0xF8, 0x00, 0xF8,
  0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFE, 0x7F, 0xF0, 0x01,
  0xF9, 0xFF, 0xF0, 0x03, 0xF7, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0xFF,
  0x00, 0x7F, 0x03, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03,
  0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC,
  0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xC0,
  0x7E, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07,
  0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x7F,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7E, 0x03, 0xF0,
  0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x21, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x03,
  0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x0F,
  0xE0, 0x01, 0xF8, 0x1F, 0xE0, 0x01, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF1, 0xFC,
  0x00, 0x03, 0xF3, 0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x07, 0xEF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFB, 0xF8,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x01,
  0xF8, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0x07,
  0xCF, 0xFF, 0xC7, 0xFF, 0xE0, 0x1F, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x3F,
  0x7C, 0xFF, 0xFE, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0x80, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x07,
  0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x07,
  0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x1F, 0xE0, 0x01, 0xF8, 0xFF, 0xF0, 0x03, 0xE3, 0xFF,
  0xE0, 0x07, 0xCF, 0xFF, 0xE0, 0x1F, 0xBF, 0xFF, 0xC0, 0x3F, 0x7F, 0xFF,
  0xC0, 0x7F, 0xE0, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0x01, 0xFE, 0x00, 0xFE,
  0x07, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xE0,
  0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x3F,
  0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x7E, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03,
  0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF8,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF3, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x1F,
  0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC,
  0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0xC3, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F,
  0x83, 0xFC, 0x00, 0x07, 0xE1, 0xFF, 0x80, 0x01, 0xF9, 0xFF, 0xF0, 0x00,
  0x7C, 0xFF, 0xFE, 0x00, 0x1F, 0x7F, 0xFF, 0x80, 0x0F, 0xDF, 0x1F, 0xF0,
  0x03, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x03, 0xF8,
  0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0,
  0x1F, 0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFE,
  0xFF, 0xFE, 0x00, 0x3F, 0x3F, 0xFF, 0x00, 0x0F, 0xC7, 0xFF, 0x80, 0x03,
  0xF0, 0xFF, 0x80, 0x01, 0xFC, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x7F, 0xF0, 0xFC,
  0x01, 0xFF, 0xF1, 0xF8, 0x07, 0xFF, 0xF7, 0xE0, 0x1F, 0xFF, 0xEF, 0xC0,
  0x7F, 0xE7, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x07,
  0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0xFE,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xF0,
  0x3F, 0x80, 0x7F, 0xE0, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0x87, 0xFF, 0x00,
  0xFF, 0xFF, 0x7E, 0x01, 0xFF, 0xFD, 0xFC, 0x01, 0xFF, 0xF3, 0xF8, 0x01,
  0xFF, 0xC7, 0xE0, 0x01, 0xFF, 0x1F, 0xC0, 0x00, 0x70, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x1F, 0xE0, 0x0F, 0x8F, 0xF8,
  0x03, 0xE7, 0xFE, 0x01, 0xF9, 0xFF, 0x80, 0x7E, 0xFF, 0xC0, 0x1F, 0xFF,
  0x30, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0x07, 0xC0, 0x7F, 0x00, 0x30, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x08, 0x00, 0x3F, 0x83, 0x00,
  0x1F, 0xE0, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xE3, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0x83, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x08, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x01, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFE, 0x0F,
  0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x7E, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC0,
  0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80,
  0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xFE, 0xF8,
  0x07, 0xFF, 0xF3, 0xE0, 0x0F, 0xFF, 0x9F, 0x80, 0x3F, 0xFC, 0x7E, 0x00,
  0x7F, 0xE1, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x03,
  0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x00,
  0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x8F,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xCF, 0xC0, 0x01,
  0xFB, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80,
  0x1F, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xBF, 0x80, 0x7F, 0xE0, 0x0F,
  0xCF, 0xE0, 0x1F, 0xF8, 0x07, 0xF3, 0xF8, 0x07, 0xFE, 0x01, 0xF8, 0xFE,
  0x03, 0xEF, 0x80, 0xFE, 0x3F, 0x80, 0xFB, 0xE0, 0x3F, 0x8F, 0xE0, 0x7E,
  0xF8, 0x0F, 0xC3, 0xF8, 0x1F, 0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xDF, 0x81,
  0xF8, 0x3F, 0x83, 0xF7, 0xE0, 0xFE, 0x0F, 0xE0, 0xF9, 0xF8, 0x3F, 0x83,
  0xF8, 0x7E, 0x7E, 0x0F, 0xC0, 0xFE, 0x1F, 0x1F, 0x87, 0xF0, 0x3F, 0x07,
  0xC7, 0xE1, 0xF8, 0x0F, 0xC3, 0xF1, 0xF8, 0xFE, 0x03, 0xF0, 0xF8, 0x7E,
  0x3F, 0x00, 0xFC, 0x7E, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x07, 0xE7, 0xF0,
  0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x7E, 0x7E, 0x00, 0xFC,
  0xF8, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x01,
  0xF7, 0xE0, 0x03, 0xF7, 0xC0, 0x7D, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0x7E,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x07, 0xF1, 0xF8, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x83, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x08, 0xFF, 0xC0, 0x00, 0x4F, 0xFF, 0x80, 0x06, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0xC0, 0x01, 0xFF, 0xE4, 0x00, 0x03, 0xFC,
  0x00,
};

const GFXglyph NotoSans_Condensed_MediumItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 18, 51, 17, 1, -50 },
  { 116, 21, 18, 26, 7, -50 },
  { 164, 36, 50, 35, 1, -50 },
  { 389, 31, 57, 31, 1, -53 },
  { 610, 42, 52, 48, 4, -51 },
  { 883, 36, 52, 37, 0, -51 },
  { 1117, 10, 18, 15, 7, -50 },
  { 1140, 22, 61, 19, 2, -50 },
  { 1308, 22, 61, 19, -5, -50 },
  { 1476, 25, 28, 30, 7, -54 },
  { 1564, 29, 33, 34, 3, -41 },
  { 1684, 13, 17, 16, -3, -8 },
  { 1712, 17, 6, 20, 1, -22 },
  { 1725, 9, 10, 16, 1, -9 },
  { 1737, 33, 50, 25, -3, -50 },
  { 1944, 29, 52, 31, 2, -51 },
  { 2133, 20, 50, 31, 8, -50 },
  { 2258, 33, 51, 31, -2, -51 },
  { 2469, 31, 52, 31, 0, -51 },
  { 2671, 32, 50, 31, -1, -50 },
  { 2871, 32, 51, 31, 0, -50 },
  { 3075, 31, 52, 31, 2, -51 },
  { 3277, 31, 50, 31, 3, -50 },
  { 3471, 31, 52, 31, 1, -51 },
  { 3673, 30, 52, 31, 1, -51 },
  { 3868, 15, 39, 16, 0, -38 },
  { 3942, 20, 47, 16, -4, -38 },
  { 4060, 29, 32, 34, 3, -41 },
  { 4176, 29, 20, 34, 3, -35 },
  { 4249, 29, 32, 34, 3, -41 },
  { 4365, 25, 52, 24, 2, -51 },
  { 4528, 45, 56, 47, 2, -50 },
  { 4843, 33, 50, 33, -4, -50 },
  { 5050, 34, 50, 34, 1, -50 },
  { 5263, 34, 52, 32, 3, -51 },
  { 5484, 35, 50, 38, 1, -50 },
  { 5703, 31, 50, 29, 1, -50 },
  { 5897, 31, 50, 28, 1, -50 },
  { 6091, 37, 52, 39, 3, -51 },
  { 6332, 39, 50, 39, 1, -50 },
  { 6576, 28, 50, 21, -3, -50 },
  { 6751, 29, 64, 17, -11, -50 },
  { 6983, 38, 50, 33, 1, -50 },
  { 7221, 22, 50, 28, 1, -50 },
  { 7359, 51, 50, 50, 1, -50 },
  { 7678, 41, 50, 41, 1, -50 },
  { 7935, 36, 52, 40, 3, -51 },
  { 8169, 33, 50, 33, 1, -50 },
  { 8376, 36, 63, 40, 3, -51 },
  { 8660, 33, 50, 33, 1, -50 },
  { 8867, 33, 52, 30, -1, -51 },
  { 9082, 28, 50, 28, 6, -50 },
  { 9257, 37, 51, 38, 3, -50 },
  { 9493, 33, 50, 32, 6, -50 },
  { 9700, 51, 50, 51, 6, -50 },
  { 10019, 40, 50, 31, -4, -50 },
  { 10269, 30, 50, 29, 6, -50 },
  { 10457, 34, 50, 28, -2, -50 },
  { 10670, 27, 61, 20, -2, -50 },
  { 10876, 13, 50, 25, 7, -50 },
  { 10958, 27, 61, 20, -5, -50 },
  { 11164, 30, 29, 32, 1, -50 },
  { 11273, 24, 5, 23, -6, 6 },
  { 11288, 11, 12, 19, 10, -54 },
  { 11305, 31, 39, 33, 2, -38 },
  { 11457, 31, 54, 33, 0, -53 },
  { 11667, 26, 39, 26, 2, -38 },
  { 11794, 34, 54, 34, 2, -53 },
  { 12024, 27, 39, 30, 2, -38 },
  { 12156, 35, 71, 19, -8, -54 },
  { 12467, 34, 55, 34, -1, -38 },
  { 12701, 31, 53, 33, 0, -53 },
  { 12907, 18, 52, 16, 0, -52 },
  { 13024, 27, 69, 16, -9, -52 },
  { 13257, 32, 53, 29, 0, -53 },
  { 13469, 18, 53, 16, 0, -53 },
  { 13589, 47, 38, 49, 0, -38 },
  { 13813, 31, 38, 33, 0, -38 },
  { 13961, 28, 39, 32, 2, -38 },
  { 14098, 34, 55, 33, -3, -38 },
  { 14332, 31, 55, 33, 2, -38 },
  { 14546, 26, 38, 23, 0, -38 },
  { 14670, 26, 39, 25, 0, -38 },
  { 14797, 19, 47, 20, 3, -46 },
  { 14909, 30, 39, 33, 2, -38 },
  { 15056, 27, 38, 27, 4, -38 },
  { 15185, 42, 38, 43, 4, -38 },
  { 15385, 34, 38, 28, -3, -38 },
  { 15547, 37, 55, 28, -6, -38 },
  { 15802, 28, 38, 24, -2, -38 },
  { 15935, 27, 61, 24, 1, -50 },
  { 16141, 6, 69, 30, 12, -53 },
  { 16193, 26, 61, 24, -4, -50 },
  { 16392, 29, 10, 34, 3, -30 },
};

const GFXfont NotoSans_Condensed_MediumItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC70PT7B_H_
