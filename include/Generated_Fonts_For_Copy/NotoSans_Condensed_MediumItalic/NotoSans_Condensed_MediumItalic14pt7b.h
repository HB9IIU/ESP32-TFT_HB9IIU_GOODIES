#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC14PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x64, 0x40, 0xCC, 0x5A, 0x95, 0x20, 0x1A, 0x28, 0x53,
  0xF2, 0x45, 0x3F, 0x24, 0x51, 0xA0, 0x08, 0x23, 0xDC, 0x70, 0xC1, 0x86,
  0x2B, 0xE2, 0x08, 0x62, 0x96, 0x94, 0xA8, 0xAF, 0xD5, 0x15, 0x29, 0x4B,
  0xC6, 0x1C, 0x48, 0x91, 0x43, 0x0E, 0x77, 0xC6, 0xCC, 0xE8, 0x56, 0x19,
  0x88, 0xC4, 0x23, 0x18, 0xC6, 0x10, 0x80, 0x11, 0x11, 0x11, 0x11, 0x22,
  0x4C, 0x14, 0xBE, 0x65, 0x2C, 0x21, 0x3F, 0xF2, 0x10, 0x2D, 0x60, 0xF0,
  0x70, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x41, 0x80, 0x1C, 0x96,
  0x51, 0x45, 0x3C, 0xF2, 0x59, 0xC0, 0x3E, 0xA6, 0x64, 0x44, 0xCC, 0x7C,
  0x90, 0x43, 0x08, 0x63, 0x18, 0xC3, 0xE0, 0x3C, 0x90, 0x43, 0x38, 0x60,
  0x82, 0x9B, 0xC0, 0x0C, 0x31, 0xCB, 0x29, 0x28, 0xBF, 0x10, 0x40, 0x3C,
  0x82, 0x18, 0x78, 0x20, 0xC2, 0x9B, 0xC0, 0x1E, 0x60, 0x83, 0x07, 0x89,
  0x93, 0x66, 0x48, 0xE0, 0xFC, 0x21, 0x84, 0x30, 0x86, 0x10, 0xC2, 0x00,
  0x3C, 0x96, 0x4B, 0x39, 0xEC, 0xA3, 0xC9, 0xE0, 0x3D, 0x94, 0x51, 0x4D,
  0xF0, 0x82, 0x13, 0x80, 0x2C, 0x00, 0x36, 0x13, 0x00, 0x00, 0x26, 0x4C,
  0x09, 0xB1, 0x83, 0x04, 0xF8, 0x01, 0xF0, 0x83, 0x06, 0x36, 0x40, 0x7A,
  0x42, 0x33, 0x11, 0x00, 0x46, 0x00, 0x0F, 0x08, 0x48, 0x29, 0xD5, 0x2A,
  0x96, 0x53, 0x3E, 0x40, 0x20, 0x0F, 0x00, 0x0C, 0x18, 0x30, 0xA1, 0x66,
  0xCF, 0xB3, 0x47, 0x8C, 0x3C, 0x4C, 0x99, 0x37, 0xC9, 0x91, 0x22, 0xCD,
  0xF0, 0x3D, 0x94, 0x30, 0x82, 0x08, 0x20, 0xC1, 0xC0, 0x3C, 0x4C, 0x89,
  0x16, 0x28, 0x51, 0xA2, 0xCD, 0xE0, 0x3C, 0x82, 0x08, 0x79, 0x04, 0x10,
  0xC3, 0xE0, 0x3C, 0x82, 0x08, 0x61, 0xE4, 0x10, 0xC3, 0x00, 0x3E, 0xC5,
  0x06, 0x08, 0x13, 0xA3, 0x46, 0xC8, 0xF0, 0x31, 0x23, 0x22, 0x22, 0x7E,
  0x46, 0x46, 0x44, 0xC4, 0xC4, 0x3C, 0x61, 0x04, 0x10, 0xC3, 0x08, 0x23,
  0xC0, 0x0C, 0x20, 0x82, 0x18, 0x61, 0x04, 0x30, 0xC2, 0x38, 0xC0, 0x33,
  0x26, 0x2C, 0x28, 0x70, 0x78, 0x58, 0x48, 0xC8, 0xCC, 0x31, 0x08, 0x46,
  0x21, 0x08, 0xC7, 0xC0, 0x30, 0xCC, 0x33, 0x14, 0xC7, 0x72, 0x94, 0xA5,
  0x49, 0x76, 0xD9, 0xB2, 0x40, 0x31, 0x31, 0x31, 0x3B, 0x6B, 0x4A, 0x4A,
  0x4E, 0xCE, 0xC4, 0x3C, 0xCD, 0x1E, 0x38, 0x70, 0xE1, 0x46, 0xD9, 0xE0,
  0x3C, 0x4C, 0x99, 0x36, 0x4F, 0x10, 0x20, 0xC1, 0x80, 0x3C, 0xCD, 0x1E,
  0x38, 0x70, 0xE1, 0x46, 0xD9, 0xE0, 0x40, 0xC0, 0x3C, 0x4C, 0x99, 0x36,
  0xCF, 0x16, 0x24, 0xC9, 0x98, 0x3D, 0x96, 0x18, 0x30, 0x60, 0x82, 0x9B,
  0xC0, 0xFC, 0x82, 0x08, 0x61, 0x84, 0x10, 0x43, 0x00, 0x66, 0x8D, 0x16,
  0x2C, 0x51, 0xA3, 0x44, 0x99, 0xE0, 0xC7, 0x8B, 0x36, 0x4D, 0x9A, 0x3C,
  0x30, 0x60, 0x80, 0xCC, 0x73, 0x3C, 0xCB, 0x52, 0xD5, 0x3D, 0x4E, 0x72,
  0x98, 0xC6, 0x31, 0x00, 0x13, 0x12, 0x16, 0x1C, 0x18, 0x18, 0x38, 0x2C,
  0x64, 0xC4, 0xCF, 0x25, 0x94, 0x71, 0x84, 0x10, 0x43, 0x00, 0x3D, 0x30,
  0x86, 0x10, 0x86, 0x10, 0xC3, 0xE0, 0x39, 0x08, 0x46, 0x21, 0x08, 0xC4,
  0x21, 0xC0, 0xC9, 0x24, 0x9B, 0x24, 0x38, 0x42, 0x31, 0x08, 0x42, 0x31,
  0x09, 0xC0, 0x18, 0x62, 0x8A, 0x47, 0x10, 0xF8, 0xD4, 0x16, 0x79, 0x92,
  0x24, 0xD9, 0xB6, 0x34, 0x30, 0x82, 0x0A, 0x7D, 0x94, 0x51, 0x4F, 0x2B,
  0x80, 0x1C, 0xE6, 0x10, 0x43, 0x04, 0x1C, 0x02, 0x04, 0x18, 0xB3, 0xCC,
  0x91, 0x26, 0xCD, 0x91, 0xE0, 0x18, 0xB4, 0xD6, 0xF3, 0x04, 0x1E, 0x06,
  0x1C, 0x20, 0x61, 0xC3, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x1C, 0x00,
  0x16, 0x79, 0x92, 0x24, 0xD9, 0xB6, 0x34, 0x08, 0x33, 0xC0, 0x30, 0x82,
  0x0A, 0x7D, 0x94, 0x53, 0x4B, 0x2C, 0x80, 0x30, 0x26, 0x64, 0x44, 0xCC,
  0x0C, 0x00, 0x86, 0x18, 0x41, 0x04, 0x30, 0xC2, 0x08, 0xE0, 0x30, 0x40,
  0x81, 0x36, 0xCF, 0x14, 0x38, 0x51, 0xB3, 0x20, 0x32, 0x22, 0x66, 0x44,
  0x4C, 0xC0, 0x29, 0xBF, 0x59, 0x29, 0x94, 0xCA, 0x4F, 0x27, 0x92, 0x29,
  0xF6, 0x51, 0x4D, 0x3C, 0xB2, 0x18, 0xF4, 0x51, 0x47, 0x34, 0x9C, 0x14,
  0x7C, 0xC9, 0x12, 0x24, 0xD9, 0x3E, 0x40, 0x83, 0x00, 0x16, 0x79, 0x92,
  0x24, 0xD9, 0xB6, 0x34, 0x08, 0x30, 0x40, 0x2B, 0xD8, 0x84, 0x23, 0x18,
  0x33, 0x50, 0xC3, 0x0A, 0x5E, 0x23, 0x76, 0x44, 0x4C, 0x60, 0x26, 0xC9,
  0x92, 0x24, 0xC9, 0x36, 0x34, 0x8C, 0xE5, 0x6A, 0x53, 0x18, 0x99, 0x99,
  0xBA, 0xAA, 0xAE, 0xCC, 0xCC, 0xC8, 0x22, 0x68, 0x70, 0xC1, 0x85, 0x1A,
  0x66, 0x22, 0x4C, 0x91, 0x22, 0x85, 0x0C, 0x18, 0x20, 0x43, 0x00, 0x7B,
  0xC4, 0x66, 0x23, 0x1E, 0x1C, 0x41, 0x0C, 0x23, 0x8C, 0x18, 0x61, 0x04,
  0x18, 0xFF, 0xFF, 0xFF, 0xF0, 0x11, 0xC6, 0x21, 0x0C, 0x66, 0x21, 0x09,
  0xC0, 0xED, 0xC0,
};

const GFXglyph NotoSans_Condensed_MediumItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 10, 3, 0, -10 },
  { 6, 5, 4, 5, 1, -10 },
  { 9, 7, 10, 7, 0, -10 },
  { 18, 6, 12, 6, 0, -11 },
  { 27, 8, 10, 10, 1, -10 },
  { 37, 7, 10, 7, 0, -10 },
  { 46, 2, 4, 3, 1, -10 },
  { 47, 5, 12, 4, 0, -10 },
  { 55, 4, 12, 4, -1, -10 },
  { 61, 5, 6, 6, 1, -11 },
  { 65, 5, 6, 7, 1, -8 },
  { 69, 3, 4, 3, -1, -2 },
  { 71, 4, 1, 4, 0, -4 },
  { 72, 2, 2, 3, 0, -2 },
  { 73, 7, 10, 5, -1, -10 },
  { 82, 6, 10, 6, 0, -10 },
  { 90, 4, 10, 6, 2, -10 },
  { 95, 6, 10, 6, 0, -10 },
  { 103, 6, 10, 6, 0, -10 },
  { 111, 6, 10, 6, 0, -10 },
  { 119, 6, 10, 6, 0, -10 },
  { 127, 7, 10, 6, 0, -10 },
  { 136, 6, 10, 6, 1, -10 },
  { 144, 6, 10, 6, 0, -10 },
  { 152, 6, 10, 6, 0, -10 },
  { 160, 3, 8, 3, 0, -8 },
  { 163, 4, 10, 3, -1, -8 },
  { 168, 5, 6, 7, 1, -8 },
  { 172, 5, 4, 7, 1, -7 },
  { 175, 5, 6, 7, 1, -8 },
  { 179, 5, 10, 5, 0, -10 },
  { 186, 9, 11, 9, 0, -10 },
  { 199, 7, 10, 7, -1, -10 },
  { 208, 7, 10, 7, 0, -10 },
  { 217, 6, 10, 6, 1, -10 },
  { 225, 7, 10, 8, 0, -10 },
  { 234, 6, 10, 6, 0, -10 },
  { 242, 6, 10, 6, 0, -10 },
  { 250, 7, 10, 8, 1, -10 },
  { 259, 8, 10, 8, 0, -10 },
  { 269, 6, 10, 4, -1, -10 },
  { 277, 6, 13, 3, -2, -10 },
  { 287, 8, 10, 7, 0, -10 },
  { 297, 5, 10, 6, 0, -10 },
  { 304, 10, 10, 10, 0, -10 },
  { 317, 8, 10, 8, 0, -10 },
  { 327, 7, 10, 8, 1, -10 },
  { 336, 7, 10, 7, 0, -10 },
  { 345, 7, 12, 8, 1, -10 },
  { 356, 7, 10, 7, 0, -10 },
  { 365, 6, 10, 6, 0, -10 },
  { 373, 6, 10, 6, 1, -10 },
  { 381, 7, 10, 8, 1, -10 },
  { 390, 7, 10, 7, 1, -10 },
  { 399, 10, 10, 10, 1, -10 },
  { 412, 8, 10, 6, -1, -10 },
  { 422, 6, 10, 6, 1, -10 },
  { 430, 6, 10, 6, 0, -10 },
  { 438, 5, 12, 4, 0, -10 },
  { 446, 3, 10, 5, 1, -10 },
  { 450, 5, 12, 4, -1, -10 },
  { 458, 6, 6, 6, 0, -10 },
  { 463, 5, 1, 5, -1, 1 },
  { 464, 2, 3, 4, 2, -11 },
  { 465, 7, 8, 7, 0, -8 },
  { 472, 6, 11, 7, 0, -11 },
  { 481, 6, 8, 5, 0, -8 },
  { 487, 7, 11, 7, 0, -11 },
  { 497, 6, 8, 6, 0, -8 },
  { 503, 7, 14, 4, -2, -11 },
  { 516, 7, 11, 7, 0, -8 },
  { 526, 6, 11, 7, 0, -11 },
  { 535, 4, 10, 3, 0, -10 },
  { 540, 6, 13, 3, -2, -10 },
  { 550, 7, 11, 6, 0, -11 },
  { 560, 4, 11, 3, 0, -11 },
  { 566, 9, 8, 10, 0, -8 },
  { 575, 6, 8, 7, 0, -8 },
  { 581, 6, 8, 7, 0, -8 },
  { 587, 7, 11, 7, -1, -8 },
  { 597, 7, 11, 7, 0, -8 },
  { 607, 5, 8, 5, 0, -8 },
  { 612, 5, 8, 5, 0, -8 },
  { 617, 4, 9, 4, 0, -9 },
  { 622, 7, 8, 7, 0, -8 },
  { 629, 5, 8, 5, 1, -8 },
  { 634, 8, 8, 9, 1, -8 },
  { 642, 7, 8, 6, -1, -8 },
  { 649, 7, 11, 6, -1, -8 },
  { 659, 5, 8, 5, 0, -8 },
  { 664, 6, 12, 5, 0, -10 },
  { 673, 2, 14, 6, 2, -11 },
  { 677, 5, 12, 5, -1, -10 },
  { 685, 5, 2, 7, 1, -6 },
};

const GFXfont NotoSans_Condensed_MediumItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC14PT7B_H_
