#ifndef _NOTOSANS_CONDENSED_MEDIUMITALIC47PT7B_H_
#define _NOTOSANS_CONDENSED_MEDIUMITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-MediumItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_MediumItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xC0, 0x00, 0x3C, 0x7D, 0xF1,
  0xF7, 0xC7, 0xDE, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x8F, 0x3C, 0x3C, 0xF0,
  0xF3, 0xC3, 0xCF, 0x0E, 0x38, 0x38, 0xE1, 0xE0, 0x00, 0x0E, 0x0E, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0x80, 0x03, 0xC1, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x78,
  0x00, 0x38, 0x38, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x87, 0x07, 0x00, 0x07, 0x83, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xC1,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x70, 0x00, 0x38,
  0x38, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x0F,
  0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x78, 0x00,
  0x38, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xEE, 0x70, 0x3E, 0x60, 0x81, 0xE3, 0x00,
  0x0F, 0x18, 0x00, 0xF9, 0xC0, 0x07, 0xCE, 0x00, 0x1E, 0x60, 0x00, 0xFB,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xDF, 0x00, 0x0C, 0xF8, 0x00, 0x63,
  0xC0, 0x03, 0x1E, 0x00, 0x38, 0xF0, 0x01, 0xCF, 0x84, 0x0C, 0x7C, 0x3C,
  0x6F, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x7F, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xC0, 0x03, 0x80, 0xFE, 0x00, 0x78, 0x1F, 0xF0, 0x07,
  0x01, 0xEF, 0x00, 0xF0, 0x3C, 0x78, 0x1E, 0x03, 0x87, 0x81, 0xC0, 0x78,
  0x78, 0x3C, 0x07, 0x07, 0x83, 0x80, 0x70, 0x70, 0x78, 0x0F, 0x07, 0x0F,
  0x00, 0xF0, 0x70, 0xE0, 0x0E, 0x0F, 0x1E, 0x00, 0xE0, 0xF1, 0xC0, 0x0E,
  0x0E, 0x3C, 0x10, 0xE1, 0xE7, 0x8F, 0xCE, 0x1E, 0x79, 0xFE, 0xE3, 0xCF,
  0x3F, 0xEF, 0x7C, 0xE7, 0x8F, 0xFF, 0x9E, 0x78, 0xF7, 0xF3, 0xCF, 0x0F,
  0x3E, 0x3C, 0xF0, 0xF0, 0x07, 0x8E, 0x0F, 0x00, 0x70, 0xE0, 0xF0, 0x0F,
  0x1E, 0x0E, 0x00, 0xE1, 0xE0, 0xE0, 0x1E, 0x1E, 0x1E, 0x03, 0xC1, 0xC1,
  0xE0, 0x38, 0x1C, 0x1C, 0x07, 0x81, 0xC3, 0xC0, 0x70, 0x1C, 0x3C, 0x0F,
  0x01, 0xE7, 0x81, 0xE0, 0x1F, 0xF0, 0x1C, 0x00, 0xFF, 0x03, 0xC0, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0xF0, 0x01, 0xE1, 0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xE3, 0xE0, 0x01, 0xE3,
  0xC0, 0x01, 0xE7, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0x1F, 0x3E,
  0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1F, 0x3C, 0x7C, 0x1F, 0x7C, 0x78, 0x0F,
  0x78, 0x78, 0x0F, 0xF8, 0xF8, 0x0F, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x07,
  0xE0, 0xF8, 0x0F, 0xE0, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xF8, 0xF8, 0x1F, 0xF0, 0xFC, 0x3D, 0xF7, 0xDF, 0x79, 0xE7,
  0x9E, 0xF3, 0xCF, 0x38, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0xE8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x20, 0xF0, 0x1E, 0x38, 0x07, 0xEE, 0x07,
  0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x3E, 0x1C, 0x1F, 0xC0, 0x0F,
  0x70, 0x07, 0x9E, 0x07, 0xE7, 0x80, 0xF0, 0xF0, 0x18, 0x3E, 0x02, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x87, 0xC3, 0xC3,
  0xE1, 0xE1, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x1C, 0x1E, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xE3, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0xF8, 0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x1F,
  0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x7C, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xC7, 0x80,
  0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8,
  0x0F, 0x07, 0x81, 0xF0, 0x78, 0x3E, 0x07, 0xC7, 0xE0, 0x7F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x1F,
  0x80, 0xFE, 0x07, 0xF8, 0x7F, 0xE3, 0xFF, 0x1F, 0xBC, 0xF8, 0xF1, 0xC7,
  0xC2, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xE0, 0xF8, 0x07, 0x01, 0xF0,
  0x10, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3C, 0x1F, 0x81, 0x80, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x03,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x08, 0x00, 0xF8, 0x60, 0x1F, 0x83,
  0xF7, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x77, 0x80, 0x03, 0xFC, 0x00, 0x1E, 0xF0,
  0x00, 0x73, 0xC0, 0x03, 0xDF, 0x00, 0x1E, 0x7C, 0x00, 0x71, 0xE0, 0x03,
  0xC7, 0x80, 0x1E, 0x1E, 0x00, 0xF0, 0xF8, 0x03, 0xC3, 0xE0, 0x1E, 0x0F,
  0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1F, 0x03,
  0xC0, 0x78, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xBE, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x20, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x08, 0x01,
  0xF8, 0x60, 0x1F, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xCF, 0xE0, 0x7D, 0xFF, 0x07, 0xBF, 0xF0, 0x7F, 0xFF, 0x8F, 0xE0, 0xF8,
  0xFC, 0x0F, 0x8F, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0x78, 0xF0, 0x07,
  0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x0F, 0x01,
  0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x3E, 0x0F, 0x81,
  0xE0, 0x7C, 0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x07,
  0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x3C, 0x3E, 0x01, 0xF3, 0xF0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0,
  0x3F, 0x1F, 0x03, 0xF0, 0x7C, 0x1F, 0x03, 0xE1, 0xF0, 0x0F, 0x0F, 0x00,
  0x78, 0x78, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF1, 0xF0, 0x07, 0x87,
  0x80, 0x7C, 0x3E, 0x07, 0xC1, 0xFC, 0x7E, 0x07, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0xFE, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0x01, 0xE1, 0xF0, 0x1F,
  0x1E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01,
  0xE3, 0xC0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7E, 0x3E, 0x0F, 0xE3, 0xF1,
  0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xBC, 0x0F, 0xF7, 0xC0, 0x38, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x01, 0x81, 0xF0, 0x7C, 0x3F, 0x0F, 0xC1,
  0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x1F, 0x07, 0xC3, 0xF0, 0xFC,
  0x1E, 0x00, 0x00, 0x60, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x0F, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x1C, 0x3F, 0x10, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x3C, 0x1C, 0x01, 0xC0, 0x70, 0xF0, 0x3F, 0xE1, 0xC3, 0x81,
  0xFF, 0x87, 0x1E, 0x0F, 0x1E, 0x1C, 0x70, 0x78, 0x70, 0x73, 0xC3, 0xC1,
  0xC1, 0xCE, 0x0E, 0x0F, 0x07, 0x38, 0x78, 0x3C, 0x1D, 0xE1, 0xE0, 0xE0,
  0xF7, 0x87, 0x03, 0x83, 0x9C, 0x3C, 0x1E, 0x0E, 0x70, 0xF0, 0x78, 0x39,
  0xC3, 0xC1, 0xC1, 0xE7, 0x0F, 0x0F, 0x07, 0x1C, 0x3C, 0x3C, 0x3C, 0xF0,
  0xF1, 0xF0, 0xE3, 0xC3, 0xCF, 0xE7, 0x07, 0x07, 0xF3, 0xFC, 0x1C, 0x1F,
  0x8F, 0xE0, 0x70, 0x1C, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x40,
  0x01, 0xF8, 0x0F, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x0F,
  0x9E, 0x00, 0x3C, 0x78, 0x01, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1F,
  0x00, 0xF8, 0x7C, 0x03, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x78, 0x1F, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0x80,
  0x7C, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x7C,
  0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xDF, 0x00, 0x0F, 0x7C, 0x00, 0x3F, 0xE0,
  0x00, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x1E, 0x1F, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0,
  0x1F, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01,
  0xE0, 0x7C, 0x07, 0xC0, 0xF0, 0x1F, 0x01, 0xE1, 0xFC, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3C, 0x3F, 0x80, 0x78, 0x0F, 0x81,
  0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xF8, 0x07, 0xC1, 0xE0, 0x0F, 0x83, 0xC0,
  0x3E, 0x0F, 0x81, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xC3, 0x80, 0x7E, 0x01, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x60, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xE0, 0x7E,
  0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xC0, 0x1F,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1F,
  0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F,
  0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x3C, 0x07, 0xE0, 0x7C, 0x3F, 0xC0,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x04, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xC1, 0xE0,
  0x1F, 0x80, 0x10, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x07,
  0xFC, 0x3E, 0x03, 0xFE, 0x3E, 0x01, 0xFF, 0x1F, 0x01, 0xFF, 0x8F, 0x80,
  0x07, 0x87, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x3E, 0x07,
  0xC0, 0x1F, 0x03, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0xF8,
  0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x80,
  0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3C, 0x07, 0xC0, 0x0F,
  0x01, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80,
  0x1E, 0x03, 0xE0, 0x0F, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x78, 0x01, 0xF0,
  0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1E, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0x03,
  0xE0, 0x3C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x01, 0xF0,
  0x03, 0xC0, 0x78, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03,
  0xE0, 0x07, 0x80, 0xF8, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0x1E, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x0F, 0x87, 0xE0, 0x07, 0x83, 0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xE3, 0xE0,
  0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0x3D, 0xF0,
  0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xF7, 0x80, 0x03, 0xF3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F,
  0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0x78, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xBF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x1F,
  0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x7F, 0x80, 0x1F,
  0xF0, 0x1F, 0xF0, 0x07, 0xBE, 0x03, 0xEE, 0x00, 0xF7, 0x80, 0x79, 0xE0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0xBE, 0x01, 0xE7, 0x81, 0xE7, 0xC0, 0x7C,
  0xF0, 0x3C, 0xF0, 0x0F, 0x1E, 0x0F, 0x1E, 0x01, 0xE3, 0xC1, 0xE3, 0xC0,
  0x3C, 0x78, 0x78, 0xF8, 0x07, 0x8F, 0x0F, 0x1F, 0x01, 0xF1, 0xE3, 0xE3,
  0xC0, 0x3C, 0x3C, 0x78, 0x78, 0x07, 0x87, 0x9F, 0x0F, 0x00, 0xF0, 0xF3,
  0xC3, 0xE0, 0x3E, 0x1E, 0x78, 0x7C, 0x07, 0xC3, 0xDE, 0x0F, 0x00, 0xF0,
  0x7B, 0xC1, 0xE0, 0x1E, 0x0F, 0xF0, 0x7C, 0x03, 0xC0, 0xFE, 0x0F, 0x80,
  0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3C, 0x03, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0xF0, 0x1F, 0x80, 0x0F, 0x01, 0xF8, 0x00, 0xF0, 0x1F, 0xC0, 0x1F,
  0x01, 0xFC, 0x01, 0xF0, 0x3F, 0xC0, 0x1E, 0x03, 0xFC, 0x01, 0xE0, 0x3F,
  0xC0, 0x1E, 0x03, 0xFE, 0x03, 0xE0, 0x3D, 0xE0, 0x3E, 0x07, 0xDE, 0x03,
  0xC0, 0x79, 0xE0, 0x3C, 0x07, 0x9F, 0x07, 0xC0, 0x78, 0xF0, 0x7C, 0x07,
  0x8F, 0x07, 0x80, 0xF8, 0xF0, 0x78, 0x0F, 0x8F, 0x07, 0x80, 0xF0, 0xF8,
  0xF8, 0x0F, 0x07, 0x8F, 0x80, 0xF0, 0x78, 0xF0, 0x1F, 0x07, 0x8F, 0x01,
  0xE0, 0x7C, 0xF0, 0x1E, 0x03, 0xDF, 0x01, 0xE0, 0x3D, 0xF0, 0x3E, 0x03,
  0xDE, 0x03, 0xE0, 0x3D, 0xE0, 0x3C, 0x03, 0xFE, 0x03, 0xC0, 0x1F, 0xE0,
  0x3C, 0x01, 0xFC, 0x07, 0xC0, 0x1F, 0xC0, 0x7C, 0x01, 0xFC, 0x07, 0x80,
  0x0F, 0xC0, 0x78, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xF8, 0x7E,
  0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0x7E, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1E, 0x7F, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x81,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E,
  0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF0, 0x0F, 0x81, 0xE0, 0x3F, 0x07, 0xC0,
  0x7C, 0x0F, 0x83, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC,
  0x01, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xF8, 0x7E, 0x07, 0xE0, 0x3E, 0x07,
  0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x01, 0xF8, 0xFC, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7E, 0x0F, 0xE0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xC7,
  0xF8, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x07, 0x80, 0x7C,
  0x1E, 0x01, 0xE0, 0xF8, 0x07, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3C,
  0x03, 0xE0, 0xF0, 0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03,
  0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1,
  0xF0, 0x1E, 0x03, 0xE0, 0x78, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8,
  0x3E, 0x01, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x00, 0x00, 0x1F, 0xC0,
  0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0x8F, 0x03, 0xF0,
  0x08, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x08, 0x01,
  0xF8, 0x70, 0x1F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0x81, 0xF0, 0x03, 0xC0, 0xF0, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x78, 0x1F, 0x00,
  0x7C, 0x0F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x07, 0x81, 0xE0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0xF0, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x0F, 0x81, 0xE0, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8,
  0x1F, 0x00, 0x78, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x7E, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3C, 0xF8, 0x01,
  0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xC3,
  0xE0, 0x1F, 0x07, 0x80, 0x78, 0x1E, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x7C, 0x07, 0x81, 0xE0, 0x1E, 0x0F, 0x80, 0x78, 0x3E, 0x01, 0xE1, 0xF0,
  0x07, 0x87, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0xF8, 0x01, 0xE3, 0xC0, 0x07,
  0x9F, 0x00, 0x1E, 0x78, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x00, 0x07, 0xBC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xFE, 0x00, 0x78, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0x7B, 0xE0, 0x0F,
  0x80, 0x3E, 0xF8, 0x07, 0xE0, 0x0F, 0x3E, 0x01, 0xF8, 0x07, 0xCF, 0x80,
  0x7E, 0x01, 0xF3, 0xE0, 0x3F, 0x80, 0x78, 0xF8, 0x0F, 0xE0, 0x3E, 0x3E,
  0x07, 0xF8, 0x0F, 0x0F, 0x81, 0xFE, 0x07, 0xC3, 0xE0, 0x77, 0x81, 0xF0,
  0xF8, 0x3D, 0xE0, 0x78, 0x3E, 0x0F, 0x78, 0x3E, 0x0F, 0x87, 0x9E, 0x0F,
  0x03, 0xE1, 0xE7, 0x87, 0xC0, 0xF8, 0xF1, 0xE1, 0xE0, 0x3E, 0x3C, 0x78,
  0x78, 0x0F, 0x8F, 0x1E, 0x3E, 0x03, 0xE7, 0x87, 0x8F, 0x00, 0xF9, 0xE1,
  0xE7, 0xC0, 0x3C, 0xF0, 0x79, 0xE0, 0x0F, 0x3C, 0x1E, 0x78, 0x03, 0xCF,
  0x07, 0xBE, 0x00, 0xF7, 0x81, 0xEF, 0x00, 0x3D, 0xE0, 0x7F, 0xC0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0x00, 0x3C, 0x07, 0xC0,
  0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE1,
  0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x1F, 0x78, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x1E, 0x00,
  0x3E, 0x03, 0xE0, 0x07, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x1F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x03,
  0xE7, 0x80, 0x7C, 0x78, 0x07, 0xC7, 0x80, 0xF8, 0x7C, 0x0F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1E, 0x03, 0xC3, 0xE0, 0x3C, 0x7C, 0x03, 0xC7, 0xC0, 0x3C,
  0xF8, 0x03, 0xCF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0x78, 0x07, 0x87, 0x80,
  0xF0, 0x78, 0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0xC3, 0xC0, 0x1E,
  0x3C, 0x01, 0xE7, 0x80, 0x1E, 0xF8, 0x00, 0xEF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF1, 0xF3, 0xE3, 0xC3, 0xC3, 0x87, 0x00,
  0x78, 0x00, 0x0F, 0xF3, 0xC0, 0xFF, 0x9E, 0x0F, 0xFF, 0xF0, 0xFC, 0x7F,
  0x07, 0xC1, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0,
  0x0F, 0x0F, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1,
  0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03,
  0xE1, 0xF0, 0x1F, 0x0F, 0x81, 0xF8, 0x3E, 0x1F, 0xC1, 0xFB, 0xFE, 0x0F,
  0xFD, 0xE0, 0x3F, 0xCF, 0x00, 0xFC, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0xE0, 0x0F, 0x9F, 0xC0, 0x7D, 0xFF, 0x03, 0xDF, 0xF8, 0x1F, 0xC7, 0xE0,
  0xFC, 0x1F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1E, 0x01,
  0xF0, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xC0, 0x1E, 0x1E,
  0x00, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xC3, 0xE0, 0x3E,
  0x1F, 0x01, 0xF1, 0xF8, 0x1F, 0x0F, 0xC1, 0xF0, 0x7F, 0xBF, 0x83, 0xFF,
  0xF8, 0x1C, 0xFF, 0x81, 0xE3, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xC1, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x02, 0x07, 0xF7, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x01,
  0xE1, 0xE0, 0x0F, 0xF3, 0xC0, 0x3F, 0xEF, 0x80, 0xFF, 0xFF, 0x03, 0xF1,
  0xFC, 0x07, 0xC1, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0xF8, 0x07,
  0xC1, 0xF0, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8,
  0x3E, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x3E,
  0x1F, 0xC0, 0x7E, 0x77, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xBC, 0x00, 0xFC,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x0F,
  0xC3, 0xC3, 0xE0, 0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x01,
  0xF7, 0xC1, 0xF9, 0xF7, 0xFC, 0x7F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x87, 0xE1, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x03, 0xFC, 0xF0, 0x1F, 0xFB, 0xC0, 0xFF, 0xFF, 0x07, 0xE3, 0xF8,
  0x1F, 0x07, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C,
  0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07,
  0x83, 0xC0, 0x1E, 0x0F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87,
  0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0xC0, 0xF8, 0x7F, 0x03, 0xF7,
  0xFC, 0x0F, 0xFD, 0xE0, 0x1F, 0xE7, 0x80, 0x3F, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x80, 0x7E, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0xE0, 0x0F, 0x9F, 0xC0,
  0x7F, 0xFF, 0x03, 0xDF, 0xF8, 0x1F, 0xC7, 0xE0, 0xFC, 0x1F, 0x0F, 0xC0,
  0xF8, 0x7C, 0x07, 0x83, 0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0xF0, 0x1F, 0x0F,
  0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xC0, 0x3C, 0x1E, 0x01, 0xE1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0x7C, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE1, 0xF0,
  0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x03, 0xE1,
  0xF0, 0x1F, 0x00, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0,
  0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x41, 0xF0,
  0x3E, 0x07, 0xC1, 0xF0, 0x1E, 0x07, 0x80, 0x78, 0x3E, 0x01, 0xE1, 0xF0,
  0x0F, 0x8F, 0x80, 0x3E, 0x7C, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x80, 0x0F,
  0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7C, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x80, 0x3C, 0x3E, 0x00,
  0xF0, 0x78, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x78, 0x1F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x70, 0x07, 0x9F, 0xE1, 0xFC, 0x07, 0xBF, 0xF3,
  0xFE, 0x07, 0xBF, 0xF7, 0xFE, 0x07, 0xF1, 0xFE, 0x3E, 0x07, 0xE1, 0xFC,
  0x1F, 0x0F, 0xC0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x1E, 0x0F, 0x81, 0xF0,
  0x1E, 0x0F, 0x01, 0xF0, 0x1E, 0x0F, 0x01, 0xF0, 0x3E, 0x1F, 0x01, 0xE0,
  0x3E, 0x1F, 0x01, 0xE0, 0x3C, 0x1E, 0x03, 0xE0, 0x3C, 0x1E, 0x03, 0xE0,
  0x3C, 0x3E, 0x03, 0xC0, 0x7C, 0x3E, 0x03, 0xC0, 0x7C, 0x3E, 0x03, 0xC0,
  0x78, 0x3C, 0x07, 0xC0, 0x78, 0x3C, 0x07, 0xC0, 0x78, 0x7C, 0x07, 0x80,
  0xF8, 0x7C, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x80,
  0xF0, 0x78, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x3C, 0x7F, 0x01, 0xEF, 0xFC, 0x0F, 0x7F, 0xE0, 0x7F, 0x1F, 0x83, 0xF0,
  0x7C, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF0, 0x7C, 0x07, 0x83,
  0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0xF0, 0x78, 0x07,
  0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0xF0, 0x78,
  0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1E, 0x0F, 0x00, 0xF0,
  0x78, 0x0F, 0x87, 0xC0, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x0F,
  0xFE, 0x03, 0xFF, 0xE0, 0xFC, 0x7E, 0x1F, 0x07, 0xC7, 0xC0, 0x78, 0xF0,
  0x0F, 0x3E, 0x01, 0xE7, 0xC0, 0x3D, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0xC0,
  0x3E, 0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xC0, 0x1F, 0xF8, 0x03, 0xDF, 0x00,
  0xFB, 0xE0, 0x1F, 0x3C, 0x07, 0xC7, 0x80, 0xF8, 0xF8, 0x3E, 0x1F, 0xDF,
  0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x03,
  0xC7, 0xF0, 0x07, 0x9F, 0xF0, 0x0F, 0x7F, 0xE0, 0x1F, 0xC7, 0xE0, 0x3F,
  0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x7C, 0x0F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF0, 0x07,
  0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x07,
  0xFB, 0xF8, 0x0F, 0x7F, 0xE0, 0x1E, 0xFF, 0x80, 0x7C, 0xFE, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xF3,
  0xC0, 0xFF, 0xDE, 0x0F, 0xFF, 0xF0, 0xFC, 0x7F, 0x07, 0xC1, 0xF8, 0x7C,
  0x07, 0xC3, 0xE0, 0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0x78,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F,
  0x81, 0xF8, 0x3E, 0x1F, 0xC1, 0xFB, 0xFE, 0x0F, 0xFD, 0xE0, 0x3F, 0xCF,
  0x00, 0xFC, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x83,
  0xCF, 0xC1, 0xEF, 0xE0, 0xF7, 0xE0, 0x7F, 0xF0, 0x3F, 0x80, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xE1,
  0xFF, 0xF1, 0xF8, 0x30, 0xF8, 0x08, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC4, 0x03, 0xE3, 0xCF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xE0,
  0x00, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0xFF,
  0xEF, 0xFE, 0xFF, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF2, 0x0F, 0xF0,
  0x7F, 0x81, 0xFC, 0x00, 0x1F, 0x01, 0xF1, 0xF0, 0x1E, 0x1E, 0x01, 0xE1,
  0xE0, 0x1E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xC3, 0xC0, 0x3C,
  0x3C, 0x03, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0x80, 0x78, 0x78, 0x07,
  0x87, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF0, 0xF0, 0x1F, 0x0F, 0x01,
  0xF0, 0xF0, 0x1F, 0x0F, 0x03, 0xF0, 0xF0, 0x7E, 0x0F, 0xDF, 0xE0, 0xFF,
  0xDE, 0x0F, 0xF9, 0xE0, 0x7F, 0x1E, 0x00, 0xF0, 0x07, 0xFC, 0x03, 0xEF,
  0x00, 0xFB, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x07, 0x8F, 0x03, 0xE3, 0xC0,
  0xF0, 0xF0, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x83, 0xC3, 0xC0, 0xF1, 0xF0,
  0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3D, 0xE0, 0x07,
  0x78, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xFF, 0x01, 0xF0, 0x1E, 0xF0,
  0x3F, 0x01, 0xEF, 0x03, 0xF0, 0x3E, 0xF0, 0x7F, 0x03, 0xCF, 0x07, 0xF0,
  0x7C, 0xF0, 0x77, 0x07, 0x8F, 0x0F, 0x70, 0x78, 0xF0, 0xF7, 0x0F, 0x8F,
  0x1E, 0x70, 0xF0, 0xF1, 0xE7, 0x1F, 0x0F, 0x1C, 0x71, 0xE0, 0xF3, 0xC7,
  0x1E, 0x0F, 0x3C, 0x73, 0xC0, 0xF7, 0x87, 0x3C, 0x0F, 0x78, 0x77, 0xC0,
  0xF7, 0x07, 0x78, 0x0F, 0xF0, 0x77, 0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x0F, 0xE0,
  0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x7E, 0x07,
  0xC0, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x0F, 0x80, 0x1E, 0x1E, 0x00, 0x3E,
  0x7C, 0x00, 0x7D, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0xBE, 0x00,
  0x3E, 0x7C, 0x00, 0x78, 0x78, 0x01, 0xF0, 0xF0, 0x07, 0xC1, 0xF0, 0x0F,
  0x03, 0xE0, 0x3E, 0x03, 0xC0, 0xF8, 0x07, 0xC0, 0x01, 0xE0, 0x0F, 0x80,
  0xF0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x03, 0xE0,
  0x0F, 0x01, 0xE0, 0x07, 0x81, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E,
  0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xF7,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x17, 0xFC, 0x03, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xE8, 0x03, 0xFC, 0x80, 0x07, 0x00,
};

const GFXglyph NotoSans_Condensed_MediumItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 13, 34, 12, 0, -34 },
  { 57, 14, 13, 17, 5, -34 },
  { 80, 25, 34, 24, 0, -34 },
  { 187, 21, 39, 21, 0, -36 },
  { 290, 28, 34, 32, 3, -34 },
  { 409, 24, 34, 25, 0, -34 },
  { 511, 6, 13, 10, 5, -34 },
  { 521, 15, 41, 13, 1, -34 },
  { 598, 16, 41, 13, -4, -34 },
  { 680, 18, 18, 20, 4, -36 },
  { 721, 19, 23, 23, 2, -28 },
  { 776, 9, 12, 11, -2, -6 },
  { 790, 11, 4, 13, 1, -15 },
  { 796, 5, 6, 11, 1, -6 },
  { 800, 22, 34, 17, -2, -34 },
  { 894, 20, 34, 21, 1, -34 },
  { 979, 14, 34, 21, 5, -34 },
  { 1039, 22, 34, 21, -1, -34 },
  { 1133, 21, 34, 21, 0, -34 },
  { 1223, 22, 34, 21, -1, -34 },
  { 1317, 21, 34, 21, 0, -34 },
  { 1407, 20, 34, 21, 2, -34 },
  { 1492, 21, 34, 21, 2, -34 },
  { 1582, 21, 34, 21, 0, -34 },
  { 1672, 20, 34, 21, 1, -34 },
  { 1757, 10, 26, 11, 0, -26 },
  { 1790, 12, 32, 11, -2, -26 },
  { 1838, 19, 22, 23, 2, -28 },
  { 1891, 19, 13, 23, 2, -23 },
  { 1922, 20, 22, 23, 2, -28 },
  { 1977, 16, 34, 16, 2, -34 },
  { 2045, 30, 38, 32, 1, -34 },
  { 2188, 22, 34, 22, -3, -34 },
  { 2282, 23, 34, 23, 0, -34 },
  { 2380, 23, 34, 22, 2, -34 },
  { 2478, 24, 34, 25, 0, -34 },
  { 2580, 22, 34, 20, 0, -34 },
  { 2674, 22, 34, 19, 0, -34 },
  { 2768, 25, 34, 26, 2, -34 },
  { 2875, 26, 34, 26, 1, -34 },
  { 2986, 19, 34, 14, -2, -34 },
  { 3067, 19, 43, 11, -7, -34 },
  { 3170, 25, 34, 22, 1, -34 },
  { 3277, 15, 34, 18, 0, -34 },
  { 3341, 35, 34, 34, 0, -34 },
  { 3490, 28, 34, 28, 0, -34 },
  { 3609, 24, 34, 27, 2, -34 },
  { 3711, 23, 34, 22, 0, -34 },
  { 3809, 24, 42, 27, 2, -34 },
  { 3935, 22, 34, 22, 1, -34 },
  { 4029, 21, 34, 20, 0, -34 },
  { 4119, 19, 34, 19, 4, -34 },
  { 4200, 25, 34, 26, 2, -34 },
  { 4307, 22, 34, 22, 4, -34 },
  { 4401, 34, 34, 34, 4, -34 },
  { 4546, 27, 34, 21, -3, -34 },
  { 4661, 20, 34, 20, 4, -34 },
  { 4746, 24, 34, 19, -2, -34 },
  { 4848, 18, 42, 14, -1, -34 },
  { 4943, 8, 34, 17, 5, -34 },
  { 4977, 18, 42, 14, -3, -34 },
  { 5072, 20, 20, 21, 1, -34 },
  { 5122, 16, 3, 16, -4, 4 },
  { 5128, 7, 8, 13, 7, -36 },
  { 5135, 21, 26, 22, 1, -26 },
  { 5204, 21, 36, 22, 0, -36 },
  { 5299, 18, 26, 17, 1, -26 },
  { 5358, 23, 36, 23, 1, -36 },
  { 5462, 18, 26, 20, 1, -26 },
  { 5521, 24, 47, 13, -6, -36 },
  { 5662, 22, 37, 23, 0, -26 },
  { 5764, 21, 36, 22, 0, -36 },
  { 5859, 12, 35, 10, 0, -35 },
  { 5912, 18, 46, 11, -6, -35 },
  { 6016, 22, 36, 20, 0, -36 },
  { 6115, 12, 36, 10, 0, -36 },
  { 6169, 32, 26, 33, 0, -26 },
  { 6273, 21, 26, 22, 0, -26 },
  { 6342, 19, 26, 22, 1, -26 },
  { 6404, 23, 37, 22, -2, -26 },
  { 6511, 21, 37, 22, 1, -26 },
  { 6609, 17, 26, 15, 0, -26 },
  { 6665, 17, 26, 17, 0, -26 },
  { 6721, 13, 31, 13, 2, -31 },
  { 6772, 20, 25, 22, 2, -25 },
  { 6835, 18, 25, 18, 3, -25 },
  { 6892, 28, 25, 29, 3, -25 },
  { 6980, 23, 25, 19, -2, -25 },
  { 7052, 25, 36, 19, -4, -25 },
  { 7165, 18, 25, 16, -1, -25 },
  { 7222, 18, 41, 16, 1, -34 },
  { 7315, 4, 47, 20, 8, -36 },
  { 7339, 18, 41, 16, -3, -34 },
  { 7432, 20, 7, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_MediumItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_MediumItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_MediumItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_CONDENSED_MEDIUMITALIC47PT7B_H_
