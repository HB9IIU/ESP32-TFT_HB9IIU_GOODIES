#ifndef _IBMPLEXMONO_MEDIUMITALIC45PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x38, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x0F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x1F, 0x00, 0x3E, 0x1F, 0x3E, 0x1E,
  0x3E, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C,
  0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0xF8, 0x7C, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0x83, 0xFF, 0x1F, 0xF8, 0x7F, 0xF0, 0x07, 0x87, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x0F,
  0x00, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x8F,
  0xFC, 0x3F, 0xF0, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x87,
  0x80, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x1F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x83, 0xF9, 0xDF, 0xC3, 0xF1, 0xE3, 0xC1, 0xF0, 0xF0,
  0xC0, 0xF8, 0x70, 0x40, 0xF8, 0x38, 0x00, 0x7C, 0x1C, 0x00, 0x3E, 0x0E,
  0x00, 0x0F, 0x8F, 0x00, 0x07, 0xE7, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1C, 0x7E, 0x00, 0x0E, 0x1F, 0x00, 0x07, 0x0F, 0x80,
  0x03, 0x83, 0xE0, 0x01, 0xC1, 0xF0, 0x01, 0xE1, 0xF0, 0x40, 0xF0, 0xF8,
  0xF0, 0x70, 0x7C, 0xFC, 0x38, 0x7C, 0x7F, 0x9C, 0xFE, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3C, 0x0F, 0xFE,
  0x00, 0xF0, 0x3F, 0xFC, 0x03, 0xC0, 0x78, 0x78, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x03, 0xC0, 0xF0, 0x78, 0x07, 0x81, 0xE0, 0xF0, 0x0E, 0x03, 0x83,
  0xC0, 0x1C, 0x0F, 0x0F, 0x00, 0x38, 0x1E, 0x1E, 0x00, 0x78, 0x7C, 0x78,
  0x00, 0xFF, 0xF1, 0xE0, 0x00, 0xFF, 0xC3, 0xC0, 0x01, 0xFF, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xE3, 0xFE, 0x00, 0x07, 0x8F, 0xFE, 0x00, 0x1E, 0x1F, 0xFC, 0x00,
  0x3C, 0x7C, 0x3C, 0x00, 0xF0, 0xF0, 0x78, 0x03, 0xC3, 0xC0, 0xF0, 0x07,
  0x87, 0x81, 0xE0, 0x1E, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xF0,
  0x3C, 0x1E, 0x03, 0xC0, 0x78, 0x7C, 0x0F, 0x00, 0xFF, 0xF0, 0x1E, 0x00,
  0xFF, 0xC0, 0x78, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0x87, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x80,
  0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x3E, 0x03, 0xC0, 0x07, 0xC0, 0x78, 0x00,
  0x78, 0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x3E,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xE7, 0xC0, 0x00, 0xF8,
  0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF0, 0x1E, 0x00,
  0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0xC1, 0x9F, 0x00,
  0xF8, 0x3F, 0xE0, 0x3F, 0x8F, 0x7E, 0x07, 0xF3, 0xC7, 0xE1, 0x9E, 0x78,
  0xFF, 0xF3, 0xFE, 0x0F, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x0F, 0xC0,
  0x3C, 0x00, 0x3C, 0xF7, 0xDF, 0x7D, 0xE7, 0x9E, 0xFB, 0xEF, 0xBC, 0xF0,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x20, 0x3E, 0x02, 0x7C,
  0x3E, 0x1E, 0x7F, 0xBC, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xCF, 0x80, 0x0F, 0x87, 0x80, 0x1F, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xE1, 0xF8,
  0x7F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0x81, 0xE0,
  0x7C, 0x0F, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE,
  0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0x3E, 0x0F,
  0x80, 0x1E, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x1C, 0x1F, 0x7C,
  0x3E, 0x1F, 0x7C, 0x7E, 0x1F, 0x7C, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC,
  0x3C, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0x7C,
  0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xF7, 0xC0, 0x1F, 0x9F,
  0x00, 0xFC, 0x7C, 0x07, 0xE1, 0xF0, 0x3F, 0x07, 0xC0, 0x78, 0x3E, 0x00,
  0x80, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF0,
  0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x03, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xE0,
  0x7F, 0x0F, 0xC0, 0x3F, 0x03, 0x00, 0x1F, 0x01, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x10, 0x00, 0x7C, 0x78, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFE, 0x07,
  0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0x78, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x0F, 0x80,
  0x0F, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xF0,
  0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0x80, 0x3C, 0x07, 0xC0, 0x1E,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x1F, 0x80, 0x1E, 0x7F, 0xE0, 0x1E, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x10, 0x00, 0xFC, 0x78, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFE,
  0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0xFC, 0x07, 0xE7, 0xFE, 0x0F, 0xBF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0x81, 0xFC, 0xFE, 0x01, 0xF9, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8,
  0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xF8, 0x3F, 0x83, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0x80, 0x07,
  0xEF, 0x00, 0x0F, 0x9E, 0x00, 0x3E, 0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF1,
  0xF0, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0x80,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00,
  0x1E, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0xF8, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0x81,
  0xF8, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0xFC, 0xFC, 0x01, 0xF8, 0xFE, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0xC7, 0xE0, 0x0F,
  0x8F, 0x80, 0x1F, 0x3F, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xEF, 0x80, 0x1F, 0xDF,
  0x80, 0x3F, 0x3F, 0x81, 0xFE, 0x3F, 0xFF, 0x7C, 0x7F, 0xFD, 0xF0, 0x7F,
  0xF3, 0xE0, 0x3F, 0x8F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xC1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x83,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x83, 0xE0,
  0x01, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x07, 0x80,
  0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x07, 0xF7, 0xC0, 0x3F,
  0x7C, 0x01, 0xFB, 0x80, 0x1F, 0x10, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xFF, 0x80, 0x3F,
  0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x1E, 0x0F,
  0x80, 0x1F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x07, 0x8F, 0x3C,
  0x1F, 0xCF, 0x3C, 0x3F, 0xEF, 0x3C, 0x3F, 0xFE, 0x7C, 0x7C, 0x3E, 0x78,
  0x78, 0x1E, 0x78, 0xF8, 0x1E, 0x78, 0xF0, 0x1E, 0x78, 0xF0, 0x1E, 0x78,
  0xF0, 0x3C, 0xF8, 0xF0, 0x3C, 0xF0, 0xF0, 0x3C, 0xF0, 0xF0, 0x3C, 0xF0,
  0xF0, 0x7C, 0xF0, 0xF0, 0xFC, 0xF0, 0xFF, 0xF8, 0xF0, 0xFF, 0xF8, 0xF0,
  0x7F, 0x78, 0xF0, 0x7E, 0x78, 0xF0, 0x10, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x3C,
  0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3,
  0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF7,
  0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xF8, 0x07, 0xE1,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7C, 0x03,
  0xF0, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xC0, 0x07, 0xCF, 0x80, 0x0F,
  0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF1,
  0xE0, 0x0F, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x3E,
  0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x18, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x40, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0x7C, 0x01, 0xF8,
  0x7C, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0x80, 0xFC, 0x0F, 0x80, 0x7E,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x3F, 0x1E, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x03, 0xF0,
  0x7C, 0x0F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFE, 0x0F, 0xC1, 0xF0, 0x0F, 0x87, 0xC0,
  0x0F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x38, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x1F, 0xFD, 0xF0, 0x3F, 0xF3, 0xE0, 0x7F, 0xE7,
  0xC0, 0xFF, 0xCF, 0x82, 0x07, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0x78, 0xF8, 0x00, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xE0,
  0x1F, 0x87, 0xE0, 0xFF, 0x0F, 0xFF, 0xBC, 0x0F, 0xFE, 0x78, 0x0F, 0xF8,
  0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0,
  0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07,
  0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x7C,
  0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x04, 0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x07,
  0xC3, 0xF0, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x01,
  0xF8, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x1F,
  0x01, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x07, 0xE0,
  0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF3,
  0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFB, 0xF0, 0x00, 0xFE, 0x3E, 0x00, 0x1F, 0x87,
  0xC0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x01, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x07,
  0xC0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFF,
  0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFE,
  0x1F, 0x78, 0xF7, 0x83, 0xEF, 0x3E, 0xF0, 0x79, 0xE7, 0x9E, 0x0F, 0x3D,
  0xE3, 0xC1, 0xE3, 0xBC, 0xF8, 0x3C, 0x7F, 0x1F, 0x0F, 0x8F, 0xE3, 0xC1,
  0xF1, 0xF8, 0x78, 0x3C, 0x3F, 0x0F, 0x07, 0x83, 0xC3, 0xE0, 0xF0, 0x70,
  0x7C, 0x1E, 0x0E, 0x0F, 0x87, 0xC1, 0x81, 0xE0, 0xF8, 0x10, 0x3C, 0x1E,
  0x04, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x07, 0xC1, 0xFC, 0x01,
  0xF0, 0x7F, 0x80, 0x7C, 0x1F, 0xE0, 0x1E, 0x07, 0xF8, 0x07, 0x81, 0xFE,
  0x01, 0xE0, 0xFF, 0x80, 0xF8, 0x3F, 0xF0, 0x3E, 0x0F, 0xBC, 0x0F, 0x83,
  0xCF, 0x03, 0xC0, 0xF3, 0xC0, 0xF0, 0x3C, 0xF8, 0x3C, 0x1F, 0x3E, 0x1F,
  0x07, 0xC7, 0x87, 0xC1, 0xF1, 0xE1, 0xF0, 0x78, 0x78, 0x78, 0x1E, 0x1F,
  0x1E, 0x07, 0x87, 0xC7, 0x83, 0xE0, 0xF3, 0xE0, 0xF8, 0x3C, 0xF8, 0x3E,
  0x0F, 0x3E, 0x0F, 0x03, 0xEF, 0x03, 0xC0, 0x7B, 0xC0, 0xF0, 0x1E, 0xF0,
  0x7C, 0x07, 0xFC, 0x1F, 0x01, 0xFF, 0x07, 0xC0, 0x7F, 0xC1, 0xE0, 0x0F,
  0xE0, 0x78, 0x03, 0xF8, 0x1E, 0x00, 0xFE, 0x0F, 0x80, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xF0, 0x7E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x3F,
  0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x07, 0x80, 0x0F, 0x87, 0xC0, 0x07,
  0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x07, 0xF0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3F,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x03, 0xF0,
  0x7F, 0x07, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x08, 0x00, 0x3E, 0x1C,
  0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x00,
  0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x07, 0x80,
  0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xF8,
  0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01,
  0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0x3E, 0x0F, 0x80, 0x1F,
  0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x7E,
  0x00, 0x7C, 0x3E, 0x00, 0x18, 0x1F, 0x00, 0x08, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x08, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x8F, 0xF0,
  0x3F, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x9F, 0x00,
  0x07, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0x7C, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x07, 0xC0,
  0x07, 0x83, 0xE0, 0x03, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF9, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x0F,
  0x1E, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0xF8, 0x3C, 0x1E, 0x1F, 0x83,
  0xC3, 0xE1, 0xF8, 0x3C, 0x3E, 0x1F, 0x87, 0xC3, 0xC3, 0xF8, 0x78, 0x3C,
  0x3F, 0x87, 0x83, 0xC3, 0xB8, 0x78, 0x3C, 0x7B, 0x8F, 0x83, 0xC7, 0x38,
  0xF0, 0x3C, 0x73, 0x8F, 0x03, 0xCF, 0x38, 0xF0, 0x3C, 0xE3, 0x8F, 0x07,
  0xCE, 0x39, 0xE0, 0x7D, 0xE3, 0x9E, 0x07, 0x9C, 0x39, 0xE0, 0x79, 0xC3,
  0x9E, 0x07, 0xBC, 0x3B, 0xC0, 0x7B, 0x83, 0xBC, 0x07, 0xB8, 0x3B, 0xC0,
  0x7F, 0x83, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0xC0,
  0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x07,
  0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xE7, 0xC0, 0x03,
  0xF1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF7, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x40, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xF9, 0xE0, 0x00, 0xF9, 0xF0, 0x01, 0xF0,
  0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xC0, 0xF8, 0x07, 0xC0, 0x78, 0x0F, 0x80,
  0x7C, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0x1E, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x10, 0x00, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x39, 0xF1, 0xF1,
  0xE3, 0xC3, 0xC7, 0x87, 0x0C, 0x00, 0xFC, 0x00, 0x07, 0xFC, 0x7C, 0x1F,
  0xFC, 0xF8, 0x7F, 0xFD, 0xE1, 0xFC, 0x1F, 0xC7, 0xE0, 0x1F, 0x8F, 0x80,
  0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF1, 0xF0, 0x03,
  0xE7, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E,
  0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xC3,
  0xE0, 0x2F, 0x87, 0xE1, 0xDF, 0xCF, 0xFF, 0x3F, 0x8F, 0xFC, 0x7F, 0x0F,
  0xF0, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x3C, 0x7F,
  0xC0, 0xF9, 0xFF, 0xC1, 0xF7, 0xFF, 0xC3, 0xEE, 0x1F, 0x87, 0xF0, 0x1F,
  0x0F, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xF9,
  0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x00, 0x1F, 0x3E,
  0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xE3, 0xE0,
  0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x60, 0xFE, 0x3E, 0xFF, 0xF8, 0x7C, 0xFF,
  0xE0, 0xF9, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFC, 0x1F, 0x1F, 0x80, 0x7C, 0xF8,
  0x03, 0x8F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x67, 0xC0, 0x07, 0xBE, 0x00, 0x7C, 0xF8, 0x07, 0xC7,
  0xE0, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x7E, 0x1F, 0x00, 0xFF, 0xCF, 0x80,
  0xFF, 0xE7, 0xC0, 0xFF, 0xFB, 0xE0, 0xFE, 0x0D, 0xF0, 0x7C, 0x03, 0xF0,
  0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F,
  0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03,
  0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x7F, 0x03, 0xF0, 0xEF, 0x81, 0xFF,
  0xF7, 0xC0, 0x7F, 0xF3, 0xE0, 0x1F, 0xF1, 0xE0, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFC,
  0x1F, 0x8F, 0x80, 0x7C, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB,
  0xE0, 0x1F, 0xFE, 0x07, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF,
  0x03, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x87, 0xC0, 0x03, 0x3E,
  0x00, 0x3C, 0xF8, 0x03, 0xE7, 0xE0, 0x7E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x01, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x10, 0x1F, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0x9F, 0x03, 0xFF, 0x9F, 0x07, 0xFF, 0xDF,
  0x0F, 0xE0, 0xDF, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3C,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC,
  0x7C, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x3E, 0x03, 0xF8, 0x3F, 0x0F, 0xF8,
  0x3F, 0xFE, 0xF8, 0x1F, 0xFC, 0xF8, 0x0F, 0xF8, 0xF8, 0x03, 0xE0, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x30, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0xF9, 0xFF,
  0x03, 0xE7, 0xFE, 0x1F, 0x3F, 0xF8, 0x7D, 0xC3, 0xF1, 0xF4, 0x07, 0xC7,
  0xE0, 0x1F, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80,
  0x1F, 0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x00, 0x3E,
  0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x1F, 0x00, 0x7C, 0x7C,
  0x01, 0xF1, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x04, 0x03, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF8, 0x7C,
  0x07, 0x87, 0xC0, 0x7C, 0x7C, 0x03, 0xEF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x30,
  0x1F, 0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xE0, 0x1F, 0x0F, 0x80, 0x7E, 0x3E,
  0x00, 0xFC, 0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0xE0,
  0x0F, 0x9F, 0xF0, 0x0F, 0x3F, 0xF8, 0x1F, 0x3F, 0xFC, 0x1F, 0x70, 0xFC,
  0x1F, 0xC0, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x3E, 0x3F, 0x00, 0x3C, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x04,
  0x7C, 0x7C, 0x0E, 0x7C, 0x3E, 0x1F, 0x7C, 0x3E, 0x3E, 0x78, 0x1F, 0x7C,
  0xF8, 0x1F, 0xF8, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x80, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x0C,
  0x0F, 0x81, 0xE0, 0xF8, 0x3F, 0x0F, 0x87, 0xC0, 0xF0, 0xF8, 0x1F, 0x1F,
  0x01, 0xF7, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x0F, 0x03, 0xCF, 0xC7, 0xE0, 0xF7, 0xF3, 0xFC, 0x3F,
  0xFD, 0xFF, 0x1F, 0x8F, 0x67, 0xC7, 0xC3, 0xF0, 0xF1, 0xF0, 0xF8, 0x3C,
  0x78, 0x3E, 0x0F, 0x1E, 0x0F, 0x03, 0xC7, 0x83, 0xC1, 0xE3, 0xC0, 0xF0,
  0x78, 0xF0, 0x3C, 0x1E, 0x3C, 0x1F, 0x07, 0x8F, 0x07, 0x81, 0xE3, 0xC1,
  0xE0, 0x79, 0xF0, 0x78, 0x3E, 0x78, 0x1E, 0x0F, 0x1E, 0x07, 0x83, 0xC7,
  0x83, 0xE0, 0xF1, 0xE0, 0xF0, 0x3C, 0x78, 0x3C, 0x0F, 0x3E, 0x0F, 0x07,
  0xCF, 0x03, 0xC1, 0xE3, 0xC1, 0xF0, 0x78, 0x00, 0x07, 0xC0, 0x3E, 0x7F,
  0xC0, 0xF1, 0xFF, 0x87, 0xCF, 0xFE, 0x1F, 0x70, 0xFC, 0x7D, 0x01, 0xF1,
  0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0,
  0x07, 0xCF, 0x80, 0x1E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xC0, 0x0F,
  0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xC7, 0xC0, 0x1F, 0x1F,
  0x00, 0x7C, 0x78, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00, 0x1E,
  0x7E, 0x00, 0x3C, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xE7,
  0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x78,
  0x00, 0xFC, 0xF0, 0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x1F, 0x83, 0xF0,
  0x7E, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x01, 0xE3, 0xFE, 0x01, 0xF3, 0xFF, 0x80, 0xFB,
  0xFF, 0xE0, 0x7D, 0xC3, 0xF0, 0x3F, 0x80, 0xF8, 0x1F, 0x80, 0x3E, 0x0F,
  0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1,
  0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F,
  0x83, 0xF0, 0x0F, 0x83, 0xEC, 0x1F, 0xC1, 0xF7, 0xFF, 0xC0, 0xF9, 0xFF,
  0xC0, 0x7C, 0xFF, 0xC0, 0x3E, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xFE, 0x7C, 0x1F, 0xFC, 0xF8, 0x7F, 0xFD, 0xF1, 0xFC, 0x1B, 0xE3,
  0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8,
  0x00, 0xF9, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xCF, 0x80, 0x0F, 0x9F, 0x00,
  0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF9, 0xF0, 0x03,
  0xE3, 0xE0, 0x0F, 0xC3, 0xE0, 0x3F, 0x87, 0xE1, 0xDF, 0x0F, 0xFF, 0xBE,
  0x0F, 0xFE, 0x7C, 0x0F, 0xF8, 0xF0, 0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xFF, 0xE0, 0xFF, 0xFF,
  0x8F, 0xEF, 0xFE, 0x7F, 0xBF, 0xF3, 0xFE, 0x03, 0xDC, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x0F,
  0xC0, 0xF8, 0x7C, 0x00, 0xC1, 0xF0, 0x02, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE3, 0x00, 0x0F, 0x9E, 0x00, 0x7C, 0xFE, 0x03, 0xF1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0x80, 0xF8, 0x1E,
  0x07, 0x81, 0xF8, 0x7C, 0x3F, 0x83, 0xE3, 0xF0, 0x1F, 0x7F, 0x00, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x7C,
  0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1E, 0x3E, 0x00, 0xF8, 0xF8,
  0x03, 0xE3, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03,
  0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x78, 0x01, 0xF3, 0xE0, 0x07, 0xCF,
  0x80, 0x1F, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x8F, 0xC0,
  0xBE, 0x3F, 0x0E, 0xF8, 0x7F, 0xF3, 0xE1, 0xFF, 0xCF, 0x03, 0xFE, 0x7C,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x18, 0xFF, 0x81, 0xF9, 0xFF, 0x01, 0xF3,
  0xFE, 0x03, 0xE7, 0xFC, 0x07, 0xD0, 0xF8, 0x07, 0x81, 0xE0, 0x0F, 0x83,
  0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x0F, 0xC0, 0x78, 0x3F, 0x00, 0xF1, 0xFC,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1E, 0x0F, 0x03, 0x0F, 0x07, 0x87, 0x87, 0x83, 0xC3, 0xC3, 0xC1, 0xE1,
  0xE1, 0xE0, 0xF0, 0x79, 0xE0, 0x78, 0x3C, 0xF0, 0x78, 0x1E, 0x78, 0x3C,
  0x0F, 0x3C, 0x1E, 0x07, 0x9E, 0x0F, 0x03, 0xCF, 0x07, 0x83, 0xEF, 0x03,
  0xC1, 0xE7, 0x83, 0xE0, 0xF3, 0xC1, 0xE0, 0x79, 0xE0, 0xF0, 0x3C, 0xF0,
  0x78, 0x3C, 0x78, 0x3C, 0x1E, 0x78, 0x3E, 0x0F, 0x3C, 0x1F, 0x0F, 0x1F,
  0x1F, 0x87, 0x8F, 0xFF, 0xC7, 0x83, 0xFC, 0xFF, 0x81, 0xFC, 0x7F, 0x80,
  0x7C, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x3F, 0x87, 0xF8, 0x0F, 0xF8,
  0xFF, 0x07, 0xFF, 0x3F, 0xF1, 0xFD, 0xEE, 0x3E, 0x7E, 0x3D, 0x83, 0xCF,
  0x07, 0xB0, 0x78, 0xC0, 0xF4, 0x0F, 0x00, 0x1F, 0x81, 0xE0, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xF0, 0x3F, 0x02,
  0x1E, 0x07, 0xE0, 0x63, 0xC1, 0xBC, 0x3E, 0x78, 0x37, 0x8F, 0xCF, 0x8E,
  0xF7, 0xF1, 0xFF, 0x9F, 0xFC, 0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0x80,
  0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3C, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0xFC, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0x86,
  0xF8, 0x1F, 0xFC, 0xF8, 0x1F, 0xFC, 0xF8, 0x0F, 0xF8, 0xF0, 0x03, 0xE1,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x30, 0x07, 0xE0, 0x7C, 0x1F, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFC,
  0x1F, 0x0F, 0xFF, 0x1E, 0x1F, 0xFF, 0x9E, 0x1E, 0x0F, 0xFE, 0x3E, 0x03,
  0xFC, 0x3C, 0x01, 0xF8, 0x3C, 0x03, 0xF0, 0x3C, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x10, 0x07, 0xE0, 0x78, 0x0F, 0xC0, 0x78, 0x1F, 0x80,
  0x38, 0x3F, 0x00, 0x3C, 0x7F, 0xE0, 0x3C, 0xFF, 0xFF, 0x3C, 0xF1, 0xFF,
  0xFC, 0xF0, 0x7F, 0xF8, 0xF0, 0x0F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x3F, 0xFC, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFC,
  0x07, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x07,
  0xC0, 0x0C, 0x0F, 0xE0, 0x0F, 0x1F, 0xF0, 0x0E, 0x3F, 0xF8, 0x1E, 0x3C,
  0x78, 0x1E, 0x78, 0x7C, 0x3C, 0x78, 0x3E, 0x7C, 0xF0, 0x1F, 0xF8, 0xF0,
  0x1F, 0xF8, 0xF0, 0x0F, 0xF0, 0x60, 0x07, 0xC0,
};

const GFXglyph IBMPlexMono_MediumItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 11, 31, 27, 8, -31 },
  { 44, 16, 13, 27, 8, -33 },
  { 70, 28, 31, 27, 0, -31 },
  { 179, 25, 43, 27, 1, -37 },
  { 314, 31, 33, 27, -1, -32 },
  { 442, 27, 33, 27, 0, -32 },
  { 554, 6, 13, 27, 13, -33 },
  { 564, 17, 40, 27, 9, -34 },
  { 649, 17, 40, 27, 2, -34 },
  { 734, 24, 22, 27, 2, -25 },
  { 800, 22, 22, 27, 3, -25 },
  { 861, 11, 14, 27, 6, -7 },
  { 881, 14, 4, 27, 7, -16 },
  { 888, 8, 7, 27, 8, -7 },
  { 895, 26, 40, 27, 1, -34 },
  { 1025, 24, 33, 27, 2, -32 },
  { 1124, 22, 31, 27, 2, -31 },
  { 1210, 24, 32, 27, 1, -32 },
  { 1306, 24, 33, 27, 1, -32 },
  { 1405, 25, 31, 27, 0, -31 },
  { 1502, 24, 32, 27, 2, -31 },
  { 1598, 23, 32, 27, 2, -31 },
  { 1690, 23, 31, 27, 4, -31 },
  { 1780, 24, 33, 27, 2, -32 },
  { 1879, 23, 32, 27, 3, -32 },
  { 1971, 11, 24, 27, 8, -24 },
  { 2004, 13, 31, 27, 6, -24 },
  { 2055, 22, 26, 27, 4, -27 },
  { 2127, 24, 14, 27, 2, -21 },
  { 2169, 22, 26, 27, 2, -27 },
  { 2241, 20, 32, 27, 5, -32 },
  { 2321, 24, 37, 27, 2, -32 },
  { 2432, 25, 31, 27, -1, -31 },
  { 2529, 23, 31, 27, 2, -31 },
  { 2619, 24, 33, 27, 3, -32 },
  { 2718, 24, 31, 27, 2, -31 },
  { 2811, 25, 31, 27, 2, -31 },
  { 2908, 25, 31, 27, 2, -31 },
  { 3005, 23, 33, 27, 3, -32 },
  { 3100, 26, 31, 27, 1, -31 },
  { 3201, 25, 31, 27, 2, -31 },
  { 3298, 23, 32, 27, 2, -31 },
  { 3390, 27, 31, 27, 2, -31 },
  { 3495, 20, 31, 27, 3, -31 },
  { 3573, 27, 31, 27, 1, -31 },
  { 3678, 26, 31, 27, 1, -31 },
  { 3779, 24, 33, 27, 2, -32 },
  { 3878, 25, 31, 27, 2, -31 },
  { 3975, 24, 41, 27, 2, -32 },
  { 4098, 25, 31, 27, 2, -31 },
  { 4195, 25, 33, 27, 1, -32 },
  { 4299, 25, 31, 27, 4, -31 },
  { 4396, 24, 32, 27, 3, -31 },
  { 4492, 25, 31, 27, 4, -31 },
  { 4589, 28, 31, 27, 1, -31 },
  { 4698, 30, 31, 27, -1, -31 },
  { 4815, 26, 31, 27, 4, -31 },
  { 4916, 27, 31, 27, 0, -31 },
  { 5021, 20, 40, 27, 6, -34 },
  { 5121, 12, 40, 27, 8, -34 },
  { 5181, 20, 40, 27, 1, -34 },
  { 5281, 24, 19, 27, 2, -31 },
  { 5338, 22, 4, 27, 0, 4 },
  { 5349, 7, 9, 27, 9, -35 },
  { 5357, 23, 25, 27, 2, -24 },
  { 5429, 23, 34, 27, 2, -33 },
  { 5527, 21, 25, 27, 3, -24 },
  { 5593, 25, 34, 27, 2, -33 },
  { 5700, 21, 25, 27, 3, -24 },
  { 5766, 30, 43, 27, -1, -33 },
  { 5928, 24, 34, 27, 1, -24 },
  { 6030, 22, 33, 27, 2, -33 },
  { 6121, 21, 34, 27, 3, -33 },
  { 6211, 22, 43, 27, 2, -33 },
  { 6330, 24, 34, 27, 2, -33 },
  { 6432, 20, 34, 27, 4, -33 },
  { 6517, 26, 24, 27, 0, -24 },
  { 6595, 22, 24, 27, 2, -24 },
  { 6661, 23, 25, 27, 2, -24 },
  { 6733, 25, 33, 27, 0, -24 },
  { 6837, 23, 33, 27, 2, -24 },
  { 6932, 22, 23, 27, 5, -23 },
  { 6996, 22, 25, 27, 2, -24 },
  { 7065, 21, 32, 27, 3, -31 },
  { 7149, 22, 24, 27, 3, -23 },
  { 7215, 23, 24, 27, 2, -24 },
  { 7284, 25, 24, 27, 1, -23 },
  { 7359, 27, 25, 27, 0, -24 },
  { 7444, 24, 33, 27, 1, -23 },
  { 7543, 24, 25, 27, 2, -24 },
  { 7618, 21, 40, 27, 5, -34 },
  { 7723, 11, 40, 27, 8, -34 },
  { 7778, 21, 40, 27, 2, -34 },
  { 7883, 24, 11, 27, 2, -19 },
};

const GFXfont IBMPlexMono_MediumItalic45pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic45pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _IBMPLEXMONO_MEDIUMITALIC45PT7B_H_
