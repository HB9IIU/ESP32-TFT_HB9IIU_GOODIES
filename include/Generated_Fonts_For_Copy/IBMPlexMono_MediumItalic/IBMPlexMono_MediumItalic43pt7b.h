#ifndef _IBMPLEXMONO_MEDIUMITALIC43PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7E, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xC0, 0xF0, 0x00, 0x3C, 0x3E, 0x78, 0x78, 0xF0,
  0xF1, 0xE1, 0xE7, 0xC3, 0xCF, 0x07, 0x9E, 0x1F, 0x3C, 0x3C, 0x78, 0x78,
  0xF0, 0xF3, 0xE1, 0xE7, 0x83, 0xCF, 0x0F, 0x80, 0x00, 0x07, 0x87, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xE1, 0xE0, 0x0F,
  0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x7F, 0xE1, 0xFF, 0x0F, 0xFC, 0x3F,
  0xE0, 0x0F, 0x07, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x01, 0xFF, 0x0F, 0xFC,
  0x3F, 0xE1, 0xFF, 0x87, 0xFC, 0x3F, 0xF1, 0xFF, 0x0F, 0xFC, 0x01, 0xE1,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x0F, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x7C, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x0F, 0xE7, 0x3F, 0x0F, 0x87, 0x1E, 0x1F, 0x07, 0x0C, 0x1F,
  0x0F, 0x00, 0x1F, 0x0E, 0x00, 0x1F, 0x0E, 0x00, 0x1F, 0x0E, 0x00, 0x0F,
  0xCE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1D, 0xFC, 0x00, 0x1C, 0x7C, 0x00,
  0x38, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x3C, 0x20, 0x38, 0x3C, 0x70,
  0x38, 0x7C, 0xF8, 0x78, 0xFC, 0xFE, 0x73, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x7C,
  0x07, 0xF8, 0x01, 0xE0, 0x3F, 0xF0, 0x0F, 0x01, 0xE1, 0xE0, 0x78, 0x0F,
  0x07, 0x81, 0xC0, 0x3C, 0x1E, 0x0F, 0x00, 0xE0, 0x78, 0x78, 0x03, 0x81,
  0xE1, 0xC0, 0x1E, 0x07, 0x8F, 0x00, 0x38, 0x1C, 0x78, 0x00, 0xE0, 0xF1,
  0xC0, 0x03, 0xC7, 0x8F, 0x00, 0x0F, 0xFE, 0x78, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xC7, 0xFE, 0x00, 0x0E, 0x3C, 0x78, 0x00, 0x79, 0xE0, 0xF0, 0x03,
  0xC7, 0x83, 0xC0, 0x1E, 0x1C, 0x0F, 0x00, 0x78, 0xF0, 0x3C, 0x03, 0xC3,
  0xC0, 0xE0, 0x1E, 0x0F, 0x03, 0x80, 0x78, 0x3C, 0x1E, 0x03, 0xC0, 0x78,
  0xF0, 0x1E, 0x01, 0xFF, 0xC0, 0x78, 0x03, 0xFE, 0x03, 0xC0, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x0F, 0x00, 0x1E, 0x03, 0xC0,
  0x07, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1F, 0x03,
  0xC0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0x81, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x03, 0xE0,
  0x8F, 0x80, 0xF8, 0x3B, 0xE0, 0x3F, 0x1F, 0xF8, 0x1B, 0xCF, 0x9F, 0x0E,
  0xFB, 0xC7, 0xFF, 0x3F, 0xE0, 0xFF, 0xC7, 0xF8, 0x3F, 0xE0, 0xFC, 0x03,
  0xE0, 0x1E, 0x00, 0x3C, 0xF3, 0xCF, 0x7D, 0xF7, 0x9E, 0x79, 0xEF, 0xBE,
  0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x03, 0x03, 0xC0, 0xDF, 0x0F, 0x1F, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xF7, 0xC0, 0x0F, 0x8F, 0x00, 0x7C, 0x3E,
  0x03, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0x18, 0x03, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x07,
  0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x3C, 0x0F,
  0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x3D, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x0F, 0xC1, 0xF0, 0x0F, 0x87, 0xC0,
  0x0F, 0x0F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x00,
  0xFB, 0xE0, 0x01, 0xF7, 0xC3, 0xC3, 0xEF, 0x8F, 0x87, 0xDF, 0x1F, 0x0F,
  0xFC, 0x3E, 0x3E, 0xF8, 0x7C, 0x7D, 0xF0, 0xF0, 0xFB, 0xE0, 0x01, 0xF7,
  0xC0, 0x03, 0xEF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3C, 0x3C,
  0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0x78, 0x03, 0xF7, 0xC0,
  0x7F, 0x3E, 0x07, 0xE1, 0xF0, 0x3E, 0x0F, 0x80, 0xE0, 0x78, 0x02, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x7E, 0x0F, 0xE1, 0xF8, 0x0F, 0xC7, 0xE0, 0x0F, 0x87,
  0x80, 0x1F, 0x02, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFE, 0x0F, 0xE0, 0xF0, 0x07, 0xC0,
  0xC0, 0x0F, 0x81, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x04, 0x00, 0x3E,
  0x38, 0x00, 0xFC, 0xF8, 0x01, 0xF1, 0xFC, 0x0F, 0xE1, 0xFF, 0xFF, 0x81,
  0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xBC, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0x7C,
  0x00, 0x3C, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78,
  0x03, 0xE0, 0x78, 0x07, 0xC0, 0xF8, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF8,
  0x1E, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x1F, 0x80, 0x0F, 0x3F, 0xE0, 0x0F, 0x7F, 0xF0, 0x1E, 0xFF, 0xF8,
  0x1F, 0xC1, 0xFC, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x08, 0x00, 0x7C,
  0x38, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0xFF, 0x07, 0xF0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x3E, 0x7F, 0xE0, 0xFB, 0xFF, 0xC7,
  0xDF, 0xFF, 0x9F, 0xE0, 0xFE, 0x7E, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7B, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0xBE, 0x00, 0x7E, 0x7C, 0x03, 0xF1, 0xF8, 0x1F, 0x83, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x78, 0x00, 0xF9, 0xE0, 0x03,
  0xEF, 0x80, 0x1F, 0x3C, 0x00, 0x7C, 0xF0, 0x03, 0xE3, 0xC0, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xE0, 0x7F, 0x0F, 0xC0,
  0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00,
  0x1E, 0x0F, 0x80, 0x3C, 0x07, 0xC0, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7F, 0x03,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xFC,
  0x1F, 0x81, 0xF8, 0xF8, 0x03, 0xE7, 0xE0, 0x07, 0x9F, 0x00, 0x1F, 0x7C,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0xF9, 0xF0, 0x07, 0xE7, 0xE0, 0x7F, 0x9F, 0xFF, 0xBE, 0x3F, 0xFD, 0xF0,
  0x7F, 0xE7, 0xC0, 0x7E, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0x87, 0xF1, 0xFC, 0xFF, 0x3F, 0xC7, 0xE1, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x87, 0x80, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0,
  0x7F, 0x81, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x3C, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x00, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x08,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xE7, 0xE0, 0xFE, 0xF8, 0x07, 0xFE, 0x00, 0xF9, 0x80, 0x1F,
  0x10, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x07, 0xF8,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7E, 0x07, 0xC1, 0xF0, 0x07, 0x87, 0xC0,
  0x07, 0x0F, 0x00, 0x0F, 0x1E, 0x0F, 0x1E, 0x78, 0x3F, 0xBC, 0xF0, 0xFF,
  0x71, 0xE3, 0xFF, 0xE7, 0x87, 0xC7, 0xCF, 0x1F, 0x07, 0x9E, 0x3C, 0x0F,
  0x3C, 0x78, 0x1E, 0x79, 0xF0, 0x38, 0xE3, 0xC0, 0xF3, 0xC7, 0x81, 0xE7,
  0x8F, 0x03, 0xCF, 0x1E, 0x0F, 0x9E, 0x3C, 0x1F, 0x3C, 0x7F, 0xDC, 0x78,
  0x7F, 0xF8, 0xF0, 0xFE, 0xF1, 0xE0, 0xF9, 0xE3, 0xC0, 0x40, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E,
  0x78, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0xF8,
  0x7C, 0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x3C, 0x03, 0xE0,
  0x3C, 0x03, 0xE0, 0x3E, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x1F, 0x00,
  0x1E, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0x80, 0xFC, 0x3E, 0x01, 0xF0, 0xF0, 0x07, 0xC3,
  0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0,
  0x3E, 0x1E, 0x01, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0xF8, 0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x7C,
  0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9E, 0x00, 0x3E, 0x78, 0x01,
  0xF3, 0xE0, 0x1F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xFF, 0xFE, 0x0F, 0xE0, 0xFC, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80,
  0x0F, 0x3E, 0x00, 0x21, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x83, 0xE0, 0x03, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0x7C, 0x03, 0xE1,
  0xF8, 0x3F, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x83, 0xC0, 0x1F, 0x07, 0x80,
  0x1E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01,
  0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x9F, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xE7,
  0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x78,
  0x03, 0xE0, 0xF0, 0x1F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0x87, 0xE0,
  0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x30, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xFF,
  0x3E, 0x0F, 0xFC, 0x7C, 0x1F, 0xF9, 0xF0, 0x3F, 0xF3, 0xE0, 0x01, 0xE7,
  0xC0, 0x03, 0xCF, 0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x1F, 0x00, 0x3C, 0x3E,
  0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0xF7, 0xC0, 0xFF,
  0xEF, 0x00, 0xFF, 0x9E, 0x00, 0xFC, 0x3C, 0x00, 0x07, 0xC0, 0x0F, 0x83,
  0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0x78, 0x01, 0xF0,
  0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1E,
  0x07, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x07, 0x81, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x1E, 0x07,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x40, 0x0F,
  0x8F, 0x80, 0x3C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC1, 0xF8, 0x7E, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0x80, 0x0F, 0xC3, 0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x3E, 0x01, 0xF8,
  0x0F, 0x80, 0xFC, 0x03, 0xC0, 0x7E, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x1F,
  0x80, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x78,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xE7, 0xC0, 0x07, 0xF1, 0xF0,
  0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x07, 0xC0,
  0x7C, 0x01, 0xE0, 0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F,
  0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x3F,
  0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0,
  0x7B, 0xC3, 0xFC, 0x1E, 0xF1, 0xEF, 0x07, 0x9C, 0x73, 0xC1, 0xE7, 0xBC,
  0xF0, 0x79, 0xFE, 0x7C, 0x3E, 0x7F, 0x9E, 0x0F, 0x9F, 0xC7, 0x83, 0xC3,
  0xF1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x0F, 0x0F, 0x87,
  0xC1, 0x83, 0xC1, 0xF0, 0x60, 0xF0, 0x78, 0x10, 0x3C, 0x1E, 0x04, 0x0F,
  0x07, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x3E, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x3E, 0x00, 0x07, 0xF0, 0x0F, 0x83, 0xF8, 0x07, 0xC1, 0xFC, 0x03,
  0xC0, 0xFE, 0x01, 0xE0, 0x7F, 0x00, 0xF0, 0x7F, 0xC0, 0x78, 0x3F, 0xE0,
  0x7C, 0x1E, 0xF0, 0x3E, 0x0F, 0x78, 0x1E, 0x07, 0xBC, 0x0F, 0x03, 0xCF,
  0x07, 0x83, 0xE7, 0x83, 0xC1, 0xE3, 0xC3, 0xE0, 0xF1, 0xE1, 0xF0, 0x78,
  0xF0, 0xF0, 0x3C, 0x3C, 0x78, 0x1E, 0x1E, 0x3C, 0x1F, 0x0F, 0x1E, 0x0F,
  0x07, 0x9F, 0x07, 0x83, 0xEF, 0x83, 0xC0, 0xF7, 0x81, 0xE0, 0x7B, 0xC0,
  0xF0, 0x3D, 0xE0, 0xF8, 0x1F, 0xF0, 0x78, 0x0F, 0xF8, 0x3C, 0x03, 0xFC,
  0x1E, 0x01, 0xFC, 0x0F, 0x00, 0xFE, 0x07, 0x80, 0x7F, 0x07, 0xC0, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0xFE, 0x0F, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x1F,
  0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xF7,
  0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x3E, 0xF8,
  0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80,
  0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x7C, 0x03,
  0xE0, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xF8, 0x07, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F,
  0x87, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x0F, 0xC1, 0xF0, 0x0F,
  0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7D,
  0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF,
  0x00, 0x0F, 0xFE, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0,
  0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00,
  0x7C, 0x3C, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x04,
  0x00, 0x3E, 0x1C, 0x00, 0x7C, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xF8, 0x07, 0xE1,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xC3, 0xC0,
  0x1F, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xF0,
  0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x07, 0xC0, 0xF0, 0x0F, 0x83,
  0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x07, 0xE0, 0x7F, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x0C, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x20, 0x00, 0x7C, 0x70, 0x00, 0x7C,
  0xFC, 0x00, 0xF8, 0xFF, 0x03, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0xF0, 0x01, 0xE3,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3C,
  0x00, 0x7C, 0x78, 0x00, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0,
  0x0F, 0x8F, 0x80, 0x1F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF8, 0x01,
  0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x00, 0x1E,
  0x1E, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xC1,
  0xF8, 0x1F, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x3E,
  0x78, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8,
  0x7C, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0x3C, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0x3E, 0x07, 0x80,
  0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x1E, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x7C, 0x00,
  0x1E, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xF0, 0xF8, 0x3C,
  0x3C, 0x1F, 0x07, 0x87, 0x83, 0xE0, 0xF0, 0xF0, 0xFC, 0x3C, 0x1E, 0x1F,
  0x87, 0x83, 0xC7, 0xF0, 0xF0, 0x78, 0xEE, 0x1E, 0x0F, 0x1D, 0xC7, 0x81,
  0xE7, 0xB8, 0xF0, 0x3C, 0xE7, 0x1E, 0x0F, 0x1C, 0xE3, 0xC1, 0xE7, 0x9C,
  0x70, 0x3C, 0xE3, 0x9E, 0x07, 0x9C, 0x73, 0xC0, 0xF7, 0x8F, 0x78, 0x1E,
  0xE1, 0xEE, 0x03, 0xDC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xE0, 0xFF,
  0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x0F,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x7C, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0xFC, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xF0,
  0x7E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x7C, 0x00,
  0x7E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01,
  0xF0, 0x3E, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x0F,
  0x80, 0x0F, 0x9F, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xBE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xBC, 0x00, 0x1E, 0x7C, 0x00, 0x7C,
  0xF8, 0x01, 0xF0, 0xF0, 0x03, 0xC1, 0xF0, 0x0F, 0x81, 0xE0, 0x3E, 0x03,
  0xC0, 0x78, 0x07, 0xC1, 0xF0, 0x07, 0x87, 0xC0, 0x0F, 0x9F, 0x00, 0x0F,
  0x3E, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0x60, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x11, 0xF3, 0xE3, 0xC7,
  0xC7, 0x87, 0x0F, 0x08, 0x01, 0xF8, 0x7C, 0x1F, 0xF1, 0xE0, 0xFF, 0xE7,
  0x87, 0xFF, 0xDE, 0x3F, 0x83, 0xF8, 0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0x9F,
  0x00, 0x3C, 0x7C, 0x00, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00,
  0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF8,
  0xF8, 0x0F, 0xE3, 0xF0, 0x6F, 0x87, 0xFF, 0xBF, 0x9F, 0xFC, 0xFE, 0x3F,
  0xE1, 0xF8, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0xFC, 0x07,
  0xCF, 0xF8, 0x1F, 0x7F, 0xF0, 0x7D, 0xFF, 0xE1, 0xEE, 0x1F, 0x8F, 0xE0,
  0x3E, 0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x00, 0x1F,
  0x3C, 0x00, 0x7D, 0xF0, 0x01, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C,
  0x00, 0xF9, 0xF0, 0x07, 0xC7, 0xC0, 0x3F, 0x3F, 0x81, 0xF8, 0xFF, 0xFF,
  0xE3, 0xEF, 0xFF, 0x0F, 0x9F, 0xF0, 0x3C, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0x83, 0xE3, 0xE0, 0x1F,
  0x7C, 0x00, 0xC7, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x08, 0xF8, 0x01, 0xEF, 0x80,
  0x3E, 0xF8, 0x07, 0xC7, 0xE0, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x01, 0xF8,
  0x7C, 0x07, 0xFE, 0x7C, 0x0F, 0xFF, 0x7C, 0x1F, 0xFF, 0x78, 0x1F, 0x81,
  0xF8, 0x3F, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x78, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x05,
  0xE0, 0x7C, 0x1F, 0xE0, 0x7F, 0xFB, 0xE0, 0x7F, 0xF3, 0xE0, 0x3F, 0xE3,
  0xE0, 0x0F, 0xC3, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE1,
  0xFF, 0xFF, 0x1F, 0x83, 0xF3, 0xE0, 0x1F, 0x7C, 0x00, 0xF7, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x81, 0xFE, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xE0,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x8F, 0x80, 0x1E, 0xF8, 0x03, 0xE7, 0xE0,
  0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x06, 0x07, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7E, 0x78, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x3E, 0x07, 0xFE, 0x7C, 0x1F, 0xFE,
  0xF8, 0x7F, 0xFD, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x78, 0x00, 0xF9, 0xF0, 0x01, 0xE3,
  0xE0, 0x03, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7E, 0x3E,
  0x00, 0xF8, 0x7E, 0x02, 0xF0, 0x7E, 0x1D, 0xE0, 0xFF, 0xF7, 0xC0, 0xFF,
  0xCF, 0x81, 0xFF, 0x1F, 0x00, 0xFC, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x60, 0x0F, 0x81, 0xE0, 0x7F, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC3, 0xF0, 0x3E, 0x3F, 0xC1, 0xF3, 0xFF, 0x0F, 0xBF, 0xF8, 0x7F,
  0x87, 0xE3, 0xD0, 0x1F, 0x3F, 0x80, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x1E, 0x00, 0x79, 0xF0, 0x07, 0xCF, 0x80,
  0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x78, 0xF0, 0x03, 0xCF,
  0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x60, 0x3C, 0x1F, 0x03, 0xC3,
  0xF0, 0x7C, 0x7E, 0x07, 0xCF, 0xC0, 0x79, 0xF8, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x80, 0xF8, 0x0E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xE1, 0xF0, 0x1F,
  0x0F, 0x00, 0x7C, 0x78, 0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x3F, 0x00, 0xF8, 0xFF, 0x01, 0xF3, 0xFF, 0x03, 0xEF, 0xFF, 0x07, 0xF8,
  0x7E, 0x0F, 0x40, 0x7C, 0x3F, 0x80, 0xF8, 0x7E, 0x01, 0xE0, 0xF8, 0x03,
  0xC1, 0xF0, 0x0F, 0x03, 0xE0, 0x7C, 0x07, 0x87, 0xE0, 0x1F, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0x78, 0x08, 0xF8, 0xF8, 0x39, 0xF1, 0xF1, 0xFB,
  0xC1, 0xF7, 0xEF, 0x83, 0xFF, 0x9F, 0x03, 0xFE, 0x3E, 0x07, 0xF0, 0x7C,
  0x03, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x02, 0x03, 0xC0, 0x60, 0x78, 0x3E, 0x0F,
  0x0F, 0xE3, 0xE3, 0xF0, 0x7C, 0xFC, 0x0F, 0x3F, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x3C, 0x1E, 0x07, 0xBF, 0x1F,
  0x87, 0xBF, 0x9F, 0xE3, 0xDF, 0xFF, 0xF1, 0xF9, 0xFC, 0xF8, 0xF8, 0x7C,
  0x3C, 0x78, 0x3C, 0x1E, 0x3C, 0x1E, 0x0F, 0x3C, 0x1E, 0x07, 0x1E, 0x0F,
  0x07, 0x8F, 0x07, 0x83, 0xC7, 0x83, 0xC1, 0xE3, 0xC1, 0xE0, 0xF3, 0xE0,
  0xF0, 0x79, 0xE0, 0xF0, 0x78, 0xF0, 0x78, 0x3C, 0x78, 0x3C, 0x1E, 0x3C,
  0x1E, 0x0F, 0x1E, 0x0F, 0x07, 0x9E, 0x07, 0x03, 0xCF, 0x07, 0x83, 0xC7,
  0x83, 0xC1, 0xE0, 0x0F, 0x0F, 0xC0, 0xF8, 0xFF, 0x07, 0xCF, 0xFC, 0x3E,
  0xFF, 0xE1, 0xFE, 0x1F, 0x8F, 0x40, 0x7C, 0x7E, 0x03, 0xE7, 0xE0, 0x1F,
  0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0,
  0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xE3,
  0xC0, 0x0F, 0x1E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1,
  0xF8, 0x1F, 0x1F, 0x80, 0x7C, 0xF8, 0x01, 0xEF, 0x80, 0x0F, 0x7C, 0x00,
  0x7B, 0xE0, 0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xCF, 0x00, 0x3E, 0x7C, 0x03, 0xF3, 0xF0, 0x7F,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x07,
  0xC3, 0xF0, 0x07, 0xCF, 0xF8, 0x07, 0xDF, 0xFC, 0x07, 0xDF, 0xFE, 0x07,
  0xB8, 0x7E, 0x0F, 0xE0, 0x3E, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0xFF, 0xF8, 0x3E, 0xFF, 0xF0, 0x3E,
  0x7F, 0xC0, 0x3C, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x7C, 0x1F,
  0xF9, 0xF0, 0xFF, 0xF7, 0xC7, 0xFF, 0xDF, 0x1F, 0x81, 0xF8, 0xFC, 0x03,
  0xE7, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0x3E, 0x00, 0x3C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80,
  0x3F, 0x3E, 0x00, 0xFC, 0xF8, 0x05, 0xE1, 0xF0, 0x7F, 0x87, 0xFF, 0xBE,
  0x1F, 0xFC, 0xF8, 0x3F, 0xE3, 0xE0, 0x3F, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE0,
  0xFD, 0xFF, 0x8F, 0xE7, 0xFE, 0x7F, 0xBF, 0xFB, 0xFE, 0x03, 0xFC, 0x00,
  0x0F, 0x40, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xF8, 0x0F,
  0x0F, 0x80, 0x10, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x30, 0x01, 0xE3, 0xE0, 0x3F, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x40, 0x78, 0x0E, 0x0F, 0x83, 0xE0, 0xF8, 0x7F, 0x0F, 0x9F, 0xC0,
  0xF3, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x78, 0x01, 0xE3, 0xC0,
  0x0F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xE3,
  0xC0, 0x0F, 0x1E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01,
  0xF3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x1F, 0xC7, 0xE1, 0xFE, 0x3F,
  0xFD, 0xF0, 0xFF, 0xCF, 0x83, 0xFC, 0x78, 0x0F, 0xC3, 0xC0, 0x7F, 0xC0,
  0x33, 0xFE, 0x0F, 0xDF, 0xE0, 0x3F, 0xFF, 0x01, 0xF0, 0x78, 0x07, 0x87,
  0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07,
  0xC3, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x78,
  0x0F, 0x83, 0xC0, 0xFC, 0x1E, 0x1F, 0xC0, 0xF3, 0xFC, 0x07, 0xFF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x1E, 0x0F, 0x06, 0x1E,
  0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x1E, 0x1E, 0x3C, 0x1E, 0x0F, 0x3C,
  0x1E, 0x0F, 0x3C, 0x1E, 0x0F, 0x3C, 0x1C, 0x0F, 0x38, 0x3C, 0x0F, 0x78,
  0x3C, 0x0E, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78,
  0x38, 0x1E, 0x70, 0x78, 0x3C, 0xF0, 0x78, 0x3C, 0xF0, 0xF8, 0x38, 0xF9,
  0xF8, 0x78, 0xFF, 0xB8, 0xF0, 0x7F, 0xBF, 0xE0, 0x7F, 0x1F, 0xC0, 0x3C,
  0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x7E, 0x1F, 0xC0, 0x7F, 0xC7, 0xF8,
  0x3F, 0xF3, 0xFE, 0x1F, 0x9D, 0xC7, 0xCF, 0xC7, 0x60, 0xF3, 0xC1, 0xD8,
  0x3C, 0x40, 0x7C, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x0F,
  0x03, 0xE0, 0x63, 0xC1, 0xF8, 0x3C, 0xF0, 0xFE, 0x3F, 0x3E, 0x73, 0x9F,
  0x8F, 0xFC, 0xFF, 0xC1, 0xFE, 0x3F, 0xE0, 0x7F, 0x8F, 0xE0, 0x0F, 0x81,
  0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x78,
  0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x07,
  0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF8,
  0x3E, 0x07, 0xF0, 0x7E, 0x1F, 0xE0, 0x7F, 0xF7, 0xC0, 0xFF, 0xCF, 0x80,
  0xFF, 0x1E, 0x00, 0xFC, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x40, 0x0F, 0x81, 0xE0, 0x7F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x3C, 0x3F,
  0xF8, 0xF1, 0xFF, 0xFB, 0xC7, 0xFF, 0xFF, 0x3E, 0x0F, 0xFC, 0xF0, 0x0F,
  0xE3, 0xC0, 0x3F, 0x0E, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x20, 0x1F, 0x03, 0xC0, 0xF8,
  0x0F, 0x0F, 0xC0, 0x1C, 0x7F, 0x80, 0x7B, 0xFF, 0xF1, 0xEF, 0xFF, 0xFF,
  0xBC, 0xFF, 0xFC, 0xF0, 0x7F, 0xF3, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x01, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x00,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x0E, 0x07, 0xF0,
  0x0F, 0x0F, 0xF8, 0x1E, 0x1F, 0xF8, 0x1E, 0x3E, 0x7C, 0x3E, 0x3C, 0x3E,
  0x3C, 0x78, 0x1F, 0xF8, 0x78, 0x1F, 0xF8, 0x70, 0x0F, 0xF0, 0xB0, 0x03,
  0xC0,
};

const GFXglyph IBMPlexMono_MediumItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 11, 30, 26, 8, -30 },
  { 43, 15, 13, 26, 8, -32 },
  { 68, 27, 30, 26, 0, -30 },
  { 170, 24, 38, 26, 1, -34 },
  { 284, 30, 30, 26, -1, -30 },
  { 397, 26, 30, 26, 0, -30 },
  { 495, 6, 13, 26, 12, -32 },
  { 505, 17, 39, 26, 8, -33 },
  { 588, 17, 39, 26, 1, -33 },
  { 671, 22, 21, 26, 2, -24 },
  { 729, 21, 22, 26, 3, -24 },
  { 787, 11, 13, 26, 5, -7 },
  { 805, 14, 4, 26, 6, -15 },
  { 812, 7, 7, 26, 8, -7 },
  { 819, 25, 39, 26, 1, -33 },
  { 941, 23, 30, 26, 2, -30 },
  { 1028, 21, 30, 26, 2, -30 },
  { 1107, 23, 30, 26, 1, -30 },
  { 1194, 23, 30, 26, 1, -30 },
  { 1281, 24, 30, 26, 0, -30 },
  { 1371, 24, 30, 26, 1, -30 },
  { 1461, 22, 30, 26, 2, -30 },
  { 1544, 22, 30, 26, 4, -30 },
  { 1627, 24, 30, 26, 1, -30 },
  { 1717, 22, 30, 26, 3, -30 },
  { 1800, 10, 23, 26, 8, -23 },
  { 1829, 13, 29, 26, 5, -23 },
  { 1877, 21, 25, 26, 4, -26 },
  { 1943, 22, 13, 26, 2, -20 },
  { 1979, 21, 25, 26, 2, -26 },
  { 2045, 19, 30, 26, 5, -30 },
  { 2117, 23, 35, 26, 2, -30 },
  { 2218, 24, 30, 26, -1, -30 },
  { 2308, 22, 30, 26, 2, -30 },
  { 2391, 22, 30, 26, 3, -30 },
  { 2474, 23, 30, 26, 2, -30 },
  { 2561, 24, 30, 26, 2, -30 },
  { 2651, 24, 30, 26, 2, -30 },
  { 2741, 23, 30, 26, 2, -30 },
  { 2828, 25, 30, 26, 1, -30 },
  { 2922, 24, 30, 26, 2, -30 },
  { 3012, 22, 30, 26, 2, -30 },
  { 3095, 26, 30, 26, 2, -30 },
  { 3193, 19, 30, 26, 3, -30 },
  { 3265, 26, 30, 26, 1, -30 },
  { 3363, 25, 30, 26, 1, -30 },
  { 3457, 23, 30, 26, 2, -30 },
  { 3544, 23, 30, 26, 2, -30 },
  { 3631, 23, 38, 26, 2, -30 },
  { 3741, 23, 30, 26, 2, -30 },
  { 3828, 24, 30, 26, 1, -30 },
  { 3918, 24, 30, 26, 4, -30 },
  { 4008, 23, 30, 26, 3, -30 },
  { 4095, 24, 30, 26, 4, -30 },
  { 4185, 27, 30, 26, 1, -30 },
  { 4287, 29, 30, 26, -1, -30 },
  { 4396, 24, 30, 26, 4, -30 },
  { 4486, 26, 30, 26, 0, -30 },
  { 4584, 19, 39, 26, 6, -33 },
  { 4677, 12, 39, 26, 7, -33 },
  { 4736, 19, 39, 26, 1, -33 },
  { 4829, 23, 18, 26, 2, -30 },
  { 4881, 21, 4, 26, 0, 4 },
  { 4892, 7, 9, 26, 9, -34 },
  { 4900, 22, 22, 26, 2, -22 },
  { 4961, 22, 32, 26, 2, -32 },
  { 5049, 20, 22, 26, 3, -22 },
  { 5104, 24, 32, 26, 2, -32 },
  { 5200, 20, 22, 26, 3, -22 },
  { 5255, 29, 41, 26, -1, -32 },
  { 5404, 23, 31, 26, 1, -22 },
  { 5494, 21, 32, 26, 2, -32 },
  { 5578, 20, 32, 26, 3, -32 },
  { 5658, 21, 41, 26, 2, -32 },
  { 5766, 23, 32, 26, 2, -32 },
  { 5858, 19, 32, 26, 4, -32 },
  { 5934, 25, 22, 26, 0, -22 },
  { 6003, 21, 22, 26, 2, -22 },
  { 6061, 21, 22, 26, 2, -22 },
  { 6119, 24, 31, 26, 0, -22 },
  { 6212, 22, 31, 26, 2, -22 },
  { 6298, 22, 22, 26, 4, -22 },
  { 6359, 21, 22, 26, 2, -22 },
  { 6417, 20, 30, 26, 3, -30 },
  { 6492, 21, 22, 26, 3, -22 },
  { 6550, 21, 22, 26, 2, -22 },
  { 6608, 24, 22, 26, 1, -22 },
  { 6674, 26, 22, 26, 0, -22 },
  { 6746, 23, 31, 26, 1, -22 },
  { 6836, 22, 22, 26, 2, -22 },
  { 6897, 20, 39, 26, 5, -33 },
  { 6995, 10, 39, 26, 8, -33 },
  { 7044, 21, 39, 26, 1, -33 },
  { 7147, 24, 10, 26, 1, -18 },
};

const GFXfont IBMPlexMono_MediumItalic43pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic43pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic43pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _IBMPLEXMONO_MEDIUMITALIC43PT7B_H_
