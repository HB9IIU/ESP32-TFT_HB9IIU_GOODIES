#ifndef _IBMPLEXMONO_MEDIUMITALIC15PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0xB6, 0x90, 0xD8, 0xDE, 0xF5, 0x20, 0x0D, 0x84, 0x82, 0xCF,
  0x71, 0x21, 0xB3, 0x9C, 0x48, 0x6C, 0x24, 0x00, 0x06, 0x02, 0x07, 0xC6,
  0xB6, 0x41, 0x20, 0xE0, 0x1E, 0x0B, 0x04, 0xB2, 0xCF, 0xC1, 0x00, 0x80,
  0x38, 0xD2, 0x64, 0xD1, 0x28, 0x70, 0x01, 0xC3, 0xD9, 0xA6, 0x49, 0x21,
  0xC0, 0x1E, 0x09, 0x8C, 0xC2, 0x61, 0x63, 0xC3, 0x21, 0x9A, 0xD5, 0xBB,
  0x80, 0x57, 0x1C, 0xC2, 0x10, 0x43, 0x08, 0x20, 0x82, 0x0C, 0x10, 0x30,
  0x30, 0x82, 0x10, 0x84, 0x21, 0x18, 0x8C, 0xCC, 0x00, 0x18, 0x18, 0xDA,
  0xFF, 0x38, 0x68, 0xCC, 0x18, 0x30, 0x67, 0xF1, 0x02, 0x0C, 0x00, 0x76,
  0xC8, 0xF8, 0xF0, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x60, 0x20, 0x30,
  0x10, 0x18, 0x08, 0x0C, 0x0C, 0x00, 0x3C, 0x62, 0x43, 0xC3, 0xDB, 0xDA,
  0x82, 0x86, 0xC4, 0x78, 0x1C, 0xDB, 0x30, 0x40, 0x83, 0x06, 0x0C, 0x19,
  0xFC, 0x1E, 0x33, 0x61, 0x01, 0x03, 0x06, 0x08, 0x30, 0x60, 0xFF, 0x1F,
  0x33, 0x01, 0x03, 0x1C, 0x03, 0x03, 0x03, 0xC6, 0x7C, 0x03, 0x07, 0x0F,
  0x1B, 0x32, 0x62, 0x46, 0xFF, 0x06, 0x04, 0x3F, 0x60, 0x40, 0x40, 0x5C,
  0xE6, 0x06, 0x06, 0xC4, 0x78, 0x0E, 0x30, 0xC3, 0x0D, 0xDC, 0xF0, 0xC3,
  0xC6, 0xF0, 0x7F, 0x43, 0xC6, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x30, 0x60,
  0x3E, 0x63, 0x43, 0x46, 0x38, 0xC6, 0x86, 0x86, 0xC6, 0x78, 0x3C, 0x62,
  0xC3, 0xC3, 0xC6, 0x7E, 0x06, 0x0C, 0x18, 0xF0, 0x6C, 0x00, 0x36, 0x33,
  0x00, 0x00, 0x76, 0xC8, 0x03, 0x06, 0x1C, 0x70, 0xC0, 0x60, 0x38, 0x0C,
  0x04, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x40, 0xE0, 0xE0, 0x70, 0x63, 0x8C,
  0x70, 0x80, 0x7B, 0x38, 0x43, 0x1C, 0xC6, 0x00, 0x63, 0x80, 0x3C, 0x62,
  0x43, 0xDF, 0xD2, 0xB2, 0xB2, 0xB6, 0x9E, 0x80, 0xC0, 0x78, 0x0E, 0x0E,
  0x1A, 0x12, 0x32, 0x22, 0x7F, 0x43, 0xC3, 0xC3, 0x7E, 0xC5, 0x0A, 0x37,
  0x98, 0xF1, 0xE3, 0xC7, 0xF8, 0x1E, 0x23, 0x62, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC2, 0xC6, 0x7C, 0x7C, 0x66, 0x63, 0x43, 0x43, 0xC2, 0xC2, 0xC6, 0xCC,
  0xF8, 0x7F, 0x60, 0x60, 0x40, 0x7E, 0xC0, 0xC0, 0xC0, 0xC0, 0xFC, 0x7F,
  0x60, 0x60, 0x40, 0x7E, 0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0x1E, 0x62, 0x43,
  0xC0, 0xC0, 0xCE, 0xD6, 0xC6, 0xC6, 0x7C, 0x31, 0x98, 0xC8, 0x64, 0x27,
  0xF3, 0x19, 0x8C, 0x86, 0x43, 0x61, 0x00, 0x7F, 0x18, 0x18, 0x18, 0x18,
  0x10, 0x10, 0x30, 0x30, 0xFC, 0x3E, 0x04, 0x18, 0x30, 0x60, 0xC1, 0x42,
  0xCC, 0xF0, 0x63, 0xB3, 0x13, 0x0B, 0x07, 0x87, 0xC3, 0x31, 0x98, 0x84,
  0x43, 0x00, 0x20, 0xC1, 0x83, 0x06, 0x08, 0x10, 0x60, 0xC1, 0xFC, 0x31,
  0x99, 0xCE, 0xEF, 0xF6, 0xD2, 0x49, 0x24, 0x86, 0xC3, 0x61, 0x80, 0x31,
  0x9C, 0xCE, 0x65, 0x26, 0x93, 0x69, 0xBC, 0x8E, 0x47, 0x63, 0x00, 0x3C,
  0x62, 0x43, 0xC3, 0xC3, 0xC2, 0x82, 0x86, 0xCC, 0x78, 0x7E, 0x63, 0x63,
  0x43, 0x42, 0xFC, 0xC0, 0xC0, 0xC0, 0x80, 0x3C, 0x62, 0x43, 0xC3, 0xC3,
  0xC2, 0x82, 0x86, 0xCC, 0x78, 0x10, 0x1A, 0x0C, 0x7E, 0x63, 0x63, 0x43,
  0x42, 0xFC, 0xC8, 0xCC, 0xCC, 0x86, 0x1F, 0x18, 0xC8, 0x04, 0x03, 0xC0,
  0x38, 0x0C, 0x06, 0xC3, 0x3E, 0x00, 0xFF, 0x8C, 0x06, 0x03, 0x01, 0x80,
  0x80, 0x40, 0x60, 0x30, 0x18, 0x00, 0x63, 0x63, 0x43, 0x42, 0xC2, 0xC6,
  0xC6, 0xC6, 0xC4, 0x78, 0xC1, 0xA1, 0x90, 0xCC, 0xC6, 0x63, 0x61, 0xB0,
  0xD0, 0x38, 0x18, 0x00, 0x60, 0xD8, 0x26, 0xC9, 0xB6, 0x5D, 0x95, 0x45,
  0x51, 0xDC, 0x67, 0x39, 0x80, 0x31, 0xCC, 0x41, 0x30, 0x78, 0x0C, 0x07,
  0x03, 0x60, 0x98, 0x62, 0x30, 0xC0, 0xC1, 0xB1, 0x99, 0x84, 0x83, 0xC1,
  0xC0, 0x40, 0x60, 0x30, 0x18, 0x00, 0x3F, 0x80, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x60, 0x60, 0x7F, 0x80, 0x3E, 0x40, 0x81, 0x02, 0x0C, 0x18,
  0x20, 0x40, 0x81, 0x06, 0x0F, 0x80, 0x88, 0x8C, 0x44, 0x46, 0x62, 0x22,
  0x30, 0x3E, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0x4F,
  0x80, 0x1C, 0x1C, 0x34, 0x66, 0x42, 0xC3, 0xFE, 0xD4, 0x3A, 0x8F, 0x1E,
  0x38, 0x70, 0xB7, 0x3B, 0x60, 0xC1, 0x82, 0xE6, 0x68, 0x70, 0xE3, 0xC7,
  0x8A, 0xE0, 0x3C, 0xCF, 0x06, 0x0C, 0x18, 0xB1, 0xBC, 0x03, 0x03, 0x03,
  0x3A, 0x4A, 0xC6, 0xC6, 0x86, 0x86, 0xDC, 0x7C, 0x3C, 0xCF, 0x1E, 0x3F,
  0x98, 0xB1, 0xBC, 0x07, 0xC1, 0x00, 0x40, 0xFE, 0x0C, 0x03, 0x00, 0xC0,
  0x20, 0x08, 0x06, 0x01, 0x82, 0x60, 0x58, 0x0C, 0x00, 0x1D, 0x23, 0x63,
  0x63, 0x43, 0x42, 0x66, 0x3A, 0x06, 0x44, 0xF8, 0x60, 0xC1, 0x83, 0xE6,
  0x68, 0xF1, 0xE3, 0xC7, 0x8A, 0x10, 0x18, 0x30, 0x07, 0xC1, 0x06, 0x0C,
  0x1A, 0x36, 0x58, 0xE0, 0x06, 0x0C, 0x03, 0xE0, 0xC1, 0x83, 0x04, 0x08,
  0x32, 0x64, 0xC5, 0x86, 0x00, 0x60, 0x60, 0x60, 0x5C, 0x66, 0x46, 0xC4,
  0xD8, 0xF2, 0xDB, 0x8C, 0x79, 0x30, 0x40, 0x83, 0x06, 0x0C, 0x10, 0x26,
  0xD0, 0xC0, 0x7B, 0x36, 0xD2, 0x69, 0x24, 0x96, 0x4B, 0x65, 0x36, 0x7C,
  0xCD, 0x1E, 0x3C, 0x78, 0xF1, 0x42, 0x3C, 0xCF, 0x0E, 0x18, 0x70, 0xF3,
  0x3C, 0x3E, 0x33, 0x61, 0x61, 0x63, 0x63, 0x62, 0x5C, 0x40, 0xC0, 0xC0,
  0x3A, 0x97, 0x1E, 0x38, 0x70, 0xF3, 0x3A, 0x0C, 0x18, 0x30, 0xEE, 0xE1,
  0x83, 0x06, 0x08, 0x10, 0x60, 0x3C, 0xC5, 0x03, 0x81, 0xC0, 0xE1, 0x3C,
  0x10, 0x23, 0xF9, 0x83, 0x04, 0x08, 0x13, 0x6C, 0x60, 0x62, 0x8F, 0x1E,
  0x3C, 0x78, 0xB7, 0x3E, 0xE6, 0xCD, 0x8B, 0x34, 0x68, 0x92, 0x38, 0x6D,
  0x36, 0xD2, 0x69, 0x34, 0x92, 0x4B, 0x64, 0xDC, 0x3B, 0xB6, 0x43, 0x21,
  0x00, 0x84, 0xCA, 0x6D, 0xDC, 0x31, 0x21, 0x63, 0x63, 0x63, 0x62, 0x6E,
  0x3A, 0x06, 0x44, 0xF8, 0x7B, 0x4E, 0xCC, 0x18, 0x34, 0x66, 0xE2, 0x9E,
  0x1E, 0x60, 0xC1, 0x81, 0x02, 0x38, 0x18, 0x30, 0xC1, 0x02, 0x07, 0x80,
  0x24, 0xB6, 0xD2, 0x5B, 0x48, 0x3C, 0x18, 0x20, 0xC1, 0x06, 0x03, 0x98,
  0x20, 0x60, 0x40, 0x8E, 0x00, 0x73, 0x92, 0x8C,
};

const GFXglyph IBMPlexMono_MediumItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 10, 9, 3, -10 },
  { 5, 5, 4, 9, 3, -11 },
  { 8, 9, 10, 9, 0, -10 },
  { 20, 9, 14, 9, 0, -12 },
  { 36, 10, 10, 9, 0, -10 },
  { 49, 9, 10, 9, 0, -10 },
  { 61, 2, 4, 9, 4, -11 },
  { 62, 6, 13, 9, 3, -11 },
  { 72, 5, 13, 9, 1, -11 },
  { 81, 8, 7, 9, 1, -8 },
  { 88, 7, 7, 9, 1, -8 },
  { 95, 4, 4, 9, 2, -2 },
  { 97, 5, 1, 9, 2, -5 },
  { 98, 2, 2, 9, 3, -2 },
  { 99, 9, 13, 9, 0, -11 },
  { 114, 8, 10, 9, 1, -10 },
  { 124, 7, 10, 9, 1, -10 },
  { 133, 8, 10, 9, 0, -10 },
  { 143, 8, 10, 9, 0, -10 },
  { 153, 8, 10, 9, 0, -10 },
  { 163, 8, 10, 9, 1, -10 },
  { 173, 7, 10, 9, 1, -10 },
  { 182, 8, 10, 9, 1, -10 },
  { 192, 8, 10, 9, 1, -10 },
  { 202, 8, 10, 9, 1, -10 },
  { 212, 3, 8, 9, 3, -8 },
  { 215, 4, 10, 9, 2, -8 },
  { 220, 8, 9, 9, 1, -9 },
  { 229, 8, 5, 9, 1, -7 },
  { 234, 7, 9, 9, 1, -9 },
  { 242, 6, 10, 9, 2, -10 },
  { 250, 8, 12, 9, 1, -10 },
  { 262, 8, 10, 9, 0, -10 },
  { 272, 7, 10, 9, 1, -10 },
  { 281, 8, 10, 9, 1, -10 },
  { 291, 8, 10, 9, 1, -10 },
  { 301, 8, 10, 9, 1, -10 },
  { 311, 8, 10, 9, 1, -10 },
  { 321, 8, 10, 9, 1, -10 },
  { 331, 9, 10, 9, 0, -10 },
  { 343, 8, 10, 9, 1, -10 },
  { 353, 7, 10, 9, 1, -10 },
  { 362, 9, 10, 9, 1, -10 },
  { 374, 7, 10, 9, 1, -10 },
  { 383, 9, 10, 9, 0, -10 },
  { 395, 9, 10, 9, 0, -10 },
  { 407, 8, 10, 9, 1, -10 },
  { 417, 8, 10, 9, 1, -10 },
  { 427, 8, 13, 9, 1, -10 },
  { 440, 8, 10, 9, 1, -10 },
  { 450, 9, 10, 9, 0, -10 },
  { 462, 9, 10, 9, 1, -10 },
  { 474, 8, 10, 9, 1, -10 },
  { 484, 9, 10, 9, 1, -10 },
  { 496, 10, 10, 9, 0, -10 },
  { 509, 10, 10, 9, 0, -10 },
  { 522, 9, 10, 9, 1, -10 },
  { 534, 9, 10, 9, 0, -10 },
  { 546, 7, 13, 9, 2, -11 },
  { 558, 4, 13, 9, 3, -11 },
  { 565, 7, 13, 9, 0, -11 },
  { 577, 8, 6, 9, 1, -10 },
  { 583, 7, 1, 9, 0, 1 },
  { 584, 2, 3, 9, 3, -12 },
  { 585, 7, 8, 9, 1, -8 },
  { 592, 7, 11, 9, 1, -11 },
  { 602, 7, 8, 9, 1, -8 },
  { 609, 8, 11, 9, 1, -11 },
  { 620, 7, 8, 9, 1, -8 },
  { 627, 10, 14, 9, 0, -11 },
  { 645, 8, 11, 9, 0, -8 },
  { 656, 7, 11, 9, 1, -11 },
  { 666, 7, 11, 9, 1, -11 },
  { 676, 7, 14, 9, 1, -11 },
  { 689, 8, 11, 9, 1, -11 },
  { 700, 7, 11, 9, 1, -11 },
  { 710, 9, 8, 9, 0, -8 },
  { 719, 7, 8, 9, 1, -8 },
  { 726, 7, 8, 9, 1, -8 },
  { 733, 8, 11, 9, 0, -8 },
  { 744, 7, 11, 9, 1, -8 },
  { 754, 7, 8, 9, 2, -8 },
  { 761, 7, 8, 9, 1, -8 },
  { 768, 7, 10, 9, 1, -10 },
  { 777, 7, 8, 9, 1, -8 },
  { 784, 7, 8, 9, 1, -8 },
  { 791, 9, 8, 9, 0, -8 },
  { 800, 9, 8, 9, 0, -8 },
  { 809, 8, 11, 9, 0, -8 },
  { 820, 8, 8, 9, 1, -8 },
  { 828, 7, 13, 9, 2, -11 },
  { 840, 3, 13, 9, 3, -11 },
  { 845, 7, 13, 9, 1, -11 },
  { 857, 8, 3, 9, 1, -6 },
};

const GFXfont IBMPlexMono_MediumItalic15pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic15pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _IBMPLEXMONO_MEDIUMITALIC15PT7B_H_
