#ifndef _IBMPLEXMONO_MEDIUMITALIC19PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x73, 0x18, 0xC4, 0x00, 0x1C, 0xEE, 0x00, 0xCF, 0x3C,
  0xF2, 0xDA, 0x60, 0x06, 0x60, 0x64, 0x04, 0xC0, 0xCC, 0x3C, 0xF7, 0x9F,
  0x19, 0x8F, 0x9E, 0xF3, 0xC3, 0x30, 0x32, 0x02, 0x60, 0x66, 0x00, 0x01,
  0x00, 0x60, 0x3E, 0x0F, 0xF3, 0xA6, 0x64, 0x0C, 0x81, 0xF0, 0x1F, 0x80,
  0xF8, 0x13, 0x22, 0x6E, 0x5C, 0xFF, 0x07, 0xC0, 0x60, 0x08, 0x00, 0x0E,
  0x0C, 0x7C, 0x43, 0x33, 0x0C, 0xD8, 0x33, 0xC0, 0xF8, 0x01, 0xCE, 0x00,
  0x7C, 0x0F, 0x30, 0x6C, 0xC3, 0x33, 0x08, 0xF8, 0xE1, 0xC0, 0x07, 0x83,
  0xF8, 0x63, 0x0C, 0x61, 0x8C, 0x1B, 0x1F, 0xC3, 0x60, 0xC6, 0x18, 0xC7,
  0x1D, 0xFD, 0xE7, 0x9C, 0x6D, 0xB5, 0x80, 0x0E, 0x30, 0xC1, 0x86, 0x08,
  0x30, 0x60, 0xC1, 0x02, 0x04, 0x0C, 0x18, 0x10, 0x30, 0x30, 0x38, 0x18,
  0x30, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x60, 0xC3, 0x0C, 0x18,
  0xC0, 0x06, 0x03, 0x00, 0xC3, 0xB7, 0x7F, 0x87, 0x03, 0x61, 0xD8, 0xE3,
  0x00, 0x06, 0x02, 0x03, 0x01, 0x8F, 0xFF, 0xFC, 0x30, 0x10, 0x18, 0x0C,
  0x00, 0x39, 0x9C, 0xC6, 0x60, 0xFF, 0xF0, 0x7F, 0x60, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x00, 0x0F, 0x0F, 0xE7,
  0x1D, 0x83, 0x60, 0xFB, 0x3C, 0xCF, 0x37, 0xC1, 0xB0, 0x6E, 0x39, 0xFC,
  0x3C, 0x00, 0x0F, 0x0F, 0x8F, 0x8E, 0xC6, 0x60, 0x30, 0x18, 0x1C, 0x0C,
  0x06, 0x03, 0x1F, 0xFF, 0xF8, 0x0F, 0x83, 0xF8, 0xE3, 0x98, 0x70, 0x0E,
  0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x3F, 0xEF, 0xFC, 0x0F,
  0x83, 0xF8, 0xE3, 0x88, 0x70, 0x0C, 0x1F, 0x03, 0xE0, 0x0E, 0x00, 0xC8,
  0x1B, 0x87, 0x3F, 0xC3, 0xE0, 0x01, 0xC0, 0x78, 0x1F, 0x03, 0x60, 0xD8,
  0x33, 0x0C, 0x63, 0x0C, 0xFF, 0xFF, 0xF8, 0x0C, 0x01, 0x80, 0x30, 0x3F,
  0xCF, 0xF3, 0x00, 0x80, 0x6F, 0x1F, 0xE6, 0x18, 0x06, 0x01, 0xA0, 0x6C,
  0x3B, 0xFC, 0x3C, 0x00, 0x07, 0x87, 0x06, 0x06, 0x06, 0xF3, 0xFF, 0x87,
  0x83, 0xC1, 0xE0, 0xF8, 0xEF, 0xE3, 0xC0, 0xFF, 0xFF, 0xEC, 0x1B, 0x0C,
  0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x00,
  0x1F, 0x8F, 0xF7, 0x0D, 0x83, 0x61, 0x8F, 0xC3, 0xF3, 0x86, 0xC1, 0xB0,
  0x6C, 0x3B, 0xFC, 0x7E, 0x00, 0x1F, 0x0F, 0xE7, 0x1D, 0x83, 0x60, 0xF8,
  0x76, 0x19, 0xFE, 0x3D, 0x80, 0xC0, 0x60, 0x70, 0x78, 0x00, 0x39, 0xCC,
  0x00, 0x00, 0x0E, 0xF3, 0x00, 0x1C, 0x71, 0x80, 0x00, 0x00, 0x0E, 0x31,
  0xC6, 0x18, 0xC0, 0x00, 0x81, 0xC3, 0xC7, 0x8F, 0x06, 0x03, 0x80, 0xF0,
  0x1C, 0x03, 0x00, 0x80, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0xFF, 0xBF, 0xE0,
  0x20, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0C, 0x1E, 0x3C, 0x78, 0x70, 0x20,
  0x00, 0x1E, 0x3F, 0x98, 0xF8, 0x70, 0x30, 0x70, 0xE0, 0x60, 0x00, 0x00,
  0x0C, 0x0E, 0x07, 0x00, 0x0F, 0x0F, 0xE3, 0x0D, 0x83, 0x66, 0xF3, 0xFD,
  0x8B, 0x62, 0xD9, 0xB7, 0xED, 0xDB, 0x00, 0xE0, 0x1F, 0x83, 0xE0, 0x07,
  0x81, 0xE0, 0x78, 0x36, 0x0D, 0x86, 0x61, 0x98, 0xC7, 0x3F, 0xDF, 0xF6,
  0x0F, 0x83, 0xC0, 0xC0, 0x3F, 0x8F, 0xE3, 0x1D, 0x83, 0x61, 0x9F, 0xC7,
  0xF1, 0x86, 0x61, 0xB0, 0x6C, 0x3B, 0xFC, 0xFE, 0x00, 0x0F, 0x07, 0xE3,
  0x0D, 0xC3, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x66, 0x39, 0xFC,
  0x3E, 0x00, 0x3F, 0x0F, 0xE3, 0x1D, 0xC3, 0x60, 0xD8, 0x36, 0x0D, 0x87,
  0x61, 0xB0, 0x6C, 0x3B, 0xFC, 0xFC, 0x00, 0x3F, 0xCF, 0xF3, 0x01, 0x80,
  0x60, 0x1F, 0xE7, 0xF9, 0x80, 0x60, 0x30, 0x0C, 0x03, 0xFC, 0xFF, 0x00,
  0x3F, 0xE7, 0xF8, 0xC0, 0x30, 0x06, 0x00, 0xFF, 0x1F, 0xE3, 0x00, 0x60,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x0F, 0x0F, 0xE3, 0x1D, 0x83, 0x60,
  0x38, 0x0C, 0x7B, 0x1E, 0xC1, 0xB0, 0x6E, 0x39, 0xF6, 0x3B, 0x00, 0x30,
  0xCC, 0x36, 0x0D, 0x83, 0x61, 0xDF, 0xE7, 0xF9, 0x86, 0xC1, 0xB0, 0x6C,
  0x1B, 0x0C, 0xC3, 0x00, 0x3F, 0xCF, 0xF0, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x06, 0x01, 0x83, 0xFC, 0xFF, 0x00, 0x1F, 0xC7, 0xE0,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x30, 0xCC, 0x71, 0xF8,
  0x3C, 0x00, 0x30, 0xE6, 0x39, 0xC6, 0x31, 0x86, 0x60, 0xD8, 0x1F, 0x03,
  0xB0, 0xE6, 0x18, 0x63, 0x0C, 0x61, 0xCC, 0x18, 0x38, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xFF, 0xF0, 0x38,
  0x73, 0x8E, 0x3C, 0xE3, 0xDE, 0x3F, 0x62, 0x76, 0x66, 0x66, 0x44, 0x64,
  0xC6, 0x0C, 0x60, 0xC4, 0x0C, 0xC0, 0xC0, 0x38, 0xCE, 0x37, 0x8D, 0xE3,
  0x68, 0xDB, 0x26, 0xD9, 0x36, 0xC5, 0xB1, 0xEC, 0x7B, 0x1C, 0xC7, 0x00,
  0x0F, 0x0F, 0xE7, 0x1D, 0x83, 0x60, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xB0,
  0x6E, 0x39, 0xFC, 0x3C, 0x00, 0x3F, 0x8F, 0xF3, 0x0D, 0xC3, 0x60, 0xD8,
  0x77, 0xF9, 0xFC, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x0F, 0x0F,
  0xE7, 0x1D, 0x83, 0x60, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xB0, 0x6E, 0x39,
  0xFC, 0x3C, 0x03, 0x20, 0xDC, 0x1E, 0x07, 0x00, 0x3F, 0x8F, 0xF3, 0x0D,
  0xC3, 0x60, 0xD8, 0x77, 0xF9, 0xFC, 0x66, 0x39, 0x8C, 0x33, 0x0C, 0xC3,
  0x80, 0x0F, 0x83, 0xFC, 0xE1, 0x98, 0x23, 0x00, 0x7C, 0x07, 0xE0, 0x1E,
  0x00, 0xC8, 0x1B, 0x87, 0x3F, 0xC1, 0xF0, 0xFF, 0xFF, 0xF0, 0xC0, 0x70,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x00,
  0x30, 0xDC, 0x36, 0x0D, 0x83, 0x60, 0xD8, 0x76, 0x1B, 0x06, 0xC1, 0xB0,
  0x6E, 0x31, 0xFC, 0x3E, 0x00, 0xC0, 0xF0, 0x7C, 0x1B, 0x06, 0xC3, 0x18,
  0xC6, 0x61, 0x98, 0x6C, 0x1B, 0x07, 0x81, 0xE0, 0x78, 0x00, 0x60, 0x6C,
  0x0D, 0x01, 0xA7, 0x2C, 0xED, 0x9D, 0xB7, 0xB6, 0xB4, 0xD6, 0x9E, 0xF3,
  0x9E, 0x73, 0xCE, 0x70, 0x38, 0x31, 0x86, 0x18, 0xC0, 0xDC, 0x0F, 0x80,
  0xF0, 0x06, 0x00, 0xF0, 0x1B, 0x03, 0x98, 0x31, 0x86, 0x1C, 0xC0, 0xC0,
  0xC0, 0xF8, 0x31, 0x8E, 0x31, 0x86, 0x60, 0x7C, 0x0F, 0x01, 0xC0, 0x18,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0xE0, 0x1C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xFC,
  0xFF, 0xC0, 0x3F, 0x3F, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60,
  0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xFC, 0xF8, 0xC2, 0x10, 0xC6, 0x30, 0x84,
  0x31, 0x8C, 0x21, 0x8C, 0x61, 0x08, 0x1F, 0x8F, 0xC0, 0x40, 0x20, 0x30,
  0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0xF8,
  0xFC, 0x00, 0x06, 0x03, 0xC1, 0xB0, 0x64, 0x31, 0x98, 0x6E, 0x0D, 0x02,
  0xFF, 0xFF, 0xC0, 0x59, 0xB0, 0x3D, 0xBF, 0xD8, 0x7C, 0x3C, 0x1E, 0x0F,
  0x0D, 0x8E, 0xFB, 0xB9, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x73, 0x7D,
  0xC6, 0xC3, 0x61, 0xB0, 0xF0, 0x7C, 0x7F, 0xF6, 0xF0, 0x1F, 0x1F, 0xDC,
  0x6C, 0x0E, 0x06, 0x03, 0x07, 0xC6, 0x7E, 0x1E, 0x00, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x1C, 0xDF, 0xE6, 0x1B, 0x86, 0xC1, 0xB0, 0x6C, 0x3B, 0x1C,
  0xFB, 0x1E, 0xC0, 0x1F, 0x1F, 0xD8, 0x6C, 0x3F, 0xF7, 0xE3, 0x05, 0xC7,
  0x7F, 0x1F, 0x00, 0x01, 0xF0, 0x3F, 0x03, 0x00, 0x30, 0x3F, 0xF3, 0xFE,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x08, 0xC0,
  0xCC, 0x0E, 0xC0, 0x7C, 0x03, 0x80, 0x0E, 0x67, 0xF8, 0xC3, 0x38, 0x66,
  0x0C, 0xC1, 0x98, 0x73, 0x1C, 0x7F, 0x87, 0xB0, 0x06, 0x21, 0x8F, 0xF0,
  0x7C, 0x00, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x73, 0x7D, 0xC6, 0xC3, 0x61,
  0xB0, 0xF8, 0x78, 0x6C, 0x36, 0x18, 0x06, 0x07, 0x03, 0x80, 0x00, 0x03,
  0xE1, 0xF1, 0x18, 0x18, 0x0C, 0x06, 0x43, 0x31, 0xF0, 0xF0, 0x70, 0x03,
  0x81, 0xC0, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x06, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x31, 0x31, 0x98, 0x6C, 0x3E, 0x0E, 0x00, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x77, 0x1B, 0xE7, 0x19, 0x86, 0x63, 0x1F, 0x0E, 0xCB, 0x37,
  0xC7, 0xB1, 0xC0, 0xF8, 0xF8, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30,
  0x32, 0x67, 0x6E, 0x7C, 0x78, 0x2E, 0xEF, 0xFD, 0xDD, 0xB3, 0x36, 0x66,
  0xCC, 0xD1, 0x16, 0x66, 0xCC, 0xD9, 0x98, 0x77, 0x37, 0xDC, 0x6C, 0x36,
  0x1B, 0x0F, 0x87, 0x86, 0xC3, 0x61, 0x80, 0x1F, 0x1F, 0xD8, 0x7C, 0x3C,
  0x1E, 0x0F, 0x07, 0xC7, 0x7F, 0x1E, 0x00, 0x33, 0x8D, 0xF3, 0x8C, 0xC3,
  0x30, 0xCC, 0x36, 0x0D, 0xC7, 0x7F, 0x9B, 0xC6, 0x01, 0x80, 0xC0, 0x30,
  0x00, 0x1C, 0xDF, 0xE6, 0x1B, 0x86, 0xC1, 0xB0, 0x6C, 0x3B, 0x1C, 0xFF,
  0x1E, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0xFB, 0xFF, 0xCE, 0x07, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x00, 0x1F, 0x1F, 0xD8, 0x4C, 0x07,
  0xE0, 0xF8, 0x0E, 0x86, 0xFF, 0x3F, 0x00, 0x0C, 0x06, 0x02, 0x0F, 0xFF,
  0xF8, 0xC0, 0x60, 0x30, 0x31, 0x18, 0xCD, 0xC7, 0xC3, 0xC0, 0x61, 0xD8,
  0x66, 0x19, 0x86, 0x61, 0xB0, 0x6C, 0x3B, 0x9C, 0x7B, 0x1E, 0xC0, 0xF1,
  0xF8, 0xCC, 0x66, 0x32, 0x1B, 0x0D, 0x8C, 0xCE, 0x7E, 0x3C, 0x00, 0x64,
  0xD3, 0x3C, 0xCF, 0x33, 0xCC, 0xF3, 0x38, 0x8A, 0x66, 0xE9, 0x3B, 0x80,
  0x1C, 0xE7, 0xBD, 0xD5, 0xA3, 0x10, 0x60, 0x0C, 0x33, 0x96, 0x77, 0xF7,
  0x8E, 0x60, 0x30, 0xE6, 0x18, 0xC3, 0x18, 0x63, 0x0C, 0x61, 0x98, 0x63,
  0x9C, 0x3D, 0x87, 0xB0, 0x06, 0x21, 0x8F, 0xF0, 0x78, 0x00, 0x3C, 0xDF,
  0xF4, 0x38, 0x0C, 0x0E, 0x06, 0x07, 0x1B, 0xE6, 0xFF, 0xB3, 0xC0, 0x0F,
  0x87, 0xC6, 0x03, 0x00, 0x80, 0x60, 0x31, 0xF0, 0xF8, 0x04, 0x02, 0x03,
  0x03, 0x01, 0x01, 0x80, 0xFC, 0x3C, 0x00, 0x33, 0x33, 0x22, 0x66, 0x66,
  0x44, 0xCC, 0xCC, 0x80, 0x3E, 0x1F, 0x00, 0x80, 0xC0, 0x40, 0x40, 0x60,
  0x1F, 0x0F, 0x8C, 0x04, 0x03, 0x00, 0x80, 0x40, 0x21, 0xF0, 0xF8, 0x00,
  0x30, 0xDE, 0x3C, 0xDB, 0x3E, 0x87, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 13, 11, 3, -13 },
  { 10, 6, 6, 11, 4, -14 },
  { 15, 12, 13, 11, 0, -13 },
  { 35, 11, 17, 11, 0, -15 },
  { 59, 14, 13, 11, -1, -13 },
  { 82, 11, 13, 11, 0, -13 },
  { 100, 3, 6, 11, 5, -14 },
  { 103, 7, 17, 11, 4, -14 },
  { 118, 7, 17, 11, 1, -14 },
  { 133, 10, 9, 11, 1, -10 },
  { 145, 9, 10, 11, 1, -11 },
  { 157, 5, 6, 11, 2, -3 },
  { 161, 6, 2, 11, 3, -7 },
  { 163, 4, 3, 11, 3, -3 },
  { 165, 11, 17, 11, 0, -14 },
  { 189, 10, 13, 11, 1, -13 },
  { 206, 9, 13, 11, 1, -13 },
  { 221, 11, 13, 11, 0, -13 },
  { 239, 11, 13, 11, 0, -13 },
  { 257, 11, 13, 11, 0, -13 },
  { 275, 10, 13, 11, 1, -13 },
  { 292, 9, 13, 11, 1, -13 },
  { 307, 10, 13, 11, 2, -13 },
  { 324, 10, 13, 11, 1, -13 },
  { 341, 10, 13, 11, 1, -13 },
  { 358, 5, 10, 11, 3, -10 },
  { 365, 6, 13, 11, 2, -10 },
  { 375, 9, 11, 11, 2, -11 },
  { 388, 10, 6, 11, 1, -9 },
  { 396, 9, 11, 11, 1, -11 },
  { 409, 9, 13, 11, 2, -13 },
  { 424, 10, 15, 11, 1, -13 },
  { 443, 10, 13, 11, 0, -13 },
  { 460, 10, 13, 11, 1, -13 },
  { 477, 10, 13, 11, 1, -13 },
  { 494, 10, 13, 11, 1, -13 },
  { 511, 10, 13, 11, 1, -13 },
  { 528, 11, 13, 11, 1, -13 },
  { 546, 10, 13, 11, 1, -13 },
  { 563, 10, 13, 11, 1, -13 },
  { 580, 10, 13, 11, 1, -13 },
  { 597, 10, 13, 11, 1, -13 },
  { 614, 11, 13, 11, 1, -13 },
  { 632, 9, 13, 11, 1, -13 },
  { 647, 12, 13, 11, 0, -13 },
  { 667, 10, 13, 11, 1, -13 },
  { 684, 10, 13, 11, 1, -13 },
  { 701, 10, 13, 11, 1, -13 },
  { 718, 10, 17, 11, 1, -13 },
  { 740, 10, 13, 11, 1, -13 },
  { 757, 11, 13, 11, 0, -13 },
  { 775, 10, 13, 11, 2, -13 },
  { 792, 10, 13, 11, 1, -13 },
  { 809, 10, 13, 11, 2, -13 },
  { 826, 11, 13, 11, 1, -13 },
  { 844, 12, 13, 11, 0, -13 },
  { 864, 11, 13, 11, 2, -13 },
  { 882, 12, 13, 11, 0, -13 },
  { 902, 8, 17, 11, 3, -14 },
  { 919, 5, 17, 11, 3, -14 },
  { 930, 9, 17, 11, 0, -14 },
  { 950, 10, 8, 11, 1, -13 },
  { 960, 9, 2, 11, 0, 2 },
  { 963, 3, 4, 11, 4, -15 },
  { 965, 9, 10, 11, 1, -10 },
  { 977, 9, 14, 11, 1, -14 },
  { 993, 9, 10, 11, 1, -10 },
  { 1005, 10, 14, 11, 1, -14 },
  { 1023, 9, 10, 11, 1, -10 },
  { 1035, 12, 18, 11, 0, -14 },
  { 1062, 11, 14, 11, 0, -10 },
  { 1082, 9, 14, 11, 1, -14 },
  { 1098, 9, 15, 11, 1, -15 },
  { 1115, 9, 19, 11, 1, -15 },
  { 1137, 10, 14, 11, 1, -14 },
  { 1155, 8, 14, 11, 2, -14 },
  { 1169, 11, 10, 11, 0, -10 },
  { 1183, 9, 10, 11, 1, -10 },
  { 1195, 9, 10, 11, 1, -10 },
  { 1207, 10, 14, 11, 0, -10 },
  { 1225, 10, 14, 11, 1, -10 },
  { 1243, 9, 10, 11, 2, -10 },
  { 1255, 9, 10, 11, 1, -10 },
  { 1267, 9, 13, 11, 1, -13 },
  { 1282, 10, 10, 11, 1, -10 },
  { 1295, 9, 10, 11, 1, -10 },
  { 1307, 10, 10, 11, 1, -10 },
  { 1320, 11, 10, 11, 0, -10 },
  { 1334, 11, 14, 11, 0, -10 },
  { 1354, 10, 10, 11, 1, -10 },
  { 1367, 9, 17, 11, 2, -14 },
  { 1387, 4, 17, 11, 4, -14 },
  { 1396, 9, 17, 11, 1, -14 },
  { 1416, 10, 5, 11, 1, -8 },
};

const GFXfont IBMPlexMono_MediumItalic19pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic19pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _IBMPLEXMONO_MEDIUMITALIC19PT7B_H_
