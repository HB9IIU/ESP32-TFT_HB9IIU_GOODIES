#ifndef _IBMPLEXMONO_MEDIUMITALIC65PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x1F, 0xC0, 0xFC,
  0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0xC7, 0xE0, 0x7F, 0x1F, 0x81, 0xFC, 0xFE,
  0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x0F,
  0xE3, 0xF0, 0x3F, 0x9F, 0xC0, 0xFC, 0x7F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7,
  0xE0, 0x7F, 0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xF3, 0xF8, 0x1F, 0x8F, 0xE0,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x80, 0xFC,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE7, 0xDF, 0xFC, 0x07, 0xF8,
  0x3E, 0x1F, 0xE0, 0x7F, 0x81, 0xF0, 0x7C, 0x03, 0xF8, 0x0F, 0x01, 0xC0,
  0x1F, 0xC0, 0xF8, 0x04, 0x01, 0xFE, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x3E,
  0x00, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x00, 0x1F,
  0xE0, 0x78, 0x00, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0x03, 0xFC, 0x3E, 0x00,
  0x00, 0x1F, 0xF9, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x7F, 0xF0, 0x00,
  0x01, 0xF0, 0xFF, 0x80, 0x00, 0x0F, 0x83, 0xFC, 0x00, 0x00, 0x7C, 0x0F,
  0xE0, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0x00,
  0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0xFE, 0x01, 0x00, 0x7C, 0x07, 0xF0,
  0x18, 0x03, 0xE0, 0x3F, 0x83, 0xE0, 0x1F, 0x03, 0xFC, 0x3F, 0x80, 0xF8,
  0x3F, 0xC3, 0xFF, 0x07, 0x83, 0xFE, 0x0F, 0xFE, 0x7C, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xC0,
  0x0F, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x07,
  0xE1, 0xF8, 0x00, 0x7E, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x3E, 0x01, 0xF0, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0x07, 0xC0, 0x1F, 0x81, 0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x0F,
  0x80, 0x01, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x80, 0x3E, 0x0F, 0xC0,
  0x00, 0x7C, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x07, 0xE0, 0x00,
  0x1F, 0x81, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x83, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0x83, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xF8, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x83, 0xFF,
  0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x1F,
  0x00, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x07, 0xC0,
  0x00, 0x7E, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x00,
  0x3E, 0x07, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x00, 0x3F,
  0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0x1F, 0x80,
  0x7C, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x03, 0xF0,
  0xFE, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFB,
  0xFF, 0x80, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x83, 0xF8,
  0x00, 0xFE, 0x00, 0xC7, 0xF0, 0x00, 0xFE, 0x03, 0xEF, 0xE0, 0x03, 0xFC,
  0x0F, 0xFF, 0xE0, 0x07, 0xFC, 0x1F, 0x9F, 0xC0, 0x1D, 0xF8, 0x7E, 0x3F,
  0xC0, 0x3B, 0xF9, 0xFC, 0x7F, 0xC1, 0xE7, 0xF3, 0xF0, 0x7F, 0xFF, 0xC7,
  0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E,
  0x1F, 0x8F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x06,
  0x00, 0x7E, 0x00, 0x63, 0xE0, 0x1F, 0x80, 0xF8, 0xFF, 0x07, 0xE1, 0xFE,
  0x7F, 0xFB, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xF9, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x1F, 0x87, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0xF8, 0x0F,
  0xF7, 0xF8, 0x3F, 0x81, 0xFC, 0xFF, 0x07, 0xF8, 0x3F, 0x9F, 0xC1, 0xFF,
  0x07, 0xF3, 0xF8, 0x3F, 0xE0, 0xFE, 0x7F, 0x07, 0xF8, 0x3F, 0xCF, 0xE0,
  0x7F, 0x07, 0xFB, 0xFC, 0x0F, 0xC0, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x1F, 0xE1, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xDF, 0xC0, 0x00, 0xFF, 0x9F, 0xC0, 0x03, 0xFF, 0x1F, 0xC0, 0x07,
  0xFC, 0x1F, 0xC0, 0x0F, 0xF8, 0x3F, 0x80, 0x1F, 0xF0, 0x3F, 0x80, 0x3F,
  0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0x80, 0x3F, 0x80, 0x02,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x30, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0x80, 0x00, 0xFF, 0x00,
  0x30, 0x00, 0x0F, 0xF0, 0x02, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x40, 0x00, 0x07, 0xF8, 0x1E, 0x00, 0x00, 0xFF,
  0x03, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x7F,
  0x80, 0x00, 0x3E, 0x1F, 0xFE, 0x00, 0x07, 0xE3, 0xFF, 0xF8, 0x00, 0x7E,
  0x7F, 0xFF, 0xC0, 0x07, 0xEF, 0xFF, 0xFE, 0x00, 0x7D, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x00,
  0xFF, 0x80, 0x04, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x04, 0x00, 0x00, 0x7F, 0x00, 0xE0,
  0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF8,
  0xFF, 0xF0, 0x03, 0xF9, 0xFF, 0xFE, 0x03, 0xF9, 0xFF, 0xFF, 0x81, 0xFD,
  0xFF, 0xFF, 0xC1, 0xFD, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFC, 0x7F,
  0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0x9F,
  0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F,
  0xCF, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE7,
  0xE0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x00, 0xFE,
  0x1F, 0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x03, 0xF8, 0xFF, 0x00,
  0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF0,
  0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0,
  0x07, 0xFE, 0x7F, 0xF0, 0x1E, 0xFE, 0x3F, 0xFF, 0xFD, 0xFC, 0x3F, 0xFF,
  0xF9, 0xFC, 0x1F, 0xFF, 0xF3, 0xF8, 0x0F, 0xFF, 0xE3, 0xF8, 0x07, 0xFF,
  0xC7, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x07, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x81, 0xFF,
  0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC1,
  0xFF, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x3F, 0xE0, 0x7F,
  0xE7, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xF1, 0xC0, 0x00, 0x7F, 0x04, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x07, 0xC3, 0xF0, 0x07, 0xC1, 0xF1, 0xF8, 0x07, 0xFC,
  0xFC, 0x7E, 0x03, 0xFF, 0xBF, 0x1F, 0x81, 0xFF, 0xEF, 0xCF, 0xC0, 0xFF,
  0xFF, 0xF3, 0xF0, 0x3F, 0x83, 0xFC, 0xFC, 0x1F, 0xC0, 0x7E, 0x3F, 0x07,
  0xE0, 0x1F, 0x8F, 0xC3, 0xF8, 0x07, 0xE7, 0xE0, 0xFC, 0x01, 0xF9, 0xF8,
  0x3F, 0x00, 0x7E, 0x7E, 0x1F, 0xC0, 0x1F, 0x9F, 0x87, 0xE0, 0x07, 0xC7,
  0xE1, 0xF8, 0x01, 0xF1, 0xF8, 0x7E, 0x00, 0xFC, 0x7C, 0x1F, 0x80, 0x3F,
  0x3F, 0x07, 0xE0, 0x0F, 0xCF, 0xC1, 0xF8, 0x03, 0xF3, 0xF0, 0x7E, 0x01,
  0xF8, 0xFC, 0x1F, 0x80, 0x7E, 0x3F, 0x07, 0xE0, 0x3F, 0x8F, 0xC1, 0xF8,
  0x1F, 0xE3, 0xF0, 0x7F, 0x9D, 0xF8, 0xFC, 0x0F, 0xFF, 0x7E, 0x3F, 0x03,
  0xFF, 0x9F, 0x0F, 0xC0, 0x7F, 0xE7, 0xC3, 0xF0, 0x0F, 0xF3, 0xF0, 0xFC,
  0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x0F, 0xF8,
  0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFF, 0x07,
  0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x0E, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1C, 0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x3F, 0xF0, 0x0F, 0xE0, 0x03, 0xFE,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0,
  0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x3F,
  0xC7, 0xF0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xE0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFE, 0x07, 0xF0, 0x07, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1C, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x0F,
  0xFF, 0xF3, 0xFC, 0x03, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xFE, 0x3F, 0xC0,
  0x3F, 0xFF, 0x8F, 0xE0, 0x0F, 0xFF, 0xE3, 0xF8, 0x03, 0xFF, 0xF8, 0xFE,
  0x01, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03,
  0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x7B, 0xF8, 0x0F, 0xFF, 0xFE, 0xFE, 0x03, 0xFF,
  0xFF, 0x3F, 0x00, 0x7F, 0xFF, 0x8F, 0xC0, 0x0F, 0xFF, 0xC3, 0xF0, 0x00,
  0xFF, 0xE1, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x01, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x07,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x00, 0x0F, 0xE0, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0xFF, 0x80,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xBF, 0xC0, 0x00, 0x07,
  0xFF, 0x8F, 0xE0, 0x00, 0x03, 0xFF, 0x87, 0xF8, 0x00, 0x01, 0xFF, 0x83,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xDF,
  0x01, 0xF7, 0xE0, 0x1F, 0xBE, 0x07, 0xEF, 0xC0, 0x7F, 0x7E, 0x1F, 0x9F,
  0x80, 0xFC, 0xFC, 0x3F, 0x3F, 0x01, 0xF8, 0xF8, 0xFC, 0xFE, 0x03, 0xF1,
  0xF1, 0xF9, 0xFC, 0x07, 0xE3, 0xF7, 0xE3, 0xF0, 0x1F, 0xC7, 0xEF, 0xC7,
  0xE0, 0x3F, 0x8F, 0xFF, 0x0F, 0xC0, 0x7E, 0x0F, 0xFC, 0x1F, 0x80, 0xFC,
  0x1F, 0xF8, 0x7F, 0x01, 0xF8, 0x3F, 0xE0, 0xFE, 0x03, 0xF0, 0x7F, 0xC1,
  0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F,
  0x81, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xC0,
  0x7F, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x07, 0xF0, 0x0E, 0x01, 0xF8, 0x0F,
  0xE0, 0x18, 0x03, 0xF0, 0x1F, 0xC0, 0x30, 0x0F, 0xE0, 0x3F, 0x00, 0x40,
  0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x7F,
  0xE0, 0x00, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xE0, 0x1F, 0xFC, 0x00, 0x3F,
  0x00, 0xFF, 0xE0, 0x01, 0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x7F, 0xF8,
  0x00, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0x00,
  0xFD, 0xF8, 0x01, 0xF8, 0x07, 0xEF, 0xC0, 0x0F, 0xC0, 0x7F, 0x7F, 0x00,
  0x7E, 0x03, 0xF9, 0xF8, 0x07, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0x80, 0xFC,
  0x7E, 0x01, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x7E,
  0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x1F, 0xC3, 0xF0, 0x3F, 0x80, 0xFE, 0x1F,
  0x81, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x7E, 0x01,
  0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0xC0, 0xFC, 0x3F, 0x80, 0xFE, 0x07, 0xE1,
  0xFC, 0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x7E, 0x01, 0xF8,
  0x07, 0xE3, 0xF0, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0xFE, 0x01, 0xF9, 0xFC,
  0x07, 0xF0, 0x0F, 0xCF, 0xE0, 0x3F, 0x80, 0x7F, 0x7F, 0x01, 0xF8, 0x01,
  0xFB, 0xF0, 0x0F, 0xC0, 0x0F, 0xDF, 0x80, 0x7E, 0x00, 0x7F, 0xFC, 0x07,
  0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0x80, 0x0F, 0xFF, 0x01, 0xF8, 0x00, 0x7F,
  0xF8, 0x0F, 0xC0, 0x03, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0xFC, 0x03, 0xF0,
  0x00, 0xFF, 0xE0, 0x3F, 0x80, 0x03, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xF8,
  0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03,
  0xFC, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x01, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x07, 0xF3, 0xFC,
  0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x03,
  0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFE,
  0x00, 0x1F, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xE0,
  0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xC0,
  0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00,
  0x3F, 0x9F, 0xE0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x00,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x20, 0x00, 0x07, 0xF0, 0x06, 0x00,
  0x00, 0xFF, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x3F,
  0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFE,
  0x00, 0x1F, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xE0,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x00, 0x0E, 0x00,
  0xFE, 0x00, 0x00, 0x20, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x08, 0x00, 0x00, 0x7F, 0x80,
  0xC0, 0x00, 0x03, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x03,
  0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFE,
  0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF0,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x1F, 0x80, 0xFF, 0x01, 0xF8, 0x1F, 0x80,
  0xFF, 0x01, 0xF8, 0x1F, 0x81, 0xFF, 0x01, 0xF8, 0x1F, 0x81, 0xFF, 0x03,
  0xF0, 0x1F, 0x81, 0xFF, 0x03, 0xF0, 0x1F, 0x83, 0xFF, 0x03, 0xF0, 0x1F,
  0x83, 0xFF, 0x03, 0xF0, 0x3F, 0x83, 0xFF, 0x07, 0xE0, 0x3F, 0x07, 0xDF,
  0x07, 0xE0, 0x3F, 0x07, 0xDF, 0x07, 0xE0, 0x3F, 0x07, 0xDF, 0x07, 0xE0,
  0x3F, 0x0F, 0x9F, 0x0F, 0xC0, 0x3F, 0x0F, 0x9F, 0x0F, 0xC0, 0x3F, 0x0F,
  0x9F, 0x0F, 0xC0, 0x3F, 0x1F, 0x1F, 0x0F, 0xC0, 0x3F, 0x1F, 0x1F, 0x0F,
  0x80, 0x3F, 0x1F, 0x1F, 0x1F, 0x80, 0x7E, 0x3E, 0x1F, 0x1F, 0x80, 0x7E,
  0x3E, 0x1F, 0x1F, 0x80, 0x7E, 0x7C, 0x1F, 0x1F, 0x80, 0x7E, 0x7C, 0x1F,
  0x3F, 0x00, 0x7E, 0x7C, 0x1F, 0x3F, 0x00, 0x7E, 0xF8, 0x1F, 0xBF, 0x00,
  0x7E, 0xF8, 0x1F, 0xBF, 0x00, 0x7E, 0xF8, 0x1F, 0xBE, 0x00, 0x7F, 0xF0,
  0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0xFE, 0x3F,
  0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x01, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xEF,
  0x80, 0x00, 0x03, 0xE0, 0xC0, 0x00, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x04, 0x07, 0x0F, 0xC3,
  0xF8, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x07,
  0x81, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0xFC, 0x1F, 0xC0, 0x3F,
  0xFF, 0x1F, 0xC0, 0x3F, 0xFF, 0xCF, 0xE0, 0x3F, 0xFF, 0xF7, 0xF0, 0x3F,
  0xFF, 0xFB, 0xF8, 0x3F, 0xF0, 0x1D, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x1F,
  0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC,
  0x7F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x07,
  0xFC, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xFE, 0x07, 0xFC, 0x0F,
  0x7F, 0xF3, 0xFF, 0xFF, 0x3F, 0xF8, 0xFF, 0xFF, 0x9F, 0xFC, 0x7F, 0xFF,
  0x87, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0xFF, 0xE0, 0x07, 0xF0, 0xFF,
  0xFC, 0x03, 0xF8, 0xFF, 0xFE, 0x03, 0xFC, 0xFF, 0xFF, 0x81, 0xFC, 0xFF,
  0xFF, 0xE0, 0xFE, 0xF8, 0x1F, 0xF0, 0x7F, 0x70, 0x07, 0xF8, 0x3F, 0xF0,
  0x01, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0x8F, 0xF0,
  0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x7F,
  0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xFC, 0x0F, 0xFE,
  0x1F, 0xDF, 0xFF, 0xFE, 0x0F, 0xE7, 0xFF, 0xFE, 0x07, 0xF3, 0xFF, 0xFE,
  0x03, 0xF8, 0xFF, 0xFE, 0x01, 0xFC, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xE0, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x01, 0xFC,
  0x7F, 0x00, 0x03, 0xC3, 0xFC, 0x00, 0x0C, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0x0F, 0xE0, 0x00, 0x0E, 0x3F, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x1F, 0xF0, 0x07, 0xF8, 0x3F,
  0xE0, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xFF,
  0xC3, 0xF8, 0x00, 0xFF, 0xFE, 0x3F, 0x80, 0x1F, 0xFF, 0xF3, 0xF8, 0x03,
  0xFF, 0xFF, 0x3F, 0x80, 0x7F, 0xFF, 0xFB, 0xF8, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0x00, 0x1F, 0xF8, 0x07, 0xF8, 0x03, 0xBF, 0x80, 0x7F,
  0xC0, 0xFB, 0xF8, 0x07, 0xFF, 0xFF, 0x3F, 0x80, 0x3F, 0xFF, 0xE7, 0xF0,
  0x01, 0xFF, 0xFC, 0x7F, 0x00, 0x1F, 0xFF, 0x87, 0xF0, 0x00, 0x7F, 0xF0,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x87, 0xFC,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0xFF, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0x7F, 0x9F, 0xC0, 0x07, 0xFF, 0x3F, 0x80, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x20, 0x7F, 0x00, 0x00, 0xF0, 0xFE, 0x00, 0x03, 0xF1,
  0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xC3, 0xFE, 0x03, 0xFF, 0x07,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x08,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xC7, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x03, 0xFF, 0xC1, 0xFC, 0x00, 0xFF, 0xFE, 0x3F, 0x80, 0x3F,
  0xFF, 0xC7, 0xF0, 0x0F, 0xFF, 0xFC, 0xFE, 0x03, 0xFF, 0xFF, 0xDF, 0xC0,
  0xFF, 0xE0, 0x7B, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x0F, 0xE1, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xF8,
  0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x3B, 0xF8, 0x0F, 0xFC, 0x1F, 0x7F, 0x00,
  0xFF, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0xF1, 0xFC, 0x01, 0xFF, 0xFE, 0x7F,
  0x00, 0x1F, 0xFF, 0x8F, 0xE0, 0x01, 0xFF, 0xC1, 0xFC, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x02, 0x00, 0x01, 0xFC, 0x00,
  0x60, 0x00, 0x7F, 0x80, 0x1E, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0xF0, 0x07, 0xF0, 0xFF, 0xF8, 0x07,
  0xF1, 0xFF, 0xFC, 0x07, 0xF3, 0xFF, 0xFC, 0x07, 0xF7, 0xFF, 0xFE, 0x0F,
  0xF7, 0x83, 0xFE, 0x0F, 0xEE, 0x01, 0xFE, 0x0F, 0xEC, 0x00, 0xFF, 0x0F,
  0xF8, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x1F,
  0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x3F,
  0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F,
  0x80, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x06, 0x00, 0x3F, 0x80, 0x3C, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8,
  0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x01, 0xFC, 0x1F,
  0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x3F, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x08, 0x00, 0x7F, 0x00, 0x0C, 0x00, 0x7F, 0x00, 0x3E,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x0F, 0xF9, 0xFC, 0x00, 0x07, 0xFD, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x83, 0xFF, 0x80, 0x07, 0xF0, 0xFF,
  0xFC, 0x00, 0xFE, 0x3F, 0xFF, 0x80, 0x1F, 0xCF, 0xFF, 0xF8, 0x03, 0xFB,
  0xFF, 0xFF, 0x00, 0xFF, 0x78, 0x3F, 0xF0, 0x1F, 0xDC, 0x01, 0xFE, 0x03,
  0xFB, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x7E,
  0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xF0, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x07,
  0xF1, 0xFF, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x20, 0x7F, 0x0F, 0xE0, 0x06, 0x1F, 0xE0, 0xFE,
  0x01, 0xE3, 0xF8, 0x1F, 0xC0, 0xFE, 0x7F, 0x03, 0xFC, 0x3F, 0xEF, 0xE0,
  0x3F, 0x8F, 0xF1, 0xFC, 0x07, 0xFB, 0xFC, 0x3F, 0x80, 0x7F, 0xFF, 0x0F,
  0xE0, 0x0F, 0xFF, 0xC1, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0x80, 0x1F, 0xFC,
  0x07, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x80, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x18, 0x03, 0xF8, 0x03,
  0xC0, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x07,
  0xF0, 0x3F, 0xC0, 0x7F, 0x07, 0xF8, 0x07, 0xF1, 0xFF, 0x00, 0x7F, 0x3F,
  0xE0, 0x07, 0xE7, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0x1F, 0x8F, 0xF0, 0x7F, 0xC0,
  0x7E, 0x7F, 0xE3, 0xFF, 0x81, 0xF9, 0xFF, 0x8F, 0xFE, 0x07, 0xEF, 0xFE,
  0x7F, 0xF8, 0x1F, 0xBF, 0xFF, 0xFF, 0xF0, 0x7F, 0xC7, 0xFE, 0x1F, 0xC3,
  0xFC, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0xFE,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x7E, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x07, 0xE1, 0xF8, 0x07, 0xE0,
  0x1F, 0x87, 0xE0, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x7E,
  0x01, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x0F, 0x83, 0xF0,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x07,
  0xE0, 0xFC, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x7E, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x07, 0xF0, 0x7F, 0xF0, 0x07, 0xF0, 0xFF, 0xF8, 0x07, 0xF1, 0xFF, 0xFC,
  0x07, 0xF3, 0xFF, 0xFC, 0x07, 0xF7, 0xFF, 0xFE, 0x0F, 0xE7, 0x83, 0xFE,
  0x0F, 0xEE, 0x01, 0xFE, 0x0F, 0xEC, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF,
  0x0F, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0xFE,
  0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xF8,
  0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x7F,
  0x80, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF,
  0x87, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFF,
  0xE0, 0x00, 0xFE, 0x1F, 0xFF, 0x80, 0x0F, 0xE3, 0xFF, 0xF8, 0x01, 0xFC,
  0x7F, 0xFF, 0xC0, 0x1F, 0xCF, 0xFF, 0xFE, 0x01, 0xFD, 0xF0, 0x3F, 0xE0,
  0x1F, 0xDC, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x1F, 0xF0, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xFE,
  0x07, 0xFF, 0x01, 0xFD, 0xFF, 0xFF, 0xE0, 0x1F, 0xCF, 0xFF, 0xFC, 0x01,
  0xFC, 0xFF, 0xFF, 0x80, 0x1F, 0xC7, 0xFF, 0xF0, 0x01, 0xFC, 0x3F, 0xFC,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xFE, 0x1F, 0xC0, 0x3F, 0xFF, 0x8F,
  0xE0, 0x3F, 0xFF, 0xE7, 0xF0, 0x3F, 0xFF, 0xF3, 0xF8, 0x3F, 0xFF, 0xFD,
  0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x1F, 0xE0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x0F, 0xE7, 0xF8, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x80,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xFC, 0x1F,
  0xC0, 0x07, 0xFE, 0x0F, 0xF0, 0x07, 0x7F, 0x07, 0xFC, 0x0F, 0xBF, 0x83,
  0xFF, 0xFF, 0x9F, 0xC0, 0xFF, 0xFF, 0x9F, 0xC0, 0x3F, 0xFF, 0x8F, 0xE0,
  0x1F, 0xFF, 0x87, 0xF0, 0x03, 0xFF, 0x83, 0xF8, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0xFF, 0xFF,
  0x0F, 0xFE, 0xFF, 0xFF, 0x1F, 0xFE, 0xFF, 0xFE, 0x3F, 0xFE, 0xFF, 0xFE,
  0x7F, 0xFC, 0x00, 0xFE, 0xF8, 0x00, 0x00, 0xFE, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x78, 0x0F, 0xF0, 0x00, 0x10, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x08, 0x00,
  0x01, 0xFC, 0x1C, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0xFF, 0xC0,
  0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x18, 0x03, 0xF8, 0x00, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7F, 0x80, 0xFE, 0x03, 0xFF, 0x03, 0xF8, 0x3F, 0xF0, 0x0F, 0xC1, 0xFF,
  0x80, 0x7F, 0x0F, 0xF8, 0x01, 0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x17, 0xF0, 0x7F, 0x00, 0x37, 0xF0, 0x7F, 0x80, 0x67, 0xF0, 0x7F,
  0xC1, 0xEF, 0xE0, 0x7F, 0xFF, 0xCF, 0xE0, 0x3F, 0xFF, 0xCF, 0xE0, 0x3F,
  0xFF, 0x8F, 0xE0, 0x1F, 0xFF, 0x0F, 0xE0, 0x0F, 0xFE, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x19, 0xFF, 0xF8, 0x01, 0xFB, 0xFF,
  0xE0, 0x0F, 0xF7, 0xFF, 0xC0, 0x0F, 0xEF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03,
  0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0xFF, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF8,
  0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0x03, 0xFF, 0x00,
  0xFE, 0x0F, 0xFC, 0x01, 0xF8, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x81,
  0xF8, 0x0F, 0xC1, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x07, 0xC0, 0x3F, 0x03,
  0xE1, 0xF8, 0x07, 0xC0, 0x7E, 0x3F, 0x00, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F,
  0x01, 0xF8, 0xFC, 0x07, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x07, 0xE3, 0xE0,
  0x1F, 0x80, 0xFC, 0xFC, 0x03, 0xF0, 0x1F, 0x9F, 0x80, 0x7C, 0x03, 0xF3,
  0xF0, 0x1F, 0x80, 0x7E, 0x7E, 0x03, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x01,
  0xF9, 0xF0, 0x0F, 0xC0, 0x3F, 0x7E, 0x01, 0xF8, 0x07, 0xEF, 0xC0, 0x3E,
  0x00, 0xFD, 0xF8, 0x0F, 0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0x07, 0xE7, 0xE0,
  0x3F, 0x00, 0xFC, 0xF8, 0x07, 0xE0, 0x1F, 0x9F, 0x00, 0xFC, 0x07, 0xE7,
  0xE0, 0x3F, 0x80, 0xFC, 0xFC, 0x07, 0xE0, 0x1F, 0x9F, 0x80, 0xFC, 0x07,
  0xE3, 0xF0, 0x3F, 0x80, 0xFC, 0x7E, 0x0E, 0xF0, 0x3F, 0x0F, 0xE3, 0xDE,
  0x0F, 0xE1, 0xFF, 0xF3, 0xE3, 0xF8, 0x3F, 0xFE, 0x7F, 0xFE, 0x07, 0xFF,
  0x8F, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xF8, 0x1F, 0xF8, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0xC3, 0xFF,
  0xE0, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xFF, 0x9F, 0xFF, 0x81, 0xFF,
  0x3F, 0x3C, 0x3F, 0x8F, 0xFC, 0x7E, 0xF0, 0x7F, 0x1F, 0xE0, 0xFD, 0xC0,
  0x7E, 0x3F, 0x81, 0xFB, 0x80, 0xFC, 0x3C, 0x03, 0xFE, 0x01, 0xF8, 0x20,
  0x07, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x20, 0x7E, 0x01, 0xFF,
  0x00, 0x60, 0xFC, 0x03, 0xFE, 0x01, 0xE1, 0xF8, 0x0E, 0xFC, 0x0F, 0xE3,
  0xF0, 0x1D, 0xF8, 0x3F, 0xC7, 0xF0, 0x7B, 0xF1, 0xFF, 0x0F, 0xE1, 0xE3,
  0xE7, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xFE, 0x01, 0xFC, 0x00,
  0xDF, 0xC0, 0x3F, 0xC0, 0x3B, 0xF8, 0x07, 0xFC, 0x1E, 0x7F, 0x00, 0xFF,
  0xFF, 0xDF, 0xC0, 0x0F, 0xFF, 0xF3, 0xF8, 0x01, 0xFF, 0xFC, 0x7F, 0x00,
  0x1F, 0xFF, 0x0F, 0xE0, 0x01, 0xFF, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x02, 0x00, 0x01, 0xFC, 0x00, 0x40,
  0x00, 0x7F, 0x80, 0x1E, 0x00, 0x3F, 0xE0, 0x07, 0xF0, 0x1F, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xFF, 0x81, 0xFC, 0x07,
  0xFF, 0xFC, 0x3F, 0x81, 0xFF, 0xFF, 0xE7, 0xE0, 0x7F, 0xFF, 0xFE, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xF0, 0x7E, 0x00, 0x3F,
  0xFE, 0x0F, 0xC0, 0x01, 0xFF, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x3E, 0x00,
  0x0F, 0xF0, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x02, 0x00, 0x03, 0xFC, 0x01, 0xC0, 0x00, 0xFF,
  0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x1F, 0xF0, 0x01, 0xF8, 0x07,
  0xF8, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x7F, 0xF8, 0x00, 0x7C,
  0x3F, 0xFF, 0xF0, 0x0F, 0xC7, 0xFF, 0xFF, 0xF1, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0x87, 0xFF, 0xFF, 0xC3, 0xF0, 0x1F, 0xFF, 0xF8, 0x7E, 0x00,
  0xFF, 0xFE, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x03,
  0xFF, 0xC0, 0x07, 0xE0, 0x7F, 0xFE, 0x00, 0x7E, 0x0F, 0xFF, 0xE0, 0x07,
  0xC0, 0xFF, 0xFF, 0x00, 0xFC, 0x1F, 0xC7, 0xF8, 0x0F, 0xC3, 0xF8, 0x3F,
  0x81, 0xF8, 0x3F, 0x01, 0xFC, 0x3F, 0x83, 0xF0, 0x0F, 0xFF, 0xF0, 0x7E,
  0x00, 0xFF, 0xFE, 0x07, 0xE0, 0x07, 0xFF, 0xE0, 0x7C, 0x00, 0x3F, 0xFC,
  0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 16, 46, 39, 12, -45 },
  { 93, 22, 19, 39, 12, -48 },
  { 146, 41, 45, 39, 0, -45 },
  { 377, 37, 61, 39, 1, -53 },
  { 660, 45, 47, 39, -2, -46 },
  { 925, 39, 47, 39, 0, -46 },
  { 1155, 10, 19, 39, 18, -48 },
  { 1179, 26, 58, 39, 12, -49 },
  { 1368, 26, 58, 39, 2, -49 },
  { 1557, 34, 32, 39, 3, -36 },
  { 1693, 32, 32, 39, 4, -36 },
  { 1821, 17, 19, 39, 8, -10 },
  { 1862, 20, 6, 39, 10, -23 },
  { 1877, 11, 11, 39, 12, -10 },
  { 1893, 38, 58, 39, 1, -49 },
  { 2169, 35, 47, 39, 3, -46 },
  { 2375, 32, 45, 39, 3, -45 },
  { 2555, 36, 46, 39, 1, -46 },
  { 2762, 36, 47, 39, 1, -46 },
  { 2974, 36, 45, 39, 1, -45 },
  { 3177, 36, 46, 39, 2, -45 },
  { 3384, 33, 46, 39, 3, -45 },
  { 3574, 34, 45, 39, 6, -45 },
  { 3766, 36, 47, 39, 2, -46 },
  { 3978, 32, 46, 39, 5, -46 },
  { 4162, 15, 35, 39, 12, -34 },
  { 4228, 19, 43, 39, 8, -34 },
  { 4331, 31, 38, 39, 6, -39 },
  { 4479, 34, 20, 39, 3, -30 },
  { 4564, 32, 38, 39, 3, -39 },
  { 4716, 28, 47, 39, 8, -46 },
  { 4881, 34, 53, 39, 3, -46 },
  { 5107, 36, 45, 39, -1, -45 },
  { 5310, 34, 45, 39, 3, -45 },
  { 5502, 34, 47, 39, 4, -46 },
  { 5702, 34, 45, 39, 3, -45 },
  { 5894, 36, 45, 39, 3, -45 },
  { 6097, 36, 45, 39, 3, -45 },
  { 6300, 34, 47, 39, 4, -46 },
  { 6500, 37, 45, 39, 2, -45 },
  { 6709, 37, 45, 39, 2, -45 },
  { 6918, 34, 46, 39, 3, -45 },
  { 7114, 41, 45, 39, 2, -45 },
  { 7345, 29, 45, 39, 4, -45 },
  { 7509, 39, 45, 39, 1, -45 },
  { 7729, 37, 45, 39, 2, -45 },
  { 7938, 35, 47, 39, 3, -46 },
  { 8144, 35, 45, 39, 3, -45 },
  { 8341, 35, 59, 39, 3, -46 },
  { 8600, 35, 45, 39, 3, -45 },
  { 8797, 37, 47, 39, 1, -46 },
  { 9015, 37, 45, 39, 5, -45 },
  { 9224, 35, 46, 39, 4, -45 },
  { 9426, 36, 45, 39, 6, -45 },
  { 9629, 40, 45, 39, 2, -45 },
  { 9854, 44, 45, 39, -2, -45 },
  { 10102, 37, 45, 39, 6, -45 },
  { 10311, 40, 45, 39, 0, -45 },
  { 10536, 29, 58, 39, 9, -49 },
  { 10747, 18, 58, 39, 11, -49 },
  { 10878, 29, 58, 39, 1, -49 },
  { 11089, 34, 27, 39, 3, -45 },
  { 11204, 32, 6, 39, 0, 6 },
  { 11228, 10, 14, 39, 14, -52 },
  { 11246, 33, 35, 39, 3, -34 },
  { 11391, 33, 49, 39, 3, -48 },
  { 11594, 30, 35, 39, 4, -34 },
  { 11726, 36, 49, 39, 3, -48 },
  { 11947, 31, 35, 39, 4, -34 },
  { 12083, 43, 62, 39, -1, -48 },
  { 12417, 35, 48, 39, 1, -34 },
  { 12627, 32, 48, 39, 3, -48 },
  { 12819, 30, 50, 39, 5, -49 },
  { 13007, 32, 63, 39, 2, -49 },
  { 13259, 35, 49, 39, 3, -48 },
  { 13474, 28, 49, 39, 6, -48 },
  { 13646, 38, 34, 39, 0, -34 },
  { 13808, 32, 34, 39, 3, -34 },
  { 13944, 31, 35, 39, 4, -34 },
  { 14080, 36, 47, 39, 0, -34 },
  { 14292, 33, 47, 39, 3, -34 },
  { 14486, 32, 34, 39, 7, -34 },
  { 14622, 32, 35, 39, 3, -34 },
  { 14762, 30, 46, 39, 5, -45 },
  { 14935, 32, 35, 39, 4, -34 },
  { 15075, 31, 35, 39, 4, -34 },
  { 15211, 35, 35, 39, 2, -34 },
  { 15365, 39, 35, 39, 0, -34 },
  { 15536, 35, 48, 39, 1, -34 },
  { 15746, 35, 35, 39, 2, -34 },
  { 15900, 31, 58, 39, 7, -49 },
  { 16125, 16, 58, 39, 12, -49 },
  { 16241, 31, 58, 39, 2, -49 },
  { 16466, 36, 15, 39, 2, -28 },
};

const GFXfont IBMPlexMono_MediumItalic65pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic65pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic65pt7bGlyphs,
  0x20, 0x7E, 85
};

#endif // _IBMPLEXMONO_MEDIUMITALIC65PT7B_H_
