#ifndef _IBMPLEXMONO_MEDIUMITALIC31PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x3C, 0x78, 0xF1, 0xE3, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC1,
  0x02, 0x00, 0x00, 0x00, 0xE3, 0xE7, 0xCF, 0x9E, 0x00, 0x71, 0xDC, 0x77,
  0x1D, 0xC7, 0x71, 0xF8, 0xEE, 0x3B, 0x8E, 0xE3, 0x80, 0x00, 0x71, 0xC0,
  0x0C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x07,
  0xF1, 0xF8, 0xFC, 0x7F, 0x3F, 0x8F, 0xE0, 0x71, 0xC0, 0x0C, 0x70, 0x03,
  0x8E, 0x00, 0x71, 0xC0, 0xFC, 0x7F, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0x0C,
  0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0C, 0x70, 0x03, 0x8E, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x3F, 0x00, 0x7F,
  0xE0, 0xFF, 0xFC, 0x79, 0x9E, 0x78, 0xC6, 0x38, 0x60, 0x1C, 0x70, 0x0F,
  0x38, 0x07, 0xD8, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFC,
  0x01, 0xCF, 0x00, 0xC7, 0x80, 0x61, 0xC8, 0x31, 0xEE, 0x18, 0xE7, 0xDD,
  0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x1F, 0xC0, 0xC0, 0xFF, 0x07, 0x07, 0x8C,
  0x38, 0x1C, 0x30, 0xC0, 0x70, 0xC7, 0x01, 0x87, 0x38, 0x07, 0x1D, 0xC0,
  0x1F, 0xE7, 0x00, 0x3F, 0xA0, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xC0, 0x0E, 0xFF, 0x80, 0x73, 0x8E, 0x01, 0x9C, 0x38, 0x0E, 0x70,
  0xE0, 0x71, 0xC3, 0x81, 0x87, 0x1C, 0x0E, 0x1F, 0xF0, 0x70, 0x3F, 0x83,
  0x80, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1E, 0x3C,
  0x07, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x03, 0x8E, 0x00,
  0xE7, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x71, 0xC0, 0x1C, 0x38, 0x0F, 0x0E,
  0x03, 0xC3, 0xC0, 0xF0, 0x70, 0xFC, 0x1E, 0x7F, 0x0B, 0xB9, 0xFE, 0xFE,
  0x7F, 0x1F, 0x07, 0x83, 0x80, 0x77, 0x77, 0xFE, 0xEE, 0xE0, 0x00, 0xF0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x00, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x41, 0xC2, 0xF3, 0x9E, 0xFF, 0xFF,
  0x7F, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3C, 0xE0, 0x38, 0xF0,
  0x70, 0x70, 0xF0, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1F, 0x1E, 0x3C,
  0x3C, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE,
  0x3E, 0x1E, 0x3C, 0x0F, 0x78, 0x0F, 0x70, 0x07, 0x70, 0x07, 0xF0, 0x07,
  0xF3, 0x8F, 0xE3, 0xCF, 0xE3, 0xCF, 0xE3, 0x8E, 0xE0, 0x0E, 0xE0, 0x1E,
  0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xF0, 0x78, 0x7F, 0xF0, 0x3F, 0xE0,
  0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xB8, 0x1F, 0x78,
  0x3E, 0x78, 0x3C, 0x70, 0x38, 0x70, 0x10, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0x01, 0xF8,
  0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0x0F, 0x3C, 0x07, 0x38, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFF,
  0x1E, 0x0F, 0x1C, 0x07, 0x08, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x1E,
  0x03, 0xFC, 0x03, 0xE0, 0x07, 0xFC, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x40, 0x1E, 0xE0, 0x1E, 0xF0, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07,
  0x70, 0x07, 0x38, 0x07, 0xBC, 0x03, 0x9E, 0x03, 0x8E, 0x03, 0x87, 0x03,
  0x83, 0x83, 0xC1, 0xC1, 0xC1, 0xE1, 0xC0, 0xF1, 0xC0, 0x70, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0xF8, 0x1D, 0xFE, 0x0F, 0xFF,
  0x87, 0x83, 0xC1, 0x80, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x20,
  0x0E, 0x38, 0x0F, 0x3E, 0x0F, 0x0F, 0xFF, 0x83, 0xFF, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x79, 0xF0, 0xEF, 0xF3, 0xFF, 0xF7, 0xC1, 0xFF, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7B, 0xC1, 0xF3,
  0xFF, 0xC3, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE,
  0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x3C, 0xE0, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xE1, 0xF1, 0xC0,
  0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x38, 0x0E, 0x1E, 0x0E, 0x07, 0xFE, 0x01,
  0xFC, 0x03, 0xFF, 0x83, 0xC1, 0xE3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E,
  0xF0, 0x0F, 0x78, 0x0F, 0x3E, 0x0F, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0x7F,
  0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3C, 0x1E, 0x78, 0x0E, 0x70,
  0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0x78, 0x3E, 0x7F,
  0xFE, 0x3F, 0xDE, 0x1F, 0xBC, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0x1C, 0x7C, 0xFB,
  0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x9F, 0x3E, 0x7C, 0xF0,
  0x07, 0x07, 0xC3, 0xE3, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0xF0, 0xF0, 0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x0E, 0x07,
  0x00, 0x00, 0x02, 0x00, 0x18, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x70, 0x00, 0x20, 0x3F,
  0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x00, 0x78, 0x00, 0x60, 0x00, 0x80, 0x00, 0x0F, 0xC1, 0xFF, 0x9F, 0xFF,
  0xF0, 0xFE, 0x03, 0xB0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x3F, 0x07,
  0xF0, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1C, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0xC1, 0xE0, 0xE1, 0xC0, 0x38, 0xE0, 0x1C, 0xE1, 0xCE, 0x71, 0xF7,
  0x31, 0xFF, 0xB9, 0xE3, 0x9C, 0xE1, 0xCE, 0x70, 0xE7, 0x38, 0x73, 0x9C,
  0x39, 0x8C, 0x1D, 0xC7, 0x1C, 0xE3, 0xFE, 0x71, 0xFF, 0x18, 0x7B, 0x8E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xEF,
  0x00, 0x3B, 0xC0, 0x1E, 0x70, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xE1, 0xC0,
  0x38, 0x70, 0x1C, 0x1C, 0x07, 0x07, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1C, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x39, 0xE0, 0x0E, 0x78, 0x03,
  0xBC, 0x00, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x1E, 0x0F, 0x1E,
  0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x0F, 0x3C, 0x1E, 0x3F, 0xFC, 0x3F,
  0xF0, 0x3F, 0xFC, 0x38, 0x1E, 0x38, 0x0E, 0x78, 0x0F, 0x78, 0x0F, 0x70,
  0x0E, 0x70, 0x1E, 0x70, 0x3E, 0x7F, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x01,
  0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x0F, 0x3C, 0x07, 0x3C, 0x07, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x08, 0xF0, 0x1E, 0xF0, 0x3C, 0x78,
  0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x07,
  0xFF, 0x83, 0xC1, 0xE1, 0xE0, 0x70, 0xE0, 0x3C, 0x70, 0x1E, 0x38, 0x0F,
  0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x00, 0xF3, 0x80, 0x71, 0xC0,
  0x38, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x1E, 0x38, 0x0F, 0x1C, 0x1F, 0x0F,
  0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF,
  0xE3, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF,
  0x87, 0xFF, 0xC7, 0xFF, 0xE0, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xF8,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F,
  0xFE, 0x1E, 0x1E, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0xFE, 0xF0, 0xFE, 0xE1, 0xFE, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xF0, 0x3C, 0xF8, 0x5C, 0x7F, 0xFC, 0x3F,
  0xB8, 0x1F, 0x38, 0x1E, 0x03, 0xC7, 0x80, 0xE1, 0xE0, 0x38, 0x70, 0x0E,
  0x1C, 0x07, 0x87, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1C, 0x3C, 0x07, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x38, 0x0F, 0x1E, 0x03, 0x87, 0x80,
  0xE1, 0xC0, 0x38, 0x70, 0x1E, 0x1C, 0x07, 0x87, 0x01, 0xE3, 0xC0, 0x70,
  0xF0, 0x1C, 0x38, 0x07, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE0,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x0F, 0xFF, 0x8F,
  0xFF, 0xC7, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0xF0, 0x3C, 0x38, 0x1E, 0x1E, 0x1E, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0x7E, 0x00, 0x0E, 0x01, 0xE3, 0xC0, 0x78, 0x78, 0x1E, 0x0F, 0x07,
  0x81, 0xC1, 0xE0, 0x38, 0x78, 0x07, 0x1E, 0x01, 0xE7, 0x80, 0x3D, 0xE0,
  0x07, 0xBC, 0x00, 0xEF, 0x80, 0x1F, 0xF0, 0x03, 0xEF, 0x00, 0xF8, 0xE0,
  0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0x70,
  0x38, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x1E, 0x00, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0x01, 0xE1, 0xE0, 0x7C, 0x3E, 0x0F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7C, 0x3B,
  0x1F, 0x87, 0x67, 0x70, 0xEE, 0xEE, 0x1D, 0xF9, 0xC7, 0x3F, 0x38, 0xE3,
  0xCE, 0x1C, 0x71, 0xC3, 0x8E, 0x38, 0x71, 0x87, 0x0E, 0x10, 0xE3, 0xC4,
  0x1C, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00,
  0x71, 0xE0, 0x1E, 0x00, 0x1F, 0x03, 0xC7, 0xC0, 0xE1, 0xF8, 0x38, 0x7E,
  0x0E, 0x1F, 0x83, 0x87, 0xE0, 0xE3, 0xF8, 0x78, 0xE7, 0x1C, 0x39, 0xC7,
  0x0E, 0x71, 0xC3, 0x9C, 0x70, 0xE7, 0x1C, 0x38, 0xEF, 0x1C, 0x3B, 0x87,
  0x0E, 0xE1, 0xC3, 0xB8, 0x70, 0xEE, 0x1C, 0x1F, 0x87, 0x07, 0xE3, 0x81,
  0xF0, 0xE0, 0x7C, 0x38, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE,
  0x3E, 0x1E, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x07, 0x70, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E,
  0xE0, 0x1E, 0xE0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0x7F, 0xF0, 0x3F, 0xE0,
  0x1F, 0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xC0, 0xF1, 0xE0,
  0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x0F, 0x1C, 0x07, 0x9E, 0x07, 0x8F,
  0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0x81, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3E, 0x1E, 0x3C, 0x0F, 0x78,
  0x0F, 0x78, 0x07, 0x70, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x78, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x07, 0x84, 0x03,
  0x8E, 0x01, 0xDE, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x0F, 0xFC, 0x07,
  0xFF, 0x87, 0xFF, 0xE3, 0xC0, 0xF1, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0E,
  0x38, 0x0F, 0x1C, 0x07, 0x9E, 0x07, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF,
  0x01, 0xC7, 0x80, 0xE1, 0xC0, 0xF0, 0xE0, 0x78, 0x78, 0x38, 0x1C, 0x1C,
  0x0F, 0x0E, 0x07, 0x87, 0x01, 0xC7, 0x80, 0xF0, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xC1, 0xF3, 0xC0, 0x31, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x40, 0x0F, 0x70, 0x0F, 0x3E, 0x0F,
  0x8F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x07, 0x9E, 0x03, 0x8E, 0x01,
  0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1C, 0x70,
  0x0E, 0x38, 0x07, 0x1C, 0x07, 0x8E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xE3,
  0x80, 0x71, 0xC0, 0x38, 0xE0, 0x3C, 0x78, 0x1C, 0x3C, 0x1E, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0xFE, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xBC, 0x03, 0xDE,
  0x01, 0xE7, 0x01, 0xE3, 0x80, 0xF1, 0xC0, 0x70, 0xE0, 0x78, 0x70, 0x38,
  0x38, 0x3C, 0x1E, 0x1C, 0x0F, 0x0E, 0x07, 0x8F, 0x01, 0xC7, 0x00, 0xE7,
  0x80, 0x73, 0x80, 0x3B, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x1C,
  0x00, 0xE3, 0x80, 0x1C, 0xE1, 0xC3, 0x9C, 0x78, 0x73, 0x8F, 0x1C, 0x71,
  0xE3, 0x8E, 0x7C, 0x71, 0xCD, 0xCE, 0x39, 0xB9, 0x87, 0x77, 0x70, 0xEC,
  0xEE, 0x1D, 0x9D, 0xC3, 0x73, 0xB0, 0xEC, 0x7E, 0x1D, 0x8F, 0xC3, 0xF1,
  0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x00, 0x0F, 0x00, 0x78,
  0x3C, 0x07, 0x81, 0xE0, 0x78, 0x07, 0x03, 0x80, 0x3C, 0x3C, 0x00, 0xE3,
  0xC0, 0x07, 0xBC, 0x00, 0x3D, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x78,
  0x00, 0xF3, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x78, 0x07, 0x81, 0xC0, 0x78,
  0x0F, 0x07, 0x80, 0x78, 0x7C, 0x01, 0xE0, 0xE0, 0x07, 0xF8, 0x03, 0x9C,
  0x03, 0xCE, 0x03, 0xC7, 0x81, 0xC1, 0xC1, 0xE0, 0xE1, 0xE0, 0x78, 0xE0,
  0x1C, 0xF0, 0x0E, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xFF, 0x07, 0xFC, 0x3F, 0xF0,
  0xE0, 0x30, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x1C, 0x06,
  0x03, 0x01, 0xC0, 0xE0, 0x70, 0x18, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0x60,
  0x30, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03,
  0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0,
  0x07, 0xF8, 0x07, 0x38, 0x0E, 0x38, 0x1E, 0x1C, 0x1C, 0x1C, 0x38, 0x1E,
  0x78, 0x0E, 0xF0, 0x0E, 0xE0, 0x0F, 0x60, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x23, 0xBC, 0xE3, 0x9C, 0x40, 0x07, 0xC7, 0x0F, 0xE7, 0x1F,
  0xFF, 0x3E, 0x1F, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0x70, 0x3C, 0x78, 0xDC, 0x7F, 0xDF, 0x3F,
  0x9F, 0x1E, 0x1E, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x7C, 0x1C, 0xFE, 0x3D, 0xFE, 0x3F,
  0x0F, 0x3E, 0x0F, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x78, 0x0F, 0x78,
  0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x78, 0x3C, 0x7F, 0xFC, 0xF7, 0xF8, 0xF3,
  0xE0, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0xCF, 0x0F, 0x78, 0x1D, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x4E, 0x01, 0xFC, 0x0F, 0x78, 0x79,
  0xFF, 0xC3, 0xFE, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x1F, 0x1C, 0x0F,
  0xF7, 0x07, 0xFD, 0xC3, 0xE1, 0xF0, 0xE0, 0x3C, 0x78, 0x0E, 0x1C, 0x03,
  0x87, 0x00, 0xE1, 0xC0, 0x38, 0xF0, 0x1E, 0x3C, 0x07, 0x87, 0x03, 0xC1,
  0xE1, 0xF0, 0x7F, 0xDC, 0x0F, 0xE7, 0x01, 0xF3, 0xC0, 0x03, 0xF0, 0x1F,
  0xF8, 0x7F, 0xF1, 0xE0, 0xF7, 0x01, 0xEE, 0x0F, 0xBF, 0xFF, 0x7F, 0xF8,
  0xFF, 0x81, 0xC0, 0x03, 0x80, 0x27, 0x80, 0xE7, 0x87, 0x8F, 0xFF, 0x0F,
  0xF8, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x10, 0x70,
  0x01, 0x83, 0x80, 0x1E, 0x1C, 0x00, 0x79, 0xE0, 0x01, 0xEF, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC7, 0x0F, 0xE7,
  0x1F, 0xF7, 0x3E, 0x17, 0x38, 0x0F, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x3C, 0x78, 0x7C, 0x7F, 0xDC,
  0x3F, 0x9C, 0x1F, 0x3C, 0x00, 0x38, 0x40, 0x78, 0x60, 0xF8, 0xFF, 0xF0,
  0x7F, 0xE0, 0x3F, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x3C, 0x1C, 0xFE, 0x3B, 0xFC, 0xF4,
  0x79, 0xF0, 0x73, 0xC0, 0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x78, 0x0E,
  0xF0, 0x3D, 0xE0, 0x7B, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0xBC, 0x0F, 0x00,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x84, 0x0F, 0x0C, 0x1C, 0x7C, 0x39, 0xF0,
  0x77, 0xC0, 0xFF, 0x01, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x04,
  0x1C, 0x1C, 0x38, 0x78, 0x70, 0x79, 0xE0, 0x7B, 0xC0, 0x7F, 0x00, 0x7E,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0xF8, 0x1C, 0xFE, 0x0E, 0xFF,
  0x0F, 0xC3, 0xC7, 0xC1, 0xC3, 0xC0, 0xE1, 0xE0, 0xF0, 0xE0, 0xF0, 0x71,
  0xE0, 0x7B, 0xC0, 0x3C, 0xE0, 0x9E, 0x79, 0xCE, 0x3D, 0xF7, 0x0F, 0xE3,
  0x87, 0xE3, 0xC1, 0xE0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x82, 0x1C, 0x39, 0xE3, 0xCF, 0x3C, 0x77,
  0xC3, 0xFC, 0x1F, 0xC0, 0x78, 0x00, 0x1D, 0xC3, 0x8E, 0xF9, 0xF3, 0xFE,
  0xFC, 0xF3, 0xA7, 0x38, 0xF1, 0xCE, 0x38, 0x73, 0x8E, 0x1D, 0xC3, 0x86,
  0x70, 0xE3, 0x9C, 0x38, 0xE7, 0x0C, 0x39, 0xC7, 0x0E, 0x71, 0xC3, 0xB8,
  0x70, 0xCE, 0x1C, 0x73, 0x86, 0x1C, 0x1C, 0x78, 0x39, 0xFC, 0x77, 0xF9,
  0xE8, 0xF3, 0xE0, 0xE7, 0x81, 0xCF, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0xF0,
  0x1D, 0xE0, 0x7B, 0xC0, 0xF7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x78, 0x1E,
  0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1, 0xE7, 0x81, 0xFE, 0x01, 0xFC,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x77, 0x01, 0xEF, 0x07,
  0x8F, 0xFE, 0x0F, 0xF8, 0x0F, 0xC0, 0x0E, 0x3E, 0x07, 0x3F, 0x87, 0xBF,
  0xC3, 0xF0, 0xF1, 0xF0, 0x78, 0xF0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x3C,
  0x07, 0x9E, 0x03, 0xCE, 0x01, 0xC7, 0x81, 0xE3, 0xC1, 0xE1, 0xFF, 0xF1,
  0xEF, 0xF0, 0xF3, 0xE0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC7, 0x0F, 0xF7, 0x1F, 0xF7, 0x3E,
  0x1F, 0x38, 0x0F, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xF0,
  0x1E, 0xF0, 0x1E, 0x70, 0x3C, 0x78, 0x5C, 0x7F, 0xDC, 0x3F, 0x9C, 0x1F,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x7F, 0x1F, 0xFE, 0x7F, 0xFD, 0xF8, 0x7E, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x0F, 0xFE, 0x1F,
  0xFF, 0x1E, 0x0C, 0x3C, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0xFC, 0x00, 0x1E, 0x20, 0x1E, 0x70, 0x3C, 0xFF, 0xFC, 0x3F,
  0xF8, 0x0F, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x04, 0x1E, 0x3C, 0x38,
  0xFC, 0x73, 0xE0, 0xFF, 0x01, 0xFC, 0x01, 0xE0, 0x00, 0x38, 0x0E, 0x70,
  0x1D, 0xE0, 0x7B, 0xC0, 0xF7, 0x01, 0xEE, 0x03, 0x9C, 0x07, 0x38, 0x0E,
  0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x83, 0xCF, 0x0B, 0x9F, 0xE7, 0x1F,
  0xDE, 0x1F, 0x3C, 0xFC, 0x0D, 0xF8, 0x3B, 0xF0, 0x78, 0xE0, 0xF1, 0xC0,
  0xE7, 0x81, 0xCE, 0x07, 0x9C, 0x0F, 0x38, 0x1C, 0x70, 0x78, 0xE1, 0xE3,
  0xC7, 0xC7, 0x3F, 0x0F, 0xFC, 0x1F, 0xE0, 0x1F, 0x00, 0x38, 0xE3, 0x18,
  0x71, 0x8C, 0x38, 0xEE, 0x18, 0x77, 0x0C, 0x3B, 0x8E, 0x1D, 0xC7, 0x0E,
  0xC3, 0x87, 0xE1, 0xC3, 0x70, 0xE3, 0xB8, 0xE1, 0xDC, 0x70, 0xCE, 0x78,
  0xE7, 0xEC, 0xE3, 0xF7, 0xE0, 0xF1, 0xE0, 0x03, 0x87, 0x81, 0xF9, 0xF8,
  0x7F, 0x3F, 0x1E, 0x6C, 0xE7, 0x8D, 0x0E, 0x41, 0xE1, 0xC0, 0x38, 0x40,
  0x07, 0x00, 0x01, 0xE0, 0x04, 0x3C, 0x03, 0x87, 0x84, 0x71, 0xF1, 0xCE,
  0x3E, 0xF9, 0xFD, 0xFC, 0x1F, 0x9F, 0x01, 0xC1, 0xC0, 0x1C, 0x07, 0x1C,
  0x07, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38,
  0x0E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x5C, 0x3F,
  0xDC, 0x3F, 0xBC, 0x1F, 0x3C, 0x00, 0x38, 0x40, 0x78, 0xE0, 0xF8, 0xFF,
  0xF0, 0xFF, 0xE0, 0x3F, 0x80, 0x0F, 0xC7, 0x8F, 0xFB, 0x8F, 0xFF, 0xC7,
  0x0F, 0xE3, 0x81, 0xE1, 0x81, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x86, 0x07, 0x83, 0x87, 0x80, 0xC7, 0xFC, 0x67, 0xFF, 0xF3, 0x8F,
  0xF9, 0xC1, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x07, 0xF8, 0x1F, 0x80, 0x3F, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x61,
  0xC3, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x87, 0x00, 0x07, 0xF0, 0x0F,
  0xF0, 0x3F, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x0F, 0xC0,
  0xFF, 0x83, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xF8, 0x00, 0x0F, 0x03, 0x0F, 0xC1, 0xCF, 0xE0, 0xCE, 0x78, 0xE7, 0x1C,
  0xF3, 0x07, 0xF3, 0x83, 0xF0, 0xC0, 0xF0,
};

const GFXglyph IBMPlexMono_MediumItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 7, 22, 19, 6, -22 },
  { 21, 10, 9, 19, 6, -23 },
  { 33, 19, 22, 19, 0, -22 },
  { 86, 17, 28, 19, 1, -25 },
  { 146, 22, 22, 19, -1, -22 },
  { 207, 18, 22, 19, 0, -22 },
  { 257, 4, 9, 19, 9, -23 },
  { 262, 12, 28, 19, 6, -24 },
  { 304, 12, 28, 19, 1, -24 },
  { 346, 16, 15, 19, 2, -17 },
  { 376, 15, 15, 19, 2, -17 },
  { 405, 8, 10, 19, 4, -5 },
  { 415, 9, 3, 19, 5, -11 },
  { 419, 5, 5, 19, 6, -5 },
  { 423, 18, 28, 19, 0, -24 },
  { 486, 16, 22, 19, 2, -22 },
  { 530, 16, 22, 19, 1, -22 },
  { 574, 16, 22, 19, 1, -22 },
  { 618, 16, 22, 19, 1, -22 },
  { 662, 17, 22, 19, 0, -22 },
  { 709, 17, 22, 19, 1, -22 },
  { 756, 15, 22, 19, 2, -22 },
  { 798, 16, 22, 19, 3, -22 },
  { 842, 17, 22, 19, 1, -22 },
  { 889, 16, 22, 19, 2, -22 },
  { 933, 7, 17, 19, 6, -17 },
  { 948, 9, 22, 19, 4, -17 },
  { 973, 15, 18, 19, 3, -18 },
  { 1007, 17, 9, 19, 1, -14 },
  { 1027, 16, 18, 19, 1, -18 },
  { 1063, 13, 22, 19, 4, -22 },
  { 1099, 17, 25, 19, 1, -22 },
  { 1153, 18, 22, 19, -1, -22 },
  { 1203, 16, 22, 19, 1, -22 },
  { 1247, 16, 22, 19, 2, -22 },
  { 1291, 17, 22, 19, 1, -22 },
  { 1338, 17, 22, 19, 1, -22 },
  { 1385, 18, 22, 19, 1, -22 },
  { 1435, 16, 22, 19, 2, -22 },
  { 1479, 18, 22, 19, 1, -22 },
  { 1529, 17, 22, 19, 1, -22 },
  { 1576, 17, 22, 19, 1, -22 },
  { 1623, 19, 22, 19, 1, -22 },
  { 1676, 14, 22, 19, 2, -22 },
  { 1715, 19, 22, 19, 0, -22 },
  { 1768, 18, 22, 19, 1, -22 },
  { 1818, 16, 22, 19, 2, -22 },
  { 1862, 17, 22, 19, 1, -22 },
  { 1909, 16, 28, 19, 2, -22 },
  { 1965, 17, 22, 19, 1, -22 },
  { 2012, 17, 22, 19, 1, -22 },
  { 2059, 17, 22, 19, 3, -22 },
  { 2106, 17, 22, 19, 2, -22 },
  { 2153, 17, 22, 19, 3, -22 },
  { 2200, 19, 22, 19, 1, -22 },
  { 2253, 21, 22, 19, -1, -22 },
  { 2311, 17, 22, 19, 3, -22 },
  { 2358, 19, 22, 19, 0, -22 },
  { 2411, 14, 28, 19, 4, -24 },
  { 2460, 9, 28, 19, 5, -24 },
  { 2492, 13, 28, 19, 1, -24 },
  { 2538, 16, 13, 19, 2, -22 },
  { 2564, 15, 3, 19, 0, 3 },
  { 2570, 5, 7, 19, 6, -25 },
  { 2575, 16, 16, 19, 1, -16 },
  { 2607, 16, 23, 19, 1, -23 },
  { 2653, 14, 16, 19, 2, -16 },
  { 2681, 18, 23, 19, 1, -23 },
  { 2733, 15, 16, 19, 2, -16 },
  { 2763, 21, 29, 19, -1, -23 },
  { 2840, 16, 22, 19, 1, -16 },
  { 2884, 15, 23, 19, 1, -23 },
  { 2928, 15, 23, 19, 2, -23 },
  { 2972, 15, 29, 19, 1, -23 },
  { 3027, 17, 23, 19, 1, -23 },
  { 3076, 13, 23, 19, 3, -23 },
  { 3114, 18, 16, 19, 0, -16 },
  { 3150, 15, 16, 19, 1, -16 },
  { 3180, 15, 16, 19, 2, -16 },
  { 3210, 17, 22, 19, 0, -16 },
  { 3257, 16, 22, 19, 1, -16 },
  { 3301, 15, 16, 19, 3, -16 },
  { 3331, 16, 16, 19, 1, -16 },
  { 3363, 15, 22, 19, 2, -22 },
  { 3405, 15, 16, 19, 2, -16 },
  { 3435, 15, 16, 19, 2, -16 },
  { 3465, 17, 16, 19, 1, -16 },
  { 3499, 19, 16, 19, 0, -16 },
  { 3537, 16, 22, 19, 1, -16 },
  { 3581, 17, 16, 19, 1, -16 },
  { 3615, 15, 28, 19, 3, -24 },
  { 3668, 7, 28, 19, 6, -24 },
  { 3693, 15, 28, 19, 1, -24 },
  { 3746, 17, 8, 19, 1, -13 },
};

const GFXfont IBMPlexMono_MediumItalic31pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic31pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic31pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _IBMPLEXMONO_MEDIUMITALIC31PT7B_H_
