#ifndef _IBMPLEXMONO_MEDIUMITALIC9PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0x20, 0xBB, 0x00, 0x29, 0xB3, 0x36, 0x51, 0x80, 0x11, 0xDA,
  0xC3, 0xD5, 0xC4, 0x66, 0xA7, 0x06, 0x6A, 0x60, 0x32, 0x4D, 0xC9, 0xFC,
  0xE0, 0x2A, 0x49, 0x26, 0x21, 0x11, 0x12, 0x2C, 0x33, 0x6C, 0xA0, 0x24,
  0xF4, 0x40, 0x60, 0xE0, 0x80, 0x08, 0x44, 0x42, 0x21, 0x10, 0x3A, 0x53,
  0x5C, 0xB8, 0x32, 0x84, 0x22, 0x7C, 0x3A, 0x42, 0x64, 0x7C, 0x3A, 0x4C,
  0x19, 0xB8, 0x19, 0x54, 0xAF, 0x88, 0x3A, 0x1C, 0x98, 0xB8, 0x19, 0x1E,
  0x98, 0xB8, 0xF9, 0x22, 0x48, 0x3A, 0x4C, 0x98, 0xB8, 0x79, 0x9F, 0x2C,
  0xC2, 0x60, 0x28, 0x16, 0x84, 0x20, 0x78, 0x3E, 0x41, 0x82, 0x6C, 0x00,
  0x79, 0x16, 0x0C, 0x3A, 0x5F, 0x5B, 0xC1, 0xC0, 0x31, 0x9C, 0x97, 0xC4,
  0x7A, 0x5C, 0x94, 0xF8, 0x79, 0x88, 0x9E, 0x7A, 0x52, 0x94, 0xF8, 0x7A,
  0x1E, 0x84, 0x78, 0x7A, 0x1E, 0x84, 0x40, 0x79, 0x8B, 0x9E, 0x4A, 0x5E,
  0x94, 0xC8, 0x78, 0x88, 0x42, 0x78, 0x38, 0x42, 0x29, 0x38, 0x4D, 0x46,
  0x14, 0x52, 0x20, 0x48, 0x88, 0x8F, 0x4D, 0xE7, 0xAA, 0x8A, 0x20, 0x6B,
  0x5A, 0xD9, 0xC8, 0x3A, 0x53, 0x1C, 0xB8, 0x7A, 0x52, 0xF4, 0x40, 0x3A,
  0x53, 0x1C, 0xB8, 0xA2, 0x7A, 0x52, 0xF5, 0x4C, 0x3A, 0x58, 0x38, 0xB8,
  0xF9, 0x10, 0x84, 0x20, 0x99, 0x99, 0x9E, 0x8C, 0xA5, 0x4A, 0x20, 0x45,
  0xEB, 0xB6, 0xDB, 0x40, 0x4C, 0xA3, 0x0C, 0x52, 0x20, 0x9C, 0x98, 0x84,
  0x20, 0x78, 0x44, 0x44, 0x7C, 0x34, 0x44, 0x48, 0x8E, 0xAA, 0xA5, 0x71,
  0x11, 0x22, 0x2E, 0x31, 0x93, 0x10, 0xF0, 0xC0, 0x7A, 0x63, 0x27, 0x80,
  0x42, 0x1E, 0x94, 0xA6, 0xC0, 0x6B, 0x89, 0xE0, 0x08, 0x5E, 0x98, 0xCD,
  0xC0, 0x79, 0xEA, 0xF0, 0x1C, 0x47, 0x88, 0x20, 0x82, 0x28, 0x60, 0x7A,
  0x73, 0x27, 0x0B, 0x80, 0x42, 0x16, 0xD4, 0xA6, 0x40, 0x60, 0xC4, 0x47,
  0x60, 0x18, 0x1C, 0x21, 0x0A, 0x4C, 0x60, 0x42, 0x16, 0xD5, 0x36, 0x40,
  0xE4, 0x44, 0x4B, 0x40, 0x6B, 0xEB, 0x5A, 0x80, 0x5B, 0x52, 0x99, 0x00,
  0x32, 0x53, 0x97, 0x00, 0x7A, 0x52, 0x9B, 0x42, 0x00, 0x7A, 0x63, 0x37,
  0x08, 0x40, 0xD6, 0x44, 0xC0, 0x7A, 0x1C, 0x1F, 0x00, 0x4F, 0x44, 0xBC,
  0x99, 0x9A, 0xE0, 0x4E, 0x52, 0xA6, 0x00, 0x6D, 0x6B, 0x5F, 0x00, 0x6D,
  0xC9, 0x5D, 0x00, 0x4A, 0x52, 0xA7, 0x0B, 0x80, 0x7A, 0xC8, 0x9B, 0x80,
  0x34, 0x2C, 0x24, 0x86, 0x5A, 0xAA, 0x30, 0x88, 0x32, 0x10, 0x9C, 0x6C,
  0xC0,
};

const GFXglyph IBMPlexMono_MediumItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 6, 5, 2, -6 },
  { 3, 3, 3, 5, 2, -7 },
  { 5, 6, 6, 5, 0, -6 },
  { 10, 5, 8, 5, 0, -7 },
  { 15, 6, 6, 5, 0, -6 },
  { 20, 5, 6, 5, 0, -6 },
  { 24, 1, 3, 5, 3, -7 },
  { 25, 3, 8, 5, 2, -7 },
  { 28, 4, 8, 5, 0, -7 },
  { 32, 5, 4, 5, 0, -5 },
  { 35, 4, 5, 5, 1, -5 },
  { 38, 2, 2, 5, 1, -1 },
  { 39, 3, 1, 5, 1, -3 },
  { 40, 1, 1, 5, 2, -1 },
  { 41, 5, 8, 5, 0, -7 },
  { 46, 5, 6, 5, 0, -6 },
  { 50, 5, 6, 5, 0, -6 },
  { 54, 5, 6, 5, 0, -6 },
  { 58, 5, 6, 5, 0, -6 },
  { 62, 5, 6, 5, 0, -6 },
  { 66, 5, 6, 5, 0, -6 },
  { 70, 5, 6, 5, 0, -6 },
  { 74, 4, 6, 5, 1, -6 },
  { 77, 5, 6, 5, 0, -6 },
  { 81, 4, 6, 5, 1, -6 },
  { 84, 2, 4, 5, 2, -4 },
  { 85, 3, 5, 5, 1, -4 },
  { 87, 4, 5, 5, 1, -5 },
  { 90, 5, 3, 5, 0, -4 },
  { 92, 5, 5, 5, 0, -5 },
  { 96, 4, 6, 5, 1, -6 },
  { 99, 5, 7, 5, 0, -6 },
  { 104, 5, 6, 5, 0, -6 },
  { 108, 5, 6, 5, 0, -6 },
  { 112, 4, 6, 5, 1, -6 },
  { 115, 5, 6, 5, 0, -6 },
  { 119, 5, 6, 5, 0, -6 },
  { 123, 5, 6, 5, 0, -6 },
  { 127, 4, 6, 5, 1, -6 },
  { 130, 5, 6, 5, 0, -6 },
  { 134, 5, 6, 5, 0, -6 },
  { 138, 5, 6, 5, 0, -6 },
  { 142, 6, 6, 5, 0, -6 },
  { 147, 4, 6, 5, 1, -6 },
  { 150, 6, 6, 5, 0, -6 },
  { 155, 5, 6, 5, 0, -6 },
  { 159, 5, 6, 5, 0, -6 },
  { 163, 5, 6, 5, 0, -6 },
  { 167, 5, 8, 5, 0, -6 },
  { 172, 5, 6, 5, 0, -6 },
  { 176, 5, 6, 5, 0, -6 },
  { 180, 5, 6, 5, 1, -6 },
  { 184, 4, 6, 5, 1, -6 },
  { 187, 5, 6, 5, 1, -6 },
  { 191, 6, 6, 5, 0, -6 },
  { 196, 6, 6, 5, 0, -6 },
  { 201, 5, 6, 5, 1, -6 },
  { 205, 5, 6, 5, 0, -6 },
  { 209, 4, 8, 5, 1, -7 },
  { 213, 2, 8, 5, 2, -7 },
  { 215, 4, 8, 5, 0, -7 },
  { 219, 5, 4, 5, 0, -6 },
  { 222, 4, 1, 5, 0, 1 },
  { 223, 1, 2, 5, 2, -8 },
  { 224, 5, 5, 5, 0, -5 },
  { 228, 5, 7, 5, 0, -7 },
  { 233, 4, 5, 5, 1, -5 },
  { 236, 5, 7, 5, 0, -7 },
  { 241, 4, 5, 5, 1, -5 },
  { 244, 6, 9, 5, 0, -7 },
  { 251, 5, 7, 5, 0, -5 },
  { 256, 5, 7, 5, 0, -7 },
  { 261, 4, 7, 5, 1, -7 },
  { 265, 5, 9, 5, 0, -7 },
  { 271, 5, 7, 5, 0, -7 },
  { 276, 4, 7, 5, 1, -7 },
  { 280, 5, 5, 5, 0, -5 },
  { 284, 5, 5, 5, 0, -5 },
  { 288, 5, 5, 5, 0, -5 },
  { 292, 5, 7, 5, 0, -5 },
  { 297, 5, 7, 5, 0, -5 },
  { 302, 4, 5, 5, 1, -5 },
  { 305, 5, 5, 5, 0, -5 },
  { 309, 4, 6, 5, 1, -6 },
  { 312, 4, 5, 5, 1, -5 },
  { 315, 5, 5, 5, 0, -5 },
  { 319, 5, 5, 5, 0, -5 },
  { 323, 5, 5, 5, 0, -5 },
  { 327, 5, 7, 5, 0, -5 },
  { 332, 5, 5, 5, 0, -5 },
  { 336, 4, 8, 5, 1, -7 },
  { 340, 2, 8, 5, 2, -7 },
  { 342, 5, 8, 5, 0, -7 },
  { 347, 5, 2, 5, 0, -4 },
};

const GFXfont IBMPlexMono_MediumItalic9pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic9pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _IBMPLEXMONO_MEDIUMITALIC9PT7B_H_
