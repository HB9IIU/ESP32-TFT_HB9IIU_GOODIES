#ifndef _IBMPLEXMONO_MEDIUMITALIC46PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x07,
  0xC0, 0x3C, 0x1E, 0x78, 0x7D, 0xF0, 0xFB, 0xE1, 0xF7, 0xC3, 0xEF, 0x07,
  0x9E, 0x0F, 0x3C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xF7, 0x83, 0xCF,
  0x07, 0x9E, 0x1F, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3E, 0x1E,
  0x00, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0,
  0xFF, 0x83, 0xFF, 0x08, 0x3C, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x3C,
  0x00, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC3,
  0xFF, 0x07, 0xFE, 0x00, 0x78, 0x7C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C,
  0x3E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0xF8,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0xE7, 0xF0, 0xFC, 0x38, 0x78,
  0x3E, 0x0E, 0x0C, 0x0F, 0x87, 0x82, 0x03, 0xE1, 0xE0, 0x01, 0xF0, 0x78,
  0x00, 0x7E, 0x1C, 0x00, 0x0F, 0x87, 0x00, 0x03, 0xF1, 0xC0, 0x00, 0xFE,
  0x70, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0E, 0xFE, 0x00, 0x07, 0x8F,
  0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x70, 0x7C, 0x00, 0x1C, 0x1F, 0x00, 0x07,
  0x07, 0xC0, 0x01, 0xC1, 0xF0, 0x40, 0xF0, 0x7C, 0x78, 0x3C, 0x3E, 0x3F,
  0x0F, 0x1F, 0x8F, 0xF3, 0x9F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0x03, 0xFF, 0x80, 0x3C, 0x07,
  0xFF, 0x80, 0x3C, 0x07, 0xC7, 0xC0, 0x78, 0x0F, 0x83, 0xC0, 0xF0, 0x0F,
  0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC1, 0xE0, 0x0F, 0x03, 0xC3, 0xC0, 0x0E,
  0x03, 0xC3, 0xC0, 0x0E, 0x07, 0x87, 0x80, 0x0E, 0x07, 0x8F, 0x00, 0x0F,
  0x0F, 0x8F, 0x00, 0x0F, 0xFF, 0x1E, 0x00, 0x07, 0xFE, 0x3C, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x78, 0xFF, 0xC0, 0x00, 0xF1, 0xFF, 0xE0, 0x01,
  0xE3, 0xE1, 0xE0, 0x01, 0xE3, 0xC0, 0xE0, 0x03, 0xC3, 0xC0, 0xE0, 0x07,
  0x87, 0x80, 0xE0, 0x07, 0x87, 0x81, 0xE0, 0x0F, 0x07, 0x81, 0xE0, 0x1E,
  0x07, 0x81, 0xE0, 0x1E, 0x07, 0x83, 0xE0, 0x3C, 0x07, 0xC7, 0xC0, 0x78,
  0x03, 0xFF, 0xC0, 0x78, 0x03, 0xFF, 0x80, 0xF0, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x3E, 0x00,
  0x3C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03,
  0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x81, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0xEF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xF7, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC1,
  0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x1E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00,
  0xF8, 0x07, 0xC1, 0x1F, 0x00, 0xF8, 0x1B, 0xE0, 0x1F, 0x87, 0xFC, 0x03,
  0xF1, 0xE7, 0xC0, 0xDE, 0x3C, 0xFC, 0x3B, 0xEF, 0x1F, 0xFE, 0x3F, 0xE1,
  0xFF, 0xC7, 0xF8, 0x1F, 0xF0, 0x7E, 0x01, 0xF8, 0x07, 0x80, 0x3E, 0x7C,
  0xF1, 0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0xF3, 0xE7, 0xCF, 0x9F, 0x00, 0x00,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x20,
  0x1E, 0x01, 0x3C, 0x1E, 0x0F, 0x7F, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xEF, 0x80, 0x0F, 0xC7, 0xC0, 0x1F,
  0x87, 0xC0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1C, 0x01, 0xC0, 0x08,
  0x01, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F,
  0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x01, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7E, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x3E,
  0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xCF,
  0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0xFD,
  0xF0, 0x78, 0x7E, 0xF8, 0x7C, 0x3E, 0x7C, 0x3E, 0x1F, 0x3E, 0x1F, 0x0F,
  0xBF, 0x1F, 0x87, 0xDF, 0x87, 0x83, 0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x01,
  0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x3C, 0x00,
  0x3E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x1F, 0x01, 0xF8,
  0x3F, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x3F, 0xBE, 0x00, 0xFE, 0xF8, 0x03, 0xF9, 0xF0, 0x0F,
  0xC3, 0xE0, 0x3F, 0x07, 0xC0, 0x3C, 0x0F, 0x80, 0x30, 0x1F, 0x00, 0x40,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0x07, 0xF0, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x03, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0x07, 0xF0, 0x7E,
  0x00, 0xFC, 0x0E, 0x00, 0x7E, 0x02, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x20, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x04, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x8F, 0xC0,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00,
  0x07, 0xC7, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3E,
  0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0xF0, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE8, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF1, 0xFC, 0x00, 0xF3, 0xFF, 0x80, 0x7B, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0x80, 0x7F, 0x01, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x08, 0x00, 0x3E, 0x1E,
  0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0xFC, 0x03,
  0xE7, 0xFE, 0x0F, 0x9F, 0xFE, 0x1F, 0x7F, 0xFE, 0x7F, 0xC1, 0xFC, 0xFE,
  0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0xF9, 0xF0, 0x03, 0xF3, 0xF0, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7C, 0x00, 0x3E,
  0x78, 0x00, 0x7E, 0x78, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0xF8, 0x01, 0xF8,
  0xF8, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7E, 0x07,
  0xF0, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x8F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xC0, 0xF8,
  0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xE0, 0x7F, 0x07, 0xC0, 0x0F, 0x87,
  0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x1F,
  0x8F, 0xC0, 0x1F, 0xC7, 0xF8, 0x1F, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0x81, 0xF8, 0xF8, 0x03,
  0xF7, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xF9, 0xFF, 0xFB, 0xE3, 0xFF, 0xDF,
  0x87, 0xFE, 0x7C, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF0,
  0x7C, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3, 0xF0, 0x7F, 0x3F, 0x00,
  0xF9, 0xF0, 0x07, 0xF7, 0x00, 0x3F, 0x08, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x07, 0xF0, 0x3E, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F,
  0x1F, 0x00, 0x0F, 0x1E, 0x07, 0xCF, 0x3E, 0x0F, 0xEF, 0x3C, 0x1F, 0xEF,
  0x3C, 0x3F, 0xFF, 0x3C, 0x3E, 0x3F, 0x7C, 0x7C, 0x1F, 0x7C, 0x78, 0x1F,
  0x78, 0xF8, 0x1E, 0x78, 0xF8, 0x1E, 0x78, 0xF0, 0x1E, 0x78, 0xF0, 0x1E,
  0xF8, 0xF0, 0x1E, 0xF8, 0xF0, 0x3E, 0xF0, 0xF0, 0x3C, 0xF0, 0xF0, 0x7C,
  0xF0, 0xF0, 0x7C, 0xF0, 0xFF, 0xBC, 0xF0, 0xFF, 0xBC, 0xF0, 0x7F, 0x3C,
  0xF0, 0x3E, 0x78, 0x78, 0x08, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x1E, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF0,
  0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0x3E,
  0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xF8, 0x00,
  0x3E, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x3F, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3E, 0x00, 0xFC, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C,
  0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C,
  0x03, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x1F, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x1C, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x20, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0x7C,
  0x00, 0xF8, 0x7E, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xC0, 0xFE, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3E,
  0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C,
  0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xE0, 0xFE, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x18, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xFC, 0xF8,
  0x1F, 0xFC, 0xF8, 0x1F, 0xFC, 0xF8, 0x1F, 0xFC, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0x7C, 0x02, 0xF0, 0x7E,
  0x0E, 0xF0, 0x7F, 0xFD, 0xF0, 0x3F, 0xF9, 0xF0, 0x1F, 0xF1, 0xF0, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x1F,
  0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x3F, 0x00,
  0x3E, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E,
  0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E,
  0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x80, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x18, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0xF8, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x07,
  0xF0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x0F,
  0x80, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x1F,
  0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x01,
  0xF1, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7E,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xCF, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE0,
  0x7C, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8,
  0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07,
  0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x87,
  0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F,
  0xF0, 0x7B, 0xC3, 0xDE, 0x0F, 0x78, 0xFB, 0xC3, 0xEF, 0x1E, 0xF8, 0x7D,
  0xE7, 0xDF, 0x0F, 0x1E, 0xF3, 0xC1, 0xE3, 0xFC, 0x78, 0x3C, 0x7F, 0x8F,
  0x07, 0x8F, 0xE3, 0xE1, 0xF1, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x83, 0xC0, 0xC1, 0xF0,
  0xF8, 0x10, 0x3E, 0x1F, 0x02, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE0, 0x03, 0xF8, 0x03, 0xE0, 0xFF, 0x00, 0x78, 0x1F, 0xE0, 0x0F, 0x03,
  0xFC, 0x03, 0xE0, 0x7F, 0x80, 0x7C, 0x0F, 0xF8, 0x0F, 0x81, 0xFF, 0x01,
  0xF0, 0x7D, 0xE0, 0x3C, 0x0F, 0xBC, 0x07, 0x81, 0xF7, 0x81, 0xF0, 0x3E,
  0xF8, 0x3E, 0x07, 0x9F, 0x07, 0xC0, 0xF1, 0xE0, 0xF8, 0x3E, 0x3C, 0x1E,
  0x07, 0xC7, 0x83, 0xC0, 0xF8, 0xF8, 0xF8, 0x1F, 0x1F, 0x1F, 0x03, 0xC1,
  0xE3, 0xE0, 0x78, 0x3C, 0x7C, 0x1F, 0x07, 0x8F, 0x03, 0xE0, 0xF9, 0xE0,
  0x7C, 0x1F, 0x7C, 0x0F, 0x81, 0xEF, 0x81, 0xE0, 0x3D, 0xF0, 0x3C, 0x07,
  0xBE, 0x0F, 0x80, 0xFF, 0x81, 0xF0, 0x0F, 0xF0, 0x3E, 0x01, 0xFE, 0x07,
  0xC0, 0x3F, 0xC0, 0xF0, 0x07, 0xF8, 0x1E, 0x00, 0xFF, 0x07, 0xC0, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x7F, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x3F,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xCF, 0x80, 0x03, 0xE7,
  0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xF3, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x3F, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x3F, 0x80, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x7C, 0x03, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0,
  0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x3E,
  0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xCF,
  0x80, 0x03, 0xE7, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F,
  0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xC0, 0x01,
  0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7C, 0x3E, 0x00,
  0x7E, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x7F, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x01, 0x00, 0x07, 0xC1, 0xC0, 0x03, 0xF1, 0xF0,
  0x00, 0xFB, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7C, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8,
  0x7C, 0x01, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x0F, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xF0, 0x1F,
  0xC1, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0x30, 0x3E, 0x00, 0x08, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0x00, 0x03, 0xE1,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0xC0, 0x7F, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x8F, 0x80,
  0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3,
  0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x0F,
  0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0xE0,
  0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F,
  0xDF, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x01,
  0xF1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00,
  0x7C, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x1E, 0x07, 0xC0, 0x0F,
  0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x7C, 0x00,
  0x07, 0xBE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x1F, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C,
  0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x0F, 0x87, 0xE0, 0xF0, 0x7C,
  0x3F, 0x07, 0x83, 0xE1, 0xFC, 0x3C, 0x1E, 0x1F, 0xE3, 0xE0, 0xF0, 0xEF,
  0x1E, 0x07, 0x87, 0x78, 0xF0, 0x3C, 0x7B, 0xC7, 0x81, 0xE3, 0x9E, 0x7C,
  0x0F, 0x1C, 0xF3, 0xC0, 0x79, 0xE7, 0x9E, 0x03, 0xCE, 0x3C, 0xF0, 0x3E,
  0xF1, 0xEF, 0x81, 0xF7, 0x8F, 0x78, 0x0F, 0x38, 0x7B, 0xC0, 0x7B, 0xC3,
  0xDE, 0x03, 0xDE, 0x1E, 0xF0, 0x1E, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8,
  0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F,
  0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x07,
  0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x1F,
  0x80, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xE7, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xCF,
  0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xF9,
  0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x78, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x1E, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x38, 0x00,
  0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x10, 0xE3, 0xE7, 0xC7, 0x8F, 0x8F, 0x1E, 0x1E, 0x30, 0x00, 0xFC, 0x3E,
  0x07, 0xFE, 0x7C, 0x1F, 0xFC, 0xF8, 0x7F, 0xFD, 0xF1, 0xFC, 0x1B, 0xE3,
  0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8,
  0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xCF, 0xC0, 0x0F, 0x9F, 0x00,
  0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF9, 0xF0, 0x03,
  0xF3, 0xF0, 0x0F, 0xC3, 0xE0, 0x3F, 0x87, 0xE1, 0xDF, 0xEF, 0xFF, 0xBF,
  0xCF, 0xFE, 0x3F, 0x8F, 0xF8, 0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x1F, 0x80, 0x7C, 0xFF, 0xC1, 0xF3, 0xFF, 0xC3, 0xE7,
  0xFF, 0x87, 0xDC, 0x3F, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x3E, 0x3F, 0x00,
  0x7C, 0xFC, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07,
  0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0xFD,
  0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x8F, 0xC0, 0x3F, 0x3E,
  0xC0, 0xFC, 0x7D, 0xFF, 0xF8, 0xF9, 0xFF, 0xE1, 0xF1, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE1, 0xFC, 0x1F, 0x8F, 0x80, 0x7C, 0xF8, 0x01, 0xC7, 0xC0, 0x10, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x67, 0xC0,
  0x07, 0xFF, 0x00, 0x7C, 0xF8, 0x07, 0xE7, 0xF0, 0x7E, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x7F, 0xE3, 0xE0, 0x7F, 0xF9,
  0xE0, 0x7F, 0xFD, 0xF0, 0x7F, 0x07, 0xF8, 0x3E, 0x00, 0xFC, 0x3F, 0x00,
  0x7E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0,
  0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x0F,
  0xC0, 0x3F, 0x83, 0xE0, 0x37, 0xC1, 0xF8, 0x3B, 0xC0, 0xFF, 0xFB, 0xE0,
  0x3F, 0xF9, 0xF0, 0x0F, 0xF8, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xC0, 0xFC,
  0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0xFD, 0xF0,
  0x07, 0xEF, 0xC1, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC,
  0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x43, 0xE0, 0x01, 0x8F,
  0x80, 0x0F, 0x9F, 0x00, 0x7C, 0x7F, 0x07, 0xF0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x60, 0x3E, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x0F, 0x80, 0xFF, 0xC7, 0xC0, 0xFF, 0xF7, 0xC0, 0xFF, 0xFB, 0xE0, 0xFE,
  0x0F, 0xF0, 0x7E, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x3F,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC7,
  0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x0F, 0x80, 0xDF, 0x07, 0xE0, 0xEF,
  0x83, 0xFF, 0xE7, 0x80, 0xFF, 0xE7, 0xC0, 0x3F, 0xE3, 0xE0, 0x07, 0xE1,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x03, 0x00, 0x3E, 0x03, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x7E, 0x03, 0xE3, 0xFC, 0x0F, 0x9F, 0xF8, 0x7E, 0xFF, 0xF1,
  0xF7, 0x0F, 0xC7, 0xD0, 0x1F, 0x1F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0,
  0x07, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x79, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F,
  0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00,
  0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x08, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x08, 0x01, 0xE0, 0x30, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x7C,
  0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x80, 0x3C, 0xFC, 0x00, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x20, 0x1F, 0x00, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xC0, 0x7C,
  0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0xF8, 0x01, 0xF1, 0xFF, 0x00, 0xF9,
  0xFF, 0xC0, 0xF9, 0xFF, 0xE0, 0x7D, 0xC3, 0xF0, 0x3E, 0x80, 0xFC, 0x1F,
  0x80, 0x3E, 0x0F, 0xC0, 0x1E, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83,
  0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0x7C, 0x7F, 0x00,
  0x3E, 0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x01, 0x0F, 0x87, 0xC0,
  0xC7, 0xC3, 0xE0, 0xF3, 0xE0, 0xF9, 0xFD, 0xF0, 0x7D, 0xF9, 0xF0, 0x3F,
  0xF8, 0xF8, 0x0F, 0xF8, 0x7C, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x08, 0x1F, 0x01, 0x83, 0xE0,
  0x7C, 0x7C, 0x1F, 0x8F, 0x87, 0xE1, 0xF1, 0xF8, 0x3C, 0x7E, 0x0F, 0x9F,
  0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x1E, 0x0F, 0x81, 0xE7, 0xE3, 0xF8, 0x3D, 0xFC, 0xFF, 0x0F, 0xFF, 0xDF,
  0xF1, 0xF8, 0xFE, 0x3E, 0x3E, 0x0F, 0x87, 0xC7, 0xC1, 0xE0, 0xF8, 0xF0,
  0x7C, 0x1E, 0x1E, 0x0F, 0x83, 0xC7, 0xC1, 0xE0, 0x78, 0xF8, 0x3C, 0x0F,
  0x1E, 0x07, 0x81, 0xE3, 0xC0, 0xF0, 0x7C, 0x78, 0x1E, 0x0F, 0x0F, 0x07,
  0xC1, 0xE3, 0xE0, 0xF0, 0x3C, 0x7C, 0x1E, 0x07, 0x8F, 0x03, 0xC1, 0xF1,
  0xE0, 0x78, 0x3E, 0x3C, 0x1F, 0x07, 0x87, 0x83, 0xE0, 0xF1, 0xF0, 0x78,
  0x1E, 0x3E, 0x0F, 0x03, 0xC7, 0x81, 0xE0, 0xF8, 0x0F, 0x87, 0xE0, 0x3E,
  0x3F, 0xC0, 0xF9, 0xFF, 0x87, 0xCF, 0xFF, 0x1F, 0x70, 0xFC, 0x7D, 0x01,
  0xF1, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0xFC, 0x01, 0xF3,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0,
  0x07, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F,
  0x9F, 0x00, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF,
  0xFC, 0x1F, 0x81, 0xF8, 0xFC, 0x03, 0xE7, 0xE0, 0x07, 0xDF, 0x00, 0x1F,
  0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3E, 0xF0, 0x00,
  0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0x3F, 0x00, 0xFC, 0x7E, 0x0F, 0xE1,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x03,
  0xE1, 0xF8, 0x01, 0xF3, 0xFF, 0x01, 0xF3, 0xFF, 0xC0, 0xF9, 0xFF, 0xE0,
  0x7D, 0xC3, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F,
  0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x3F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0x83, 0xF0,
  0x0F, 0xC3, 0xEC, 0x0F, 0xC1, 0xF7, 0xFF, 0xE0, 0xF9, 0xFF, 0xE0, 0x7C,
  0x7F, 0xC0, 0x3E, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x03, 0xFF,
  0x1F, 0x07, 0xFF, 0xBE, 0x0F, 0xFF, 0xBE, 0x1F, 0xC1, 0xFE, 0x1F, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01,
  0xF8, 0xFC, 0x03, 0xF8, 0x7C, 0x06, 0xF8, 0x7E, 0x0F, 0xF0, 0x7F, 0xFD,
  0xF0, 0x3F, 0xF9, 0xF0, 0x1F, 0xF1, 0xF0, 0x07, 0xC1, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xFF, 0xE0,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0x03, 0xFC, 0x00,
  0x0F, 0x60, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x03, 0x07, 0xC0, 0x04,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x40, 0x03, 0xE3, 0xC0,
  0x0F, 0xCF, 0xE0, 0x3F, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x02, 0x01, 0xF0, 0x1C, 0x07, 0xC0,
  0xF8, 0x1F, 0x07, 0xF0, 0x78, 0x7F, 0x03, 0xE3, 0xF8, 0x0F, 0x9F, 0x80,
  0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x3E, 0x3C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0,
  0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1,
  0xF0, 0x07, 0xE3, 0xE0, 0x17, 0xC7, 0xE0, 0x7F, 0x0F, 0xE1, 0xBE, 0x0F,
  0xFF, 0x7C, 0x1F, 0xFC, 0xF8, 0x1F, 0xF1, 0xF0, 0x0F, 0x80, 0x00, 0x7F,
  0xE0, 0x0C, 0xFF, 0x80, 0xF9, 0xFF, 0x01, 0xF3, 0xFE, 0x01, 0xF8, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07,
  0xC1, 0xE0, 0x0F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF0,
  0x3E, 0x0F, 0xE0, 0x7C, 0x3F, 0x80, 0xF9, 0xFE, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x07, 0x83, 0x0F,
  0x03, 0xC7, 0xC7, 0x83, 0xC1, 0xE3, 0xC1, 0xE0, 0xF1, 0xE0, 0xF0, 0x79,
  0xF0, 0x78, 0x3C, 0xF0, 0x3C, 0x1E, 0x78, 0x1E, 0x0F, 0x3C, 0x1F, 0x07,
  0x9E, 0x0F, 0x03, 0xCF, 0x07, 0x81, 0xE7, 0x83, 0xC0, 0xF7, 0x81, 0xE0,
  0x7B, 0xC0, 0xF0, 0x3D, 0xE0, 0xF8, 0x3C, 0xF0, 0x78, 0x1E, 0x78, 0x3C,
  0x0F, 0x3C, 0x1E, 0x07, 0xBE, 0x1F, 0x07, 0x9F, 0x0B, 0x83, 0xCF, 0x8D,
  0xC3, 0xC7, 0xFC, 0xF3, 0xC1, 0xFE, 0x7F, 0xE0, 0xFE, 0x1F, 0xC0, 0x3E,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x1F, 0xC1, 0xFC, 0x03, 0xFE,
  0x3F, 0xE0, 0xFF, 0xE7, 0xFE, 0x1F, 0xDE, 0x71, 0xE3, 0xF1, 0xEE, 0x1E,
  0x3E, 0x1E, 0xC1, 0xF1, 0x80, 0xEC, 0x1E, 0x00, 0x0F, 0x81, 0xE0, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xF0,
  0x3F, 0x01, 0x0F, 0x03, 0xF0, 0x38, 0xF0, 0x7F, 0x07, 0x8F, 0x86, 0xF1,
  0xFC, 0xF8, 0xEF, 0xBF, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xC7, 0xFC, 0x07,
  0xF8, 0x7F, 0x80, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x83, 0xC0,
  0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0,
  0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xFC,
  0x1F, 0x00, 0xBE, 0x0F, 0xC0, 0xDF, 0x03, 0xF0, 0xDF, 0x01, 0xFF, 0xEF,
  0x80, 0x7F, 0xE7, 0xC0, 0x3F, 0xE3, 0xE0, 0x07, 0xC1, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x03, 0x00,
  0x7E, 0x03, 0xE0, 0x7E, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0x07, 0xFF, 0x1F,
  0x0F, 0xFF, 0xDF, 0x1F, 0xFF, 0xFF, 0x1F, 0x0F, 0xFF, 0x3E, 0x01, 0xFE,
  0x3C, 0x00, 0xFC, 0x3C, 0x01, 0xF8, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x18, 0x07, 0xE0, 0x78, 0x0F, 0xC0, 0x3C, 0x1F, 0x80, 0x3C,
  0x3F, 0x00, 0x3C, 0x7F, 0xE0, 0x3C, 0xFF, 0xFF, 0x1C, 0xF9, 0xFF, 0xFC,
  0xF0, 0x3F, 0xFC, 0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x0F, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E,
  0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x06, 0x07, 0xF8, 0x07, 0xC7, 0xFE,
  0x03, 0xC7, 0xFF, 0x01, 0xE3, 0xC7, 0xC1, 0xE3, 0xC1, 0xE0, 0xF1, 0xE0,
  0xF8, 0xF1, 0xE0, 0x3F, 0xF8, 0xF0, 0x0F, 0xF8, 0x78, 0x07, 0xF8, 0x18,
  0x00, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 12, 32, 28, 8, -32 },
  { 49, 15, 14, 28, 9, -34 },
  { 76, 29, 32, 28, 0, -32 },
  { 192, 26, 44, 28, 1, -38 },
  { 335, 32, 34, 28, -1, -33 },
  { 471, 27, 34, 28, 0, -33 },
  { 586, 7, 14, 28, 13, -34 },
  { 599, 18, 41, 28, 9, -35 },
  { 692, 18, 41, 28, 2, -35 },
  { 785, 24, 23, 28, 2, -25 },
  { 854, 22, 22, 28, 3, -25 },
  { 915, 11, 14, 28, 6, -7 },
  { 935, 14, 4, 28, 7, -16 },
  { 942, 8, 8, 28, 8, -8 },
  { 950, 26, 41, 28, 1, -35 },
  { 1084, 25, 34, 28, 2, -33 },
  { 1191, 23, 32, 28, 2, -32 },
  { 1283, 25, 33, 28, 1, -33 },
  { 1387, 25, 34, 28, 1, -33 },
  { 1494, 26, 32, 28, 0, -32 },
  { 1598, 25, 33, 28, 2, -32 },
  { 1702, 23, 33, 28, 2, -32 },
  { 1797, 24, 32, 28, 4, -32 },
  { 1893, 25, 34, 28, 2, -33 },
  { 2000, 22, 33, 28, 4, -33 },
  { 2091, 11, 25, 28, 8, -25 },
  { 2126, 13, 32, 28, 6, -25 },
  { 2178, 22, 27, 28, 4, -28 },
  { 2253, 24, 14, 28, 2, -21 },
  { 2295, 23, 27, 28, 2, -28 },
  { 2373, 21, 33, 28, 5, -33 },
  { 2460, 24, 38, 28, 2, -33 },
  { 2574, 26, 32, 28, -1, -32 },
  { 2678, 24, 32, 28, 2, -32 },
  { 2774, 24, 34, 28, 3, -33 },
  { 2876, 24, 32, 28, 2, -32 },
  { 2972, 25, 32, 28, 2, -32 },
  { 3072, 26, 32, 28, 2, -32 },
  { 3176, 24, 34, 28, 3, -33 },
  { 3278, 27, 32, 28, 1, -32 },
  { 3386, 25, 32, 28, 2, -32 },
  { 3486, 24, 33, 28, 2, -32 },
  { 3585, 28, 32, 28, 2, -32 },
  { 3697, 21, 32, 28, 3, -32 },
  { 3781, 27, 32, 28, 1, -32 },
  { 3889, 27, 32, 28, 1, -32 },
  { 3997, 25, 34, 28, 2, -33 },
  { 4104, 25, 32, 28, 2, -32 },
  { 4204, 25, 42, 28, 2, -33 },
  { 4336, 25, 32, 28, 2, -32 },
  { 4436, 26, 34, 28, 1, -33 },
  { 4547, 26, 32, 28, 4, -32 },
  { 4651, 25, 33, 28, 3, -32 },
  { 4755, 25, 32, 28, 5, -32 },
  { 4855, 29, 32, 28, 1, -32 },
  { 4971, 31, 32, 28, -1, -32 },
  { 5095, 26, 32, 28, 4, -32 },
  { 5199, 28, 32, 28, 0, -32 },
  { 5311, 20, 41, 28, 7, -35 },
  { 5414, 13, 41, 28, 8, -35 },
  { 5481, 20, 41, 28, 1, -35 },
  { 5584, 24, 19, 28, 2, -32 },
  { 5641, 22, 4, 28, 0, 4 },
  { 5652, 7, 10, 28, 10, -37 },
  { 5661, 23, 25, 28, 2, -24 },
  { 5733, 23, 35, 28, 2, -34 },
  { 5834, 21, 25, 28, 3, -24 },
  { 5900, 25, 35, 28, 2, -34 },
  { 6010, 22, 25, 28, 3, -24 },
  { 6079, 31, 44, 28, -1, -34 },
  { 6250, 25, 34, 28, 1, -24 },
  { 6357, 22, 34, 28, 2, -34 },
  { 6451, 22, 35, 28, 3, -34 },
  { 6548, 22, 44, 28, 2, -34 },
  { 6669, 25, 35, 28, 2, -34 },
  { 6779, 19, 35, 28, 5, -34 },
  { 6863, 27, 24, 28, 0, -24 },
  { 6944, 22, 24, 28, 2, -24 },
  { 7010, 22, 25, 28, 3, -24 },
  { 7079, 25, 33, 28, 0, -24 },
  { 7183, 24, 33, 28, 2, -24 },
  { 7282, 22, 24, 28, 5, -24 },
  { 7348, 23, 25, 28, 2, -24 },
  { 7420, 22, 33, 28, 3, -32 },
  { 7511, 23, 25, 28, 3, -24 },
  { 7583, 23, 24, 28, 2, -24 },
  { 7652, 25, 25, 28, 1, -24 },
  { 7731, 28, 25, 28, 0, -24 },
  { 7819, 25, 34, 28, 1, -24 },
  { 7926, 24, 25, 28, 2, -24 },
  { 8001, 22, 41, 28, 5, -35 },
  { 8114, 11, 41, 28, 9, -35 },
  { 8171, 22, 41, 28, 2, -35 },
  { 8284, 25, 11, 28, 2, -19 },
};

const GFXfont IBMPlexMono_MediumItalic46pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic46pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic46pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _IBMPLEXMONO_MEDIUMITALIC46PT7B_H_
