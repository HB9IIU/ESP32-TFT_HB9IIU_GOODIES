#ifndef _IBMPLEXMONO_MEDIUMITALIC32PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x18,
  0x18, 0x18, 0x10, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF8, 0xF0, 0x78,
  0xEE, 0x3D, 0xC7, 0x38, 0xE7, 0x1C, 0xE3, 0xBC, 0x77, 0x1E, 0xE3, 0x9C,
  0x70, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0xF1, 0x80, 0x0E, 0x38, 0x00,
  0xE3, 0x80, 0x1C, 0x30, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x3F, 0x87, 0xF0,
  0x38, 0xE0, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x07, 0xF1, 0xFC,
  0xFE, 0x3F, 0xCF, 0xE3, 0xF8, 0x0E, 0x38, 0x00, 0xC7, 0x00, 0x1C, 0x70,
  0x01, 0xC7, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xE7, 0x7C,
  0xF1, 0x86, 0x3C, 0x60, 0x0F, 0x18, 0x03, 0xC6, 0x00, 0xFB, 0x80, 0x1F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xCF, 0x00, 0x71,
  0xC0, 0x1C, 0x71, 0x06, 0x1C, 0xE1, 0x8F, 0x3E, 0x67, 0x87, 0xFF, 0xE0,
  0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x03,
  0xE0, 0x1C, 0x1F, 0xC0, 0xE0, 0xFF, 0x83, 0x07, 0x8E, 0x1C, 0x1C, 0x38,
  0xE0, 0x70, 0xE7, 0x01, 0x83, 0x98, 0x07, 0x1C, 0xE0, 0x1F, 0xF7, 0x00,
  0x3F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x0E,
  0x7F, 0x80, 0x33, 0x8E, 0x01, 0xCC, 0x18, 0x0E, 0x70, 0x60, 0x71, 0xC3,
  0x81, 0x83, 0x0E, 0x0E, 0x0F, 0xF0, 0x70, 0x3F, 0x83, 0x80, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xC3, 0x80, 0x70, 0x78,
  0x0E, 0x07, 0x01, 0xC1, 0xE0, 0x3C, 0x38, 0x03, 0x87, 0x00, 0x73, 0xC0,
  0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0x9E, 0x00, 0xE1, 0xC0, 0x3C, 0x3C, 0x07,
  0x83, 0x80, 0xF0, 0x78, 0xDE, 0x0F, 0x3F, 0xC3, 0xF7, 0x3F, 0xCF, 0xC7,
  0xF9, 0xF8, 0x3C, 0x1E, 0x00, 0x7B, 0xDC, 0xE7, 0x39, 0xDE, 0xE7, 0x00,
  0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x81, 0xC1, 0xF1, 0xCF, 0xFF, 0xFF, 0x7F, 0xFE,
  0x0F, 0xF0, 0x07, 0xC0, 0x0F, 0xE0, 0x1E, 0xE0, 0x3C, 0xF0, 0x78, 0x70,
  0x70, 0x38, 0x20, 0x20, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x1F, 0x1E,
  0x3E, 0x3C, 0x3C, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x83, 0xC1, 0xE3, 0xC0, 0x73, 0xC0, 0x39,
  0xE0, 0x1C, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0xE3, 0xBC, 0xF1, 0xDC, 0x79,
  0xEE, 0x38, 0xF7, 0x00, 0x7B, 0x80, 0x39, 0xC0, 0x3C, 0xE0, 0x1E, 0x78,
  0x1E, 0x3E, 0x1F, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xB8, 0x1F, 0x38, 0x3E, 0x78, 0x3C, 0x78,
  0x18, 0x78, 0x10, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xE1, 0xF1, 0xE0, 0x79, 0xE0, 0x3C, 0x20, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0xFF,
  0xEF, 0xFF, 0xE7, 0xFF, 0xF0, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xE1, 0xF0, 0xC0, 0x78, 0x40, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x01, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x1E, 0x20, 0x0E, 0x70, 0x0F, 0x3E, 0x0F, 0x8F, 0xFF, 0x83,
  0xFF, 0x80, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x3D, 0xC0, 0x0E, 0x70, 0x07, 0x1C, 0x03, 0x87,
  0x01, 0xE3, 0xC0, 0xF0, 0xF0, 0x38, 0x38, 0x1C, 0x0E, 0x0E, 0x03, 0x87,
  0x00, 0xE1, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xF8, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0xF8, 0x06, 0xFF, 0x83, 0xBF, 0xE0, 0xF8, 0x7C, 0x18, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x20, 0x0F, 0x1C, 0x07, 0x8F, 0x83,
  0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x79, 0xF0, 0x7B, 0xFC, 0xF7, 0xFE, 0xFC, 0x3E, 0xF0, 0x0E, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1E, 0xF8, 0x7C, 0x7F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xF0, 0x0F,
  0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x1E, 0x1E, 0x03, 0x87,
  0x00, 0xF1, 0xC0, 0x38, 0x70, 0x1E, 0x1E, 0x0F, 0x03, 0xFF, 0x80, 0x3F,
  0x80, 0x7F, 0xF8, 0x3C, 0x1F, 0x1E, 0x03, 0xCF, 0x00, 0x73, 0xC0, 0x1C,
  0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x83, 0xE1, 0xFF, 0xF8, 0x3F, 0xF8, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x3E, 0x1F, 0x78, 0x0F,
  0x78, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x3F,
  0x7F, 0xFE, 0x3F, 0xDE, 0x0F, 0x9E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0x1E, 0x7C,
  0xF9, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x9F, 0x3E, 0x7C,
  0xF0, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x0E, 0x0F,
  0x07, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x60,
  0x00, 0x40, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0x80,
  0x20, 0x00, 0x70, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0xF0, 0x01, 0x80, 0x02, 0x00, 0x00,
  0x0F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1F, 0xF0, 0x3D, 0x80, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x78, 0x1F, 0xC0, 0xFC, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x00, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x0F, 0x3C,
  0x07, 0x38, 0x03, 0x70, 0xF7, 0x71, 0xFF, 0x73, 0xFF, 0xE3, 0x8F, 0xE7,
  0x87, 0xE7, 0x07, 0xE7, 0x06, 0xE7, 0x0E, 0xE7, 0x0E, 0xC7, 0x1E, 0xC7,
  0xEE, 0xC7, 0xEE, 0xC3, 0xCC, 0xC0, 0x10, 0xE0, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0xF7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x07,
  0x1C, 0x01, 0xC7, 0x00, 0xF1, 0xE0, 0x38, 0x78, 0x1E, 0x1E, 0x07, 0x03,
  0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1C, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xFC, 0x00, 0x70, 0x0F, 0xFC, 0x07,
  0xFF, 0x83, 0xFF, 0xC3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x70, 0x1E,
  0x38, 0x0F, 0x1C, 0x0F, 0x1F, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0xC3, 0x80,
  0xF1, 0xC0, 0x78, 0xE0, 0x1C, 0xF0, 0x1E, 0x78, 0x0F, 0x38, 0x07, 0x9C,
  0x07, 0x8F, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0x80, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xE1, 0xE3, 0xE0, 0x79, 0xE0, 0x3D, 0xE0, 0x10, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x18, 0xF0, 0x0E, 0x38, 0x0F, 0x1E, 0x0F,
  0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0xC3, 0xC1, 0xF1, 0xE0, 0x78, 0xF0, 0x1C, 0x70, 0x0E, 0x38, 0x07,
  0x1C, 0x03, 0x9E, 0x01, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0x80, 0x79, 0xC0,
  0x3C, 0xE0, 0x1E, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x1C, 0x0F, 0x8F,
  0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xFC, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0xFF, 0xFC, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8,
  0x03, 0xFE, 0x03, 0xFF, 0x83, 0xC1, 0xE3, 0xC0, 0x71, 0xC0, 0x39, 0xE0,
  0x12, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x3F, 0xDE, 0x1F, 0xCF,
  0x0F, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x3C, 0xF0, 0x1E, 0x78, 0x1E,
  0x3E, 0x1F, 0x0F, 0xFB, 0x83, 0xF9, 0xC0, 0xF8, 0xE0, 0x0E, 0x01, 0xC7,
  0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0,
  0x38, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC,
  0x38, 0x07, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x0E, 0x1C,
  0x03, 0x87, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x80, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0xF0,
  0x1C, 0x38, 0x1E, 0x1E, 0x1F, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x7E, 0x00,
  0x0E, 0x01, 0xF0, 0xE0, 0x3E, 0x1E, 0x07, 0xC1, 0xE0, 0xF8, 0x1E, 0x1F,
  0x01, 0xC3, 0xE0, 0x1C, 0x7C, 0x01, 0xC7, 0x80, 0x3C, 0xF0, 0x03, 0xDE,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xE7, 0x80, 0x7C,
  0x78, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x07,
  0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x01,
  0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xDC,
  0xEE, 0x1D, 0xCE, 0xE1, 0xDD, 0xDE, 0x1D, 0xDD, 0xC1, 0xCF, 0x9C, 0x3C,
  0xF1, 0xC3, 0x8F, 0x1C, 0x38, 0xE3, 0xC3, 0x86, 0x38, 0x38, 0x43, 0x83,
  0x84, 0x38, 0x78, 0x03, 0x87, 0x00, 0x38, 0x70, 0x07, 0x87, 0x00, 0x70,
  0x70, 0x07, 0x0F, 0x00, 0x70, 0x0F, 0x01, 0xC7, 0xE0, 0x71, 0xF8, 0x1C,
  0x7E, 0x0F, 0x1F, 0x83, 0x87, 0xE0, 0xE1, 0xDC, 0x38, 0xF7, 0x0E, 0x39,
  0xC3, 0x8E, 0x71, 0xE3, 0x9E, 0x70, 0xE3, 0x9C, 0x38, 0xE7, 0x1E, 0x39,
  0xC7, 0x0E, 0x71, 0xC1, 0xFC, 0x70, 0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xE3,
  0xC1, 0xF8, 0xE0, 0x3E, 0x38, 0x0F, 0x80, 0x01, 0xF8, 0x03, 0xFE, 0x07,
  0xFF, 0x83, 0xC1, 0xE3, 0xC0, 0xF3, 0xC0, 0x39, 0xE0, 0x1C, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xBC, 0x01, 0xDE, 0x01, 0xEE, 0x00, 0xF7, 0x00,
  0x7B, 0x80, 0x3D, 0xC0, 0x3C, 0xE0, 0x1E, 0x78, 0x1E, 0x3E, 0x1F, 0x0F,
  0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF,
  0xF8, 0x78, 0x1F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x0F,
  0x1C, 0x03, 0x8F, 0x03, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFE,
  0x03, 0xFF, 0x83, 0xC1, 0xE3, 0xC0, 0xF3, 0xC0, 0x39, 0xE0, 0x1C, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xBC, 0x01, 0xDE, 0x01, 0xEE, 0x00, 0xF7,
  0x00, 0x7B, 0x80, 0x3D, 0xC0, 0x3C, 0xE0, 0x1E, 0x78, 0x1E, 0x3E, 0x1F,
  0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x1E, 0x10, 0x07, 0x8C, 0x01,
  0xCF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x78, 0x1F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C,
  0x70, 0x0F, 0x1C, 0x03, 0x8F, 0x03, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xF8, 0x0E, 0x1C, 0x03, 0x87, 0x01, 0xE1, 0xE0, 0x78, 0x38, 0x1E, 0x0F,
  0x07, 0x03, 0xC1, 0xC0, 0x70, 0x70, 0x1E, 0x3C, 0x07, 0x80, 0x01, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x1F, 0x1C, 0x03, 0x8F, 0x00, 0x83,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x7F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x40, 0x0F,
  0x38, 0x03, 0xCF, 0x83, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x03, 0x9E, 0x01, 0xCF, 0x01, 0xE7, 0x00, 0xF3, 0x80,
  0x79, 0xC0, 0x39, 0xE0, 0x1C, 0xF0, 0x1E, 0x78, 0x0F, 0x38, 0x07, 0x9C,
  0x03, 0xCE, 0x01, 0xCF, 0x00, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xC0, 0x3C,
  0xE0, 0x1C, 0x78, 0x1E, 0x3E, 0x1F, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xFE,
  0x00, 0xF0, 0x03, 0xFC, 0x01, 0xEF, 0x00, 0x79, 0xC0, 0x3C, 0x70, 0x0F,
  0x1C, 0x03, 0x87, 0x01, 0xE1, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x07,
  0x87, 0x80, 0xE1, 0xC0, 0x38, 0xF0, 0x0E, 0x3C, 0x03, 0x8E, 0x00, 0xE7,
  0x80, 0x39, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0x38, 0x00, 0x73, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80,
  0x0E, 0x38, 0x00, 0xE3, 0x8F, 0x1C, 0x78, 0xF1, 0xC7, 0x1F, 0x1C, 0x71,
  0xF1, 0xC7, 0x1B, 0x38, 0x73, 0xB3, 0x87, 0x33, 0x38, 0x73, 0x33, 0x87,
  0x73, 0x30, 0x76, 0x37, 0x07, 0x63, 0x70, 0xEE, 0x37, 0x0E, 0xC3, 0x60,
  0xEC, 0x3E, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x0F, 0x00,
  0x7C, 0x1E, 0x01, 0xE0, 0x78, 0x0F, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xC0,
  0x07, 0x8E, 0x00, 0x1E, 0x78, 0x00, 0x3B, 0xC0, 0x00, 0xFE, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x3D, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x0F, 0x00, 0x3C, 0x1C, 0x01,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x03, 0xC3, 0xE0, 0x0F, 0x00, 0xF0,
  0x03, 0xFC, 0x01, 0xE7, 0x00, 0xF1, 0xE0, 0x3C, 0x78, 0x1E, 0x0E, 0x0F,
  0x03, 0xC3, 0xC0, 0x71, 0xE0, 0x1C, 0xF0, 0x07, 0xB8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0x83, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xC0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x60, 0x70, 0x70, 0x70, 0x30, 0x38, 0x38, 0x38, 0x38, 0x18,
  0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0E, 0x0E, 0x0E, 0x06, 0x07, 0x07, 0x07,
  0x07, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC3, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xB8, 0x07, 0x38,
  0x0F, 0x1C, 0x0E, 0x1C, 0x1C, 0x1E, 0x3C, 0x0E, 0x78, 0x0E, 0x70, 0x0F,
  0xF0, 0x07, 0xE0, 0x07, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE,
  0x27, 0x38, 0xE7, 0x1C, 0xC0, 0x07, 0x8F, 0x1F, 0xEE, 0x3F, 0xEE, 0x7C,
  0x3E, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x7C, 0xF0, 0xF8, 0xFF, 0xBE, 0x7F,
  0x3E, 0x3E, 0x1E, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0xF8, 0x1C, 0xFE, 0x0E, 0xFF,
  0x8F, 0xC3, 0xC7, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xE0, 0x1E, 0x70,
  0x0F, 0x78, 0x07, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC7, 0xC3, 0xE3,
  0xBF, 0xE1, 0xDF, 0xE1, 0xE7, 0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1,
  0xF0, 0xF7, 0x80, 0xCF, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x27, 0x80, 0xEF, 0x03, 0xEF, 0x0F, 0x1F, 0xFC, 0x1F, 0xF0,
  0x0F, 0xC0, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x0F, 0x9E, 0x1F, 0xEF, 0x1F, 0xFF, 0x9F,
  0x0F, 0x8F, 0x03, 0xCF, 0x00, 0xE7, 0x80, 0xF3, 0x80, 0x79, 0xC0, 0x3C,
  0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x0F, 0x1C, 0x0F, 0x8F, 0x0F, 0xC7, 0xFD,
  0xE1, 0xFC, 0xE0, 0x7C, 0x70, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF9, 0xF0,
  0xF7, 0x80, 0xEE, 0x03, 0xDC, 0x1F, 0xFF, 0xFE, 0xFF, 0xF1, 0xFF, 0x03,
  0xC0, 0x07, 0x80, 0x4F, 0x01, 0xEF, 0x07, 0x9F, 0xFE, 0x1F, 0xF8, 0x0F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x01, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x02, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0xF8, 0xE0, 0x01, 0xE3, 0x80,
  0x03, 0xDE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE7, 0x87, 0xFB, 0xC7, 0xFD, 0xE7, 0xC3, 0xE3, 0xC0, 0xF3, 0xC0,
  0x39, 0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x0F, 0x38, 0x07, 0x1C, 0x03, 0x8E,
  0x03, 0xC7, 0x03, 0xE3, 0xC3, 0xF1, 0xFF, 0x70, 0x7F, 0x38, 0x1F, 0x1C,
  0x00, 0x1E, 0x10, 0x0E, 0x0C, 0x0F, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x7E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x7C, 0x1C, 0xFE, 0x1D, 0xFF, 0x1D, 0x0F, 0x3E,
  0x0F, 0x3C, 0x07, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x78,
  0x0E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1C, 0xF0,
  0x1C, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x02, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x04, 0x0E, 0x1C, 0x3C,
  0x78, 0x79, 0xE0, 0xEF, 0x81, 0xFE, 0x03, 0xF8, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x20, 0xF0, 0x70, 0xE0, 0xF8, 0xE0,
  0x7C, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x78, 0x1C, 0xFE, 0x0E, 0xFF, 0x87, 0x43, 0xC7, 0xC0, 0xE3,
  0xC0, 0x71, 0xE0, 0x70, 0xF0, 0x78, 0x70, 0xF0, 0x3B, 0xE0, 0x3C, 0xE0,
  0x1E, 0x78, 0x4F, 0x3C, 0x77, 0x0F, 0x7B, 0x87, 0xF9, 0xC1, 0xF9, 0xE0,
  0x70, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x10, 0x70, 0xE1, 0xC7, 0xCF, 0x3C,
  0x3D, 0xE0, 0xFF, 0x03, 0xF8, 0x07, 0x80, 0x1C, 0xE3, 0x83, 0xBC, 0xF8,
  0xEF, 0xFF, 0x1E, 0x3C, 0xF3, 0xC7, 0x0C, 0x70, 0xE3, 0x8E, 0x18, 0x71,
  0xC7, 0x0E, 0x70, 0xE1, 0xCE, 0x1C, 0x39, 0xC3, 0x87, 0x38, 0x71, 0xC7,
  0x1C, 0x38, 0xE3, 0x87, 0x38, 0x70, 0xE7, 0x0E, 0x1C, 0xE1, 0xC7, 0x80,
  0x1E, 0x7C, 0x1C, 0xFE, 0x1D, 0xFF, 0x1D, 0x0F, 0x3E, 0x0F, 0x3C, 0x07,
  0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x78, 0x0E, 0x78, 0x0E,
  0x78, 0x0E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1C, 0xF0, 0x1C, 0x03, 0xF0,
  0x1F, 0xF0, 0x7F, 0xF1, 0xE0, 0xF7, 0x80, 0xEE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFF, 0x03, 0xDF, 0x0F,
  0x9F, 0xFE, 0x1F, 0xF8, 0x0F, 0x80, 0x0E, 0x3E, 0x03, 0x9F, 0xC0, 0xEF,
  0xF8, 0x7E, 0x1E, 0x1F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x0F,
  0x1C, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x0F,
  0x87, 0xC3, 0xBF, 0xE1, 0xEF, 0xF0, 0x79, 0xF8, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xCF,
  0x1F, 0xEF, 0x3F, 0xFF, 0x7C, 0x3E, 0x78, 0x1E, 0xF0, 0x0E, 0xF0, 0x1E,
  0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x7C,
  0xF0, 0xFC, 0xFF, 0xBC, 0x7F, 0x38, 0x3E, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x7F, 0x0F, 0x7F, 0x3F,
  0xFF, 0x7F, 0x0F, 0x40, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x03, 0xF8, 0x0F, 0xFE, 0x1F, 0xFF,
  0x1E, 0x0E, 0x1C, 0x04, 0x1C, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0x1E, 0x00, 0x0E, 0x20, 0x0E, 0x78, 0x3E, 0xFF, 0xFC,
  0x3F, 0xF8, 0x0F, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x0F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x06, 0x1E, 0x1E,
  0x3C, 0xF8, 0x7B, 0xE0, 0xFF, 0x01, 0xFC, 0x01, 0xE0, 0x00, 0x38, 0x0F,
  0x38, 0x0F, 0x38, 0x0E, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x1E, 0x70, 0x1E,
  0x70, 0x1E, 0x70, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C,
  0xF0, 0xBC, 0x7F, 0xB8, 0x7F, 0x38, 0x3E, 0x38, 0xFE, 0x05, 0xFC, 0x3F,
  0xF0, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xCF, 0x03, 0x9E, 0x07, 0x38,
  0x1E, 0x70, 0x3C, 0xE0, 0xF1, 0xC1, 0xE7, 0x8F, 0x8F, 0x3E, 0x1F, 0xF8,
  0x1F, 0xE0, 0x3F, 0x00, 0x38, 0xE1, 0x9C, 0x71, 0xCC, 0x38, 0xEE, 0x1C,
  0x77, 0x0E, 0x3B, 0x87, 0x1D, 0xC7, 0x0E, 0xE3, 0x87, 0x61, 0xC3, 0xF0,
  0xE1, 0xF8, 0x70, 0xFC, 0x38, 0xEE, 0x3C, 0x77, 0x3E, 0x33, 0xF7, 0x39,
  0xFB, 0xF8, 0x78, 0xF0, 0x00, 0x03, 0x83, 0xC1, 0xF8, 0xF8, 0x7F, 0xBF,
  0x9F, 0x74, 0x77, 0x8F, 0x8E, 0x41, 0xE1, 0xC0, 0x3C, 0x30, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x01, 0x87, 0x80, 0x70, 0xF0, 0xCE, 0x16, 0x3D,
  0xC6, 0xCF, 0x3F, 0x9F, 0xC3, 0xF3, 0xF0, 0x38, 0x38, 0x00, 0x1C, 0x07,
  0x8E, 0x03, 0xC7, 0x01, 0xC7, 0x80, 0xE3, 0xC0, 0x71, 0xE0, 0x78, 0xE0,
  0x3C, 0x70, 0x1E, 0x38, 0x0E, 0x1C, 0x07, 0x1E, 0x07, 0x8F, 0x03, 0xC7,
  0x83, 0xE3, 0xE3, 0xF0, 0xFF, 0x70, 0x7F, 0x38, 0x1F, 0x1C, 0x00, 0x1E,
  0x10, 0x0E, 0x0C, 0x1F, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x07,
  0xC3, 0x8F, 0xF9, 0xC7, 0xFF, 0xE7, 0x07, 0xF3, 0x80, 0xF1, 0xC1, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC1, 0x03, 0xC3, 0x83, 0xC0,
  0xE3, 0xC0, 0x73, 0xFF, 0x3B, 0xFF, 0xFD, 0xE7, 0xFE, 0xE0, 0x7C, 0x00,
  0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x7F, 0x80, 0x7E, 0x00, 0xFF, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0x07, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0,
  0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x41, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x30, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F,
  0xE0, 0x0F, 0xC0, 0xFF, 0x81, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC1, 0xFF,
  0x03, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0x01, 0x8F, 0xC1, 0xCF, 0xF0, 0xEF,
  0x38, 0x77, 0x1E, 0x73, 0x07, 0xFB, 0x81, 0xF8, 0xC0, 0x78,
};

const GFXglyph IBMPlexMono_MediumItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 8, 22, 19, 6, -22 },
  { 23, 11, 10, 19, 6, -24 },
  { 37, 20, 22, 19, 0, -22 },
  { 92, 18, 28, 19, 1, -25 },
  { 155, 22, 22, 19, -1, -22 },
  { 216, 19, 22, 19, 0, -22 },
  { 269, 5, 10, 19, 9, -24 },
  { 276, 13, 28, 19, 6, -24 },
  { 322, 13, 28, 19, 1, -24 },
  { 368, 16, 16, 19, 2, -18 },
  { 400, 16, 15, 19, 2, -17 },
  { 430, 8, 10, 19, 4, -5 },
  { 440, 10, 3, 19, 5, -11 },
  { 444, 5, 5, 19, 6, -5 },
  { 448, 19, 28, 19, 0, -24 },
  { 515, 17, 22, 19, 2, -22 },
  { 562, 16, 22, 19, 1, -22 },
  { 606, 17, 22, 19, 1, -22 },
  { 653, 17, 22, 19, 1, -22 },
  { 700, 18, 22, 19, 0, -22 },
  { 750, 18, 22, 19, 1, -22 },
  { 800, 16, 22, 19, 2, -22 },
  { 844, 16, 22, 19, 3, -22 },
  { 888, 18, 22, 19, 1, -22 },
  { 938, 16, 22, 19, 2, -22 },
  { 982, 7, 17, 19, 6, -17 },
  { 997, 9, 22, 19, 4, -17 },
  { 1022, 15, 19, 19, 3, -19 },
  { 1058, 17, 10, 19, 1, -15 },
  { 1080, 15, 19, 19, 2, -19 },
  { 1116, 14, 22, 19, 4, -22 },
  { 1155, 16, 26, 19, 2, -22 },
  { 1207, 18, 22, 19, -1, -22 },
  { 1257, 17, 22, 19, 1, -22 },
  { 1304, 17, 22, 19, 2, -22 },
  { 1351, 17, 22, 19, 1, -22 },
  { 1398, 18, 22, 19, 1, -22 },
  { 1448, 18, 22, 19, 1, -22 },
  { 1498, 17, 22, 19, 2, -22 },
  { 1545, 18, 22, 19, 1, -22 },
  { 1595, 18, 22, 19, 1, -22 },
  { 1645, 17, 22, 19, 1, -22 },
  { 1692, 20, 22, 19, 1, -22 },
  { 1747, 14, 22, 19, 2, -22 },
  { 1786, 20, 22, 19, 0, -22 },
  { 1841, 18, 22, 19, 1, -22 },
  { 1891, 17, 22, 19, 2, -22 },
  { 1938, 18, 22, 19, 1, -22 },
  { 1988, 17, 28, 19, 2, -22 },
  { 2048, 18, 22, 19, 1, -22 },
  { 2098, 18, 22, 19, 1, -22 },
  { 2148, 18, 22, 19, 3, -22 },
  { 2198, 17, 22, 19, 2, -22 },
  { 2245, 18, 22, 19, 3, -22 },
  { 2295, 20, 22, 19, 1, -22 },
  { 2350, 22, 22, 19, -1, -22 },
  { 2411, 18, 22, 19, 3, -22 },
  { 2461, 20, 22, 19, 0, -22 },
  { 2516, 14, 28, 19, 5, -24 },
  { 2565, 8, 28, 19, 6, -24 },
  { 2593, 14, 28, 19, 1, -24 },
  { 2642, 16, 14, 19, 2, -22 },
  { 2670, 16, 3, 19, 0, 3 },
  { 2676, 5, 7, 19, 7, -26 },
  { 2681, 16, 17, 19, 2, -17 },
  { 2715, 17, 24, 19, 1, -24 },
  { 2766, 15, 17, 19, 2, -17 },
  { 2798, 17, 24, 19, 2, -24 },
  { 2849, 15, 17, 19, 2, -17 },
  { 2881, 22, 30, 19, -1, -24 },
  { 2964, 17, 23, 19, 1, -17 },
  { 3013, 16, 24, 19, 1, -24 },
  { 3061, 15, 24, 19, 2, -24 },
  { 3106, 16, 30, 19, 1, -24 },
  { 3166, 17, 24, 19, 1, -24 },
  { 3217, 14, 24, 19, 3, -24 },
  { 3259, 19, 17, 19, 0, -17 },
  { 3300, 16, 17, 19, 1, -17 },
  { 3334, 15, 17, 19, 2, -17 },
  { 3366, 18, 23, 19, 0, -17 },
  { 3418, 16, 23, 19, 2, -17 },
  { 3464, 16, 17, 19, 3, -17 },
  { 3498, 16, 17, 19, 1, -17 },
  { 3532, 15, 22, 19, 2, -22 },
  { 3574, 16, 17, 19, 2, -17 },
  { 3608, 15, 17, 19, 2, -17 },
  { 3640, 17, 17, 19, 1, -17 },
  { 3677, 19, 17, 19, 0, -17 },
  { 3718, 17, 23, 19, 1, -17 },
  { 3767, 17, 17, 19, 1, -17 },
  { 3804, 16, 28, 19, 3, -24 },
  { 3860, 8, 28, 19, 6, -24 },
  { 3888, 15, 28, 19, 1, -24 },
  { 3941, 17, 8, 19, 1, -14 },
};

const GFXfont IBMPlexMono_MediumItalic32pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic32pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _IBMPLEXMONO_MEDIUMITALIC32PT7B_H_
