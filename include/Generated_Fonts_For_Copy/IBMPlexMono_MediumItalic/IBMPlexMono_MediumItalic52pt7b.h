#ifndef _IBMPLEXMONO_MEDIUMITALIC52PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xFC, 0x3F, 0xE0, 0xFE, 0x03,
  0xE0, 0x00, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF7, 0xE0,
  0xFB, 0xE0, 0xFD, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0xBF,
  0x07, 0xDF, 0x07, 0xEF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF8, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F,
  0x83, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x0F, 0xFF,
  0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x7F, 0xF8,
  0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF8, 0x7F, 0xF0,
  0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xCF, 0x7F, 0x81, 0xFC, 0x38, 0x7F, 0x07, 0xE0, 0xE0, 0xF0, 0x3F,
  0x07, 0x81, 0x00, 0xFC, 0x1E, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x0F, 0xC1,
  0xE0, 0x00, 0x3F, 0x07, 0x80, 0x00, 0xFE, 0x1C, 0x00, 0x01, 0xFC, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xE7, 0xF8, 0x00, 0x07, 0x87, 0xE0, 0x00,
  0x1E, 0x1F, 0x80, 0x00, 0x70, 0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F,
  0x03, 0xE0, 0x40, 0x3C, 0x1F, 0x81, 0x80, 0xF0, 0x7E, 0x1F, 0x03, 0xC3,
  0xF8, 0xFE, 0x0E, 0x1F, 0xC1, 0xFE, 0x79, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x00, 0xFF, 0xF0, 0x01, 0xE0,
  0x1F, 0x0F, 0x00, 0x3E, 0x01, 0xE0, 0x78, 0x07, 0xC0, 0x3C, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0x7C, 0x07, 0x81, 0xF0, 0x07, 0xC0,
  0x78, 0x1E, 0x00, 0x7C, 0x07, 0x83, 0xC0, 0x07, 0x80, 0xF8, 0x7C, 0x00,
  0x78, 0x0F, 0x8F, 0x80, 0x07, 0x80, 0xF0, 0xF0, 0x00, 0x78, 0x0F, 0x1F,
  0x00, 0x07, 0xC1, 0xE3, 0xE0, 0x00, 0x3C, 0x3E, 0x3C, 0x00, 0x03, 0xFF,
  0xC4, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0x3E, 0x1E, 0x00, 0x03, 0xE7, 0xC1, 0xE0, 0x00, 0x7C,
  0x78, 0x0F, 0x00, 0x07, 0x8F, 0x80, 0xF0, 0x00, 0xF8, 0xF8, 0x0F, 0x00,
  0x1F, 0x0F, 0x00, 0xF0, 0x03, 0xE0, 0xF0, 0x1F, 0x00, 0x3C, 0x0F, 0x01,
  0xF0, 0x07, 0xC0, 0xF0, 0x1E, 0x00, 0xF8, 0x0F, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x3E, 0x01, 0xF0, 0x0F, 0x03, 0xC0, 0x3E, 0x00, 0xF8, 0x7C, 0x07,
  0xC0, 0x07, 0xFF, 0x80, 0x78, 0x00, 0x3F, 0xF0, 0x08, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xFC, 0x03, 0xE0,
  0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F,
  0x80, 0x8F, 0xC0, 0x1F, 0x83, 0xDF, 0x80, 0x3F, 0x07, 0xFF, 0x00, 0xFF,
  0x1F, 0x3F, 0x01, 0xBE, 0x7E, 0x7F, 0x0F, 0x7C, 0xF8, 0xFF, 0xFC, 0xFF,
  0xE0, 0xFF, 0xF8, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0x01, 0xFF, 0x81, 0xFC,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3E, 0x7C, 0xF9, 0xF7, 0xEF, 0x9F, 0x3E,
  0x7C, 0xFB, 0xF7, 0xCF, 0x9F, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x03, 0x00, 0xF8, 0x02, 0x7C, 0x1F, 0x03, 0xCF, 0xE3, 0xE3,
  0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xE3, 0xF0, 0x01, 0xFC,
  0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x07, 0xC0,
  0x1C, 0x00, 0xE0, 0x01, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x0F, 0xE7, 0xF9, 0xFF,
  0x7F, 0xBF, 0xEF, 0xF9, 0xFC, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F,
  0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xE3, 0xF0,
  0x00, 0xFC, 0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x3E,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x78, 0x3F, 0xFC, 0x1F,
  0x87, 0xFF, 0x87, 0xF0, 0xFF, 0xF0, 0xFE, 0x1F, 0xFE, 0x1F, 0x83, 0xFF,
  0xC3, 0xF0, 0xFD, 0xF8, 0x3C, 0x1F, 0xBE, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x7E, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x7C,
  0x00, 0x0F, 0xCF, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x07, 0xE0, 0x7F, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xBE, 0x00, 0x3F, 0x8F, 0x80,
  0x1F, 0xC7, 0xE0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x1F,
  0x00, 0x38, 0x07, 0xC0, 0x04, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x7E,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x3C, 0x00, 0x3F, 0x00, 0x80, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xC1, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x3C, 0x00, 0x3F,
  0x00, 0x80, 0x03, 0xF0, 0x08, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x08, 0x00,
  0x0F, 0xC3, 0x80, 0x01, 0xFC, 0x7C, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF8,
  0x7F, 0x80, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E,
  0xFC, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF8, 0x00, 0xF8,
  0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x03, 0xF0,
  0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x7F, 0x00, 0x0F, 0x9F, 0xFC, 0x00, 0xF3, 0xFF, 0xE0, 0x0F,
  0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xF8, 0x01,
  0xFC, 0x07, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x80, 0x01, 0xFC, 0x18, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF8,
  0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xFC, 0x03, 0xF1,
  0xFF, 0xC0, 0xFD, 0xFF, 0xF8, 0x3E, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7,
  0xFC, 0x0F, 0xFB, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07,
  0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xBE, 0x00,
  0x07, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0xCF, 0xE0, 0x0F, 0xE1, 0xFC, 0x07, 0xF8, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x07, 0xE7, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xC3,
  0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0x80,
  0xFF, 0x07, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01,
  0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xF8, 0x1F,
  0xE3, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x1F, 0xE7, 0xF8, 0x1F, 0xF9, 0xFF, 0xFF, 0x7C, 0x3F, 0xFF,
  0xBF, 0x07, 0xFF, 0xCF, 0x80, 0xFF, 0xE7, 0xE0, 0x0F, 0xE1, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x03, 0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0xFF, 0x87, 0xFC,
  0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8,
  0x04, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xF0, 0x3F, 0x9F, 0x80, 0x3F, 0xBF, 0x00,
  0x3F, 0xFC, 0x00, 0x7E, 0x30, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x00,
  0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x1F, 0x0F, 0x01, 0xF1, 0xF1, 0xF0, 0x3F, 0x9F, 0x1F, 0x07,
  0xFD, 0xF1, 0xE0, 0xFF, 0xDF, 0x3E, 0x1F, 0x87, 0xE3, 0xE1, 0xF0, 0x3E,
  0x3E, 0x3E, 0x03, 0xE3, 0xC3, 0xE0, 0x3E, 0x7C, 0x3E, 0x03, 0xE7, 0xC3,
  0xC0, 0x3E, 0x7C, 0x7C, 0x03, 0xC7, 0xC7, 0xC0, 0x3C, 0x7C, 0x7C, 0x07,
  0xC7, 0x87, 0xC0, 0x7C, 0x78, 0x7C, 0x07, 0xC7, 0x87, 0xC0, 0xFC, 0x78,
  0x7C, 0x0F, 0x87, 0x87, 0xC1, 0x78, 0xF8, 0x3F, 0x7F, 0x8F, 0x83, 0xFE,
  0xF8, 0x78, 0x3F, 0xEF, 0x87, 0x81, 0xFC, 0xF8, 0x78, 0x06, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7E, 0x7E, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x1F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8,
  0xFE, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00,
  0x3F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x0F,
  0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xF0, 0x03, 0xF8, 0x3E, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xC0,
  0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xF8,
  0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x07,
  0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x1F,
  0x80, 0x03, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x08, 0x07, 0xC0,
  0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x03, 0xF0, 0x07, 0xE0, 0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xFC, 0x07, 0xE0,
  0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03,
  0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xF1, 0xF8, 0x00, 0x7E, 0x1F,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0xFE, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x83,
  0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x03,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xF0, 0x3F, 0x81, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x08, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x1F,
  0xFF, 0x7E, 0x03, 0xFF, 0xCF, 0xC0, 0x7F, 0xF9, 0xF8, 0x0F, 0xFF, 0x3F,
  0x01, 0xFF, 0xE7, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03,
  0xE3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x83, 0xFE,
  0x07, 0xFF, 0xF7, 0xC0, 0xFF, 0xFC, 0xF8, 0x0F, 0xFF, 0x1F, 0x00, 0xFF,
  0xC7, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x3F, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x1F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F,
  0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x03, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x03,
  0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x1F,
  0xC0, 0x07, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x0F, 0x8F, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x1F, 0xBF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0xE0, 0x00, 0x3F, 0xE3, 0xF0,
  0x00, 0x3F, 0xC3, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x3E, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00,
  0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F,
  0xF0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFF,
  0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xBC, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0xF8,
  0x3E, 0xF8, 0xFB, 0xE0, 0x7C, 0xF1, 0xE7, 0xC0, 0xF9, 0xE7, 0xCF, 0x83,
  0xF3, 0xFF, 0x1F, 0x07, 0xC7, 0xFE, 0x3E, 0x0F, 0x87, 0xF8, 0xFC, 0x1F,
  0x0F, 0xF1, 0xF0, 0x3E, 0x1F, 0xC3, 0xE0, 0x7C, 0x3F, 0x07, 0xC1, 0xF8,
  0x7E, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF0, 0x7C, 0x0F, 0x81,
  0xC0, 0xF8, 0x1F, 0x03, 0x01, 0xF0, 0x3E, 0x02, 0x03, 0xE0, 0xFC, 0x08,
  0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0xF8, 0x3F, 0xC0, 0x07,
  0xC1, 0xFF, 0x00, 0x3E, 0x0F, 0xF8, 0x03, 0xF0, 0x7F, 0xC0, 0x1F, 0x03,
  0xFE, 0x00, 0xF8, 0x1F, 0xF0, 0x07, 0xC1, 0xFF, 0xC0, 0x3E, 0x0F, 0xBE,
  0x01, 0xF0, 0x7D, 0xF0, 0x1F, 0x83, 0xEF, 0x80, 0xF8, 0x1F, 0x3E, 0x07,
  0xC0, 0xF9, 0xF0, 0x3E, 0x0F, 0xCF, 0x81, 0xF0, 0x7C, 0x7C, 0x0F, 0x83,
  0xE3, 0xE0, 0xFC, 0x1F, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x3E, 0x07, 0xC3,
  0xE1, 0xF0, 0x7E, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x03, 0xE7,
  0xE0, 0xF8, 0x1F, 0x3E, 0x07, 0xC0, 0xF9, 0xF0, 0x3E, 0x07, 0xCF, 0x83,
  0xE0, 0x1E, 0x7C, 0x1F, 0x00, 0xFB, 0xE0, 0xF8, 0x07, 0xFF, 0x07, 0xC0,
  0x3F, 0xF0, 0x3E, 0x01, 0xFF, 0x81, 0xF0, 0x07, 0xFC, 0x1F, 0x00, 0x3F,
  0xE0, 0xF8, 0x01, 0xFF, 0x07, 0xC0, 0x0F, 0xF8, 0x3E, 0x00, 0x7F, 0x81,
  0xF0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F,
  0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF0,
  0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0x7E,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x7E, 0xF8, 0x00, 0x1F, 0xDF, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x7C,
  0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xF0, 0x03, 0xF8, 0x1F,
  0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3E, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x03, 0xF0,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF,
  0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFD, 0xF8,
  0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x1F,
  0x9F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x1F, 0xE0,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFC, 0x04, 0x00, 0x0F, 0xC0, 0xC0,
  0x01, 0xF8, 0x3C, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xF0, 0x03,
  0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8,
  0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0xFC, 0x1F, 0x80, 0x1F, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFC,
  0x1F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x0F,
  0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E,
  0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0x40,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x10,
  0x00, 0x07, 0xE0, 0x60, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x3F, 0x80,
  0x07, 0xF0, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00,
  0x3E, 0x1F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1,
  0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x3F, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC,
  0x3E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xE0,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x1F,
  0x87, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x07,
  0xE0, 0x1F, 0x00, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0x7E,
  0x07, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x7C, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x7C, 0x3E, 0x07, 0xE0, 0x78, 0x3E, 0x0F, 0xE0, 0xF8, 0x3E, 0x0F, 0xE0,
  0xF8, 0x3E, 0x0F, 0xE0, 0xF8, 0x3E, 0x1F, 0xE0, 0xF0, 0x3E, 0x1F, 0xE1,
  0xF0, 0x3C, 0x1F, 0xE1, 0xF0, 0x7C, 0x3D, 0xE1, 0xF0, 0x7C, 0x3D, 0xE1,
  0xE0, 0x7C, 0x3D, 0xE3, 0xE0, 0x7C, 0x79, 0xE3, 0xE0, 0x7C, 0x79, 0xE3,
  0xE0, 0x7C, 0x79, 0xE3, 0xC0, 0x7C, 0xF1, 0xE3, 0xC0, 0x7C, 0xF1, 0xE7,
  0xC0, 0x79, 0xE1, 0xE7, 0xC0, 0x79, 0xE1, 0xE7, 0xC0, 0x79, 0xE1, 0xE7,
  0x80, 0xFB, 0xC1, 0xEF, 0x80, 0xFB, 0xC1, 0xEF, 0x80, 0xFB, 0xC1, 0xEF,
  0x80, 0xFF, 0x81, 0xEF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xF8, 0x1F, 0xC0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x3F,
  0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x3F, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xC0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7D, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xE3, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0x7C,
  0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x7E, 0x00,
  0x03, 0xF7, 0x80, 0x00, 0x3C, 0x20, 0x00, 0x04, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x08, 0x78, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1F, 0x0F, 0x0C,
  0x00, 0x7F, 0x07, 0xE0, 0x3F, 0xF8, 0xF8, 0x0F, 0xFF, 0x1F, 0x03, 0xFF,
  0xF3, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x87, 0xF0, 0x07, 0xF1,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF1, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x1F,
  0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07,
  0xE3, 0xF0, 0x01, 0xFC, 0x3E, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC,
  0x03, 0x7C, 0x1F, 0xC1, 0xFF, 0xF3, 0xFF, 0xFB, 0xFE, 0x3F, 0xFE, 0x3F,
  0xC3, 0xFF, 0x87, 0xF8, 0x7F, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0xFE, 0x00, 0xFC, 0x3F, 0xF0, 0x1F, 0x9F, 0xFF, 0x03, 0xF3,
  0xFF, 0xE0, 0x7E, 0xFF, 0xFE, 0x0F, 0xBC, 0x1F, 0xC1, 0xF6, 0x01, 0xF8,
  0x7F, 0x80, 0x1F, 0x8F, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xC7, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0xFC, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xFC, 0x7F,
  0x00, 0x7F, 0x0F, 0xF8, 0x1F, 0xE1, 0xF7, 0xFF, 0xF8, 0x7E, 0xFF, 0xFE,
  0x0F, 0xCF, 0xFF, 0x81, 0xF8, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x00, 0x7C, 0x3F, 0x00, 0x3D,
  0x3F, 0x00, 0x08, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x04, 0x1F, 0x00, 0x07, 0x8F, 0x80,
  0x07, 0xE7, 0xE0, 0x07, 0xE3, 0xF8, 0x07, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x0F,
  0xFC, 0x7E, 0x01, 0xFF, 0xF3, 0xF0, 0x1F, 0xFF, 0xDF, 0x81, 0xFF, 0xFE,
  0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0xFC, 0x1F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xF0,
  0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xE0, 0x7E,
  0x01, 0xFF, 0x03, 0xFC, 0x3D, 0xF0, 0x1F, 0xFF, 0xEF, 0x80, 0x7F, 0xFE,
  0x7C, 0x01, 0xFF, 0xE7, 0xE0, 0x07, 0xFE, 0x3F, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0x81, 0xFC, 0x7F, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0xDF, 0x80, 0x1F, 0xCF,
  0xC0, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01,
  0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x03,
  0x0F, 0x80, 0x03, 0xC7, 0xE0, 0x03, 0xF3, 0xF8, 0x03, 0xF1, 0xFE, 0x07,
  0xF8, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x00, 0x7C, 0x00, 0x00, 0x70,
  0x1F, 0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x00, 0xFE, 0x7E, 0x00,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x0F, 0xFE, 0x3F, 0x01,
  0xFF, 0xF3, 0xF0, 0x3F, 0xFF, 0xBF, 0x07, 0xFF, 0xFB, 0xE0, 0x7F, 0x81,
  0xBE, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1,
  0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x3F, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC,
  0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x83, 0xF0,
  0x07, 0xF8, 0x3F, 0x00, 0xFF, 0x83, 0xFC, 0x3D, 0xF8, 0x1F, 0xFF, 0xDF,
  0x01, 0xFF, 0xF9, 0xF0, 0x0F, 0xFF, 0x3F, 0x00, 0x7F, 0xE3, 0xF0, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x10, 0x00, 0xFE, 0x03, 0x80, 0x1F, 0xC0, 0x7E, 0x03, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xC3, 0xFE, 0x03,
  0xF1, 0xFF, 0xC0, 0xFC, 0xFF, 0xF8, 0x3F, 0x7F, 0xFE, 0x0F, 0xDC, 0x3F,
  0x83, 0xFC, 0x07, 0xF0, 0xFA, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7C,
  0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x0C, 0x01, 0xF0, 0x1E,
  0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0xFE, 0x03, 0xE1, 0xFC,
  0x03, 0xE3, 0xF8, 0x03, 0xE7, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x80, 0x3F, 0x00, 0xE0, 0x1F, 0x01, 0xF8,
  0x0F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F, 0xE3, 0xF0, 0x03,
  0xF9, 0xF8, 0x01, 0xFC, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xC3, 0xFF, 0x00, 0xFC, 0x7F, 0xF8, 0x0F,
  0xCF, 0xFF, 0x80, 0xFD, 0xFF, 0xFC, 0x0F, 0xFC, 0x1F, 0xC0, 0xFB, 0x00,
  0xFC, 0x0F, 0xE0, 0x0F, 0xC1, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0x81,
  0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x3F, 0xC0, 0x03, 0xF3, 0xF0, 0x00,
  0x3F, 0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x0C, 0x3E, 0x1F, 0x81, 0xE7, 0xE0,
  0xFC, 0x3F, 0x7E, 0x0F, 0xC7, 0xF7, 0xE0, 0x7C, 0xFE, 0x7E, 0x07, 0xFF,
  0xC7, 0xC0, 0x7F, 0xF8, 0x7C, 0x03, 0xFE, 0x0F, 0xC0, 0x1F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x03, 0x01, 0xF0, 0x1E, 0x0F, 0xC0, 0xFC, 0x3F,
  0x07, 0xF0, 0xF8, 0x3F, 0x83, 0xE1, 0xFC, 0x0F, 0x8F, 0xE0, 0x7E, 0xFF,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x8F, 0x81, 0xF0, 0x3E, 0x7F, 0x0F, 0xE0, 0xFB,
  0xFC, 0x7F, 0xC3, 0xEF, 0xFB, 0xFF, 0x0F, 0xFF, 0xEF, 0xFC, 0x3F, 0x8F,
  0xF1, 0xF1, 0xFC, 0x3F, 0x07, 0xC7, 0xE0, 0xFC, 0x1F, 0x1F, 0x03, 0xE0,
  0x7C, 0x7C, 0x0F, 0x81, 0xF1, 0xF0, 0x3E, 0x07, 0x87, 0xC0, 0xF0, 0x1E,
  0x3E, 0x03, 0xC0, 0xF8, 0xF8, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x0F, 0x8F,
  0x81, 0xF0, 0x3E, 0x3E, 0x07, 0xC0, 0xF0, 0xF8, 0x1E, 0x03, 0xC7, 0xC0,
  0xF8, 0x1F, 0x1F, 0x03, 0xE0, 0x7C, 0x7C, 0x0F, 0x81, 0xF1, 0xF0, 0x3E,
  0x07, 0xC7, 0xC0, 0xF8, 0x1E, 0x1E, 0x03, 0xC0, 0x78, 0x78, 0x1F, 0x03,
  0xE3, 0xE0, 0x7C, 0x0F, 0x8F, 0x81, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8,
  0x01, 0xF0, 0xFF, 0x80, 0xFC, 0x7F, 0xF0, 0x3F, 0x3F, 0xFE, 0x0F, 0xDF,
  0xFF, 0x83, 0xF7, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x3E, 0x80, 0x3F, 0x1F,
  0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xE1,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xE3, 0xF0, 0x07, 0xF1, 0xFC, 0x0F,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x87, 0xFE,
  0x00, 0xFC, 0xFF, 0xF8, 0x07, 0xE7, 0xFF, 0xC0, 0x3E, 0x7F, 0xFF, 0x01,
  0xF7, 0x83, 0xF8, 0x1F, 0xB0, 0x0F, 0xC0, 0xFF, 0x00, 0x3F, 0x07, 0xF0,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x87, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xEF, 0xFF, 0xF0, 0x3F, 0x7F, 0xFF, 0x01,
  0xF9, 0xFF, 0xF0, 0x0F, 0xC7, 0xFF, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x1F, 0xF8, 0xFC, 0x0F, 0xFF, 0x9F, 0x83, 0xFF, 0xFB, 0xF0, 0xFF, 0xFF,
  0x7C, 0x1F, 0xE0, 0x7F, 0x87, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xE0,
  0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0xFC,
  0x3E, 0x00, 0x3F, 0x87, 0xE0, 0x0F, 0xF0, 0xFC, 0x03, 0xFE, 0x1F, 0xE1,
  0xEF, 0x83, 0xFF, 0xF9, 0xF0, 0x3F, 0xFF, 0x7E, 0x03, 0xFF, 0xCF, 0xC0,
  0x3F, 0xF1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x7F, 0xFC, 0x1F, 0xDF, 0xFE, 0x1F, 0xF7, 0xFF, 0x8F, 0xF9, 0xFF,
  0xE7, 0xFE, 0xFF, 0xFB, 0xFF, 0x80, 0x7E, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xD0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFC, 0x07,
  0xC0, 0xFC, 0x00, 0x60, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x10, 0x00,
  0x3F, 0x0F, 0x00, 0x0F, 0xC7, 0xF0, 0x0F, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x0C, 0x07, 0xE0, 0x3C, 0x07, 0xC0, 0x7E,
  0x07, 0xC0, 0xFF, 0x07, 0xC3, 0xFC, 0x0F, 0xC7, 0xF8, 0x0F, 0xDF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xE7, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xF9, 0xF8, 0x00,
  0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0,
  0x01, 0xF9, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x3E,
  0x00, 0x7F, 0x1F, 0x00, 0x3F, 0x8F, 0x80, 0x2F, 0xC7, 0xE0, 0x37, 0xC3,
  0xF8, 0x7B, 0xE1, 0xFF, 0xFB, 0xF0, 0x7F, 0xF9, 0xF8, 0x3F, 0xF8, 0xFC,
  0x0F, 0xFC, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0x7F, 0xF0,
  0x0F, 0xBF, 0xF8, 0x0F, 0xDF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xF8, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87,
  0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF8,
  0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F,
  0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x83, 0xE0, 0x3F, 0x81, 0xF0, 0x3F,
  0x80, 0xF8, 0x3F, 0xC0, 0xFC, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x07, 0xC0, 0x41, 0xE0, 0x7C, 0x3E, 0x1E, 0x07, 0xC3, 0xE3, 0xE0, 0x7C,
  0x1E, 0x3E, 0x07, 0x81, 0xE3, 0xE0, 0x78, 0x1F, 0x3E, 0x07, 0x81, 0xF3,
  0xC0, 0xF8, 0x1F, 0x3C, 0x0F, 0x81, 0xF7, 0xC0, 0xF8, 0x1F, 0x7C, 0x0F,
  0x81, 0xF7, 0xC0, 0xF0, 0x1F, 0x7C, 0x0F, 0x01, 0xE7, 0x81, 0xF0, 0x1E,
  0x78, 0x1F, 0x03, 0xEF, 0x81, 0xF0, 0x3E, 0xF8, 0x1F, 0x03, 0xEF, 0x81,
  0xE0, 0x3C, 0xF0, 0x3E, 0x07, 0xCF, 0x03, 0xE0, 0x7C, 0xF0, 0x3E, 0x07,
  0x8F, 0x07, 0xE0, 0xF8, 0xF8, 0xFE, 0x1F, 0x0F, 0xFD, 0xF3, 0xF0, 0xFF,
  0xDF, 0xFE, 0x0F, 0xF8, 0xFF, 0xC0, 0x7F, 0x0F, 0xF8, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xFE, 0x3F,
  0xF0, 0x1F, 0xFC, 0x7F, 0xE0, 0x7F, 0xF9, 0xFF, 0xE1, 0xFC, 0xF3, 0x8F,
  0xCF, 0xF1, 0xEE, 0x0F, 0x8F, 0x83, 0xFC, 0x1F, 0x1C, 0x07, 0xF0, 0x3E,
  0x10, 0x0F, 0xE0, 0x7C, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xE0,
  0x3F, 0x00, 0x87, 0xC0, 0xDE, 0x07, 0x8F, 0x81, 0xBC, 0x1F, 0x9F, 0x07,
  0x78, 0xFE, 0x3F, 0x1E, 0xFB, 0xF8, 0x7F, 0xF9, 0xFF, 0xE0, 0x7F, 0xF3,
  0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xC1,
  0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xF8, 0x1F, 0x00,
  0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x81, 0xF8, 0x07, 0xF8,
  0x1F, 0x80, 0xDF, 0x81, 0xFC, 0x1D, 0xF0, 0x1F, 0xFF, 0x9F, 0x00, 0xFF,
  0xF3, 0xF0, 0x0F, 0xFF, 0x3F, 0x00, 0x7F, 0xE3, 0xF0, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x10,
  0x00, 0xFC, 0x03, 0x80, 0x1F, 0xC0, 0x7E, 0x07, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x3F, 0xFC, 0x3E, 0x07, 0xFF,
  0xF3, 0xE0, 0xFF, 0xFF, 0xBE, 0x0F, 0xFF, 0xFF, 0xE1, 0xF8, 0x3F, 0xFE,
  0x1F, 0x00, 0x7F, 0xC1, 0xE0, 0x03, 0xF8, 0x1E, 0x00, 0x7F, 0x01, 0xE0,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x07, 0x00, 0x3F, 0x80, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x00,
  0x78, 0x3F, 0x80, 0x07, 0x87, 0xFF, 0xC0, 0x7C, 0x7F, 0xFF, 0xC7, 0xCF,
  0xDF, 0xFF, 0xFC, 0xF8, 0x7F, 0xFF, 0x8F, 0x80, 0xFF, 0xF8, 0xF8, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0xC0, 0x7F, 0x80, 0x1F, 0x0F,
  0xFC, 0x01, 0xF1, 0xFF, 0xE0, 0x1E, 0x1F, 0xFE, 0x03, 0xE3, 0xF3, 0xF0,
  0x3E, 0x3E, 0x1F, 0x87, 0xC7, 0xC0, 0xFC, 0xFC, 0x7C, 0x0F, 0xFF, 0x8F,
  0x80, 0x7F, 0xF0, 0xF8, 0x03, 0xFF, 0x0F, 0x00, 0x3F, 0xE0, 0x30, 0x00,
  0xF8, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 13, 37, 31, 9, -36 },
  { 62, 17, 15, 31, 10, -38 },
  { 94, 32, 36, 31, 0, -36 },
  { 238, 30, 48, 31, 1, -42 },
  { 418, 36, 38, 31, -2, -37 },
  { 589, 31, 38, 31, 0, -37 },
  { 737, 7, 15, 31, 15, -38 },
  { 751, 20, 47, 31, 10, -40 },
  { 869, 20, 47, 31, 2, -40 },
  { 987, 27, 26, 31, 3, -29 },
  { 1075, 26, 25, 31, 3, -28 },
  { 1157, 14, 16, 31, 6, -8 },
  { 1185, 16, 5, 31, 8, -18 },
  { 1195, 10, 9, 31, 9, -8 },
  { 1207, 30, 47, 31, 1, -40 },
  { 1384, 27, 38, 31, 3, -37 },
  { 1513, 26, 36, 31, 2, -36 },
  { 1630, 28, 37, 31, 1, -37 },
  { 1760, 28, 38, 31, 1, -37 },
  { 1893, 28, 36, 31, 1, -36 },
  { 2019, 28, 37, 31, 2, -36 },
  { 2149, 26, 37, 31, 3, -36 },
  { 2270, 27, 36, 31, 5, -36 },
  { 2392, 28, 38, 31, 2, -37 },
  { 2525, 26, 37, 31, 4, -37 },
  { 2646, 13, 28, 31, 9, -27 },
  { 2692, 16, 35, 31, 6, -27 },
  { 2762, 26, 30, 31, 4, -31 },
  { 2860, 28, 16, 31, 2, -24 },
  { 2916, 26, 30, 31, 2, -31 },
  { 3014, 23, 38, 31, 6, -37 },
  { 3124, 28, 43, 31, 2, -37 },
  { 3275, 29, 36, 31, -1, -36 },
  { 3406, 27, 36, 31, 2, -36 },
  { 3528, 28, 38, 31, 3, -37 },
  { 3661, 28, 36, 31, 2, -36 },
  { 3787, 29, 36, 31, 2, -36 },
  { 3918, 30, 36, 31, 2, -36 },
  { 4053, 27, 38, 31, 3, -37 },
  { 4182, 29, 36, 31, 2, -36 },
  { 4313, 29, 36, 31, 2, -36 },
  { 4444, 27, 37, 31, 2, -36 },
  { 4569, 32, 36, 31, 2, -36 },
  { 4713, 24, 36, 31, 3, -36 },
  { 4821, 31, 36, 31, 1, -36 },
  { 4961, 29, 36, 31, 2, -36 },
  { 5092, 27, 38, 31, 3, -37 },
  { 5221, 29, 36, 31, 2, -36 },
  { 5352, 27, 47, 31, 3, -37 },
  { 5511, 29, 36, 31, 2, -36 },
  { 5642, 30, 38, 31, 1, -37 },
  { 5785, 30, 36, 31, 4, -36 },
  { 5920, 28, 37, 31, 3, -36 },
  { 6050, 29, 36, 31, 5, -36 },
  { 6181, 32, 36, 31, 2, -36 },
  { 6325, 35, 36, 31, -1, -36 },
  { 6483, 30, 36, 31, 4, -36 },
  { 6618, 32, 36, 31, 0, -36 },
  { 6762, 24, 47, 31, 7, -40 },
  { 6903, 14, 47, 31, 9, -40 },
  { 6986, 23, 47, 31, 1, -40 },
  { 7122, 27, 22, 31, 3, -36 },
  { 7197, 25, 5, 31, 0, 4 },
  { 7213, 8, 11, 31, 11, -41 },
  { 7224, 27, 28, 31, 2, -27 },
  { 7319, 27, 39, 31, 2, -38 },
  { 7451, 25, 28, 31, 3, -27 },
  { 7539, 29, 39, 31, 2, -38 },
  { 7681, 25, 28, 31, 3, -27 },
  { 7769, 35, 49, 31, -1, -38 },
  { 7984, 28, 38, 31, 1, -27 },
  { 8117, 26, 38, 31, 2, -38 },
  { 8241, 24, 40, 31, 4, -39 },
  { 8361, 25, 50, 31, 2, -39 },
  { 8518, 28, 39, 31, 2, -38 },
  { 8655, 22, 39, 31, 5, -38 },
  { 8763, 30, 27, 31, 0, -27 },
  { 8865, 26, 27, 31, 2, -27 },
  { 8953, 25, 28, 31, 3, -27 },
  { 9041, 29, 37, 31, 0, -27 },
  { 9176, 27, 37, 31, 2, -27 },
  { 9301, 26, 27, 31, 5, -27 },
  { 9389, 26, 28, 31, 2, -27 },
  { 9480, 24, 37, 31, 4, -36 },
  { 9591, 25, 28, 31, 4, -27 },
  { 9679, 25, 28, 31, 3, -27 },
  { 9767, 28, 28, 31, 2, -27 },
  { 9865, 31, 28, 31, 0, -27 },
  { 9974, 28, 38, 31, 1, -27 },
  { 10107, 28, 28, 31, 2, -27 },
  { 10205, 24, 47, 31, 6, -40 },
  { 10346, 12, 47, 31, 10, -40 },
  { 10417, 25, 47, 31, 2, -40 },
  { 10564, 28, 13, 31, 2, -22 },
};

const GFXfont IBMPlexMono_MediumItalic52pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic52pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic52pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _IBMPLEXMONO_MEDIUMITALIC52PT7B_H_
