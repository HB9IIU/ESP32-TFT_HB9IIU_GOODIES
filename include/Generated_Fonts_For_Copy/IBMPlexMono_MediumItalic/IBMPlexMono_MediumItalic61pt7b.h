#ifndef _IBMPLEXMONO_MEDIUMITALIC61PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFE, 0x01, 0xF8, 0x00,
  0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8,
  0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1,
  0xF8, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03,
  0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x7E, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x08, 0x0F,
  0x81, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF1, 0xE7, 0xFE, 0x07, 0xF8,
  0x3C, 0x3F, 0x80, 0xFE, 0x0F, 0x83, 0xE0, 0x3F, 0x81, 0xF0, 0x38, 0x07,
  0xF0, 0x3E, 0x02, 0x00, 0xFE, 0x07, 0x80, 0x00, 0x1F, 0xC0, 0xF0, 0x00,
  0x03, 0xF8, 0x1E, 0x00, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0xF8,
  0x00, 0x01, 0xFF, 0x1F, 0x00, 0x00, 0x1F, 0xFB, 0xC0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xBF, 0xF0, 0x00, 0x01, 0xF1,
  0xFF, 0x00, 0x00, 0x3E, 0x0F, 0xE0, 0x00, 0x07, 0xC1, 0xFC, 0x00, 0x00,
  0xF0, 0x1F, 0x80, 0x00, 0x1E, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x7E, 0x02,
  0x00, 0xF8, 0x1F, 0xC0, 0x60, 0x1F, 0x03, 0xF8, 0x3E, 0x03, 0xE0, 0x7F,
  0x0F, 0xE0, 0x78, 0x1F, 0xC3, 0xFE, 0x0F, 0x0F, 0xF8, 0x3F, 0xF1, 0xE7,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0,
  0x07, 0xFF, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x03, 0xE0, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x7C, 0x00, 0x3E,
  0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x03, 0xE0, 0x1F,
  0x07, 0xC0, 0x00, 0xF0, 0x07, 0xC3, 0xF0, 0x00, 0x3C, 0x03, 0xF1, 0xF8,
  0x00, 0x0F, 0x80, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xFE, 0x3F, 0x00, 0x00,
  0xFF, 0xFF, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x87, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xF1, 0xFF, 0xFC, 0x00, 0x00,
  0xF8, 0x7F, 0xFF, 0x00, 0x00, 0x7C, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x1F,
  0x80, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x0F,
  0x80, 0x03, 0xF0, 0xFC, 0x03, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x00,
  0x7C, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x80,
  0x3E, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xC0,
  0x00, 0x7F, 0xF0, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xFF, 0xEF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xF7, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0xCF, 0xE0, 0x03, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0x83, 0xFF, 0xE0,
  0x07, 0xF8, 0x3E, 0x7E, 0x00, 0xDF, 0xC7, 0xE7, 0xF0, 0x0C, 0xFC, 0x7C,
  0x7F, 0x83, 0xCF, 0xCF, 0x83, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFF, 0x87,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0x80, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0xFC, 0x7E, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x20, 0x03, 0xF0, 0x02,
  0x3C, 0x03, 0xE0, 0x1E, 0x7F, 0x03, 0xE0, 0xFE, 0x7F, 0xE7, 0xE7, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x87, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xF7, 0xFE, 0x7F, 0x87, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0x3F, 0x7F, 0x03, 0xE0, 0x7F, 0x7F, 0x07, 0xF0, 0x7F, 0x7F,
  0x07, 0xF0, 0x7F, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF, 0x0F, 0xF0, 0x7F, 0xFE,
  0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0xFE, 0xFE, 0x07, 0xC0, 0xFE, 0xFE,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFC, 0xFE,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xF8, 0xFE,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFB,
  0xF0, 0x00, 0x7F, 0xCF, 0xC0, 0x03, 0xFE, 0x7F, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0x80, 0x3F, 0xC0, 0x7E, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0xF0, 0x0F, 0xE0, 0x01, 0x80, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFC,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x07, 0xF0, 0x02, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x1F, 0xC0, 0x18, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x10, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x08, 0x00, 0x01, 0xFE, 0x06, 0x00, 0x00, 0xFE, 0x0F,
  0x80, 0x00, 0xFF, 0x0F, 0xC0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0xFF, 0x83,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0x7F, 0x3F, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x1F, 0x80, 0x7F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE3, 0xFF,
  0xC0, 0x03, 0xE3, 0xFF, 0xF0, 0x01, 0xF3, 0xFF, 0xFC, 0x01, 0xFB, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0x80,
  0x0F, 0xF0, 0x1F, 0x80, 0x03, 0xFC, 0x10, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x04, 0x00, 0x01, 0xFC, 0x06, 0x00, 0x00, 0xFE, 0x0F,
  0x80, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE3, 0xFF, 0x80, 0x7F, 0x3F, 0xFF,
  0x81, 0xFD, 0xFF, 0xFF, 0x0F, 0xEF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xE0, 0x3F, 0xE7, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0xFF, 0x7F,
  0x80, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xF0,
  0xFF, 0x81, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x9F, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03,
  0xF9, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7F,
  0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x7F, 0xC3, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x03,
  0xF9, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x01,
  0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0x0F, 0xFF, 0xFD, 0xFC, 0x3F, 0xFF, 0xE7,
  0xE0, 0x7F, 0xFF, 0x3F, 0x80, 0x7F, 0xF8, 0xFC, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x1F,
  0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F,
  0xF8, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xF0,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x8F, 0xF8, 0x1F, 0xF3, 0xFC, 0x00,
  0xFF, 0x7F, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x86,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x1F, 0x1F, 0x80, 0x7E, 0x1F, 0x1F, 0x80, 0xFF, 0x3F, 0x1F,
  0x03, 0xFF, 0xBF, 0x3F, 0x03, 0xFF, 0xBF, 0x3F, 0x07, 0xFF, 0xFE, 0x3F,
  0x0F, 0xF0, 0xFE, 0x3E, 0x0F, 0xC0, 0x7E, 0x7E, 0x1F, 0x80, 0x7E, 0x7E,
  0x1F, 0x80, 0x7E, 0x7E, 0x1F, 0x80, 0x7E, 0x7E, 0x1F, 0x00, 0x7C, 0x7C,
  0x3F, 0x00, 0x7C, 0x7C, 0x3F, 0x00, 0x7C, 0xFC, 0x3F, 0x00, 0x7C, 0xFC,
  0x3F, 0x00, 0xFC, 0xFC, 0x3F, 0x00, 0xFC, 0xFC, 0x3F, 0x00, 0xF8, 0xF8,
  0x3F, 0x01, 0xF8, 0xF8, 0x3F, 0x03, 0xF8, 0xF8, 0x3F, 0x03, 0xF8, 0xF8,
  0x3F, 0x8F, 0xF8, 0xF8, 0x1F, 0xFD, 0xF8, 0xF8, 0x1F, 0xFD, 0xF0, 0xF8,
  0x0F, 0xF9, 0xF0, 0xF8, 0x07, 0xF1, 0xF0, 0xF8, 0x01, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x07,
  0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xF8, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xE0,
  0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0,
  0x07, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFE, 0x1F, 0x80,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xFC, 0x3F, 0x00,
  0x07, 0xF8, 0x3F, 0x00, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFC,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x20, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0x80, 0xFE, 0x00,
  0x01, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0xFF, 0x1F, 0x80,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00,
  0x01, 0xFC, 0x3F, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7E, 0x00,
  0x3F, 0xE0, 0x7E, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x03,
  0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x0F,
  0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3E, 0x1F, 0xE0, 0x00, 0x20, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFC, 0x7F,
  0x00, 0xFF, 0xFC, 0x7F, 0x00, 0xFF, 0xFC, 0x7F, 0x00, 0xFF, 0xFC, 0x7F,
  0x00, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFC, 0xFE, 0x00, 0x00, 0xF8, 0xFE,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x3F,
  0xC0, 0x1B, 0xF0, 0x3F, 0xE0, 0x7B, 0xF0, 0x1F, 0xFF, 0xF7, 0xE0, 0x0F,
  0xFF, 0xE7, 0xE0, 0x07, 0xFF, 0xC7, 0xE0, 0x03, 0xFF, 0x87, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0x80,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03,
  0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x3C,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x81, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x01,
  0xFF, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xE0, 0x00, 0x3F,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x01, 0xF8,
  0x3F, 0xC0, 0x00, 0x07, 0xE1, 0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0x00, 0xFE, 0x7F, 0x80, 0x00, 0x03, 0xFB, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xBF, 0x80, 0x00, 0x1F, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0xE3,
  0xFC, 0x00, 0x01, 0xFF, 0x87, 0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0x7C, 0x0F, 0xFF,
  0x01, 0xFB, 0xE0, 0x7D, 0xF8, 0x0F, 0xDF, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x3E, 0x7E, 0x03, 0xF3, 0xE3, 0xF3, 0xE0, 0x1F, 0x1F, 0x1F, 0x3F, 0x01,
  0xF8, 0xF9, 0xF9, 0xF8, 0x0F, 0xC7, 0xCF, 0x8F, 0xC0, 0x7E, 0x3F, 0xF8,
  0x7E, 0x03, 0xF0, 0xFF, 0xC3, 0xF0, 0x1F, 0x87, 0xFC, 0x1F, 0x00, 0xF8,
  0x3F, 0xE1, 0xF8, 0x0F, 0xC1, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0xF0, 0x7E,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x0F,
  0x81, 0xF8, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0x7E, 0x01, 0xC0, 0x7E, 0x03,
  0xF0, 0x0C, 0x03, 0xF0, 0x1F, 0x80, 0x60, 0x1F, 0x80, 0xFC, 0x02, 0x00,
  0xFC, 0x07, 0xE0, 0x10, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xE0, 0x3F, 0xE0, 0x01, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0x01, 0xFF,
  0x80, 0x07, 0xE0, 0x3F, 0xF8, 0x00, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0x80,
  0xFF, 0xE0, 0x03, 0xF0, 0x1F, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x1F,
  0x80, 0xFD, 0xF8, 0x03, 0xF0, 0x1F, 0xBF, 0x00, 0x7E, 0x03, 0xF7, 0xE0,
  0x0F, 0xC0, 0x7E, 0x7C, 0x01, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0x01, 0xF9,
  0xF8, 0x0F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x01,
  0xF8, 0x7C, 0x07, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x07, 0xE1, 0xF8, 0x3F,
  0x00, 0xFC, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x7C,
  0x1F, 0x80, 0xFC, 0x0F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xF0,
  0x3F, 0x1F, 0x80, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x80, 0x7C, 0x7E, 0x03,
  0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x01, 0xF9, 0xF8, 0x0F, 0xC0, 0x3F, 0x3F,
  0x01, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x00, 0x7D, 0xF8, 0x0F, 0xC0, 0x0F,
  0xFF, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0x00, 0x3F, 0xFC, 0x07, 0xE0,
  0x07, 0xFF, 0x80, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x0F, 0xFC, 0x07,
  0xE0, 0x01, 0xFF, 0x80, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0x80, 0x07, 0xFE,
  0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x07, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x18,
  0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x0F, 0xF0, 0x7C, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03,
  0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xF0, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x7F, 0x00, 0x00, 0xE0, 0x1F, 0xC0,
  0x00, 0x08, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x08, 0x00,
  0x00, 0x7F, 0x01, 0x80, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03,
  0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x00, 0x7E, 0x1F, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x1F, 0x07, 0xE0,
  0x7F, 0x01, 0xF8, 0x3F, 0x03, 0xF8, 0x0F, 0xC1, 0xF8, 0x1F, 0xC0, 0x7E,
  0x0F, 0x81, 0xFE, 0x03, 0xE0, 0x7C, 0x0F, 0xF8, 0x3F, 0x07, 0xE0, 0x7F,
  0xC1, 0xF8, 0x3F, 0x07, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0xF0, 0x7C, 0x0F,
  0xC1, 0xEF, 0x83, 0xE0, 0x7E, 0x1F, 0x7C, 0x3F, 0x03, 0xF0, 0xFB, 0xE1,
  0xF8, 0x1F, 0x87, 0x9F, 0x0F, 0x80, 0xF8, 0x7C, 0xF8, 0x7C, 0x07, 0xC3,
  0xE7, 0xC7, 0xE0, 0x3E, 0x1E, 0x3E, 0x3F, 0x01, 0xF1, 0xF1, 0xF1, 0xF0,
  0x1F, 0x8F, 0x8F, 0x8F, 0x80, 0xFC, 0x78, 0x7C, 0xFC, 0x07, 0xE7, 0xC3,
  0xE7, 0xE0, 0x3F, 0x3E, 0x1F, 0x3F, 0x01, 0xF9, 0xE0, 0xF9, 0xF0, 0x0F,
  0xDF, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x3E, 0xFC, 0x03, 0xE7, 0x81, 0xF7,
  0xE0, 0x1F, 0x7C, 0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0x7D, 0xF0, 0x0F, 0xDE,
  0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x1F,
  0xEF, 0xE0, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8,
  0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0x1C, 0x00, 0x00, 0x3C, 0x08, 0x00, 0x00, 0x20,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x04,
  0x1E, 0x3F, 0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x0F, 0xC3, 0xE1,
  0xF0, 0x40, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xE1, 0xFC, 0x07, 0xFF,
  0xE3, 0xF0, 0x1F, 0xFF, 0xE7, 0xE0, 0x7F, 0xFF, 0xDF, 0xC1, 0xFF, 0x03,
  0xFF, 0x87, 0xF8, 0x01, 0xFF, 0x0F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03,
  0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFC,
  0x7F, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x1F,
  0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x3F, 0xE1, 0xFC, 0x00, 0xFF, 0xC1, 0xFC, 0x03, 0xBF, 0x03, 0xFC,
  0x1E, 0x7F, 0xE7, 0xFF, 0xFC, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0x87, 0xFF,
  0xC1, 0xFE, 0x07, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0xFF, 0xF0, 0x07, 0xF1,
  0xFF, 0xF8, 0x07, 0xF3, 0xFF, 0xFC, 0x07, 0xF7, 0xFF, 0xFC, 0x07, 0xE7,
  0x83, 0xFE, 0x07, 0xEE, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFE, 0x0F, 0xF8,
  0x00, 0x7E, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0xC0,
  0x0F, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x7F, 0x7F, 0xFF, 0xE0, 0x7E, 0x7F,
  0xFF, 0xC0, 0x7E, 0x3F, 0xFF, 0x00, 0x7E, 0x1F, 0xFE, 0x00, 0x80, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0x0F,
  0xF0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xC3, 0xF8, 0x00,
  0x20, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x18, 0xFE, 0x00, 0x03, 0xCF, 0xE0,
  0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x3F,
  0xC3, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFF, 0xC1, 0xF8,
  0x03, 0xFF, 0xF1, 0xFC, 0x03, 0xFF, 0xFC, 0xFE, 0x03, 0xFF, 0xFF, 0x7F,
  0x03, 0xFF, 0x03, 0xBF, 0x01, 0xFC, 0x00, 0xFF, 0x81, 0xFC, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0xDF, 0x80, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xC1, 0xEF, 0xE0, 0x3F,
  0xFF, 0xE7, 0xF0, 0x0F, 0xFF, 0xE3, 0xF0, 0x03, 0xFF, 0xE1, 0xF8, 0x00,
  0xFF, 0xE1, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00,
  0x7F, 0x1F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFE,
  0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0x3F, 0x00, 0x1F, 0xFB, 0xF8,
  0x0F, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x04, 0x1F, 0xC0, 0x00, 0x78, 0x7E,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x80,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x18, 0x03, 0xF8, 0x00, 0x00, 0x3C, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xC0, 0x1F, 0xFF, 0x8F, 0xE0, 0x1F,
  0xFF, 0xE7, 0xF0, 0x1F, 0xFF, 0xFB, 0xF8, 0x1F, 0xF8, 0x1D, 0xF8, 0x1F,
  0xF0, 0x07, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F,
  0xF0, 0x1F, 0xC0, 0x0D, 0xF8, 0x0F, 0xE0, 0x0E, 0xFC, 0x07, 0xFC, 0x1E,
  0xFE, 0x01, 0xFF, 0xFE, 0x7F, 0x00, 0xFF, 0xFF, 0x3F, 0x80, 0x3F, 0xFF,
  0x1F, 0x80, 0x0F, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x40, 0x00, 0xFE, 0x00, 0x70,
  0x00, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xFF, 0x00, 0xFC,
  0x7F, 0xFC, 0x0F, 0xE7, 0xFF, 0xF0, 0x7F, 0x3F, 0xFF, 0xC3, 0xFB, 0xC1,
  0xFE, 0x1F, 0xF8, 0x07, 0xF0, 0xFD, 0x80, 0x3F, 0x87, 0xF8, 0x00, 0xFC,
  0x7F, 0x80, 0x07, 0xE3, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF8, 0xFE,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7E,
  0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF1, 0xF8, 0x00,
  0x1F, 0x8F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F,
  0x3F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x08, 0x00, 0xFC, 0x01, 0xC0, 0x1F, 0xC0, 0x3E, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x83,
  0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xFB, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x02, 0x00,
  0x3F, 0x00, 0x1C, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0xFE, 0x3F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xFB, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x07, 0xE0, 0xFF, 0xE0, 0x07, 0xE1, 0xFF, 0xF0, 0x0F,
  0xE7, 0xFF, 0xF0, 0x0F, 0xE7, 0xFF, 0xF8, 0x0F, 0xEF, 0x07, 0xF8, 0x0F,
  0xFC, 0x03, 0xF8, 0x0F, 0xD8, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x1F,
  0xE0, 0x01, 0xF8, 0x1F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F,
  0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x83, 0xFE, 0x00, 0x3F,
  0x9F, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x0C, 0x7F, 0x07, 0xE0, 0x1E, 0x7F,
  0x07, 0xF0, 0x3F, 0x7E, 0x03, 0xF0, 0x7E, 0x7E, 0x03, 0xF8, 0xFC, 0xFE,
  0x03, 0xF9, 0xF8, 0xFE, 0x01, 0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0xE0, 0xFE,
  0x00, 0xFF, 0xC0, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x08, 0x07, 0xF0, 0x07, 0x01, 0xFC,
  0x03, 0xE0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0xFF, 0x03,
  0xF8, 0x7F, 0x80, 0xFE, 0x3F, 0xC0, 0x3F, 0x1F, 0xE0, 0x0F, 0xCF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0xFF,
  0x07, 0xF8, 0x1F, 0xBF, 0xE1, 0xFF, 0x83, 0xE7, 0xFE, 0x7F, 0xF0, 0x7D,
  0xFF, 0xDF, 0xFE, 0x0F, 0xB1, 0xFB, 0x0F, 0xC3, 0xF8, 0x1F, 0xC1, 0xF8,
  0x7F, 0x03, 0xF8, 0x1F, 0x0F, 0xC0, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0xC0,
  0xFC, 0x3E, 0x03, 0xF0, 0x1F, 0x87, 0xC0, 0x7E, 0x03, 0xF1, 0xF8, 0x0F,
  0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x01, 0xF0, 0xF8,
  0x07, 0xC0, 0x7E, 0x1F, 0x01, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x01, 0xF8,
  0xFC, 0x07, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x00,
  0xF8, 0x7C, 0x03, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x07, 0xE1, 0xF0, 0x1F,
  0x80, 0xFC, 0x7E, 0x03, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x03, 0xE1, 0xF8,
  0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x1F, 0x87, 0xC0, 0x7E, 0x03, 0xF0,
  0xF8, 0x0F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x87, 0xFE, 0x01, 0xF8, 0xFF, 0xF8,
  0x0F, 0xCF, 0xFF, 0xE0, 0xFE, 0x7F, 0xFF, 0x87, 0xF7, 0x83, 0xFC, 0x3F,
  0xF0, 0x0F, 0xE1, 0xFB, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xF8, 0x7F, 0x00,
  0x0F, 0xC7, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x1F,
  0x8F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7F, 0x3F,
  0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x7E, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F,
  0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFD, 0xFC, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0x9F,
  0x80, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x83, 0xF8,
  0x01, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x0F, 0xFF, 0x00, 0x1F, 0xC7,
  0xFF, 0xE0, 0x07, 0xF3, 0xFF, 0xFC, 0x01, 0xFD, 0xFF, 0xFF, 0x00, 0x7E,
  0x78, 0x3F, 0xE0, 0x1F, 0xB8, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0xFE, 0x03,
  0xFE, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0x80,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xF0, 0x3F, 0xE0,
  0x1F, 0xDF, 0xFF, 0xF8, 0x07, 0xE7, 0xFF, 0xFC, 0x01, 0xF8, 0xFF, 0xFC,
  0x00, 0x7E, 0x1F, 0xFE, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0xFC, 0x07, 0xFF, 0xE3, 0xF8, 0x1F, 0xFF, 0xE7, 0xF0,
  0x7F, 0xFF, 0xEF, 0xE1, 0xFF, 0x81, 0xDF, 0x83, 0xF8, 0x01, 0xFF, 0x0F,
  0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x7F, 0x1F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x03,
  0xFC, 0x7F, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x6F,
  0xC1, 0xFC, 0x01, 0xFF, 0x83, 0xFE, 0x0F, 0x7F, 0x07, 0xFF, 0xFC, 0xFE,
  0x07, 0xFF, 0xF1, 0xF8, 0x07, 0xFF, 0xC3, 0xF0, 0x07, 0xFF, 0x0F, 0xE0,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0xFF, 0x01, 0xFD, 0xFF, 0xFC, 0x3F, 0xF7, 0xFF, 0xE1, 0xFF, 0xDF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFE, 0x7F, 0xF8, 0x03, 0xF9, 0xFF, 0xE0, 0x0F, 0xEF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFD, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0x03, 0xF8,
  0x00, 0x18, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x18, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0xFE, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x02, 0x00, 0x3F, 0x00, 0x18, 0x03, 0xF8, 0x03, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x7F, 0x80, 0x3F,
  0x07, 0xF8, 0x01, 0xF8, 0xFF, 0x80, 0x0F, 0xCF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80,
  0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x01,
  0xFC, 0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7E,
  0x1F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00,
  0x7F, 0xC3, 0xFC, 0x03, 0x7F, 0x07, 0xF8, 0x3D, 0xF8, 0x1F, 0xFF, 0xE7,
  0xE0, 0x3F, 0xFF, 0x1F, 0x80, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xC3, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x31, 0xFF, 0xF0, 0x07, 0xE7,
  0xFF, 0x80, 0x3F, 0x9F, 0xFE, 0x00, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xE0,
  0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F,
  0x80, 0x3F, 0x80, 0xFC, 0x01, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7F, 0x03, 0xFE, 0x01, 0xFC, 0x1F, 0xF0, 0x07, 0xF3, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x07, 0xC0, 0x7E, 0x1F, 0x83, 0xE0, 0x3E, 0x0F, 0xC3, 0xF0, 0x1F, 0x03,
  0xE1, 0xF8, 0x0F, 0x81, 0xF0, 0xFC, 0x07, 0xC0, 0xFC, 0x7C, 0x07, 0xE0,
  0x7E, 0x3E, 0x03, 0xF0, 0x3F, 0x1F, 0x01, 0xF0, 0x1F, 0x9F, 0x80, 0xF8,
  0x0F, 0xCF, 0xC0, 0x7C, 0x07, 0xE7, 0xE0, 0x3E, 0x03, 0xF3, 0xE0, 0x3F,
  0x01, 0xF9, 0xF0, 0x1F, 0x80, 0xFC, 0xF8, 0x0F, 0xC0, 0x7E, 0xFC, 0x07,
  0xC0, 0x3E, 0x7E, 0x03, 0xE0, 0x1F, 0x3E, 0x01, 0xF0, 0x0F, 0x9F, 0x01,
  0xF8, 0x07, 0xCF, 0x80, 0xFC, 0x07, 0xE7, 0xC0, 0x7E, 0x03, 0xE7, 0xE0,
  0x3E, 0x01, 0xF3, 0xF0, 0x1F, 0x01, 0xF9, 0xF8, 0x1F, 0x80, 0xF8, 0xF8,
  0x0F, 0xC0, 0x7C, 0x7C, 0x0F, 0xE0, 0x7C, 0x3F, 0x06, 0xF0, 0x3E, 0x1F,
  0x87, 0x78, 0x3E, 0x0F, 0xFF, 0x3E, 0x3F, 0x07, 0xFF, 0x9F, 0xFF, 0x01,
  0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F,
  0xE0, 0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xF0,
  0xFF, 0x9F, 0x1C, 0x3F, 0x1F, 0xF1, 0xF3, 0x83, 0xF3, 0xFC, 0x1F, 0x38,
  0x1F, 0x1F, 0x81, 0xFF, 0x01, 0xF0, 0xE0, 0x1F, 0xF0, 0x1F, 0x08, 0x01,
  0xFE, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xF8, 0x01, 0x0F, 0xC0, 0x7F, 0x80,
  0x78, 0xFC, 0x06, 0xF8, 0x0F, 0x8F, 0xC0, 0xEF, 0xC3, 0xFC, 0xFC, 0x1E,
  0xFC, 0x7F, 0x8F, 0xE3, 0xC7, 0xDF, 0xF0, 0x7F, 0xFC, 0x7F, 0xFE, 0x07,
  0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xF8,
  0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xE0, 0x1F,
  0xF8, 0x07, 0xF8, 0x3D, 0xFC, 0x03, 0xFF, 0xFC, 0xFC, 0x00, 0xFF, 0xFC,
  0x7E, 0x00, 0x3F, 0xFE, 0x3F, 0x00, 0x0F, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x01, 0x80,
  0x01, 0xFC, 0x01, 0xE0, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x0F, 0xC0, 0xFF, 0xFE, 0x0F, 0xC0, 0x7F, 0xFF, 0xC7,
  0xE0, 0x7F, 0xFF, 0xF3, 0xF0, 0x3F, 0x07, 0xFF, 0xF8, 0x3F, 0x00, 0x7F,
  0xF8, 0x1F, 0x00, 0x0F, 0xF8, 0x0F, 0x80, 0x03, 0xF8, 0x07, 0xC0, 0x07,
  0xF8, 0x03, 0xE0, 0x07, 0xF8, 0x01, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x04, 0x00, 0x0F, 0xF0, 0x0E, 0x00, 0x0F, 0xF0, 0x0F, 0x80, 0x0F,
  0xF0, 0x07, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0xF8, 0x0F,
  0xE0, 0x00, 0x7C, 0x1F, 0xFE, 0x00, 0x3E, 0x1F, 0xFF, 0xF0, 0x1F, 0x0F,
  0xFF, 0xFF, 0xCF, 0x87, 0xE3, 0xFF, 0xFF, 0xC3, 0xF0, 0x7F, 0xFF, 0xE3,
  0xF0, 0x07, 0xFF, 0xE1, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x02, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x40, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0C, 0x00, 0xFF, 0x80, 0x07, 0xC1,
  0xFF, 0xE0, 0x03, 0xE1, 0xFF, 0xF0, 0x03, 0xE0, 0xFF, 0xFC, 0x01, 0xF0,
  0xFC, 0x7F, 0x01, 0xF8, 0xFC, 0x1F, 0x80, 0xF8, 0x7E, 0x07, 0xE0, 0xFC,
  0x3E, 0x01, 0xF8, 0xFC, 0x3F, 0x00, 0xFF, 0xFE, 0x1F, 0x00, 0x3F, 0xFE,
  0x1F, 0x80, 0x0F, 0xFE, 0x0F, 0x80, 0x03, 0xFE, 0x00, 0xC0, 0x00, 0xFC,
  0x00,
};

const GFXglyph IBMPlexMono_MediumItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 15, 44, 37, 11, -43 },
  { 84, 21, 18, 37, 11, -45 },
  { 132, 38, 43, 37, 0, -43 },
  { 337, 35, 56, 37, 1, -49 },
  { 582, 42, 44, 37, -2, -43 },
  { 813, 36, 44, 37, 0, -43 },
  { 1011, 9, 18, 37, 17, -45 },
  { 1032, 24, 54, 37, 12, -46 },
  { 1194, 24, 54, 37, 2, -46 },
  { 1356, 32, 30, 37, 3, -33 },
  { 1476, 30, 29, 37, 4, -33 },
  { 1585, 16, 18, 37, 7, -9 },
  { 1621, 19, 6, 37, 9, -22 },
  { 1636, 11, 10, 37, 11, -9 },
  { 1650, 35, 54, 37, 1, -46 },
  { 1887, 32, 44, 37, 3, -43 },
  { 2063, 30, 43, 37, 3, -43 },
  { 2225, 33, 43, 37, 1, -43 },
  { 2403, 33, 44, 37, 1, -43 },
  { 2585, 33, 43, 37, 1, -43 },
  { 2763, 33, 44, 37, 2, -43 },
  { 2945, 30, 44, 37, 3, -43 },
  { 3110, 31, 43, 37, 6, -43 },
  { 3277, 33, 44, 37, 2, -43 },
  { 3459, 30, 43, 37, 5, -43 },
  { 3621, 14, 33, 37, 11, -32 },
  { 3679, 18, 41, 37, 7, -32 },
  { 3772, 30, 36, 37, 5, -37 },
  { 3907, 32, 18, 37, 3, -28 },
  { 3979, 30, 36, 37, 3, -37 },
  { 4114, 27, 44, 37, 7, -43 },
  { 4263, 32, 50, 37, 3, -43 },
  { 4463, 34, 43, 37, -1, -43 },
  { 4646, 32, 43, 37, 2, -43 },
  { 4818, 32, 44, 37, 4, -43 },
  { 4994, 32, 43, 37, 3, -43 },
  { 5166, 33, 43, 37, 3, -43 },
  { 5344, 34, 43, 37, 3, -43 },
  { 5527, 32, 44, 37, 3, -43 },
  { 5703, 35, 43, 37, 2, -43 },
  { 5892, 34, 43, 37, 2, -43 },
  { 6075, 32, 44, 37, 3, -43 },
  { 6251, 38, 43, 37, 2, -43 },
  { 6456, 27, 43, 37, 4, -43 },
  { 6602, 37, 43, 37, 1, -43 },
  { 6801, 35, 43, 37, 2, -43 },
  { 6990, 32, 44, 37, 3, -43 },
  { 7166, 33, 43, 37, 3, -43 },
  { 7344, 32, 55, 37, 3, -43 },
  { 7564, 33, 43, 37, 3, -43 },
  { 7742, 35, 44, 37, 1, -43 },
  { 7935, 35, 43, 37, 5, -43 },
  { 8124, 33, 44, 37, 4, -43 },
  { 8306, 33, 43, 37, 6, -43 },
  { 8484, 37, 43, 37, 2, -43 },
  { 8683, 40, 43, 37, -1, -43 },
  { 8898, 35, 43, 37, 5, -43 },
  { 9087, 37, 43, 37, 0, -43 },
  { 9286, 27, 54, 37, 9, -46 },
  { 9469, 16, 54, 37, 11, -46 },
  { 9577, 27, 54, 37, 1, -46 },
  { 9760, 32, 26, 37, 3, -43 },
  { 9864, 30, 6, 37, 0, 5 },
  { 9887, 9, 13, 37, 13, -48 },
  { 9902, 31, 33, 37, 3, -32 },
  { 10030, 32, 46, 37, 2, -45 },
  { 10214, 28, 33, 37, 4, -32 },
  { 10330, 33, 46, 37, 3, -45 },
  { 10520, 29, 33, 37, 4, -32 },
  { 10640, 40, 58, 37, -1, -45 },
  { 10930, 33, 45, 37, 1, -32 },
  { 11116, 29, 45, 37, 3, -45 },
  { 11280, 28, 46, 37, 5, -45 },
  { 11441, 30, 58, 37, 2, -45 },
  { 11659, 32, 46, 37, 3, -45 },
  { 11843, 26, 46, 37, 6, -45 },
  { 11993, 35, 32, 37, 0, -32 },
  { 12133, 29, 32, 37, 3, -32 },
  { 12249, 30, 33, 37, 3, -32 },
  { 12373, 34, 44, 37, 0, -32 },
  { 12560, 31, 44, 37, 3, -32 },
  { 12731, 30, 31, 37, 6, -31 },
  { 12848, 30, 33, 37, 3, -32 },
  { 12972, 29, 44, 37, 4, -43 },
  { 13132, 30, 32, 37, 4, -31 },
  { 13252, 30, 33, 37, 3, -32 },
  { 13376, 33, 33, 37, 2, -32 },
  { 13513, 36, 33, 37, 0, -32 },
  { 13662, 33, 44, 37, 1, -31 },
  { 13844, 33, 33, 37, 2, -32 },
  { 13981, 30, 54, 37, 6, -46 },
  { 14184, 14, 54, 37, 12, -46 },
  { 14279, 29, 54, 37, 2, -46 },
  { 14475, 33, 14, 37, 2, -26 },
};

const GFXfont IBMPlexMono_MediumItalic61pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic61pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic61pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _IBMPLEXMONO_MEDIUMITALIC61PT7B_H_
