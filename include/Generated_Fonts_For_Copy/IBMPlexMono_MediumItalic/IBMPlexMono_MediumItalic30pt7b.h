#ifndef _IBMPLEXMONO_MEDIUMITALIC30PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x18,
  0x18, 0x18, 0x00, 0x00, 0x00, 0x38, 0x7C, 0x7C, 0xF8, 0x78, 0x71, 0xDC,
  0x77, 0x3B, 0x8E, 0xE3, 0xB8, 0xEE, 0x3B, 0x8E, 0xE7, 0x00, 0x00, 0x73,
  0x80, 0x1C, 0x70, 0x03, 0x8C, 0x00, 0x63, 0x80, 0x1C, 0x70, 0x03, 0x8C,
  0x07, 0xE3, 0xF9, 0xFC, 0x7F, 0x3F, 0x8F, 0xC0, 0x63, 0x80, 0x1C, 0x70,
  0x03, 0x8C, 0x07, 0xE3, 0xF9, 0xFC, 0x7E, 0x3F, 0x8F, 0xC0, 0x63, 0x80,
  0x1C, 0x70, 0x03, 0x8C, 0x00, 0x63, 0x80, 0x1C, 0x70, 0x03, 0x9C, 0x00,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0xFF,
  0xF8, 0x79, 0xBE, 0x79, 0xC4, 0x38, 0xE0, 0x1C, 0x60, 0x0F, 0x30, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x03, 0x7C, 0x01, 0x8E,
  0x00, 0xC7, 0x10, 0x63, 0x9C, 0x73, 0xCF, 0x33, 0xE3, 0xFF, 0xE0, 0xFF,
  0xE0, 0x1F, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x38, 0x3F, 0x03, 0x83, 0xFC, 0x18, 0x38, 0xE1, 0x81, 0xC3, 0x1C, 0x0C,
  0x39, 0xC0, 0x61, 0xCC, 0x03, 0x1E, 0xE0, 0x1F, 0xEE, 0x00, 0xFE, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x3F, 0x00, 0x3B, 0xFC, 0x03, 0xBC, 0x60, 0x19,
  0xC3, 0x01, 0xCE, 0x18, 0x1C, 0x61, 0xC1, 0xC3, 0x8E, 0x0C, 0x1F, 0xE0,
  0xE0, 0x7E, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x7F,
  0xE0, 0x1E, 0x38, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x38,
  0x03, 0x9E, 0x03, 0xEF, 0x03, 0xFF, 0x81, 0xE7, 0x00, 0x71, 0xC0, 0x3C,
  0x38, 0x0E, 0x0E, 0x03, 0x81, 0xC6, 0xF0, 0xF1, 0xFC, 0x6E, 0xE7, 0xFB,
  0xF1, 0xFC, 0x7C, 0x1E, 0x1E, 0x00, 0x39, 0xCC, 0xE7, 0x39, 0xCE, 0xE0,
  0x00, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x61, 0xC3, 0x7D, 0xDF, 0x7F, 0xFF,
  0x9F, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x1E, 0x70, 0x3C, 0x70,
  0x78, 0x38, 0x10, 0x20, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1E, 0x7C, 0xF1,
  0xC7, 0x8E, 0x1C, 0x70, 0xE0, 0x7F, 0xDF, 0xFF, 0xFC, 0x39, 0xFF, 0xFE,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF0, 0xF3, 0x80, 0xEF,
  0x01, 0xDC, 0x03, 0xF8, 0x07, 0xF3, 0x8F, 0xC7, 0x1F, 0x9E, 0x3F, 0x1C,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0x70, 0x1E, 0xE0, 0x39, 0xE1, 0xF1,
  0xFF, 0xC3, 0xFF, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xE0,
  0x7B, 0x81, 0xE7, 0x07, 0x8E, 0x0E, 0x1C, 0x08, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x81, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0,
  0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x1F, 0x3C, 0x0F, 0x18, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xFC, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x1E, 0x1F,
  0x1C, 0x0F, 0x08, 0x0F, 0x00, 0x0E, 0x00, 0x3E, 0x03, 0xF8, 0x07, 0xE0,
  0x07, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x40, 0x1C,
  0xE0, 0x3C, 0xF0, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0x70, 0x07,
  0x38, 0x07, 0x1C, 0x07, 0x0E, 0x07, 0x07, 0x03, 0x87, 0x03, 0x83, 0x83,
  0x81, 0xC3, 0x80, 0xE1, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x19, 0xF0, 0x3B,
  0xFC, 0x3F, 0xFC, 0x3C, 0x3E, 0x18, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x20, 0x1E, 0x70, 0x1C, 0xF8, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F,
  0xC0, 0x00, 0xFC, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0xC0, 0x0E, 0x7C, 0x77, 0xF9, 0xFF, 0xFF, 0x83, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0xC1, 0xE7, 0xFF, 0x1F, 0xF8,
  0x1F, 0x80, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xEE, 0x03, 0xDC,
  0x07, 0x38, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFF,
  0x1E, 0x0F, 0x1C, 0x07, 0x3C, 0x07, 0x3C, 0x07, 0x1C, 0x0F, 0x1E, 0x1E,
  0x0F, 0xFC, 0x07, 0xF0, 0x1F, 0xFC, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0E,
  0xE0, 0x0E, 0xF0, 0x1E, 0xF8, 0x3E, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xC0,
  0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xE0, 0xF7, 0x80, 0xEE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3D, 0xE0, 0xFB, 0xFF, 0xE3, 0xFD,
  0xC3, 0xE7, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x1E, 0x1E, 0x3F, 0x3E, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x7C, 0xFC, 0xF8, 0x78, 0x0F, 0x07, 0x87, 0xE3,
  0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC3, 0xE1, 0xE0,
  0xE0, 0xF0, 0x70, 0x38, 0x38, 0x1C, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07,
  0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x00, 0xE0, 0x03, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x18, 0x00,
  0x20, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x10, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E,
  0x00, 0x30, 0x00, 0x80, 0x00, 0x0F, 0xC1, 0xFF, 0x1F, 0xFD, 0xE1, 0xFE,
  0x07, 0xB0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x3F, 0x07, 0xE0, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x0F,
  0x1C, 0x07, 0x38, 0x03, 0x38, 0x73, 0x31, 0xFF, 0x71, 0xFF, 0x73, 0xC7,
  0x73, 0x87, 0x73, 0x06, 0x67, 0x06, 0x67, 0x0E, 0xE7, 0x1E, 0xE3, 0xFE,
  0xE3, 0xEC, 0xE3, 0xCC, 0x60, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3F, 0xF0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0E, 0xE0, 0x0F, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0x8F, 0x01,
  0xC7, 0x81, 0xE1, 0xC0, 0xE0, 0xE0, 0xF0, 0x70, 0x7F, 0xF8, 0x7F, 0xFC,
  0x3F, 0xFE, 0x3C, 0x07, 0x9E, 0x03, 0xCE, 0x01, 0xEF, 0x00, 0x7F, 0x00,
  0x38, 0x0F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFE, 0x1C, 0x0F, 0x1C, 0x07, 0x1C,
  0x07, 0x1C, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F,
  0xFC, 0x38, 0x1E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x70,
  0x3C, 0x7F, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x01, 0xF0, 0x07, 0xFC, 0x0F,
  0xFE, 0x1E, 0x1E, 0x3C, 0x0F, 0x38, 0x0F, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x18, 0xE0, 0x1C, 0xF0, 0x3C, 0x78, 0x78, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x1C, 0x0F, 0x1C,
  0x07, 0x1C, 0x07, 0x3C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38,
  0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x70, 0x1E, 0x70, 0x3C, 0x70,
  0x7C, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xC3, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xFF, 0x80, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF0, 0xF3, 0xC0, 0xEF, 0x01,
  0xDC, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC7, 0xF7, 0x0F, 0xEE,
  0x1F, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x1E, 0xF0, 0x39, 0xE1, 0xF1, 0xFF,
  0xE3, 0xFD, 0xC1, 0xE3, 0x80, 0x1E, 0x03, 0x8E, 0x03, 0xC7, 0x01, 0xE3,
  0x80, 0xE1, 0xC0, 0x71, 0xE0, 0x38, 0xF0, 0x1C, 0x70, 0x1E, 0x38, 0x0F,
  0x1F, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0x80, 0xE3, 0xC0, 0x71, 0xC0,
  0x78, 0xE0, 0x38, 0x70, 0x1C, 0x78, 0x0E, 0x3C, 0x07, 0x1E, 0x07, 0x8E,
  0x03, 0xC0, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC0, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0x78, 0x78, 0x7F,
  0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x1E, 0x03, 0xE3, 0xC0, 0xF0, 0x70, 0x3C,
  0x0E, 0x0F, 0x01, 0xC3, 0xC0, 0x38, 0xF8, 0x0F, 0x1E, 0x01, 0xE7, 0x80,
  0x39, 0xE0, 0x07, 0x78, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xEF, 0x00,
  0xF8, 0xE0, 0x1E, 0x1E, 0x03, 0x83, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x83,
  0xC0, 0x70, 0x78, 0x0F, 0x0E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x03, 0xE1, 0xE0, 0x78, 0x7C,
  0x1F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x3B, 0x87, 0x67, 0x60, 0xEF,
  0xDC, 0x39, 0xF3, 0x87, 0x3E, 0x70, 0xE3, 0x8E, 0x1C, 0x71, 0xC3, 0x8C,
  0x70, 0x71, 0x8E, 0x1C, 0x21, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00,
  0xE1, 0xC0, 0x38, 0x38, 0x07, 0x0E, 0x00, 0xE0, 0x1F, 0x03, 0x8F, 0x81,
  0xC7, 0xC0, 0xE3, 0xE0, 0xE1, 0xF8, 0x71, 0xDC, 0x38, 0xEE, 0x1C, 0x77,
  0x0E, 0x39, 0x87, 0x1C, 0xE7, 0x0E, 0x73, 0x8E, 0x39, 0xC7, 0x1C, 0xE3,
  0x87, 0x71, 0xC3, 0xB8, 0xE1, 0xF8, 0x70, 0xFC, 0x70, 0x7E, 0x38, 0x1F,
  0x1C, 0x0F, 0x8E, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF0,
  0xF3, 0x80, 0xEF, 0x01, 0xDC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0x70, 0x1E, 0xE0,
  0x79, 0xE1, 0xF1, 0xFF, 0xC3, 0xFF, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x0F,
  0xFF, 0x07, 0xFF, 0xC3, 0xC1, 0xE1, 0xC0, 0x78, 0xE0, 0x3C, 0x70, 0x1E,
  0x38, 0x0E, 0x3C, 0x07, 0x1E, 0x07, 0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFF,
  0x81, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1,
  0xF0, 0xF3, 0x80, 0xEF, 0x01, 0xDC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0x70, 0x1E,
  0xE0, 0x79, 0xE1, 0xF1, 0xFF, 0xC3, 0xFF, 0x01, 0xF8, 0x00, 0xE1, 0x00,
  0xE3, 0x01, 0xEF, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0x80, 0x0F, 0xFC, 0x0F,
  0xFF, 0x07, 0xFF, 0xC3, 0xC1, 0xE1, 0xC0, 0x78, 0xE0, 0x3C, 0x70, 0x1E,
  0x38, 0x0E, 0x3C, 0x07, 0x1E, 0x07, 0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFF,
  0x01, 0xC7, 0x01, 0xE3, 0xC0, 0xF0, 0xE0, 0x70, 0x70, 0x38, 0x3C, 0x1C,
  0x0E, 0x0E, 0x07, 0x8F, 0x01, 0xC0, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF,
  0xC3, 0xC1, 0xF3, 0xC0, 0x21, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x80, 0x1C, 0xE0, 0x1E, 0x7C, 0x1E, 0x3F, 0xFF, 0x07, 0xFF,
  0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xF0, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x3C, 0x07, 0x38, 0x07, 0x38, 0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x78, 0x0E,
  0x70, 0x0E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1E, 0xF0, 0x1C, 0xF0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x78, 0xF0, 0xF8,
  0xFF, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E,
  0xF0, 0x1E, 0xF0, 0x1C, 0x70, 0x1C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x78,
  0x70, 0x70, 0x70, 0xF0, 0x70, 0xE0, 0x78, 0xE0, 0x39, 0xC0, 0x39, 0xC0,
  0x3B, 0x80, 0x3B, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xC0, 0x07, 0x70, 0x01, 0x9C,
  0x78, 0xE7, 0x1E, 0x39, 0xC7, 0x8E, 0x73, 0xE3, 0x1C, 0xD9, 0xC7, 0x36,
  0x71, 0xDD, 0x9C, 0x76, 0x66, 0x19, 0x9B, 0x86, 0xE6, 0xE3, 0xB1, 0xB8,
  0xEC, 0x6E, 0x3F, 0x1B, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x00,
  0x0F, 0x00, 0xF0, 0x70, 0x0E, 0x07, 0x81, 0xE0, 0x38, 0x3C, 0x03, 0xC7,
  0x80, 0x1C, 0x70, 0x01, 0xCE, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x3D, 0xC0, 0x07,
  0x9C, 0x00, 0xF1, 0xE0, 0x0E, 0x0E, 0x01, 0xE0, 0xF0, 0x3C, 0x07, 0x07,
  0x80, 0x78, 0xF0, 0x07, 0x80, 0xE0, 0x07, 0xF8, 0x07, 0xBC, 0x07, 0x8E,
  0x03, 0x87, 0x83, 0xC1, 0xC3, 0xC0, 0xE1, 0xC0, 0x79, 0xE0, 0x1D, 0xE0,
  0x0E, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF,
  0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x7F, 0xC3, 0xFE, 0x0F,
  0xF8, 0x00, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x70, 0x30, 0x30, 0x38, 0x38,
  0x38, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x06,
  0x06, 0x07, 0x07, 0x07, 0x03, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0xFF, 0x87, 0xFC, 0x3F,
  0xC0, 0x01, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x3B, 0x80, 0xF3, 0x81, 0xC7,
  0x07, 0x0E, 0x1E, 0x0E, 0x38, 0x1C, 0xE0, 0x3B, 0x80, 0x3F, 0x00, 0x74,
  0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0x67, 0x9C, 0x63, 0x88,
  0x07, 0xCF, 0x1F, 0xEE, 0x3F, 0xEE, 0x3C, 0x1E, 0x78, 0x1E, 0x70, 0x1E,
  0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0x78, 0xFC,
  0x7F, 0xBE, 0x3F, 0x3E, 0x1E, 0x1E, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x78, 0x3D, 0xFC,
  0x3F, 0xFE, 0x3F, 0x1E, 0x3C, 0x0E, 0x38, 0x0F, 0x38, 0x0F, 0x78, 0x0E,
  0x78, 0x0E, 0x70, 0x1E, 0x70, 0x1E, 0x78, 0x3C, 0x7F, 0xF8, 0xF7, 0xF0,
  0xF3, 0xE0, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0x0F, 0x78, 0x19, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x13, 0x80, 0x6F, 0x03, 0xFC, 0x3C, 0x7F,
  0xF0, 0xFF, 0x81, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x0F, 0x9E, 0x0F, 0xEF,
  0x0F, 0xFF, 0x0F, 0x07, 0x8F, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xF1, 0xC0,
  0x71, 0xE0, 0x38, 0xF0, 0x1C, 0x78, 0x1E, 0x1E, 0x37, 0x0F, 0xFF, 0x83,
  0xFB, 0x80, 0xF9, 0xC0, 0x03, 0xF0, 0x3F, 0xE3, 0xFF, 0xCF, 0x0F, 0x78,
  0x1D, 0xC0, 0x7F, 0x0F, 0xBF, 0xFC, 0xFF, 0x83, 0x80, 0x0E, 0x01, 0xBC,
  0x1F, 0x7F, 0xF0, 0xFF, 0x81, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x08, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x02,
  0x0E, 0x00, 0x71, 0xE0, 0x0F, 0x9C, 0x00, 0x3D, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xC7, 0x0F, 0xEF, 0x1F, 0xFE, 0x3C,
  0x1E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0xF0, 0x1C, 0xF0,
  0x1C, 0x70, 0x3C, 0x78, 0xDC, 0x7F, 0xFC, 0x3F, 0xB8, 0x1E, 0x38, 0x00,
  0x38, 0x40, 0x78, 0x60, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x3C, 0x1C, 0xFC, 0x7B, 0xFC, 0xFC, 0x79, 0xF0, 0x73, 0xC0, 0xE7,
  0x01, 0xCE, 0x07, 0xBC, 0x0E, 0x78, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x81,
  0xE7, 0x03, 0xDE, 0x07, 0x00, 0x01, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x86, 0x0E, 0x3C, 0x39,
  0xF0, 0xEF, 0x03, 0xF8, 0x0F, 0xC0, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x04, 0x0E, 0x0C,
  0x3C, 0x3C, 0x78, 0x3C, 0xE0, 0x3D, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x78, 0x1D, 0xFC, 0x3D, 0xFE, 0x3F, 0x1E, 0x3C,
  0x0E, 0x3C, 0x0C, 0x38, 0x1C, 0x38, 0x70, 0x7B, 0xC0, 0x7B, 0xC2, 0x71,
  0xC7, 0x71, 0xEF, 0x70, 0xFE, 0x70, 0xFC, 0xF0, 0x70, 0xFF, 0x87, 0xFC,
  0x3F, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x83, 0x86, 0x38,
  0xF9, 0xCF, 0x8E, 0xF8, 0x7F, 0x03, 0xF0, 0x0F, 0x00, 0x19, 0xC7, 0x1D,
  0xF7, 0xCF, 0xFF, 0xE7, 0x9E, 0x73, 0x8E, 0x19, 0xC7, 0x1C, 0xC3, 0x8E,
  0xE1, 0x87, 0x70, 0xC3, 0xB8, 0xE1, 0x9C, 0x71, 0xCC, 0x38, 0xEE, 0x1C,
  0x77, 0x0C, 0x3B, 0x8E, 0x18, 0x1C, 0x78, 0x39, 0xF8, 0xF7, 0xF9, 0xF8,
  0xF3, 0xE0, 0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x0F, 0x78, 0x1C, 0xF0, 0x39,
  0xC0, 0x73, 0x80, 0xE7, 0x03, 0xCE, 0x07, 0xBC, 0x0E, 0x00, 0x07, 0xE0,
  0x7F, 0xE3, 0xFF, 0x9F, 0x0F, 0x70, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xBC, 0x1E, 0x7F, 0xF1, 0xFF, 0x81, 0xF8,
  0x00, 0x0E, 0x3C, 0x07, 0x7F, 0x07, 0xFF, 0xC3, 0xB1, 0xE1, 0xE0, 0x70,
  0xE0, 0x3C, 0x70, 0x1E, 0x78, 0x0E, 0x3C, 0x07, 0x1C, 0x07, 0x8E, 0x03,
  0xC7, 0x83, 0xC3, 0xFF, 0xC3, 0xDF, 0xC1, 0xE7, 0xC0, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xCF,
  0x0F, 0xEF, 0x1F, 0xFE, 0x3C, 0x1E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x1E,
  0x70, 0x1E, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0x78, 0xFC, 0x7F, 0xFC,
  0x3F, 0xBC, 0x1E, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0xFF, 0x1F, 0xFE, 0xFF, 0xFB, 0xF0, 0x74, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0xF8, 0x7F, 0xF8, 0xE0, 0x63, 0x80, 0x07, 0xC0, 0x07, 0xFC, 0x0F, 0xFC,
  0x07, 0xFC, 0x00, 0x78, 0x00, 0x73, 0x81, 0xEF, 0xFF, 0x8F, 0xFE, 0x07,
  0xF0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x87, 0x0E, 0x1C, 0x7C, 0x77, 0xE1, 0xFE, 0x07,
  0xF0, 0x0F, 0x00, 0x38, 0x1E, 0x70, 0x39, 0xE0, 0x73, 0x80, 0xE7, 0x01,
  0xCE, 0x07, 0x9C, 0x0F, 0x78, 0x1C, 0xE0, 0x39, 0xC0, 0xF3, 0x81, 0xE7,
  0x8F, 0xCF, 0xF7, 0x8F, 0xCE, 0x0F, 0x1C, 0x00, 0xFC, 0x1B, 0xF0, 0xFF,
  0xC1, 0xC7, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0F, 0x38, 0x3C,
  0xE1, 0xE7, 0x0F, 0x1C, 0xFC, 0x7F, 0xE1, 0xFE, 0x03, 0xE0, 0x00, 0x38,
  0xE2, 0x30, 0xC7, 0x70, 0xC7, 0x71, 0xC7, 0x71, 0xC7, 0x71, 0xC7, 0x61,
  0xC7, 0x61, 0x87, 0xE3, 0x87, 0xE3, 0x86, 0xE3, 0x8E, 0xE5, 0x8E, 0xFD,
  0x9C, 0xF9, 0xF8, 0x70, 0xF0, 0x03, 0x87, 0x03, 0xF3, 0xE1, 0xFD, 0xFC,
  0xF7, 0x67, 0x78, 0xF1, 0xC8, 0x38, 0x70, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x38, 0x78, 0x4E, 0x3E, 0x7B, 0x9B, 0xBC, 0xFE, 0xFE, 0x1F, 0x3F,
  0x03, 0x87, 0x80, 0x1C, 0x0F, 0x1C, 0x0E, 0x3C, 0x0E, 0x38, 0x0E, 0x38,
  0x0E, 0x38, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x78, 0x1C, 0x70, 0x3C, 0x78,
  0x3C, 0x78, 0xFC, 0x7F, 0xBC, 0x3F, 0xB8, 0x1E, 0x38, 0x00, 0x78, 0x40,
  0x78, 0xE0, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0x00, 0x0F, 0xC7, 0x1F,
  0xF7, 0x3F, 0xFF, 0x38, 0x7F, 0x30, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x84, 0x1E, 0x0C, 0x3C, 0x0E, 0x7F, 0x8E, 0xFF, 0xFE, 0xE7,
  0xFE, 0xE0, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x0F, 0xF8, 0x1F, 0x80, 0x3F, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x87,
  0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x87,
  0x0C, 0x38, 0x70, 0xE1, 0xC3, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0xFC, 0x01, 0xF0, 0x3F, 0xC1, 0xE0, 0x07, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0x00, 0x0E, 0x03, 0x3F, 0x87, 0x3F, 0x87,
  0x73, 0xCE, 0x61, 0xFE, 0xE0, 0xFC, 0xE0, 0x78,
};

const GFXglyph IBMPlexMono_MediumItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 8, 21, 18, 5, -21 },
  { 22, 10, 9, 18, 6, -22 },
  { 34, 19, 21, 18, 0, -21 },
  { 84, 17, 27, 18, 1, -24 },
  { 142, 21, 21, 18, -1, -21 },
  { 198, 18, 21, 18, 0, -21 },
  { 246, 5, 9, 18, 8, -22 },
  { 252, 12, 27, 18, 6, -23 },
  { 293, 12, 27, 18, 1, -23 },
  { 334, 16, 15, 18, 1, -16 },
  { 364, 15, 15, 18, 2, -17 },
  { 393, 7, 9, 18, 4, -5 },
  { 401, 10, 3, 18, 4, -11 },
  { 405, 6, 5, 18, 5, -5 },
  { 409, 18, 27, 18, 0, -23 },
  { 470, 15, 21, 18, 2, -21 },
  { 510, 15, 21, 18, 1, -21 },
  { 550, 16, 21, 18, 1, -21 },
  { 592, 16, 21, 18, 1, -21 },
  { 634, 17, 21, 18, 0, -21 },
  { 679, 16, 21, 18, 1, -21 },
  { 721, 14, 21, 18, 2, -21 },
  { 758, 15, 21, 18, 3, -21 },
  { 798, 16, 21, 18, 1, -21 },
  { 840, 15, 21, 18, 2, -21 },
  { 880, 8, 16, 18, 5, -16 },
  { 896, 9, 20, 18, 4, -16 },
  { 919, 14, 17, 18, 3, -18 },
  { 949, 16, 10, 18, 1, -14 },
  { 969, 15, 17, 18, 1, -18 },
  { 1001, 13, 21, 18, 4, -21 },
  { 1036, 16, 24, 18, 1, -21 },
  { 1084, 17, 21, 18, -1, -21 },
  { 1129, 16, 21, 18, 1, -21 },
  { 1171, 16, 21, 18, 2, -21 },
  { 1213, 16, 21, 18, 1, -21 },
  { 1255, 17, 21, 18, 1, -21 },
  { 1300, 17, 21, 18, 1, -21 },
  { 1345, 15, 21, 18, 2, -21 },
  { 1385, 17, 21, 18, 1, -21 },
  { 1430, 17, 21, 18, 1, -21 },
  { 1475, 16, 21, 18, 1, -21 },
  { 1517, 19, 21, 18, 1, -21 },
  { 1567, 13, 21, 18, 2, -21 },
  { 1602, 19, 21, 18, 0, -21 },
  { 1652, 17, 21, 18, 1, -21 },
  { 1697, 15, 21, 18, 2, -21 },
  { 1737, 17, 21, 18, 1, -21 },
  { 1782, 15, 27, 18, 2, -21 },
  { 1833, 17, 21, 18, 1, -21 },
  { 1878, 17, 21, 18, 1, -21 },
  { 1923, 17, 21, 18, 2, -21 },
  { 1968, 16, 21, 18, 2, -21 },
  { 2010, 16, 21, 18, 3, -21 },
  { 2052, 18, 21, 18, 1, -21 },
  { 2100, 20, 21, 18, -1, -21 },
  { 2153, 17, 21, 18, 3, -21 },
  { 2198, 18, 21, 18, 0, -21 },
  { 2246, 14, 27, 18, 4, -23 },
  { 2294, 8, 27, 18, 5, -23 },
  { 2321, 13, 27, 18, 1, -23 },
  { 2365, 15, 13, 18, 2, -21 },
  { 2390, 15, 3, 18, 0, 2 },
  { 2396, 5, 6, 18, 6, -23 },
  { 2400, 16, 15, 18, 1, -15 },
  { 2430, 16, 22, 18, 1, -22 },
  { 2474, 14, 15, 18, 2, -15 },
  { 2501, 17, 22, 18, 1, -22 },
  { 2548, 14, 15, 18, 2, -15 },
  { 2575, 20, 28, 18, -1, -22 },
  { 2645, 16, 21, 18, 1, -15 },
  { 2687, 15, 22, 18, 1, -22 },
  { 2729, 14, 22, 18, 2, -22 },
  { 2768, 15, 28, 18, 1, -22 },
  { 2821, 16, 22, 18, 1, -22 },
  { 2865, 13, 22, 18, 3, -22 },
  { 2901, 17, 15, 18, 0, -15 },
  { 2933, 15, 15, 18, 1, -15 },
  { 2962, 14, 15, 18, 2, -15 },
  { 2989, 17, 21, 18, 0, -15 },
  { 3034, 16, 21, 18, 1, -15 },
  { 3076, 15, 15, 18, 3, -15 },
  { 3105, 15, 15, 18, 1, -15 },
  { 3134, 14, 21, 18, 2, -21 },
  { 3171, 15, 15, 18, 2, -15 },
  { 3200, 14, 15, 18, 2, -15 },
  { 3227, 16, 15, 18, 1, -15 },
  { 3257, 18, 15, 18, 0, -15 },
  { 3291, 16, 21, 18, 1, -15 },
  { 3333, 16, 15, 18, 1, -15 },
  { 3363, 15, 27, 18, 3, -23 },
  { 3414, 7, 27, 18, 6, -23 },
  { 3438, 14, 27, 18, 1, -23 },
  { 3486, 16, 7, 18, 1, -13 },
};

const GFXfont IBMPlexMono_MediumItalic30pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic30pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic30pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _IBMPLEXMONO_MEDIUMITALIC30PT7B_H_
