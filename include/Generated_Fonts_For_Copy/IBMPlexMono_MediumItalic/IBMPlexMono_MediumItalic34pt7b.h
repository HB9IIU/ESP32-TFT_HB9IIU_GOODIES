#ifndef _IBMPLEXMONO_MEDIUMITALIC34PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x0F,
  0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x8F,
  0xC7, 0xE3, 0xF0, 0xF0, 0x38, 0xF3, 0x8F, 0x38, 0xF7, 0x8E, 0x78, 0xE7,
  0x0E, 0x71, 0xE7, 0x1E, 0x71, 0xEF, 0x1C, 0x00, 0x38, 0xF0, 0x01, 0xC7,
  0x00, 0x1C, 0x38, 0x00, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x70, 0xE0, 0x03,
  0x8E, 0x03, 0xFC, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x3F, 0xC0, 0xF1, 0xC0,
  0x07, 0x0E, 0x00, 0x38, 0xE0, 0x03, 0xC7, 0x01, 0xFC, 0x3F, 0x9F, 0xE3,
  0xFC, 0xFF, 0x1F, 0xE0, 0x70, 0xE0, 0x03, 0x8E, 0x00, 0x3C, 0x70, 0x01,
  0xC3, 0x80, 0x0E, 0x38, 0x00, 0xF1, 0xC0, 0x07, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x1F, 0xFF,
  0x87, 0xCC, 0xF8, 0xF1, 0x8E, 0x3C, 0x30, 0x87, 0x8E, 0x00, 0xF1, 0xC0,
  0x1F, 0x38, 0x01, 0xF6, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x1C, 0xF0, 0x03, 0x0E, 0x00, 0x61, 0xE0, 0x0C, 0x38,
  0x43, 0x8F, 0x3C, 0x71, 0xE7, 0xCE, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0x80,
  0x3F, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x0F, 0x07, 0xF8, 0x1E, 0x0F, 0xF8, 0x1C, 0x0E, 0x38, 0x38, 0x1C, 0x1C,
  0x70, 0x1C, 0x1C, 0x70, 0x1C, 0x38, 0xE0, 0x1C, 0x39, 0xC0, 0x1C, 0x79,
  0xC0, 0x1F, 0xF3, 0x80, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xF0, 0x01, 0xDF, 0xF0, 0x03, 0x9C, 0x70, 0x07, 0x38,
  0x38, 0x07, 0x38, 0x38, 0x0E, 0x38, 0x70, 0x1C, 0x38, 0x70, 0x38, 0x38,
  0xF0, 0x38, 0x3F, 0xE0, 0x70, 0x1F, 0xC0, 0xE0, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x3C, 0x78, 0x03, 0x83, 0xC0, 0x78,
  0x3C, 0x07, 0x83, 0xC0, 0x38, 0x3C, 0x03, 0x83, 0x80, 0x3C, 0x78, 0x01,
  0xCF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0x8E, 0x00, 0x70, 0xF0, 0x0F,
  0x07, 0x00, 0xF0, 0x78, 0x0F, 0x03, 0x82, 0xF0, 0x3C, 0x7F, 0x05, 0xCF,
  0x78, 0xDE, 0xE7, 0xFC, 0xFC, 0x3F, 0x8F, 0xC1, 0xF0, 0x78, 0x7B, 0x9C,
  0xEF, 0x7B, 0xDC, 0xE7, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x03, 0x0F, 0x1F, 0xF7, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFE, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xE7, 0x01, 0xE3,
  0xC1, 0xE0, 0xE0, 0xE0, 0x78, 0x30, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x8F, 0x87,
  0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0x70, 0x70, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x39, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFC, 0x01,
  0xFF, 0x80, 0xFF, 0xF0, 0x7C, 0x3E, 0x3E, 0x07, 0x8F, 0x00, 0xE7, 0x80,
  0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xFC, 0x70, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F,
  0xF3, 0xE7, 0xBC, 0x71, 0xEF, 0x00, 0x7B, 0x80, 0x1E, 0xE0, 0x07, 0x38,
  0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x78, 0x78, 0x7C, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFB, 0x80,
  0xFB, 0xC0, 0xF9, 0xE0, 0xF8, 0xF0, 0x78, 0x78, 0x18, 0x38, 0x08, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x03,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0xF8, 0x7C, 0x1F, 0x1E, 0x03, 0xCF, 0x00, 0xF0, 0x40, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC,
  0x00, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x1F, 0x0E, 0x03, 0xC1,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x3F,
  0xE0, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE2, 0x00, 0xF3, 0xC0, 0x3C, 0xF8, 0x3E, 0x1F,
  0xFF, 0x83, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x3C, 0xE0, 0x07,
  0x1C, 0x01, 0xC7, 0x80, 0x78, 0xF0, 0x1E, 0x1E, 0x07, 0x83, 0xC0, 0xE0,
  0x70, 0x38, 0x0E, 0x0E, 0x03, 0xC3, 0xC0, 0x78, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x8F, 0x80, 0x77, 0xF8, 0x1F, 0xFF, 0x83, 0xE0, 0xF8, 0x78, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0xC0, 0x1E,
  0x38, 0x07, 0x8F, 0xC1, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x7C, 0x1E, 0xFF, 0x8F,
  0xFF, 0xEF, 0xC1, 0xF7, 0xC0, 0x7B, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xC7, 0x83, 0xE3, 0xFF, 0xE0, 0xFF,
  0xE0, 0x1F, 0xC0, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF9, 0xC0, 0x1E,
  0x70, 0x0F, 0x3C, 0x03, 0xCE, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xC1, 0xE1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7,
  0x00, 0x78, 0xE0, 0x0E, 0x1E, 0x03, 0xC1, 0xE0, 0xF0, 0x1F, 0xF8, 0x01,
  0xFE, 0x01, 0xFF, 0xF0, 0x7C, 0x1F, 0x1E, 0x01, 0xE3, 0xC0, 0x1C, 0xF0,
  0x03, 0x9E, 0x00, 0xFB, 0xC0, 0x1E, 0x78, 0x07, 0xC7, 0xC1, 0xF0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF,
  0x8F, 0x83, 0xE7, 0x80, 0xF7, 0x80, 0x3B, 0xC0, 0x1D, 0xE0, 0x0F, 0xF0,
  0x0F, 0x78, 0x07, 0xBC, 0x07, 0xDF, 0x07, 0xE7, 0xFE, 0xF3, 0xFE, 0xF0,
  0x7E, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x0E, 0x1F, 0x3F,
  0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x7C,
  0xFC, 0xFC, 0xFC, 0x78, 0x03, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x7C,
  0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x03, 0x80, 0x00, 0x01,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x18,
  0x00, 0x08, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x80,
  0x10, 0x00, 0x18, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7F,
  0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1, 0xFF,
  0x01, 0xEE, 0x03, 0xC8, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x3F,
  0xC0, 0x7F, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE0, 0xF1, 0xC0, 0x39,
  0xE0, 0x1C, 0xE0, 0x06, 0xF0, 0xF7, 0x70, 0xFF, 0xB8, 0xFF, 0xDC, 0xF1,
  0xFE, 0x70, 0x7E, 0x38, 0x3F, 0x3C, 0x1F, 0x9E, 0x1D, 0xCE, 0x0E, 0xE7,
  0x07, 0x73, 0xC7, 0xB9, 0xFD, 0xDC, 0x7F, 0xEE, 0x3E, 0xE7, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0xEF, 0x00, 0x3C, 0xE0, 0x07, 0x1C, 0x01, 0xE3, 0x80, 0x38,
  0x70, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x38, 0x3C, 0x0F, 0x07, 0x81, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xC0, 0x38, 0x70, 0x07, 0x9E, 0x00,
  0xF3, 0xC0, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7F, 0x80, 0x0F, 0x0F, 0xFE,
  0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x38, 0x1F, 0x0E, 0x03, 0xC7, 0x80, 0xF1,
  0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0x87, 0x01, 0xE1, 0xFF, 0xF0, 0xFF,
  0xE0, 0x3F, 0xFF, 0x0F, 0x03, 0xE3, 0xC0, 0x78, 0xE0, 0x1E, 0x38, 0x07,
  0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3E, 0x78, 0x1F, 0x1F, 0xFF, 0x87,
  0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3E,
  0x1E, 0x1E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x10, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xC7, 0x00, 0xF1, 0xE0,
  0x7C, 0x7C, 0x3E, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xFC,
  0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0x83, 0xC0, 0xE0, 0x3C, 0x3C, 0x07,
  0x87, 0x80, 0x70, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x70, 0x07,
  0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E,
  0x38, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x87, 0x83, 0xE0,
  0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x87, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x7C,
  0x3E, 0x1E, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x21, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC1, 0xFE, 0xF0, 0xFF, 0x3C, 0x3F, 0xCF,
  0x00, 0x73, 0xC0, 0x1C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x78, 0x78, 0x2E, 0x1F, 0xFB, 0x83, 0xFC, 0xE0, 0x3E, 0x78, 0x0F, 0x00,
  0xE1, 0xE0, 0x3C, 0x38, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03,
  0xC7, 0x80, 0x70, 0xF0, 0x1E, 0x1C, 0x03, 0xC7, 0x80, 0x78, 0xFF, 0xFF,
  0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x70, 0x0F, 0x0E, 0x01, 0xE3, 0xC0, 0x3C,
  0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1C, 0x3C, 0x07, 0x87, 0x00, 0xF1,
  0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0xFF, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x10, 0x0E, 0x38, 0x0F, 0x1E, 0x07, 0x8F, 0x87,
  0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0x00, 0xF8, 0x78, 0x0F,
  0x83, 0xC0, 0xF8, 0x1C, 0x0F, 0x81, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0x78,
  0x78, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x00, 0xE7, 0x80, 0x0F, 0x7C, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xBC, 0x00, 0xF9, 0xE0, 0x07, 0x87,
  0x80, 0x78, 0x3C, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3E, 0x07,
  0x80, 0xF0, 0x38, 0x07, 0x83, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0xF8, 0x7C, 0x07,
  0xC3, 0xE0, 0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xE1, 0xB8, 0x7F,
  0x1D, 0xC3, 0x98, 0xDE, 0x1C, 0xEE, 0xF0, 0xE7, 0xE7, 0x07, 0x3F, 0x38,
  0x39, 0xF1, 0xC3, 0xC7, 0x8E, 0x1E, 0x38, 0xF0, 0xE1, 0xC7, 0x87, 0x0C,
  0x38, 0x38, 0x61, 0xC1, 0xC2, 0x0E, 0x1E, 0x00, 0x70, 0xF0, 0x07, 0x87,
  0x00, 0x3C, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x1E, 0x00, 0x70, 0x0F, 0x80,
  0xE1, 0xF0, 0x1C, 0x3E, 0x03, 0x8F, 0xE0, 0xF1, 0xFC, 0x1E, 0x3B, 0x83,
  0xC7, 0x70, 0x70, 0xEE, 0x0E, 0x1D, 0xE1, 0xC7, 0x9C, 0x78, 0xF3, 0x8F,
  0x1C, 0x71, 0xE3, 0x8E, 0x38, 0x71, 0xE7, 0x0E, 0x1C, 0xE3, 0xC3, 0xBC,
  0x78, 0x77, 0x8E, 0x0E, 0xF1, 0xC1, 0xFC, 0x38, 0x1F, 0x87, 0x03, 0xF1,
  0xE0, 0x7E, 0x3C, 0x0F, 0xC7, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0x80,
  0xFF, 0xF0, 0x7C, 0x3E, 0x3E, 0x07, 0x8F, 0x00, 0xE7, 0x80, 0x3D, 0xE0,
  0x0F, 0x78, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07,
  0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xE0, 0x0F, 0x3C, 0x03, 0xCF,
  0x00, 0xF3, 0xC0, 0x78, 0x78, 0x7C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F,
  0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0x81, 0xF0, 0xE0,
  0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0,
  0x78, 0x70, 0x1F, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7C, 0x3E, 0x3E, 0x07, 0x8F, 0x00, 0xE7,
  0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xE0, 0x0F,
  0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x78, 0x78, 0x7C, 0x1F, 0xFE, 0x03,
  0xFF, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x00, 0x70, 0x40, 0x1E, 0x38, 0x03,
  0x9C, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0x81, 0xF0, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x78, 0x70, 0x1F, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x38, 0x3C,
  0x07, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x1C,
  0x1C, 0x03, 0xC7, 0x80, 0x78, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0x0F, 0x81, 0xF1, 0xE0, 0x1C, 0x3C, 0x01, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x80, 0x1E, 0x78, 0x07, 0xCF, 0x81, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00,
  0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x01, 0xE3, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78,
  0x07, 0x8F, 0x00, 0xE1, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0,
  0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x70, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x07, 0x83,
  0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0xF0, 0x01, 0xEE, 0x00,
  0x79, 0xC0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x03,
  0xC3, 0xC0, 0x78, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xE0, 0x70, 0x1C, 0x1E,
  0x03, 0x83, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x3C, 0xF0,
  0x07, 0x9C, 0x00, 0xF7, 0x80, 0x0E, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x39, 0xC0, 0x03, 0xCE, 0x00,
  0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE1, 0xE3, 0x87,
  0x1F, 0x1C, 0x78, 0xF8, 0xE3, 0xC7, 0xC7, 0x1E, 0x7E, 0x78, 0xE3, 0x73,
  0x87, 0x1B, 0x9C, 0x39, 0xDC, 0xE1, 0xCC, 0xE7, 0x0E, 0xE7, 0x70, 0x77,
  0x3B, 0x83, 0xB1, 0xDC, 0x1F, 0x8E, 0xE1, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0,
  0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x07, 0xC0, 0x07, 0x80, 0x3E, 0x0F,
  0x00, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x07, 0x80, 0x1E, 0x1F, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xF7, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x0F, 0x00,
  0x3E, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x1F,
  0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xFE, 0x00, 0x79, 0xE0, 0x0F,
  0x3C, 0x03, 0xC3, 0x80, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x80, 0xE1, 0xE0,
  0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x3B, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x00, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x38, 0x1C, 0x0E, 0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03,
  0x9C, 0x01, 0xE7, 0x80, 0xF0, 0xE0, 0x38, 0x38, 0x1E, 0x0F, 0x0F, 0x01,
  0xC7, 0x80, 0x79, 0xC0, 0x1E, 0xF0, 0x03, 0x98, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0x37, 0x9C, 0xF3, 0x9C, 0x40, 0x07, 0xC7,
  0x8F, 0xF3, 0xCF, 0xFD, 0xC7, 0xC2, 0xE7, 0x80, 0xF3, 0xC0, 0x7B, 0xC0,
  0x3D, 0xE0, 0x1E, 0xF0, 0x0E, 0x78, 0x07, 0x38, 0x07, 0x9C, 0x03, 0xCE,
  0x03, 0xE7, 0x83, 0xF3, 0xC3, 0x71, 0xFF, 0xBE, 0x7F, 0x9F, 0x1F, 0x07,
  0x80, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0xF8, 0x1E, 0xFF, 0x07, 0xBF, 0xE1,
  0xD8, 0x78, 0x7C, 0x0F, 0x3E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0,
  0x0F, 0x38, 0x03, 0xCE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x0F,
  0x1F, 0x07, 0xC7, 0x7F, 0xE1, 0xCF, 0xF0, 0xF1, 0xF0, 0x00, 0x01, 0xF8,
  0x07, 0xFC, 0x1F, 0xFE, 0x3E, 0x1F, 0x3C, 0x0F, 0x78, 0x08, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x04, 0xF0, 0x0F,
  0x70, 0x1E, 0x7C, 0x3C, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x1F, 0x1E, 0x1F, 0xF7, 0x8F, 0xFD, 0xE3, 0xE1, 0xF9, 0xE0,
  0x3C, 0x78, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F,
  0x38, 0x03, 0x8E, 0x01, 0xE3, 0x80, 0x78, 0xF0, 0x3E, 0x3E, 0x37, 0x8F,
  0xFD, 0xE1, 0xFE, 0x70, 0x3E, 0x3C, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x1F,
  0xFF, 0x1E, 0x0F, 0x3C, 0x07, 0x78, 0x07, 0x78, 0x0F, 0x70, 0x7F, 0xFF,
  0xFE, 0xFF, 0xF8, 0xFF, 0x80, 0xF0, 0x00, 0xF0, 0x04, 0x70, 0x0F, 0x78,
  0x3E, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x20, 0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xE3, 0xC0,
  0x01, 0xE7, 0x80, 0x01, 0xEE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xE3, 0xC3, 0xFE, 0xF1, 0xFF, 0xBC, 0x7C, 0x3E,
  0x3C, 0x07, 0x8F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E,
  0x01, 0xC7, 0x00, 0x71, 0xC0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0xC7, 0xC7,
  0xF0, 0xFF, 0xBC, 0x3F, 0xCE, 0x03, 0xE3, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x40, 0x3C, 0x1C, 0x1F, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xC0, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x7C, 0x3C, 0xFE, 0x3D, 0xFF, 0x3F, 0x1F, 0x3A, 0x0F,
  0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0E,
  0x70, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xE0, 0x1C,
  0xE0, 0x1C, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x30, 0x70, 0xF0, 0xE3, 0xC3, 0xCF, 0x07, 0xBC, 0x0F, 0xF0, 0x0F,
  0xC0, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x20, 0x70, 0x38, 0x38, 0x3C, 0x3C,
  0x0F, 0x1E, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF1, 0xF0, 0x3C, 0xFE, 0x0F, 0x7F,
  0xC3, 0xF0, 0xF0, 0xE8, 0x3C, 0x3C, 0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xE1,
  0xE0, 0xF0, 0x78, 0xF0, 0x1C, 0xF0, 0x07, 0x3C, 0x03, 0xC7, 0x06, 0xF1,
  0xE3, 0xFC, 0x39, 0xEF, 0x0F, 0xF3, 0x83, 0xF8, 0xE0, 0x78, 0x00, 0x7F,
  0xC0, 0xFF, 0x83, 0xFF, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x18, 0x78, 0x78, 0xF1,
  0xE1, 0xCF, 0x83, 0xBE, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0x00, 0x1C, 0xE1,
  0xE1, 0xDF, 0x3E, 0x1F, 0xF7, 0xF3, 0xE7, 0x4F, 0x3C, 0x78, 0xF3, 0x87,
  0x8F, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x38, 0x70, 0xE7, 0x87, 0x0E, 0x70,
  0xF0, 0xE7, 0x0E, 0x1E, 0x70, 0xE1, 0xC7, 0x0E, 0x1C, 0x70, 0xE1, 0xCF,
  0x0E, 0x1C, 0xE1, 0xE1, 0xCE, 0x1C, 0x3C, 0x3C, 0x7C, 0x3C, 0xFE, 0x3D,
  0xFF, 0x3F, 0x1F, 0x3A, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xE0, 0x1C, 0xE0, 0x1C, 0x03, 0xF0, 0x07, 0xFE, 0x07,
  0xFF, 0x87, 0xC3, 0xE7, 0x80, 0xF3, 0xC0, 0x3B, 0xC0, 0x1D, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80,
  0xF1, 0xE0, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0x1F,
  0x01, 0xEF, 0xF0, 0x3D, 0xFF, 0x07, 0x61, 0xE0, 0xF8, 0x1E, 0x3E, 0x03,
  0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0x80, 0x3C, 0x70, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x0F, 0x83, 0xE1, 0xDF, 0xF8,
  0x39, 0xFE, 0x0F, 0x1F, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC7,
  0x8F, 0xFB, 0xCF, 0xFD, 0xE7, 0xC3, 0xE7, 0x80, 0xF3, 0xC0, 0x7B, 0xC0,
  0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xB8, 0x03, 0x9C, 0x03, 0xCE,
  0x01, 0xE7, 0x81, 0xF3, 0xE3, 0x79, 0xFF, 0xBC, 0x7F, 0x9C, 0x1F, 0x9E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x7F, 0x8F, 0xBF, 0xCF, 0xDF, 0xEF, 0xF0, 0xFC,
  0x00, 0x74, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xFE, 0x1F,
  0xFF, 0x3E, 0x0E, 0x3C, 0x04, 0x38, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x0E, 0x60, 0x1E, 0xF0,
  0x3E, 0xFF, 0xFC, 0x7F, 0xF8, 0x1F, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x01, 0xFF, 0xFE, 0xFF, 0xFE,
  0x7F, 0xFF, 0x43, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x02, 0x07, 0x83, 0x03, 0x87, 0xC1,
  0xC7, 0xC1, 0xEF, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x00, 0x3C, 0x07,
  0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x00, 0xE3, 0x80, 0xF3, 0xC0, 0x79, 0xE0,
  0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x38, 0x07, 0x1C, 0x07, 0x9E, 0x03, 0xCF,
  0x03, 0xE7, 0x81, 0xF3, 0xE3, 0x78, 0xFF, 0xB8, 0x7F, 0x9C, 0x0F, 0x1E,
  0x00, 0xFE, 0x02, 0x7F, 0x07, 0xBF, 0x83, 0xC3, 0xC0, 0xE1, 0xE0, 0x78,
  0xE0, 0x3C, 0x70, 0x1E, 0x38, 0x0E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03,
  0xC7, 0x83, 0xC3, 0x83, 0xC1, 0xC3, 0xE0, 0xE7, 0xE0, 0x7F, 0xE0, 0x3F,
  0xC0, 0x0F, 0x80, 0x00, 0x38, 0x70, 0xCE, 0x1C, 0x73, 0x87, 0x1C, 0xE1,
  0xC7, 0x78, 0xE1, 0xDC, 0x38, 0x77, 0x0E, 0x1D, 0xC3, 0x87, 0x70, 0xE1,
  0xDC, 0x38, 0x7E, 0x1E, 0x1F, 0x87, 0x07, 0xE1, 0xC3, 0xB8, 0x70, 0xEE,
  0x2C, 0x73, 0xFB, 0x1C, 0xFC, 0xFE, 0x1E, 0x1E, 0x00, 0x03, 0xC1, 0xE0,
  0x7E, 0x7F, 0x1F, 0xE7, 0xF3, 0xEE, 0xC7, 0x78, 0xEC, 0x73, 0x06, 0x87,
  0x00, 0x78, 0x70, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x0E, 0x0F, 0x00, 0xE1, 0xF0, 0xCE, 0x1F, 0x1E, 0xF3, 0x77, 0xCF, 0xF7,
  0xF8, 0x7E, 0x3F, 0x03, 0xC3, 0xC0, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0,
  0x3C, 0x70, 0x0E, 0x1C, 0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E,
  0x3C, 0x07, 0x8E, 0x01, 0xC3, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x1F, 0x1E,
  0x07, 0xC3, 0xC6, 0xF0, 0xFF, 0xB8, 0x1F, 0xCE, 0x03, 0xC7, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x40, 0x3C, 0x1C, 0x1F, 0x0F, 0xFF, 0x81, 0xFF, 0xC0,
  0x1F, 0xC0, 0x00, 0x07, 0xE1, 0xC7, 0xFE, 0x71, 0xFF, 0xFC, 0xF0, 0xFF,
  0x38, 0x0F, 0x8E, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x30, 0x3C, 0x1C, 0x1E, 0x03, 0x8F, 0x80, 0xE7, 0xFF,
  0x39, 0xFF, 0xFE, 0xF1, 0xFF, 0x3C, 0x1F, 0x80, 0x00, 0xFF, 0x01, 0xFF,
  0x03, 0xFE, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0xFF, 0x80, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0x83,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1,
  0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC0, 0x07, 0xF8, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xFF, 0x00, 0x3F, 0x01, 0xFF, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x0F,
  0x00, 0xC3, 0xF8, 0x3C, 0xFF, 0x07, 0x1C, 0xF0, 0xE7, 0x0F, 0x38, 0xE0,
  0xFF, 0x38, 0x1F, 0xC3, 0x01, 0xE0,
};

const GFXglyph IBMPlexMono_MediumItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 9, 24, 20, 6, -24 },
  { 28, 12, 10, 20, 6, -25 },
  { 43, 21, 24, 20, 0, -24 },
  { 106, 19, 30, 20, 1, -27 },
  { 178, 24, 24, 20, -1, -24 },
  { 250, 20, 24, 20, 0, -24 },
  { 310, 5, 10, 20, 10, -25 },
  { 317, 14, 31, 20, 6, -26 },
  { 372, 14, 31, 20, 1, -26 },
  { 427, 17, 17, 20, 2, -19 },
  { 464, 17, 17, 20, 2, -19 },
  { 501, 9, 10, 20, 4, -5 },
  { 513, 11, 3, 20, 5, -12 },
  { 518, 6, 6, 20, 6, -6 },
  { 523, 19, 31, 20, 1, -26 },
  { 597, 18, 24, 20, 2, -24 },
  { 651, 17, 24, 20, 1, -24 },
  { 702, 18, 24, 20, 1, -24 },
  { 756, 18, 24, 20, 1, -24 },
  { 810, 19, 24, 20, 0, -24 },
  { 867, 19, 24, 20, 1, -24 },
  { 924, 17, 24, 20, 2, -24 },
  { 975, 18, 24, 20, 3, -24 },
  { 1029, 19, 24, 20, 1, -24 },
  { 1086, 17, 24, 20, 3, -24 },
  { 1137, 8, 19, 20, 6, -19 },
  { 1156, 10, 24, 20, 4, -19 },
  { 1186, 16, 20, 20, 3, -20 },
  { 1226, 17, 10, 20, 2, -15 },
  { 1248, 16, 20, 20, 2, -20 },
  { 1288, 15, 24, 20, 4, -24 },
  { 1333, 17, 28, 20, 2, -24 },
  { 1393, 19, 24, 20, -1, -24 },
  { 1450, 18, 24, 20, 1, -24 },
  { 1504, 18, 24, 20, 2, -24 },
  { 1558, 19, 24, 20, 1, -24 },
  { 1615, 19, 24, 20, 1, -24 },
  { 1672, 20, 24, 20, 1, -24 },
  { 1732, 18, 24, 20, 2, -24 },
  { 1786, 19, 24, 20, 1, -24 },
  { 1843, 19, 24, 20, 1, -24 },
  { 1900, 17, 24, 20, 2, -24 },
  { 1951, 21, 24, 20, 1, -24 },
  { 2014, 15, 24, 20, 2, -24 },
  { 2059, 21, 24, 20, 0, -24 },
  { 2122, 19, 24, 20, 1, -24 },
  { 2179, 18, 24, 20, 2, -24 },
  { 2233, 19, 24, 20, 1, -24 },
  { 2290, 18, 31, 20, 2, -24 },
  { 2360, 19, 24, 20, 1, -24 },
  { 2417, 19, 24, 20, 1, -24 },
  { 2474, 19, 24, 20, 3, -24 },
  { 2531, 19, 24, 20, 2, -24 },
  { 2588, 19, 24, 20, 3, -24 },
  { 2645, 21, 24, 20, 1, -24 },
  { 2708, 23, 24, 20, -1, -24 },
  { 2777, 19, 24, 20, 3, -24 },
  { 2834, 21, 24, 20, 0, -24 },
  { 2897, 15, 31, 20, 5, -26 },
  { 2956, 9, 31, 20, 6, -26 },
  { 2991, 15, 31, 20, 1, -26 },
  { 3050, 18, 14, 20, 2, -24 },
  { 3082, 17, 3, 20, 0, 3 },
  { 3089, 5, 7, 20, 7, -27 },
  { 3094, 17, 18, 20, 2, -18 },
  { 3133, 18, 25, 20, 1, -25 },
  { 3190, 16, 18, 20, 2, -18 },
  { 3226, 18, 25, 20, 2, -25 },
  { 3283, 16, 18, 20, 2, -18 },
  { 3319, 23, 32, 20, -1, -25 },
  { 3411, 18, 25, 20, 1, -18 },
  { 3468, 16, 25, 20, 2, -25 },
  { 3518, 15, 26, 20, 3, -26 },
  { 3567, 17, 33, 20, 1, -26 },
  { 3638, 18, 25, 20, 2, -25 },
  { 3695, 15, 25, 20, 3, -25 },
  { 3742, 20, 18, 20, 0, -18 },
  { 3787, 16, 18, 20, 2, -18 },
  { 3823, 17, 18, 20, 2, -18 },
  { 3862, 19, 25, 20, 0, -18 },
  { 3922, 17, 25, 20, 2, -18 },
  { 3976, 17, 18, 20, 3, -18 },
  { 4015, 16, 18, 20, 2, -18 },
  { 4051, 17, 24, 20, 2, -24 },
  { 4102, 17, 18, 20, 2, -18 },
  { 4141, 17, 18, 20, 2, -18 },
  { 4180, 18, 18, 20, 1, -18 },
  { 4221, 20, 18, 20, 0, -18 },
  { 4266, 18, 25, 20, 1, -18 },
  { 4323, 18, 18, 20, 1, -18 },
  { 4364, 16, 31, 20, 4, -26 },
  { 4426, 9, 31, 20, 6, -26 },
  { 4461, 16, 31, 20, 1, -26 },
  { 4523, 19, 8, 20, 1, -14 },
};

const GFXfont IBMPlexMono_MediumItalic34pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic34pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic34pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _IBMPLEXMONO_MEDIUMITALIC34PT7B_H_
