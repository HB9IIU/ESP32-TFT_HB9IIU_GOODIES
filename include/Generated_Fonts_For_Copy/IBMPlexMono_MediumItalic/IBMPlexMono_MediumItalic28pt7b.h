#ifndef _IBMPLEXMONO_MEDIUMITALIC28PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x78, 0xE1, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x40, 0x80,
  0x00, 0x00, 0x38, 0xF9, 0xF3, 0xE3, 0x80, 0x71, 0xDC, 0x77, 0x19, 0xCE,
  0x73, 0x98, 0xEE, 0x3B, 0x8E, 0x00, 0xE7, 0x00, 0x63, 0x80, 0x71, 0x80,
  0x39, 0xC0, 0x18, 0xE0, 0x1C, 0x60, 0xFE, 0x7E, 0x7E, 0x3F, 0x07, 0x18,
  0x03, 0x9C, 0x01, 0x8E, 0x00, 0xC6, 0x0F, 0xE7, 0xF7, 0xE3, 0xF0, 0x71,
  0x80, 0x39, 0xC0, 0x18, 0xE0, 0x1C, 0x60, 0x0E, 0x70, 0x06, 0x38, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x1F, 0x80, 0xFF, 0xC3, 0xFF, 0xCF,
  0x37, 0x9C, 0x62, 0x38, 0xC0, 0x73, 0x80, 0xF6, 0x01, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x01, 0xCE, 0x03, 0x1C, 0x86, 0x3B, 0x8C, 0x77,
  0x9B, 0xEF, 0xFF, 0x87, 0xFE, 0x07, 0xF0, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x03, 0xC0, 0x70, 0xFE, 0x0E, 0x1C, 0x61, 0xC1, 0x86, 0x18, 0x18,
  0x63, 0x81, 0x86, 0x30, 0x18, 0x66, 0x01, 0x8E, 0xE0, 0x1F, 0xCC, 0x00,
  0xF1, 0x00, 0x00, 0x1E, 0x00, 0x33, 0xF0, 0x06, 0x71, 0x80, 0xE6, 0x18,
  0x0C, 0x61, 0x81, 0xCE, 0x18, 0x38, 0xE3, 0x83, 0x06, 0x30, 0x70, 0x7F,
  0x0E, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xFE, 0x01, 0xC7, 0x00, 0xC1, 0x80,
  0xE0, 0xE0, 0x70, 0x70, 0x18, 0x30, 0x0E, 0x38, 0x07, 0x18, 0x07, 0xF8,
  0x0E, 0xE0, 0x0E, 0x38, 0x06, 0x1C, 0x07, 0x0E, 0x03, 0x83, 0x81, 0xC1,
  0xC7, 0xE1, 0x73, 0x38, 0xBB, 0x1F, 0xCF, 0x87, 0x83, 0x80, 0x77, 0x76,
  0x6E, 0xEE, 0x00, 0xE0, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01,
  0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01,
  0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x06, 0x18, 0x6F, 0xFF, 0xFF,
  0xFF, 0x07, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x73, 0x81, 0xC7, 0x07, 0x87,
  0x02, 0x04, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01,
  0x83, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x1F, 0x1E, 0x3C, 0x3C, 0x38, 0x70, 0x70, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xF3, 0xC0, 0xE7, 0x01, 0xDE,
  0x03, 0xB8, 0x07, 0x71, 0x8E, 0xE7, 0x9D, 0xCF, 0x3F, 0x9C, 0xFE, 0x01,
  0xDC, 0x03, 0xB8, 0x07, 0x38, 0x1C, 0x78, 0x78, 0xFF, 0xE0, 0xFF, 0x80,
  0x7C, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x1E, 0xE0, 0xF3,
  0x87, 0x8E, 0x04, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF1, 0xE3, 0x81, 0xE3, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xFF, 0xF3, 0xFF,
  0xE7, 0xFF, 0xC0, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xE0, 0xF1, 0x81,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x07, 0xF0, 0x0F, 0x80, 0x1F, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x90, 0x0F, 0x70, 0x1C, 0xF0, 0x79, 0xFF,
  0xE1, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0xEE, 0x00, 0xFC, 0x01, 0xDC, 0x03, 0x9C, 0x07, 0x1C, 0x0E, 0x1C, 0x0C,
  0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x38, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x0F, 0xFE, 0x1F,
  0xFC, 0x7F, 0xF8, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0xF0,
  0x3F, 0xF8, 0x7F, 0xF8, 0xE0, 0xF0, 0x80, 0xE0, 0x01, 0xC0, 0x03, 0x88,
  0x07, 0x30, 0x1E, 0xF0, 0x78, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E,
  0x7C, 0x3F, 0xF9, 0xDF, 0xF7, 0xC3, 0xDC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E,
  0x01, 0xDC, 0x0F, 0x78, 0x79, 0xFF, 0xC3, 0xFE, 0x03, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0E, 0xE0, 0x3B, 0x01, 0xCC, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xF0, 0x1F,
  0xF8, 0x7F, 0xF8, 0xF0, 0xF3, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0E,
  0x1C, 0x38, 0x1F, 0xE0, 0x7F, 0xC1, 0xC1, 0xC7, 0x01, 0xDC, 0x03, 0xB8,
  0x07, 0x70, 0x1E, 0xF0, 0x7D, 0xFF, 0xF1, 0xFF, 0xC0, 0xFE, 0x00, 0x07,
  0xE0, 0x7F, 0xC3, 0xFF, 0x9E, 0x0F, 0x70, 0x1F, 0xC0, 0x7E, 0x01, 0xF8,
  0x07, 0xF0, 0x3F, 0xC1, 0xF7, 0xFF, 0x9F, 0xEE, 0x1E, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0x1C, 0x7C,
  0xF9, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC7, 0xCF, 0x9F, 0x1C, 0x00,
  0x07, 0x07, 0xC3, 0xE1, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE1, 0xE1, 0xE0, 0xF0, 0x70, 0x70, 0x38, 0x38, 0x00, 0x00, 0x04,
  0x00, 0x70, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x1C, 0x00,
  0x70, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0x00, 0x08, 0x3F, 0xFE, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x7F, 0xFE, 0x10, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x00, 0x3C, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x06, 0x00, 0x20, 0x00, 0x0F, 0xC0, 0xFF,
  0x0F, 0xFC, 0xF0, 0xFF, 0x07, 0x90, 0x3C, 0x01, 0xC0, 0x0E, 0x01, 0xE0,
  0x7E, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x38, 0x70,
  0xE0, 0x73, 0x80, 0xE7, 0x00, 0xCC, 0x39, 0xB8, 0xFF, 0x73, 0x8E, 0xE6,
  0x1D, 0x9C, 0x33, 0x38, 0x66, 0x70, 0xDC, 0xE3, 0xB9, 0xC7, 0x73, 0xFC,
  0xE3, 0xD9, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0xFC, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xDC,
  0x01, 0xDC, 0x03, 0x9C, 0x03, 0x8E, 0x03, 0x8E, 0x07, 0x0E, 0x07, 0x0E,
  0x0E, 0x0E, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x3C, 0x0F, 0x38, 0x0F,
  0x38, 0x07, 0x70, 0x07, 0xF0, 0x07, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0,
  0xE0, 0xF1, 0xC0, 0xE3, 0x81, 0xCE, 0x07, 0x1C, 0x1E, 0x3F, 0xF0, 0x7F,
  0xE0, 0xE0, 0xE1, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x1E,
  0x70, 0x78, 0xFF, 0xF3, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xE0, 0x1F, 0xF0,
  0x7F, 0xF1, 0xF1, 0xE3, 0x81, 0xCF, 0x01, 0xDC, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x04, 0x38, 0x0E,
  0x70, 0x3C, 0xF0, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0xF0, 0x7F, 0xF0, 0xE1, 0xE1, 0xC0, 0xE3, 0x81, 0xCE, 0x03, 0x9C,
  0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0xF7, 0x01, 0xEE, 0x03,
  0x9C, 0x0F, 0x38, 0x1C, 0x70, 0xF8, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x00,
  0x1F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF0, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xF8, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0xC1,
  0xFF, 0x8F, 0x0F, 0x78, 0x1D, 0xC0, 0x77, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x87, 0xEE, 0x1F, 0xB8, 0xFE, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x1C,
  0xE0, 0x73, 0xC3, 0xC7, 0xF7, 0x0F, 0x9C, 0x1C, 0x07, 0x1C, 0x0F, 0x1C,
  0x0E, 0x1C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x3F,
  0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70,
  0x38, 0x70, 0x38, 0xF0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x78, 0x1F,
  0xFF, 0x1F, 0xFE, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0xFF,
  0xF8, 0xFF, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x40, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x18, 0x1C, 0x78, 0x38, 0x70, 0xF0, 0xFF,
  0xC0, 0xFF, 0x00, 0xFC, 0x00, 0x1C, 0x07, 0x8E, 0x07, 0x87, 0x07, 0x83,
  0x87, 0x81, 0xC7, 0x81, 0xC3, 0x80, 0xE3, 0x80, 0x73, 0x80, 0x3B, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xBC, 0x07, 0x8E, 0x03, 0xC7, 0x01, 0xC1,
  0xC0, 0xE0, 0xE0, 0x70, 0x78, 0x78, 0x1C, 0x38, 0x0F, 0x1C, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x07, 0x8F, 0x83, 0xC7, 0xC3,
  0xE3, 0xE1, 0xF1, 0xF1, 0xF8, 0xD8, 0xD8, 0x6E, 0xEC, 0x77, 0x6E, 0x39,
  0xF7, 0x1C, 0xF3, 0x8E, 0x71, 0xC7, 0x38, 0xC3, 0x08, 0xE3, 0x84, 0x71,
  0xC4, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x06, 0x18, 0x03, 0x1C, 0x03,
  0x80, 0x1E, 0x07, 0x1E, 0x07, 0x1F, 0x06, 0x1F, 0x0E, 0x3F, 0x0E, 0x3B,
  0x0E, 0x3B, 0x0E, 0x3B, 0x8E, 0x33, 0x8C, 0x33, 0x8C, 0x71, 0x9C, 0x71,
  0x9C, 0x71, 0xDC, 0x71, 0xDC, 0x71, 0xD8, 0x60, 0xD8, 0xE0, 0xF8, 0xE0,
  0xF8, 0xE0, 0xF8, 0xE0, 0xF8, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0,
  0xF3, 0xC0, 0xE7, 0x01, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D,
  0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xBC, 0x0F, 0x38, 0x1C, 0x78,
  0x78, 0xFF, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F,
  0xF8, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x1E,
  0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x87, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x0F,
  0xF0, 0x3F, 0xF0, 0xF0, 0xF3, 0xC0, 0xE7, 0x01, 0xDE, 0x03, 0xB8, 0x07,
  0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xBC,
  0x0F, 0x38, 0x1C, 0x78, 0x78, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x38,
  0x00, 0x71, 0x80, 0x77, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x1F, 0xF8,
  0x3F, 0xF8, 0x7F, 0xF8, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xCE, 0x03, 0x9C,
  0x07, 0x38, 0x1E, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x07, 0x9C, 0x0E, 0x1C,
  0x1C, 0x38, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xE3, 0xC0, 0xE7, 0x01, 0xC0,
  0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF9, 0xE0, 0xF3, 0x80, 0x47, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xE0, 0x03,
  0xC0, 0x03, 0x90, 0x07, 0x70, 0x1E, 0xF0, 0x79, 0xFF, 0xF1, 0xFF, 0xC0,
  0xFE, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x73,
  0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x39, 0xC0,
  0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0F, 0x38, 0x1C, 0x70, 0x38,
  0xF0, 0xF1, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0xE0, 0x0F, 0xC0, 0x3B,
  0x80, 0x77, 0x01, 0xEE, 0x03, 0x9C, 0x07, 0x1C, 0x1C, 0x38, 0x38, 0x70,
  0xE0, 0xE1, 0xC1, 0xC7, 0x83, 0x8E, 0x07, 0x1C, 0x0E, 0x70, 0x1C, 0xE0,
  0x1B, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x30, 0x03,
  0x98, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x67, 0x00, 0x73, 0x8E, 0x39, 0xC7,
  0x1C, 0xE7, 0x8C, 0x73, 0xC6, 0x31, 0xE7, 0x19, 0xB3, 0x8C, 0xD9, 0x86,
  0xEC, 0xC7, 0x66, 0xE3, 0xB3, 0x71, 0xF9, 0xB8, 0xF8, 0xD8, 0x7C, 0x7C,
  0x3E, 0x3E, 0x1E, 0x1F, 0x00, 0x0F, 0x01, 0xE0, 0xE0, 0x78, 0x1C, 0x0E,
  0x03, 0xC3, 0xC0, 0x38, 0xF0, 0x07, 0x9C, 0x00, 0x77, 0x00, 0x0F, 0xE0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3B, 0x80,
  0x0F, 0x70, 0x03, 0xC7, 0x00, 0x70, 0xE0, 0x1C, 0x1E, 0x07, 0x81, 0xC1,
  0xE0, 0x38, 0x78, 0x03, 0x80, 0xF0, 0x07, 0xB8, 0x07, 0x1E, 0x07, 0x87,
  0x03, 0x83, 0x83, 0x81, 0xE3, 0xC0, 0x71, 0xC0, 0x39, 0xC0, 0x1D, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0F, 0xF8, 0xFF, 0x00, 0xC1, 0xC3, 0x83,
  0x06, 0x0C, 0x1C, 0x38, 0x30, 0x60, 0xC1, 0xC3, 0x83, 0x06, 0x0E, 0x1C,
  0x38, 0x30, 0x60, 0xE1, 0xC1, 0x83, 0x06, 0x07, 0xF8, 0x7F, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x0F, 0xF0, 0xFF, 0x80,
  0x01, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x3B, 0x80, 0x73, 0x81, 0xC7, 0x07,
  0x07, 0x0E, 0x0E, 0x38, 0x1C, 0xE0, 0x1D, 0xC0, 0x3D, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0x80, 0x2E, 0x67, 0x33, 0x07, 0x9C, 0x7F, 0x73,
  0xC3, 0xCE, 0x07, 0x70, 0x1D, 0xC0, 0xF7, 0x03, 0xBC, 0x0E, 0xE0, 0x3B,
  0x81, 0xEF, 0x07, 0x9C, 0x3E, 0x7F, 0x7C, 0xF8, 0xF0, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x3C, 0x3B,
  0xF8, 0xE8, 0xF3, 0xC1, 0xCE, 0x07, 0x78, 0x1D, 0xC0, 0x77, 0x01, 0xDC,
  0x07, 0x70, 0x1D, 0xC0, 0xE6, 0x87, 0xBB, 0xFC, 0xE7, 0xC0, 0x07, 0xE0,
  0xFF, 0x8E, 0x1E, 0xE0, 0x67, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x01, 0xB8, 0x1E, 0xE1, 0xC7, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x07,
  0x8E, 0x1F, 0xFC, 0x3C, 0x3C, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70,
  0x1C, 0xF0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xF0, 0x78, 0x70, 0xB8, 0x7F,
  0xB8, 0x3E, 0x70, 0x07, 0xE0, 0xFF, 0x8E, 0x0E, 0xE0, 0x77, 0x03, 0xF0,
  0x7B, 0xFF, 0x9F, 0xE0, 0xE0, 0x07, 0x01, 0x38, 0x1E, 0xE1, 0xE7, 0xFE,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0xC3, 0x80, 0x3C, 0x70, 0x01, 0xCE, 0x00, 0x1D,
  0x80, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x8E, 0x3F, 0xF8, 0xF0,
  0xF1, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x78, 0x1C, 0xF0, 0x39,
  0xE0, 0x71, 0xC1, 0xE3, 0x85, 0xC7, 0xF3, 0x83, 0xCE, 0x00, 0x1C, 0x00,
  0x38, 0x40, 0xE1, 0xC3, 0xC3, 0xFF, 0x03, 0xF8, 0x00, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x3C, 0x39,
  0xF8, 0xE8, 0xF3, 0xC1, 0xCE, 0x07, 0x38, 0x1D, 0xE0, 0x77, 0x03, 0x9C,
  0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0xBC, 0x0E, 0xE0, 0x70, 0x03, 0x80,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC3,
  0x1E, 0x70, 0xE7, 0x07, 0x70, 0x3F, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x1F,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x41, 0xC3, 0x87, 0x07,
  0x1C, 0x0E, 0x70, 0x3F, 0x80, 0x7E, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x78,
  0x39, 0xF8, 0x74, 0x78, 0xF0, 0x71, 0xC0, 0xE3, 0x83, 0x8F, 0x0E, 0x1C,
  0x78, 0x3B, 0xC0, 0x73, 0x84, 0xE7, 0x1D, 0xC7, 0x77, 0x8F, 0xCE, 0x0F,
  0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x43,
  0x87, 0x38, 0xE3, 0x9C, 0x3B, 0x83, 0xF0, 0x3C, 0x00, 0x3B, 0x8E, 0x3B,
  0xDF, 0x3D, 0xE7, 0x38, 0xE3, 0x30, 0xC7, 0x31, 0xC7, 0x71, 0xC7, 0x71,
  0xC7, 0x71, 0x86, 0x61, 0x86, 0x61, 0x8E, 0xE3, 0x8E, 0xE3, 0x8E, 0xE3,
  0x8C, 0x1C, 0xF0, 0xE7, 0xE3, 0xA3, 0xCF, 0x07, 0x38, 0x1C, 0xE0, 0x73,
  0x81, 0xDC, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x3B,
  0x81, 0xC0, 0x07, 0xC0, 0xFF, 0x8E, 0x1C, 0xE0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1D, 0xE1, 0xC7, 0xFC, 0x0F,
  0x80, 0x1E, 0x78, 0x3B, 0xF8, 0x74, 0x78, 0xF0, 0x71, 0xC0, 0xE3, 0x81,
  0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x71, 0xA1, 0xE7,
  0x7F, 0x8E, 0x7C, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x00, 0x07, 0x8E, 0x3F, 0xF8, 0xF0, 0xF1, 0xC0, 0xE7, 0x01,
  0xCE, 0x03, 0x9C, 0x07, 0x78, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0xC1, 0xE3,
  0x85, 0xC7, 0xF3, 0x87, 0xCE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0xFE, 0x3F, 0xFB, 0xE0, 0xEF, 0x87, 0xC0,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0xF1, 0xC1, 0x8E,
  0x04, 0x38, 0x00, 0xF0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x78, 0x00, 0xE2,
  0x03, 0xBC, 0x1E, 0x7F, 0xF0, 0x7F, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x43, 0x87, 0x1C, 0xF1, 0xCE,
  0x07, 0xE0, 0x3C, 0x00, 0x78, 0x3D, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70,
  0x39, 0xC0, 0xEE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x1F, 0x3C,
  0x5C, 0x7E, 0xE0, 0xF3, 0x80, 0xFC, 0x17, 0xC3, 0xCE, 0x0E, 0x70, 0x73,
  0x83, 0x9C, 0x1C, 0xE0, 0xEE, 0x07, 0x70, 0x73, 0x87, 0x9C, 0x78, 0xE7,
  0x87, 0xF8, 0x1F, 0x00, 0x31, 0xC4, 0xE3, 0x9D, 0xC6, 0x3B, 0x8C, 0x76,
  0x18, 0xEC, 0x71, 0xD8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8D, 0xC6, 0x1B, 0x1C,
  0x77, 0x38, 0xCF, 0xB3, 0x0E, 0x3C, 0x00, 0x07, 0x0F, 0x0F, 0xCF, 0x8F,
  0x6C, 0xEE, 0x34, 0x72, 0x1E, 0x38, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x71, 0xE1, 0x38, 0xF1, 0x9C, 0xDB, 0xEF, 0xCF, 0xC3, 0xC3,
  0x80, 0x1E, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C,
  0x0E, 0x38, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x7C, 0x3C,
  0x5C, 0x1F, 0xB8, 0x0F, 0x38, 0x00, 0x38, 0x00, 0x38, 0x40, 0x70, 0x70,
  0xF0, 0xFF, 0xE0, 0x3F, 0x80, 0x0F, 0x8E, 0x7F, 0xDC, 0xE3, 0xF9, 0x81,
  0xC3, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x18, 0x38, 0x30,
  0xE0, 0x77, 0xFC, 0x6E, 0x7F, 0xDC, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0xC1,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xC1, 0xFC, 0x0F, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x07, 0xF8, 0x1F,
  0x80, 0x0E, 0x1C, 0x38, 0x60, 0xC1, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC3,
  0x87, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE0, 0x0F,
  0xE0, 0x7F, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x00, 0xC0, 0x07, 0xF0, 0x3F, 0x83, 0x80, 0x38, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x1F, 0xE0, 0xFE, 0x00, 0x1E, 0x06, 0x7E, 0x1D, 0xCE, 0x33, 0x0C, 0xEE,
  0x1F, 0x98, 0x1E, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 7, 20, 17, 5, -20 },
  { 19, 10, 8, 17, 5, -21 },
  { 29, 17, 20, 17, 0, -20 },
  { 72, 15, 26, 17, 1, -23 },
  { 121, 20, 20, 17, -1, -20 },
  { 171, 17, 20, 17, 0, -20 },
  { 214, 4, 8, 17, 8, -21 },
  { 218, 11, 25, 17, 5, -21 },
  { 253, 11, 25, 17, 1, -21 },
  { 288, 15, 14, 17, 1, -15 },
  { 315, 13, 14, 17, 2, -16 },
  { 338, 8, 8, 17, 3, -4 },
  { 346, 9, 3, 17, 4, -10 },
  { 350, 5, 5, 17, 5, -5 },
  { 354, 17, 25, 17, 0, -21 },
  { 408, 15, 20, 17, 1, -20 },
  { 446, 14, 20, 17, 1, -20 },
  { 481, 15, 20, 17, 1, -20 },
  { 519, 15, 20, 17, 1, -20 },
  { 557, 16, 20, 17, 0, -20 },
  { 597, 15, 20, 17, 1, -20 },
  { 635, 14, 20, 17, 1, -20 },
  { 670, 14, 20, 17, 3, -20 },
  { 705, 15, 20, 17, 1, -20 },
  { 743, 14, 20, 17, 2, -20 },
  { 778, 7, 15, 17, 5, -15 },
  { 792, 9, 19, 17, 3, -15 },
  { 814, 14, 16, 17, 2, -17 },
  { 842, 15, 8, 17, 1, -13 },
  { 857, 14, 16, 17, 1, -17 },
  { 885, 13, 20, 17, 3, -20 },
  { 918, 15, 23, 17, 1, -20 },
  { 962, 16, 20, 17, -1, -20 },
  { 1002, 15, 20, 17, 1, -20 },
  { 1040, 15, 20, 17, 2, -20 },
  { 1078, 15, 20, 17, 1, -20 },
  { 1116, 16, 20, 17, 1, -20 },
  { 1156, 16, 20, 17, 1, -20 },
  { 1196, 14, 20, 17, 2, -20 },
  { 1231, 16, 20, 17, 1, -20 },
  { 1271, 16, 20, 17, 1, -20 },
  { 1311, 15, 20, 17, 1, -20 },
  { 1349, 17, 20, 17, 1, -20 },
  { 1392, 12, 20, 17, 2, -20 },
  { 1422, 17, 20, 17, 0, -20 },
  { 1465, 16, 20, 17, 1, -20 },
  { 1505, 15, 20, 17, 1, -20 },
  { 1543, 15, 20, 17, 1, -20 },
  { 1581, 15, 26, 17, 1, -20 },
  { 1630, 15, 20, 17, 1, -20 },
  { 1668, 15, 20, 17, 1, -20 },
  { 1706, 16, 20, 17, 2, -20 },
  { 1746, 15, 20, 17, 2, -20 },
  { 1784, 15, 20, 17, 3, -20 },
  { 1822, 17, 20, 17, 1, -20 },
  { 1865, 19, 20, 17, -1, -20 },
  { 1913, 17, 20, 17, 2, -20 },
  { 1956, 17, 20, 17, 0, -20 },
  { 1999, 12, 25, 17, 4, -21 },
  { 2037, 7, 25, 17, 5, -21 },
  { 2059, 13, 25, 17, 0, -21 },
  { 2100, 15, 12, 17, 1, -20 },
  { 2123, 14, 3, 17, 0, 2 },
  { 2129, 4, 6, 17, 6, -22 },
  { 2132, 14, 14, 17, 1, -14 },
  { 2157, 14, 21, 17, 1, -21 },
  { 2194, 13, 14, 17, 2, -14 },
  { 2217, 16, 21, 17, 1, -21 },
  { 2259, 13, 14, 17, 2, -14 },
  { 2282, 19, 27, 17, -1, -21 },
  { 2347, 15, 20, 17, 1, -14 },
  { 2385, 14, 21, 17, 1, -21 },
  { 2422, 13, 21, 17, 2, -21 },
  { 2457, 14, 27, 17, 1, -21 },
  { 2505, 15, 21, 17, 1, -21 },
  { 2545, 12, 21, 17, 3, -21 },
  { 2577, 16, 14, 17, 0, -14 },
  { 2605, 14, 14, 17, 1, -14 },
  { 2630, 13, 14, 17, 2, -14 },
  { 2653, 15, 20, 17, 0, -14 },
  { 2691, 15, 20, 17, 1, -14 },
  { 2729, 14, 14, 17, 3, -14 },
  { 2754, 14, 14, 17, 1, -14 },
  { 2779, 13, 20, 17, 2, -20 },
  { 2812, 14, 14, 17, 2, -14 },
  { 2837, 13, 14, 17, 2, -14 },
  { 2860, 15, 14, 17, 1, -14 },
  { 2887, 17, 14, 17, 0, -14 },
  { 2917, 16, 20, 17, 0, -14 },
  { 2957, 15, 14, 17, 1, -14 },
  { 2984, 13, 25, 17, 3, -21 },
  { 3025, 7, 25, 17, 5, -21 },
  { 3047, 13, 25, 17, 1, -21 },
  { 3088, 15, 6, 17, 1, -12 },
};

const GFXfont IBMPlexMono_MediumItalic28pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic28pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic28pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _IBMPLEXMONO_MEDIUMITALIC28PT7B_H_
