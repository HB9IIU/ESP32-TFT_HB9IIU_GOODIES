#ifndef _IBMPLEXMONO_MEDIUMITALIC60PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x01, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x00, 0xF8, 0x00, 0x1F, 0x81,
  0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF0, 0x3F,
  0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xE1, 0xF8,
  0x3F, 0x0F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x00, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x40, 0x7C, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xF8,
  0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x1F, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x3E, 0xFF, 0xC0, 0xFF, 0x0F, 0x87,
  0xF0, 0x3F, 0x83, 0xC0, 0xF0, 0x1F, 0xC0, 0xF0, 0x18, 0x07, 0xF0, 0x3C,
  0x04, 0x01, 0xF8, 0x0F, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x07, 0xF0, 0x78, 0x00, 0x01, 0xFC, 0x1E, 0x00, 0x00, 0x7F,
  0x87, 0x80, 0x00, 0x0F, 0xFD, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xF1, 0xFE, 0x00, 0x00, 0x78,
  0x3F, 0xC0, 0x00, 0x1E, 0x07, 0xF0, 0x00, 0x07, 0x81, 0xFC, 0x00, 0x03,
  0xE0, 0x7F, 0x00, 0x00, 0xF8, 0x1F, 0xC0, 0x80, 0x3E, 0x07, 0xF0, 0x20,
  0x0F, 0x01, 0xF8, 0x3C, 0x03, 0xC0, 0xFE, 0x1F, 0x80, 0xF0, 0x7F, 0x8F,
  0xF8, 0x7C, 0x3F, 0xC1, 0xFF, 0x9F, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xF0, 0x03, 0xFF,
  0xC0, 0x01, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0xFF, 0xFE, 0x00,
  0x3E, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x00, 0xF8,
  0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0x7C,
  0x1F, 0x80, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xC3, 0xE0,
  0x00, 0x3C, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0x81, 0xF8, 0x7C, 0x00, 0x03,
  0xF0, 0xFC, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0x1F, 0x00, 0x00, 0x1F, 0xFF,
  0x8F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xF1, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x3F,
  0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x3C,
  0x00, 0x07, 0xC3, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x01,
  0xF8, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x03,
  0xE0, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x03,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0xFE, 0x00,
  0x7C, 0x00, 0x7F, 0xFF, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x80,
  0x03, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x02, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x07, 0xC0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0xDF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xF7, 0xFE, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0x8F, 0xE0, 0x07, 0xF0, 0x1E, 0xFE,
  0x00, 0x7F, 0x03, 0xFF, 0xE0, 0x05, 0xF8, 0x7E, 0x7E, 0x00, 0xDF, 0x87,
  0xC7, 0xF0, 0x1D, 0xFC, 0xF8, 0x7F, 0x83, 0xCF, 0xDF, 0x83, 0xFF, 0xF8,
  0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xE0, 0x0F,
  0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x1F, 0x8F, 0xCF, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x20, 0x03, 0xE0, 0x04, 0x78, 0x0F, 0xC0, 0x7D, 0xFE, 0x1F, 0x87, 0xFB,
  0xFF, 0xBF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x80, 0x01,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x80, 0x1F, 0x9F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00,
  0x7E, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x03, 0xE0, 0x7F, 0x7F, 0x07, 0xF0, 0x7F, 0x7F, 0x0F, 0xF0,
  0x7E, 0x7F, 0x0F, 0xF0, 0xFE, 0xFE, 0x0F, 0xF0, 0xFE, 0xFE, 0x0F, 0xE0,
  0xFE, 0xFE, 0x0F, 0xE0, 0xFE, 0xFE, 0x07, 0xC0, 0xFE, 0xFE, 0x00, 0x00,
  0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x7F,
  0x8F, 0xE0, 0x07, 0xF8, 0x7E, 0x00, 0x7F, 0x83, 0xF0, 0x07, 0xF8, 0x1F,
  0x80, 0x7F, 0x81, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0x80, 0x7F, 0x00,
  0x18, 0x03, 0xF0, 0x00, 0x80, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x07,
  0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x07, 0xF0, 0x02, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x0F, 0xFC, 0x07, 0xF8, 0x01,
  0xFF, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x70, 0x00, 0x1F, 0xC0, 0x18, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x08, 0x00, 0x01, 0xFC, 0x06, 0x00, 0x00, 0xFE,
  0x0F, 0x00, 0x00, 0xFF, 0x0F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF,
  0x83, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0x80, 0x07,
  0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xC3, 0xFF, 0x80, 0x03, 0xE7,
  0xFF, 0xF0, 0x01, 0xF7, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0x80, 0x0F, 0xF0, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x0C, 0x00, 0x03, 0xFC, 0x1F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFE,
  0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC7,
  0xFF, 0x80, 0x7F, 0x3F, 0xFF, 0x01, 0xF9, 0xFF, 0xFE, 0x0F, 0xEF, 0xFF,
  0xFC, 0x3F, 0x7F, 0xFF, 0xF9, 0xFF, 0xE0, 0x7F, 0xE7, 0xFE, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x07,
  0xF8, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0x7F, 0x07, 0xC0, 0x00, 0xFE, 0x0F, 0x80, 0x03, 0xF8, 0x20, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x7F,
  0xC0, 0x7F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xFB, 0xF8, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0xE0, 0x3F, 0xF9, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0xFC, 0x3F, 0xFF, 0xEF, 0xE0, 0xFF, 0xFE, 0x7E, 0x03,
  0xFF, 0xC7, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF1,
  0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F,
  0xF8, 0x3F, 0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x03,
  0xFD, 0xF0, 0x00, 0x3F, 0x86, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x3F,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF1, 0xF8, 0x07, 0xC3, 0xE3, 0xE0,
  0x3F, 0xE7, 0xC7, 0xC0, 0xFF, 0xEF, 0x9F, 0x83, 0xFF, 0xDF, 0x3F, 0x07,
  0xFF, 0xBE, 0x7C, 0x1F, 0xC3, 0xFC, 0xF8, 0x3F, 0x01, 0xFB, 0xF0, 0xFC,
  0x03, 0xE7, 0xE1, 0xF8, 0x07, 0xCF, 0xC3, 0xE0, 0x0F, 0x9F, 0x0F, 0xC0,
  0x1F, 0x3E, 0x1F, 0x80, 0x7E, 0x7C, 0x3F, 0x00, 0xFD, 0xF8, 0x7E, 0x01,
  0xF3, 0xF0, 0xF8, 0x03, 0xE7, 0xE1, 0xF0, 0x07, 0xCF, 0x83, 0xE0, 0x1F,
  0x9F, 0x07, 0xC0, 0x3F, 0x3E, 0x0F, 0x80, 0xFE, 0x7C, 0x1F, 0x83, 0xF8,
  0xF8, 0x3F, 0x9D, 0xF1, 0xF0, 0x7F, 0xFB, 0xE3, 0xE0, 0x7F, 0xE7, 0xC7,
  0xC0, 0xFF, 0xDF, 0x8F, 0x80, 0xFF, 0x3F, 0x1F, 0x00, 0x70, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F,
  0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xFC,
  0x07, 0xE0, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC,
  0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC,
  0x3F, 0x00, 0x03, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF8,
  0x3F, 0x00, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0xFE,
  0x00, 0x03, 0xE1, 0xFC, 0x00, 0x04, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x40, 0x7F, 0x00, 0x01, 0xE0, 0xFE, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07,
  0xF8, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xFC, 0x07,
  0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F,
  0x80, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x3F,
  0x00, 0x03, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x1F, 0xE0, 0x7E,
  0x00, 0x3F, 0xE0, 0x7E, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x03, 0xFC, 0x03,
  0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7C, 0x1F, 0xC0, 0x00, 0x40, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFC, 0x7F,
  0x00, 0xFF, 0xFC, 0x7F, 0x01, 0xFF, 0xFC, 0x7F, 0x01, 0xFF, 0xF8, 0xFF,
  0x01, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xF8, 0xFE, 0x00, 0x01, 0xF8, 0xFE,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F,
  0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x77, 0xE0, 0x1F, 0xFF, 0xF7, 0xE0, 0x0F,
  0xFF, 0xE7, 0xE0, 0x0F, 0xFF, 0xC7, 0xE0, 0x03, 0xFF, 0x87, 0xE0, 0x00,
  0xFE, 0x08, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x0F,
  0xE0, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01,
  0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x07, 0xE0, 0x3F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x80, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x1E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x7E, 0x00,
  0x07, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x7F,
  0x80, 0x03, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x03, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0x83, 0xFC, 0x00, 0x00, 0xFC, 0x3F,
  0xC0, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x03,
  0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xDF, 0xC0, 0x00, 0x1F, 0xFC, 0xFE, 0x00, 0x00, 0xFF, 0xC7, 0xF0, 0x00,
  0x07, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x0F, 0xC0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7E, 0xF8, 0x1F, 0x7C, 0x07, 0xEF,
  0x83, 0xF7, 0xC0, 0x7E, 0xF8, 0x3E, 0xFC, 0x07, 0xCF, 0x87, 0xEF, 0xC0,
  0x7C, 0xFC, 0x7C, 0xFC, 0x0F, 0xC7, 0xCF, 0x8F, 0xC0, 0xFC, 0x7C, 0xF8,
  0xF8, 0x0F, 0xC7, 0xDF, 0x0F, 0x80, 0xFC, 0x7F, 0xF1, 0xF8, 0x0F, 0xC3,
  0xFE, 0x1F, 0x80, 0xF8, 0x3F, 0xE1, 0xF8, 0x1F, 0x83, 0xFC, 0x1F, 0x81,
  0xF8, 0x3F, 0xC1, 0xF0, 0x1F, 0x83, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x03,
  0xF0, 0x1F, 0x81, 0xF0, 0x3F, 0x01, 0xF0, 0x1E, 0x03, 0xF0, 0x3F, 0x01,
  0xE0, 0x3F, 0x03, 0xF0, 0x0C, 0x03, 0xE0, 0x3F, 0x00, 0xC0, 0x7E, 0x03,
  0xF0, 0x08, 0x07, 0xE0, 0x3F, 0x00, 0x80, 0x7E, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0x00, 0x0F, 0xC0, 0x7F, 0xC0, 0x03, 0xF0, 0x3F, 0xF0, 0x00, 0xFC, 0x0F,
  0xFC, 0x00, 0x3E, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0xFF, 0xE0, 0x07, 0xE0,
  0x3F, 0xF8, 0x01, 0xF8, 0x0F, 0xFE, 0x00, 0x7E, 0x07, 0xFF, 0x80, 0x1F,
  0x81, 0xFB, 0xE0, 0x07, 0xC0, 0x7E, 0xFC, 0x03, 0xF0, 0x1F, 0xBF, 0x00,
  0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0xC0, 0xFC, 0x7C,
  0x03, 0xF0, 0x3F, 0x1F, 0x80, 0xF8, 0x0F, 0xC7, 0xE0, 0x7E, 0x03, 0xF1,
  0xF8, 0x1F, 0x80, 0xFC, 0x3E, 0x07, 0xE0, 0x3E, 0x0F, 0x81, 0xF8, 0x1F,
  0x83, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0x01, 0xF8, 0x3F, 0x0F, 0xC0,
  0x7E, 0x07, 0xC3, 0xF0, 0x1F, 0x81, 0xF0, 0xFC, 0x07, 0xC0, 0x7E, 0x3F,
  0x03, 0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x07, 0xE3, 0xE0, 0x3F, 0x00, 0xF9,
  0xF8, 0x0F, 0xC0, 0x3F, 0x7E, 0x03, 0xF0, 0x0F, 0xDF, 0x80, 0xF8, 0x03,
  0xF7, 0xE0, 0x7E, 0x00, 0xFD, 0xF8, 0x1F, 0x80, 0x1F, 0xFC, 0x07, 0xE0,
  0x07, 0xFF, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7E, 0x00, 0x7F, 0xF0, 0x1F,
  0x00, 0x1F, 0xFC, 0x0F, 0xC0, 0x03, 0xFF, 0x03, 0xF0, 0x00, 0xFF, 0x80,
  0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xC0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x01, 0xFF, 0x07, 0xF0, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0xFF, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x07,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x7E, 0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x30, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x01,
  0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x01,
  0xFE, 0x1F, 0xC0, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0x80,
  0xFE, 0x00, 0x01, 0x80, 0x7F, 0x00, 0x00, 0x40, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x08, 0x00, 0x00, 0xFE, 0x02, 0x00, 0x00, 0x3F, 0x83, 0xC0, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x3F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F,
  0x1F, 0x80, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x7F, 0x01, 0xF0, 0x3E, 0x03, 0xF8, 0x0F, 0x81, 0xF0, 0x3F, 0xC0,
  0xFC, 0x0F, 0x81, 0xFE, 0x07, 0xE0, 0xFC, 0x0F, 0xF0, 0x3E, 0x07, 0xE0,
  0xFF, 0x81, 0xF0, 0x3F, 0x07, 0xFC, 0x1F, 0x81, 0xF8, 0x3D, 0xE0, 0xFC,
  0x0F, 0xC3, 0xEF, 0x07, 0xC0, 0x7E, 0x1E, 0x78, 0x3E, 0x03, 0xE0, 0xF3,
  0xC3, 0xF0, 0x1F, 0x0F, 0x9E, 0x1F, 0x80, 0xF8, 0x78, 0xF0, 0xF8, 0x07,
  0xC3, 0xC7, 0x87, 0xC0, 0x7E, 0x3E, 0x3C, 0x3E, 0x03, 0xF1, 0xE1, 0xE3,
  0xF0, 0x1F, 0x8F, 0x0F, 0x1F, 0x80, 0xFC, 0xF8, 0x78, 0xF8, 0x07, 0xE7,
  0x83, 0xC7, 0xC0, 0x3F, 0x3C, 0x1E, 0x7E, 0x01, 0xF3, 0xE0, 0xF3, 0xF0,
  0x0F, 0x9E, 0x07, 0x9F, 0x00, 0x7C, 0xF0, 0x3C, 0xF8, 0x03, 0xEF, 0x81,
  0xF7, 0xC0, 0x1F, 0x78, 0x0F, 0xFE, 0x01, 0xFB, 0xC0, 0x7F, 0xE0, 0x0F,
  0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x07, 0xF3,
  0xFC, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x01, 0xFE, 0x3F,
  0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07,
  0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0,
  0x0F, 0xF0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFE,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x01,
  0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x03,
  0xF1, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x30,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x04, 0x07,
  0x87, 0xE3, 0xF8, 0x7F, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0x7C,
  0x1F, 0x02, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x83, 0xF0, 0x1F,
  0xFF, 0x9F, 0xC0, 0xFF, 0xFE, 0x7F, 0x07, 0xFF, 0xFD, 0xFC, 0x3F, 0xE0,
  0x77, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x03,
  0xF8, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFC,
  0x7F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F,
  0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x3F, 0x8F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0xC3, 0xF8, 0x01, 0xBF, 0x07, 0xF0, 0x0F, 0xFC, 0x1F, 0xE0, 0xF7, 0xFF,
  0x7F, 0xFF, 0x9F, 0xF8, 0xFF, 0xFE, 0x3F, 0xE1, 0xFF, 0xF0, 0xFF, 0x83,
  0xFF, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFE, 0x1F,
  0xFC, 0x01, 0xFC, 0x7F, 0xFC, 0x03, 0xF9, 0xFF, 0xFC, 0x07, 0xE7, 0xFF,
  0xFC, 0x0F, 0xDE, 0x07, 0xF8, 0x1F, 0xB8, 0x07, 0xF0, 0x7F, 0xE0, 0x07,
  0xF0, 0xFF, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFC,
  0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7E, 0x3F,
  0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFE, 0x1F, 0xF0,
  0x03, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x7E, 0x7F, 0xFF, 0xC0, 0xFC, 0xFF,
  0xFF, 0x01, 0xF8, 0xFF, 0xFC, 0x07, 0xF0, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0x81, 0xFE, 0x0F,
  0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0x83, 0xF8, 0x00,
  0x20, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x30, 0xFE, 0x00, 0x03, 0xCF, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x3F,
  0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xFF, 0x87, 0xF0, 0x07, 0xFF, 0xE3, 0xF0,
  0x07, 0xFF, 0xF9, 0xF8, 0x07, 0xFF, 0xFC, 0xFC, 0x07, 0xFC, 0x0F, 0xFE,
  0x07, 0xF8, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0xFC, 0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xFE, 0x07, 0xF0, 0x03, 0xFF, 0x01, 0xFC,
  0x03, 0xBF, 0x00, 0xFF, 0x07, 0xDF, 0x80, 0x7F, 0xFF, 0xCF, 0xC0, 0x1F,
  0xFF, 0xCF, 0xE0, 0x07, 0xFF, 0xC7, 0xF0, 0x01, 0xFF, 0xC3, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0,
  0xFF, 0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0x7E, 0x00,
  0x0F, 0xF7, 0xE0, 0x03, 0xFE, 0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0x0F, 0xE0, 0x00, 0x3C, 0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFE, 0x7F,
  0x00, 0x1F, 0xC3, 0xFC, 0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x18,
  0x03, 0xF8, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x1F, 0xE7,
  0xE0, 0x00, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x1F, 0xC0, 0x1F, 0xFF, 0x8F, 0xC0, 0x1F, 0xFF,
  0xE7, 0xE0, 0x1F, 0xFF, 0xF3, 0xF0, 0x1F, 0xF0, 0x3F, 0xF8, 0x1F, 0xE0,
  0x07, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xF0,
  0x3F, 0x80, 0x0F, 0xF8, 0x0F, 0xE0, 0x1D, 0xFC, 0x07, 0xF8, 0x1E, 0xFC,
  0x01, 0xFF, 0xFE, 0x7E, 0x00, 0xFF, 0xFE, 0x3F, 0x00, 0x3F, 0xFE, 0x1F,
  0x80, 0x0F, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x40, 0x00, 0xFE, 0x00, 0x70, 0x00,
  0xFE, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x07, 0xF0, 0x03, 0xF0, 0xFF, 0xE0, 0x1F, 0x8F, 0xFF, 0x81, 0xFC, 0xFF,
  0xFC, 0x0F, 0xEF, 0xFF, 0xF0, 0x7E, 0x70, 0x7F, 0x83, 0xF7, 0x01, 0xFE,
  0x1F, 0xB0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0x7F,
  0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFC, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F,
  0x1F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF8, 0xFE, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F,
  0x1F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x10, 0x01,
  0xFC, 0x01, 0x80, 0x1F, 0xC0, 0x3E, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0x81,
  0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0x9F, 0xC0, 0x03, 0xF3, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x10, 0x03, 0xF8, 0x01, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xE7, 0xE0, 0x00, 0x7F, 0x3F, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07,
  0xE0, 0xFF, 0xC0, 0x07, 0xE3, 0xFF, 0xE0, 0x0F, 0xE7, 0xFF, 0xF0, 0x0F,
  0xEF, 0xFF, 0xF0, 0x0F, 0xCE, 0x0F, 0xF8, 0x0F, 0xDC, 0x03, 0xF8, 0x0F,
  0xD8, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xF8, 0x1F, 0xE0, 0x01, 0xF8, 0x1F,
  0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x1F,
  0x80, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x1F, 0xF0, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7F,
  0x0F, 0xE0, 0x18, 0x7F, 0x0F, 0xE0, 0x3E, 0x7E, 0x07, 0xE0, 0x7F, 0x7E,
  0x07, 0xF0, 0xFE, 0x7E, 0x03, 0xF1, 0xFC, 0xFE, 0x03, 0xFB, 0xF8, 0xFE,
  0x01, 0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0xC0, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x40,
  0x1F, 0xC0, 0x18, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xF0, 0xFE, 0x07,
  0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0xFE, 0x00, 0xFC,
  0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x1F, 0x00, 0xFC, 0xFE, 0x0F, 0xF0, 0x1F, 0xBF, 0xE3, 0xFF, 0x03,
  0xEF, 0xFC, 0x7F, 0xE0, 0x7D, 0xFF, 0xDF, 0xFE, 0x0F, 0xF1, 0xFB, 0x1F,
  0xC3, 0xF8, 0x3F, 0xC1, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0x0F, 0xC0, 0xFE,
  0x07, 0xE1, 0xF8, 0x1F, 0x80, 0xF8, 0x3E, 0x03, 0xF0, 0x1F, 0x07, 0xC0,
  0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0x80, 0x7C, 0x3F, 0x01, 0xF0, 0x1F, 0x87,
  0xC0, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0xC0, 0x7E, 0x1F, 0x01, 0xF8, 0x0F,
  0x83, 0xE0, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0xF8,
  0x0F, 0xC3, 0xE0, 0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xE0, 0x3F, 0x0F, 0x80,
  0xFC, 0x07, 0xC1, 0xF0, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xE0, 0x1F, 0x0F,
  0xC0, 0x7C, 0x07, 0xE1, 0xF8, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0x1F,
  0x87, 0xC0, 0x7E, 0x03, 0xE0, 0xF8, 0x0F, 0xC0, 0x7C, 0x3F, 0x01, 0xF0,
  0x0F, 0x87, 0xE0, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x0F,
  0xFE, 0x01, 0xF8, 0xFF, 0xF8, 0x1F, 0xCF, 0xFF, 0xC0, 0xFE, 0xFF, 0xFF,
  0x07, 0xE7, 0x07, 0xF8, 0x3F, 0x70, 0x1F, 0xE1, 0xFB, 0x00, 0x7F, 0x0F,
  0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x8F,
  0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x80,
  0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xF8,
  0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7F, 0x7F,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x1F, 0xFC, 0x00, 0x7F, 0x1F, 0xFF, 0x00, 0x3F, 0x9F, 0xFF, 0xC0, 0x1F,
  0x9F, 0xFF, 0xF0, 0x0F, 0xDE, 0x07, 0xF8, 0x07, 0xEE, 0x01, 0xFC, 0x07,
  0xFE, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8,
  0x3F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0x01, 0xF9, 0xFF, 0xFF, 0x00, 0xFC, 0xFF, 0xFF, 0x00, 0x7E, 0x3F,
  0xFF, 0x00, 0x7F, 0x0F, 0xFF, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFF, 0xE1, 0xFC, 0x07, 0xFF, 0xE3, 0xF0, 0x1F, 0xFF, 0xE7, 0xE0,
  0x7F, 0xFF, 0xCF, 0xC1, 0xFF, 0x03, 0xFF, 0x87, 0xF8, 0x01, 0xFF, 0x0F,
  0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xC0,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0x3F, 0x8F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xE1, 0xFC, 0x00, 0xFF,
  0xC1, 0xFC, 0x03, 0xBF, 0x03, 0xFC, 0x1F, 0x7E, 0x07, 0xFF, 0xFC, 0xFC,
  0x07, 0xFF, 0xF3, 0xF8, 0x07, 0xFF, 0xC7, 0xF0, 0x07, 0xFF, 0x0F, 0xE0,
  0x03, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0xFE, 0x03, 0xFD, 0xFF, 0xF8, 0x3F, 0xE7, 0xFF, 0xE1, 0xFF, 0xBF, 0xFF,
  0x8F, 0xFE, 0xFF, 0xFE, 0x7F, 0xF8, 0x03, 0xFB, 0xFF, 0xE0, 0x0F, 0xCE,
  0x00, 0x00, 0x3F, 0x70, 0x00, 0x00, 0xFD, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x83, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0x81, 0xFC, 0x00,
  0x18, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x10,
  0x00, 0x07, 0xE1, 0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF1, 0xFF, 0x80,
  0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x40, 0x0F, 0xE0, 0x07,
  0x00, 0x7F, 0x00, 0x7C, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0xFF, 0x00,
  0xFC, 0x0F, 0xF0, 0x07, 0xE1, 0xFF, 0x00, 0x3F, 0x1F, 0xE0, 0x01, 0xF9,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0xFE, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x7E, 0x3F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xFC,
  0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF1, 0xFC,
  0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x7E, 0x3F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC,
  0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE,
  0x00, 0xFF, 0x87, 0xF8, 0x0E, 0xFC, 0x1F, 0xE0, 0xE7, 0xE0, 0xFF, 0xFF,
  0x7F, 0x03, 0xFF, 0xF3, 0xF8, 0x1F, 0xFF, 0x1F, 0x80, 0x7F, 0xF0, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x31, 0xFF, 0xE0, 0x07, 0xC7,
  0xFF, 0x80, 0x7F, 0x9F, 0xFE, 0x00, 0xFE, 0xFF, 0xF8, 0x03, 0xFB, 0xFF,
  0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF0,
  0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xE0,
  0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F,
  0x00, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0,
  0x7F, 0x80, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x3F, 0xE0, 0x07, 0xE3, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x06,
  0x1F, 0x80, 0xF8, 0x3E, 0x1F, 0x80, 0xF8, 0x3E, 0x1F, 0x81, 0xF8, 0x3F,
  0x1F, 0x01, 0xF8, 0x3F, 0x1F, 0x01, 0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0x1F,
  0x3F, 0x01, 0xF0, 0x1F, 0x3F, 0x01, 0xF0, 0x1F, 0x3F, 0x03, 0xF0, 0x1F,
  0x3E, 0x03, 0xF0, 0x1F, 0x3E, 0x03, 0xE0, 0x1F, 0x3E, 0x03, 0xE0, 0x1F,
  0x7E, 0x03, 0xE0, 0x1F, 0x7E, 0x03, 0xE0, 0x1F, 0x7E, 0x07, 0xE0, 0x3F,
  0x7C, 0x07, 0xE0, 0x3F, 0x7C, 0x07, 0xE0, 0x3E, 0x7C, 0x07, 0xC0, 0x3E,
  0xFC, 0x07, 0xC0, 0x3E, 0xFC, 0x07, 0xC0, 0x7E, 0xFC, 0x0F, 0xC0, 0x7C,
  0xF8, 0x0F, 0xC0, 0x7C, 0xF8, 0x0F, 0xC0, 0xFC, 0xF8, 0x1F, 0xC0, 0xF8,
  0xF8, 0x3F, 0xC1, 0xF8, 0xFC, 0x77, 0xC1, 0xF0, 0xFF, 0xF7, 0xC7, 0xE0,
  0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03, 0xFC, 0x07,
  0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF,
  0xF1, 0xFF, 0xE0, 0xFF, 0x9F, 0x3C, 0x7F, 0x1F, 0xE1, 0xF3, 0x83, 0xF3,
  0xFC, 0x1F, 0x70, 0x3F, 0x1F, 0x01, 0xF7, 0x03, 0xF0, 0xE0, 0x1F, 0x60,
  0x3F, 0x08, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xF8, 0x02, 0x0F,
  0xC0, 0x6F, 0x80, 0x70, 0xFC, 0x0E, 0xF8, 0x1F, 0x8F, 0xC0, 0xEF, 0x83,
  0xFC, 0xFC, 0x1C, 0xF8, 0xFF, 0x8F, 0xE3, 0xCF, 0xDF, 0xE0, 0x7F, 0xFC,
  0xFF, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x03,
  0xFE, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01,
  0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xF8, 0x1F, 0xC0, 0x0F, 0xF8, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xE0, 0x3B,
  0xF0, 0x0F, 0xF0, 0x7B, 0xF0, 0x0F, 0xFF, 0xF3, 0xF0, 0x07, 0xFF, 0xE7,
  0xF0, 0x07, 0xFF, 0xC7, 0xF0, 0x03, 0xFF, 0x87, 0xE0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x18, 0x00, 0x3F,
  0x80, 0x3C, 0x00, 0x7F, 0x80, 0x7F, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x3F, 0x03, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0xFE, 0x3F, 0x07, 0xFF, 0xFF,
  0x3F, 0x0F, 0xE0, 0xFF, 0xFE, 0x0F, 0xC0, 0x1F, 0xFE, 0x0F, 0x80, 0x07,
  0xFC, 0x0F, 0x80, 0x07, 0xF8, 0x0F, 0x80, 0x0F, 0xF0, 0x1F, 0x00, 0x1F,
  0xC0, 0x1F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x20, 0x00, 0x7F, 0x80,
  0x70, 0x00, 0xFE, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xF8, 0x03, 0xF8, 0x00,
  0xF8, 0x07, 0xF0, 0x00, 0xF8, 0x1F, 0xE0, 0x00, 0xFC, 0x3F, 0xF8, 0x00,
  0x7C, 0x7F, 0xFF, 0xC0, 0x7C, 0x7F, 0xFF, 0xFC, 0x7C, 0x7E, 0x7F, 0xFF,
  0xFC, 0x7E, 0x0F, 0xFF, 0xF8, 0xFC, 0x03, 0xFF, 0xF8, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0C, 0x01,
  0xFF, 0x00, 0x0F, 0xC1, 0xFF, 0xC0, 0x07, 0xC1, 0xFF, 0xF0, 0x03, 0xE0,
  0xFF, 0xFC, 0x03, 0xF0, 0xFC, 0x7E, 0x01, 0xF0, 0xFC, 0x1F, 0x81, 0xF8,
  0x7C, 0x07, 0xE0, 0xF8, 0x7E, 0x03, 0xF8, 0xFC, 0x3E, 0x00, 0xFF, 0xFC,
  0x1F, 0x00, 0x7F, 0xFC, 0x1F, 0x80, 0x1F, 0xFC, 0x0F, 0x80, 0x07, 0xFC,
  0x00, 0xC0, 0x00, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 15, 43, 36, 11, -42 },
  { 82, 21, 18, 36, 11, -44 },
  { 130, 37, 42, 36, 0, -42 },
  { 325, 34, 56, 36, 1, -49 },
  { 563, 42, 44, 36, -2, -43 },
  { 794, 36, 44, 36, 0, -43 },
  { 992, 9, 18, 36, 17, -44 },
  { 1013, 24, 54, 36, 11, -46 },
  { 1175, 24, 54, 36, 2, -46 },
  { 1337, 31, 30, 36, 3, -33 },
  { 1454, 29, 29, 36, 4, -33 },
  { 1560, 16, 18, 36, 7, -9 },
  { 1596, 19, 6, 36, 9, -21 },
  { 1611, 10, 10, 36, 11, -9 },
  { 1624, 35, 54, 36, 1, -46 },
  { 1861, 32, 44, 36, 3, -43 },
  { 2037, 29, 42, 36, 3, -42 },
  { 2190, 33, 43, 36, 1, -43 },
  { 2368, 33, 44, 36, 1, -43 },
  { 2550, 33, 42, 36, 1, -42 },
  { 2724, 33, 43, 36, 2, -42 },
  { 2902, 30, 43, 36, 3, -42 },
  { 3064, 31, 42, 36, 5, -42 },
  { 3227, 33, 44, 36, 2, -43 },
  { 3409, 29, 43, 36, 5, -43 },
  { 3565, 14, 32, 36, 11, -31 },
  { 3621, 18, 40, 36, 7, -31 },
  { 3711, 29, 35, 36, 5, -36 },
  { 3838, 31, 18, 36, 3, -27 },
  { 3908, 29, 35, 36, 3, -36 },
  { 4035, 27, 44, 36, 7, -43 },
  { 4184, 31, 50, 36, 3, -43 },
  { 4378, 33, 42, 36, -1, -42 },
  { 4552, 32, 42, 36, 2, -42 },
  { 4720, 31, 44, 36, 4, -43 },
  { 4891, 32, 42, 36, 3, -42 },
  { 5059, 33, 42, 36, 3, -42 },
  { 5233, 33, 42, 36, 3, -42 },
  { 5407, 32, 44, 36, 3, -43 },
  { 5583, 34, 42, 36, 2, -42 },
  { 5762, 34, 42, 36, 2, -42 },
  { 5941, 31, 43, 36, 3, -42 },
  { 6108, 37, 42, 36, 2, -42 },
  { 6303, 27, 42, 36, 4, -42 },
  { 6445, 36, 42, 36, 1, -42 },
  { 6634, 34, 42, 36, 2, -42 },
  { 6813, 32, 44, 36, 3, -43 },
  { 6989, 32, 42, 36, 3, -42 },
  { 7157, 32, 55, 36, 3, -43 },
  { 7377, 32, 42, 36, 3, -42 },
  { 7545, 34, 44, 36, 1, -43 },
  { 7732, 34, 42, 36, 5, -42 },
  { 7911, 32, 43, 36, 4, -42 },
  { 8083, 33, 42, 36, 6, -42 },
  { 8257, 37, 42, 36, 2, -42 },
  { 8452, 40, 42, 36, -1, -42 },
  { 8662, 35, 42, 36, 5, -42 },
  { 8846, 37, 42, 36, 0, -42 },
  { 9041, 26, 54, 36, 9, -46 },
  { 9217, 17, 54, 36, 10, -46 },
  { 9332, 27, 54, 36, 1, -46 },
  { 9515, 31, 25, 36, 3, -42 },
  { 9612, 29, 6, 36, 0, 5 },
  { 9634, 10, 13, 36, 12, -48 },
  { 9651, 30, 33, 36, 3, -32 },
  { 9775, 31, 45, 36, 2, -44 },
  { 9950, 28, 33, 36, 4, -32 },
  { 10066, 33, 45, 36, 3, -44 },
  { 10252, 28, 33, 36, 4, -32 },
  { 10368, 40, 57, 36, -1, -44 },
  { 10653, 33, 45, 36, 1, -32 },
  { 10839, 29, 44, 36, 3, -44 },
  { 10999, 28, 46, 36, 5, -45 },
  { 11160, 29, 58, 36, 2, -45 },
  { 11371, 32, 45, 36, 3, -44 },
  { 11551, 26, 45, 36, 6, -44 },
  { 11698, 35, 32, 36, 0, -32 },
  { 11838, 29, 32, 36, 3, -32 },
  { 11954, 30, 33, 36, 3, -32 },
  { 12078, 33, 44, 36, 0, -32 },
  { 12260, 31, 44, 36, 3, -32 },
  { 12431, 30, 31, 36, 6, -31 },
  { 12548, 29, 33, 36, 3, -32 },
  { 12668, 29, 43, 36, 4, -42 },
  { 12824, 29, 32, 36, 4, -31 },
  { 12940, 30, 33, 36, 3, -32 },
  { 13064, 32, 32, 36, 2, -31 },
  { 13192, 36, 33, 36, 0, -32 },
  { 13341, 32, 44, 36, 1, -31 },
  { 13517, 32, 33, 36, 2, -32 },
  { 13649, 29, 54, 36, 6, -46 },
  { 13845, 15, 54, 36, 11, -46 },
  { 13947, 29, 54, 36, 2, -46 },
  { 14143, 33, 14, 36, 2, -25 },
};

const GFXfont IBMPlexMono_MediumItalic60pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic60pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic60pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _IBMPLEXMONO_MEDIUMITALIC60PT7B_H_
