#ifndef _IBMPLEXMONO_MEDIUMITALIC14PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xA4, 0x90, 0xD8, 0xD9, 0x9B, 0x09, 0x05, 0x86, 0x8E, 0x71,
  0x61, 0xA3, 0x9C, 0x58, 0x68, 0x2C, 0x00, 0x04, 0x1E, 0x2D, 0x68, 0x68,
  0x38, 0x0E, 0x0B, 0x0B, 0xD2, 0x7C, 0x10, 0x38, 0xA4, 0x92, 0x89, 0x47,
  0x40, 0x38, 0xE4, 0xD2, 0x49, 0x47, 0x00, 0x1E, 0x32, 0x32, 0x32, 0x14,
  0x78, 0xC8, 0xC9, 0xD5, 0x76, 0x7E, 0x19, 0x18, 0x8C, 0x42, 0x10, 0x84,
  0x20, 0x86, 0x00, 0x10, 0x20, 0xC1, 0x04, 0x10, 0x43, 0x08, 0x21, 0x0C,
  0xE0, 0x18, 0x23, 0x5B, 0xE3, 0x09, 0x33, 0x00, 0x18, 0x20, 0x47, 0xF3,
  0x06, 0x08, 0x00, 0x6B, 0x40, 0xF8, 0xF0, 0x01, 0x03, 0x02, 0x06, 0x04,
  0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0xC0, 0x3C, 0xCD, 0x0E, 0x1D,
  0x76, 0xE1, 0xC2, 0xCC, 0xF0, 0x1C, 0xA4, 0xA6, 0x18, 0x61, 0x04, 0x13,
  0xF0, 0x1E, 0x23, 0x63, 0x03, 0x02, 0x04, 0x18, 0x30, 0x60, 0xFE, 0x1E,
  0x23, 0x03, 0x02, 0x1C, 0x06, 0x02, 0x02, 0xC6, 0x7C, 0x07, 0x0E, 0x0A,
  0x12, 0x36, 0x66, 0xC6, 0xFF, 0x04, 0x0C, 0x3F, 0x20, 0x20, 0x20, 0x3E,
  0x62, 0x03, 0x02, 0x46, 0xFC, 0x0C, 0x61, 0x83, 0x0D, 0xDC, 0xE1, 0xC3,
  0xCC, 0xF0, 0x7F, 0x46, 0xC6, 0x0C, 0x0C, 0x18, 0x10, 0x30, 0x20, 0x60,
  0x1E, 0x33, 0x21, 0x23, 0x1C, 0x62, 0x43, 0xC3, 0x46, 0x3C, 0x3C, 0x8F,
  0x0E, 0x3C, 0x6F, 0xC3, 0x04, 0x31, 0xC0, 0x7C, 0x01, 0xB0, 0x37, 0x00,
  0x06, 0x4C, 0x80, 0x02, 0x1C, 0xE7, 0x0C, 0x06, 0x07, 0x02, 0xFE, 0x00,
  0x07, 0xE0, 0x41, 0xC1, 0x83, 0x0C, 0xEE, 0x20, 0x7B, 0x30, 0xC3, 0x39,
  0xC6, 0x00, 0xE3, 0x00, 0x3C, 0xCD, 0x0E, 0xDB, 0x74, 0xE9, 0xD2, 0xBD,
  0x03, 0x03, 0xC0, 0x0C, 0x0C, 0x1E, 0x16, 0x36, 0x26, 0x7E, 0x42, 0xC2,
  0xC3, 0x7C, 0x8D, 0x1A, 0x2F, 0x98, 0xB1, 0x43, 0x8D, 0xF0, 0x3C, 0xCD,
  0x16, 0x0C, 0x18, 0x20, 0x62, 0xCE, 0xF0, 0x7C, 0x8D, 0x1A, 0x1C, 0x78,
  0xF1, 0xE2, 0x8D, 0xF0, 0x7E, 0x81, 0x02, 0x0F, 0xD8, 0x30, 0x60, 0x81,
  0xF8, 0x7F, 0x40, 0x40, 0x40, 0xFC, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x3C,
  0xCD, 0x16, 0x0C, 0x13, 0xE1, 0x42, 0xCC, 0xF8, 0x31, 0x21, 0x23, 0x63,
  0x7F, 0x63, 0x42, 0x42, 0x46, 0xC6, 0x7E, 0x30, 0x60, 0x81, 0x02, 0x0C,
  0x18, 0x31, 0xF8, 0x3E, 0x0C, 0x18, 0x20, 0x41, 0x83, 0x06, 0x89, 0xE0,
  0x31, 0x91, 0x89, 0x85, 0x87, 0x83, 0xE1, 0xB0, 0x8C, 0x46, 0x61, 0x80,
  0x61, 0x86, 0x18, 0x41, 0x04, 0x30, 0xC3, 0xF0, 0x33, 0x99, 0x9D, 0xCE,
  0xA5, 0x92, 0x59, 0x4C, 0x84, 0xC2, 0x61, 0x00, 0x31, 0x31, 0x39, 0x7B,
  0x6B, 0x6B, 0x4A, 0x4E, 0x4E, 0xC6, 0x3C, 0xCD, 0x0E, 0x1C, 0x70, 0xE1,
  0xC2, 0xCC, 0xF0, 0x7C, 0x8D, 0x0A, 0x1C, 0x7F, 0xB0, 0x60, 0x81, 0x00,
  0x3C, 0xCD, 0x0E, 0x1C, 0x70, 0xE1, 0xC2, 0xCC, 0xF0, 0xC0, 0xB0, 0xC0,
  0x7C, 0x8D, 0x0A, 0x1C, 0x7F, 0xB6, 0x64, 0x8D, 0x18, 0x1E, 0x31, 0x60,
  0x60, 0x38, 0x06, 0x03, 0x02, 0xC6, 0x7C, 0xFF, 0x18, 0x18, 0x10, 0x10,
  0x10, 0x30, 0x30, 0x30, 0x20, 0x62, 0x85, 0x1E, 0x3C, 0x78, 0xF1, 0x42,
  0xCC, 0xF0, 0xC3, 0x42, 0x46, 0x46, 0x44, 0x4C, 0x68, 0x78, 0x70, 0x70,
  0x60, 0xB0, 0xD3, 0x49, 0xA5, 0x52, 0xA9, 0x5C, 0xCC, 0x66, 0x73, 0x00,
  0x61, 0x99, 0x85, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x4C, 0x66, 0x61, 0x80,
  0xC3, 0x42, 0x66, 0x6C, 0x28, 0x30, 0x30, 0x30, 0x30, 0x20, 0x3F, 0x81,
  0x81, 0x80, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x7F, 0x00, 0x3C, 0x82,
  0x08, 0x61, 0x04, 0x10, 0x41, 0x0C, 0x30, 0xF0, 0xC4, 0x44, 0x62, 0x22,
  0x23, 0x11, 0x10, 0x3C, 0x10, 0x41, 0x0C, 0x30, 0x82, 0x08, 0x20, 0x86,
  0xF0, 0x18, 0x78, 0x93, 0x2C, 0x70, 0x40, 0xFE, 0xB4, 0x77, 0x9B, 0x14,
  0x28, 0xD1, 0xBF, 0x80, 0x60, 0xC1, 0x02, 0xE6, 0x78, 0xF1, 0xC2, 0xCD,
  0x70, 0x3D, 0x1C, 0x30, 0x87, 0x37, 0x80, 0x02, 0x04, 0x1B, 0xFC, 0x78,
  0xA1, 0x46, 0x8D, 0xF8, 0x3C, 0x8F, 0x17, 0xC8, 0x99, 0x9E, 0x00, 0x07,
  0x82, 0x03, 0x07, 0xF0, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x24, 0x0A,
  0x07, 0x00, 0x3F, 0x63, 0x62, 0x42, 0x46, 0x46, 0x7E, 0x06, 0x44, 0xF8,
  0x61, 0x84, 0x17, 0x67, 0x1C, 0x71, 0x8E, 0x30, 0x18, 0x30, 0x07, 0x83,
  0x06, 0x0C, 0x13, 0x28, 0x60, 0x06, 0x0C, 0x01, 0xF0, 0x40, 0x81, 0x06,
  0x0C, 0x1B, 0x23, 0x43, 0x80, 0x60, 0xC1, 0x02, 0xE6, 0x58, 0xB2, 0x78,
  0x97, 0x38, 0xF8, 0x43, 0x0C, 0x30, 0x82, 0x19, 0x69, 0xC0, 0x7B, 0x6D,
  0x49, 0x49, 0xDB, 0xD2, 0x92, 0x5D, 0x9C, 0x71, 0xC6, 0x38, 0xC0, 0x3C,
  0x8B, 0x1C, 0x38, 0x59, 0x9E, 0x00, 0x2E, 0x33, 0x63, 0x63, 0x42, 0x66,
  0x5C, 0x40, 0xC0, 0xC0, 0x7F, 0x8F, 0x14, 0x28, 0xD1, 0xBF, 0x06, 0x08,
  0x10, 0x77, 0x70, 0xC1, 0x02, 0x04, 0x18, 0x00, 0x3C, 0x8D, 0x03, 0xC0,
  0xD1, 0xBE, 0x00, 0x10, 0x20, 0xC7, 0xF2, 0x04, 0x08, 0x32, 0x68, 0xE0,
  0x46, 0x8F, 0x16, 0x2C, 0xD9, 0x9F, 0x00, 0xE4, 0xCD, 0x1A, 0x24, 0xDB,
  0x1C, 0x00, 0x6B, 0x49, 0x49, 0x49, 0x59, 0xEA, 0x6C, 0x33, 0x5D, 0x09,
  0x18, 0x98, 0xAB, 0xEC, 0x23, 0x23, 0x62, 0x62, 0x66, 0x66, 0x3E, 0x04,
  0x8C, 0x78, 0x3F, 0x66, 0x04, 0x18, 0x32, 0x72, 0xDE, 0x1E, 0x20, 0x40,
  0xC0, 0x81, 0x1C, 0x48, 0x18, 0x60, 0x83, 0x03, 0x80, 0x25, 0xA4, 0x92,
  0xD2, 0x48, 0x3C, 0x08, 0x10, 0x61, 0x83, 0x01, 0x8C, 0x10, 0x30, 0x60,
  0xCF, 0x00, 0x31, 0x4B, 0xCE,
};

const GFXglyph IBMPlexMono_MediumItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 10, 8, 3, -10 },
  { 5, 4, 4, 8, 3, -10 },
  { 7, 9, 10, 8, 0, -10 },
  { 19, 8, 12, 8, 0, -11 },
  { 31, 9, 10, 8, 0, -10 },
  { 43, 8, 10, 8, 0, -10 },
  { 53, 2, 4, 8, 4, -10 },
  { 54, 5, 13, 8, 3, -11 },
  { 63, 6, 13, 8, 0, -11 },
  { 73, 7, 7, 8, 1, -8 },
  { 80, 7, 7, 8, 1, -8 },
  { 87, 3, 4, 8, 2, -2 },
  { 89, 5, 1, 8, 2, -5 },
  { 90, 2, 2, 8, 3, -2 },
  { 91, 8, 13, 8, 0, -11 },
  { 104, 7, 10, 8, 1, -10 },
  { 113, 6, 10, 8, 1, -10 },
  { 121, 8, 10, 8, 0, -10 },
  { 131, 8, 10, 8, 0, -10 },
  { 141, 8, 10, 8, 0, -10 },
  { 151, 8, 10, 8, 0, -10 },
  { 161, 7, 10, 8, 1, -10 },
  { 170, 8, 10, 8, 1, -10 },
  { 180, 8, 10, 8, 0, -10 },
  { 190, 7, 10, 8, 1, -10 },
  { 199, 3, 7, 8, 3, -7 },
  { 202, 4, 9, 8, 2, -7 },
  { 207, 7, 8, 8, 1, -8 },
  { 214, 7, 4, 8, 1, -6 },
  { 218, 6, 8, 8, 1, -8 },
  { 224, 6, 10, 8, 2, -10 },
  { 232, 7, 12, 8, 1, -10 },
  { 243, 8, 10, 8, 0, -10 },
  { 253, 7, 10, 8, 1, -10 },
  { 262, 7, 10, 8, 1, -10 },
  { 271, 7, 10, 8, 1, -10 },
  { 280, 7, 10, 8, 1, -10 },
  { 289, 8, 10, 8, 1, -10 },
  { 299, 7, 10, 8, 1, -10 },
  { 308, 8, 10, 8, 0, -10 },
  { 318, 7, 10, 8, 1, -10 },
  { 327, 7, 10, 8, 1, -10 },
  { 336, 9, 10, 8, 0, -10 },
  { 348, 6, 10, 8, 1, -10 },
  { 356, 9, 10, 8, 0, -10 },
  { 368, 8, 10, 8, 0, -10 },
  { 378, 7, 10, 8, 1, -10 },
  { 387, 7, 10, 8, 1, -10 },
  { 396, 7, 13, 8, 1, -10 },
  { 408, 7, 10, 8, 1, -10 },
  { 417, 8, 10, 8, 0, -10 },
  { 427, 8, 10, 8, 1, -10 },
  { 437, 7, 10, 8, 1, -10 },
  { 446, 8, 10, 8, 1, -10 },
  { 456, 9, 10, 8, 0, -10 },
  { 468, 9, 10, 8, 0, -10 },
  { 480, 8, 10, 8, 1, -10 },
  { 490, 9, 10, 8, 0, -10 },
  { 502, 6, 13, 8, 2, -11 },
  { 512, 4, 13, 8, 2, -11 },
  { 519, 6, 13, 8, 0, -11 },
  { 529, 7, 6, 8, 1, -10 },
  { 535, 7, 1, 8, 0, 1 },
  { 536, 2, 3, 8, 3, -11 },
  { 537, 7, 7, 8, 1, -7 },
  { 544, 7, 10, 8, 1, -10 },
  { 553, 6, 7, 8, 1, -7 },
  { 559, 7, 10, 8, 1, -10 },
  { 568, 7, 7, 8, 1, -7 },
  { 575, 9, 13, 8, 0, -10 },
  { 590, 8, 10, 8, 0, -7 },
  { 600, 6, 10, 8, 1, -10 },
  { 608, 7, 10, 8, 1, -10 },
  { 617, 7, 13, 8, 0, -10 },
  { 629, 7, 10, 8, 1, -10 },
  { 638, 6, 10, 8, 1, -10 },
  { 646, 8, 7, 8, 0, -7 },
  { 653, 6, 7, 8, 1, -7 },
  { 659, 7, 7, 8, 1, -7 },
  { 666, 8, 10, 8, 0, -7 },
  { 676, 7, 10, 8, 1, -7 },
  { 685, 7, 7, 8, 1, -7 },
  { 692, 7, 7, 8, 1, -7 },
  { 699, 7, 10, 8, 1, -10 },
  { 708, 7, 7, 8, 1, -7 },
  { 715, 7, 7, 8, 1, -7 },
  { 722, 8, 7, 8, 0, -7 },
  { 729, 8, 7, 8, 0, -7 },
  { 736, 8, 10, 8, 0, -7 },
  { 746, 8, 7, 8, 0, -7 },
  { 753, 7, 13, 8, 1, -11 },
  { 765, 3, 13, 8, 3, -11 },
  { 770, 7, 13, 8, 0, -11 },
  { 782, 8, 3, 8, 0, -6 },
};

const GFXfont IBMPlexMono_MediumItalic14pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic14pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _IBMPLEXMONO_MEDIUMITALIC14PT7B_H_
