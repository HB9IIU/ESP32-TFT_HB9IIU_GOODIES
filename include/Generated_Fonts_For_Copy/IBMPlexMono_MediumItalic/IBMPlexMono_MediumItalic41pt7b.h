#ifndef _IBMPLEXMONO_MEDIUMITALIC41PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C,
  0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC3, 0xF8, 0x3F, 0x07, 0xC0, 0x3C, 0x7D, 0xE1, 0xE7, 0x87, 0x9E, 0x1E,
  0x78, 0x79, 0xE1, 0xE7, 0x8F, 0xBC, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F,
  0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x87, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0x78, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3,
  0x80, 0x01, 0xE1, 0xE0, 0x0F, 0xF8, 0x7F, 0xC7, 0xFE, 0x1F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0x78, 0x00,
  0x1E, 0x1E, 0x00, 0x07, 0x87, 0x00, 0x01, 0xC3, 0xC0, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x01, 0xE1,
  0xE0, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x03,
  0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x0F, 0xCE, 0x7E, 0x1F, 0x1C, 0x38, 0x7C, 0x38, 0x20, 0xF0, 0x70, 0x01,
  0xE0, 0xE0, 0x03, 0xE3, 0x80, 0x07, 0xC7, 0x00, 0x07, 0xEE, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x07, 0x3F, 0x00, 0x0E, 0x3E, 0x00, 0x1C, 0x3C, 0x00, 0x30,
  0x78, 0x40, 0xE0, 0xF1, 0xC1, 0xC3, 0xE7, 0xC3, 0x8F, 0xCF, 0xE7, 0x3F,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x03, 0xFC, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0xF0, 0x3F, 0xE0, 0x0E, 0x07, 0xFE, 0x01, 0xC0, 0x78,
  0xF0, 0x3C, 0x0F, 0x07, 0x07, 0x80, 0xE0, 0x70, 0x70, 0x0E, 0x07, 0x0F,
  0x01, 0xE0, 0x71, 0xE0, 0x1E, 0x0F, 0x1C, 0x01, 0xE0, 0xF3, 0xC0, 0x1E,
  0x0E, 0x78, 0x00, 0xE1, 0xEF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0x78, 0x70, 0x01, 0xE7, 0x07, 0x00, 0x3C, 0xF0, 0x78, 0x03, 0x8F,
  0x07, 0x80, 0x78, 0xE0, 0x70, 0x0F, 0x0E, 0x07, 0x00, 0xE0, 0xE0, 0x70,
  0x1E, 0x0E, 0x0F, 0x03, 0xC0, 0xF1, 0xE0, 0x38, 0x07, 0xFE, 0x07, 0x00,
  0x7F, 0xC0, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0x78,
  0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78,
  0x01, 0xE0, 0x78, 0x01, 0xF0, 0xF0, 0x00, 0xF1, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x3E, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x3E, 0x00, 0xF8, 0x1E, 0x00, 0xF8, 0x1F, 0x04, 0xF8, 0x0F, 0x06,
  0xF8, 0x0F, 0x8F, 0xF8, 0x1F, 0x8F, 0x7C, 0x37, 0xDE, 0x7F, 0xF3, 0xFC,
  0x7F, 0xE3, 0xFC, 0x3F, 0xE1, 0xF8, 0x0F, 0x80, 0xF0, 0x7D, 0xE7, 0x9E,
  0x79, 0xEF, 0xBC, 0xF3, 0xCF, 0x3C, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x01, 0xC1, 0xE0, 0xEF, 0xCF, 0x3F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x1E, 0xF8, 0x01, 0xF3, 0xC0, 0x1F, 0x0F, 0x01,
  0xF0, 0x7C, 0x1F, 0x01, 0xE0, 0x30, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xE1,
  0xF8, 0x7E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x01,
  0xC0, 0x78, 0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x7E,
  0x7F, 0xFE, 0xFE, 0x7E, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xFC, 0x0F, 0xC1, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x07, 0x8F,
  0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00,
  0x1F, 0x7C, 0x78, 0x7D, 0xE1, 0xF1, 0xFF, 0x8F, 0xC7, 0xBE, 0x3E, 0x3E,
  0xF8, 0x78, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBC, 0x00, 0x3C, 0xF0,
  0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x1E, 0x01, 0xF0, 0x7E, 0x0F,
  0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xEF,
  0x00, 0xFC, 0xF0, 0x1F, 0x8F, 0x03, 0xF1, 0xF0, 0x7E, 0x1F, 0x03, 0xC1,
  0xF0, 0x18, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE,
  0x0F, 0xE1, 0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC3, 0x80, 0x1F, 0x02,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xC1, 0xFC, 0x3E,
  0x01, 0xF0, 0x60, 0x07, 0xC0, 0x80, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x80, 0x07, 0xC7, 0x00, 0x1F,
  0x3E, 0x00, 0xFC, 0xFC, 0x0F, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xEF, 0x00, 0x07,
  0xDE, 0x00, 0x1F, 0x3C, 0x00, 0x3C, 0xF8, 0x00, 0xF1, 0xF0, 0x03, 0xC3,
  0xC0, 0x0F, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x7C,
  0x07, 0x80, 0xF8, 0x1E, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xE0, 0x07, 0x83,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xC0,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x7E,
  0x00, 0x73, 0xFE, 0x01, 0xEF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xE0, 0xFE,
  0x0F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x82, 0x00, 0x1F, 0x0E, 0x00, 0x7C, 0x3E,
  0x01, 0xF8, 0xFE, 0x07, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x3F, 0x03, 0xEF, 0xFC, 0x3D,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x03, 0xF7, 0xE0, 0x1F, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xE7, 0x80, 0x3E, 0x7E, 0x0F, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF,
  0x01, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x00, 0x1F, 0x78, 0x00, 0xF3, 0xC0, 0x0F,
  0x9E, 0x00, 0x78, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00,
  0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0x01, 0xF0,
  0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xC0, 0x03, 0xCF, 0x80, 0x0F, 0x9F,
  0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7E, 0x07, 0xF0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xF8, 0x3F,
  0x1F, 0x00, 0xF9, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7E, 0x01, 0xF9,
  0xF8, 0x3F, 0xCF, 0xFF, 0xBC, 0x3F, 0xFF, 0xE0, 0xFF, 0x9E, 0x01, 0xF1,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0x83, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE0,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x7E, 0x1F, 0xCF, 0xE3, 0xF8, 0x7E, 0x1F, 0x00, 0x01, 0xE0, 0x3F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFC, 0x1F,
  0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x70,
  0x0F, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x3F,
  0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x10, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00,
  0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7E, 0x1F,
  0xFE, 0x01, 0xFF, 0x00, 0x7C, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xC0, 0xF8, 0x3C, 0x01, 0xE1,
  0xE0, 0x03, 0x87, 0x80, 0x0E, 0x3C, 0x1F, 0x3C, 0xF0, 0xFE, 0xE3, 0x87,
  0xFB, 0x9E, 0x3E, 0x3E, 0x78, 0xF0, 0x79, 0xE3, 0x81, 0xE7, 0x9E, 0x07,
  0x9C, 0x78, 0x1C, 0xF1, 0xE0, 0x73, 0xC7, 0x83, 0xCF, 0x1C, 0x0F, 0x3C,
  0x70, 0x7C, 0xF1, 0xE1, 0xF3, 0xC7, 0xFB, 0x8F, 0x1F, 0xEE, 0x3C, 0x3F,
  0x78, 0xF0, 0xF9, 0xE3, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xDE, 0x00, 0x0F,
  0xBC, 0x00, 0x1E, 0x78, 0x00, 0x7C, 0xF8, 0x00, 0xF1, 0xF0, 0x01, 0xE3,
  0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1E,
  0x01, 0xF0, 0x3C, 0x03, 0xC0, 0x7C, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x87, 0xC0, 0x0F, 0x0F,
  0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x78, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0,
  0x01, 0xFF, 0x80, 0x03, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xF0, 0x1F, 0x87, 0x80, 0x7C, 0x7C, 0x01, 0xE3,
  0xE0, 0x1F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x7C, 0x3C, 0x07,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3C,
  0x03, 0xE1, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0x80, 0x1F,
  0x3C, 0x00, 0xF9, 0xE0, 0x07, 0xCF, 0x00, 0x7C, 0xF8, 0x07, 0xE7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFC, 0x1F, 0x0F,
  0x80, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0x7C, 0x00, 0x83, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x1C, 0x78, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0xF8, 0x7E, 0x1F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x0F, 0x03, 0xF0, 0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x1E, 0x1F, 0x00, 0x78, 0x78, 0x01, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1F,
  0x3E, 0x00, 0x78, 0xF8, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x00, 0x3E, 0x3C,
  0x00, 0xF8, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0x7C, 0x01,
  0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x3E, 0x1E, 0x01, 0xF8, 0xF8, 0x1F, 0xC3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF,
  0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xC1, 0xF8, 0x3E, 0x03, 0xE1,
  0xF0, 0x07, 0x87, 0x80, 0x1F, 0x3E, 0x00, 0x40, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC1, 0xFF,
  0xBE, 0x07, 0xFC, 0xF8, 0x1F, 0xF3, 0xE0, 0xFF, 0xCF, 0x80, 0x0F, 0x3E,
  0x00, 0x3C, 0xF8, 0x01, 0xE3, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1F, 0x00,
  0xF8, 0x7E, 0x0F, 0xE0, 0xFF, 0xF7, 0x83, 0xFF, 0xBE, 0x07, 0xFC, 0xF0,
  0x07, 0xE3, 0xC0, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3E,
  0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C,
  0x1F, 0x00, 0x7C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0xF8,
  0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x7C, 0x01, 0xF0,
  0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0,
  0xF8, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x78, 0x03, 0xE3,
  0xE0, 0x1E, 0x1F, 0x01, 0xF0, 0xFC, 0x1F, 0x83, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xC1, 0xF0,
  0x07, 0xC0, 0x78, 0x03, 0xF0, 0x1E, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x03,
  0xE0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x0F, 0xC0,
  0x03, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xDF, 0x00, 0x0F, 0xE3, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00,
  0x3C, 0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x01, 0xE0,
  0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F,
  0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFE, 0x1E, 0xE1, 0xFE, 0x1E, 0xE1, 0xDE,
  0x1E, 0xF3, 0xDE, 0x1E, 0xF3, 0x9E, 0x1E, 0xF7, 0x9E, 0x3C, 0x7F, 0x3C,
  0x3C, 0x7F, 0x3C, 0x3C, 0x7E, 0x3C, 0x3C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x38, 0x3C, 0x78, 0x38, 0x78, 0x78, 0x30, 0x78, 0x78, 0x30, 0x78,
  0x78, 0x20, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF8, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x1E, 0x07, 0xE0, 0x1E,
  0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x3E,
  0x0F, 0x70, 0x3C, 0x0F, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x3C,
  0x1E, 0x78, 0x3C, 0x1E, 0x38, 0x3C, 0x1E, 0x3C, 0x78, 0x1E, 0x3C, 0x78,
  0x3E, 0x3C, 0x78, 0x3C, 0x3C, 0x78, 0x3C, 0x1C, 0x78, 0x3C, 0x1E, 0x78,
  0x3C, 0x1E, 0xF0, 0x3C, 0x1E, 0xF0, 0x7C, 0x1E, 0xF0, 0x78, 0x0E, 0xF0,
  0x78, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x0F, 0xE0, 0x78, 0x0F, 0xE0,
  0xF8, 0x07, 0xE0, 0xF0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xC1, 0xF8, 0x7E, 0x03, 0xE1, 0xF0,
  0x07, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF0, 0x01, 0xF7, 0xC0, 0x07,
  0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xBE,
  0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00,
  0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x1F, 0x01, 0xF0,
  0x7E, 0x0F, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x03,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0x00, 0xFC, 0x3C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1F, 0x3E,
  0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xC1, 0xF8,
  0x7E, 0x03, 0xE1, 0xF0, 0x07, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF0,
  0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80,
  0x3E, 0x1F, 0x01, 0xF8, 0x7E, 0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x07, 0xC0, 0x80, 0x0F, 0x83, 0x00,
  0x1E, 0x1E, 0x00, 0x7D, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0x00, 0xFC, 0x3C, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xE0, 0x07, 0xC7, 0x80,
  0x1F, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0x80, 0x7C,
  0x1E, 0x01, 0xF0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0xF8, 0x0F,
  0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xE0,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0xFE, 0x07, 0xE1, 0xF0, 0x07, 0x87, 0xC0, 0x06, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x84, 0x00, 0x1F, 0x1C, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xFE, 0x07, 0xF0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x7C, 0x78, 0x01, 0xE3, 0xE0, 0x07, 0x8F,
  0x80, 0x1E, 0x3E, 0x00, 0xF8, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x8F, 0x00,
  0x3C, 0x7C, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x7C,
  0x78, 0x01, 0xF1, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x3E, 0x00, 0x78, 0xF8,
  0x03, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF0, 0x03,
  0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x7C, 0x3E, 0x03, 0xE0, 0xFC, 0x1F, 0x83,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xBE, 0x00, 0x3E, 0x78, 0x00,
  0xF9, 0xE0, 0x07, 0xC7, 0x80, 0x1F, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xE1,
  0xF0, 0x0F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xE0, 0x7C, 0x0F, 0x80, 0xF0,
  0x3E, 0x03, 0xC0, 0xF0, 0x0F, 0x07, 0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0xF8,
  0x03, 0xC3, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x78, 0x00, 0x79, 0xE0, 0x01,
  0xEF, 0x80, 0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xC7, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x0F,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x3E, 0x0F,
  0x0F, 0x0F, 0x83, 0x83, 0xC3, 0xE1, 0xE0, 0xF1, 0xFC, 0x78, 0x3C, 0x7F,
  0x1E, 0x0F, 0x1F, 0xC7, 0x03, 0x8E, 0x73, 0xC0, 0xE3, 0x9C, 0xF0, 0x78,
  0xE7, 0x3C, 0x1E, 0x71, 0xCE, 0x07, 0x9C, 0x77, 0x81, 0xE7, 0x1D, 0xE0,
  0x7B, 0x87, 0x78, 0x1E, 0xE1, 0xDC, 0x07, 0xB8, 0x77, 0x01, 0xFC, 0x1F,
  0xC0, 0x77, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF8,
  0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF9,
  0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x3C, 0x00,
  0x7C, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x01,
  0xF0, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x3E,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x0F, 0x07, 0xC0, 0x0F,
  0x87, 0xC0, 0x0F, 0x8F, 0x80, 0x07, 0x9F, 0x00, 0x07, 0x9E, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x1F, 0xFF, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07,
  0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0,
  0x38, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x0E,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80,
  0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xF7, 0x80, 0x07,
  0xDF, 0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0x81, 0xE0, 0x3E, 0x07,
  0x80, 0xF0, 0x1F, 0x07, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF0, 0x01, 0xE7,
  0x80, 0x07, 0xBE, 0x00, 0x1E, 0x30, 0x00, 0x34, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x21, 0xCF, 0x3E, 0x79, 0xE3, 0xCF,
  0x10, 0x01, 0xF0, 0xF8, 0x3F, 0xE7, 0x83, 0xFF, 0xBC, 0x3F, 0xFD, 0xE3,
  0xF0, 0x2F, 0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x78, 0x01,
  0xE7, 0xC0, 0x0F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x00, 0x3C, 0x78,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xFC, 0x3F, 0xC3, 0xFF, 0xBF,
  0x9F, 0xF9, 0xFC, 0x7F, 0x87, 0xE1, 0xF8, 0x1F, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0xFC, 0x07,
  0x8F, 0xF8, 0x3C, 0xFF, 0xC1, 0xEF, 0xFF, 0x1F, 0xE0, 0xF8, 0xFE, 0x03,
  0xC7, 0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xE0, 0x07, 0xCF, 0x00, 0x3E, 0xF8,
  0x01, 0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0xF9, 0xE0, 0x07, 0xCF, 0x00, 0x7C,
  0x7C, 0x03, 0xE7, 0xF0, 0x7E, 0x3F, 0xFF, 0xF1, 0xEF, 0xFF, 0x0F, 0x3F,
  0xF0, 0x78, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xE3, 0xF0, 0x7C, 0xFC, 0x07, 0xDF, 0x00, 0x63, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x11, 0xE0,
  0x07, 0xBC, 0x01, 0xF7, 0xC0, 0x7C, 0xFC, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x07, 0xE1, 0xE0, 0x7F, 0xCF,
  0x83, 0xFF, 0xBE, 0x1F, 0xFF, 0xF0, 0xFE, 0x0F, 0xC3, 0xE0, 0x1F, 0x1F,
  0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xE0, 0x07, 0xCF, 0x80, 0x1E, 0x3E, 0x00,
  0x78, 0xF8, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x3E, 0x01, 0xF8,
  0xF8, 0x0B, 0xC3, 0xF0, 0x6F, 0x07, 0xFF, 0x3C, 0x1F, 0xFD, 0xF0, 0x3F,
  0xE7, 0xC0, 0x3E, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF,
  0x0F, 0xFF, 0xF3, 0xF0, 0x3E, 0xF8, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x1F,
  0xF8, 0x1F, 0xDF, 0xFF, 0xF3, 0xFF, 0xF8, 0x7F, 0xE0, 0x0F, 0x00, 0x01,
  0xE0, 0x02, 0x3C, 0x00, 0xF7, 0xC0, 0x3E, 0xFC, 0x0F, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x01, 0x03, 0xE0, 0x00, 0x60, 0x78, 0x00,
  0x3E, 0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x3C, 0x0F, 0xF9, 0xF0, 0x7F, 0xF7,
  0xC3, 0xFF, 0xDE, 0x1F, 0xC1, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x3E, 0x3C, 0x00, 0xF9, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x1F, 0x00,
  0x3C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x01, 0xF8,
  0x7E, 0x0D, 0xE0, 0xFF, 0xF7, 0x83, 0xFF, 0xBE, 0x07, 0xFC, 0xF8, 0x07,
  0xC3, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x08, 0x03, 0xE0, 0x78, 0x1F,
  0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0xF8, 0x1F, 0x3F, 0xC1, 0xE7, 0xFE, 0x1E, 0xFF, 0xE1, 0xEC, 0x3F, 0x3F,
  0x81, 0xF3, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3C, 0x01, 0xE3,
  0xC0, 0x1E, 0x7C, 0x01, 0xE7, 0xC0, 0x1E, 0x7C, 0x03, 0xE7, 0x80, 0x3E,
  0x78, 0x03, 0xC7, 0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x80, 0x3C, 0xF8, 0x07,
  0xCF, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x81, 0x01, 0xF0, 0x70, 0x3E, 0x1F,
  0x07, 0x87, 0xC0, 0xF3, 0xF0, 0x1E, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x01, 0x01, 0xE0, 0x78, 0x1E, 0x0F, 0xC3,
  0xE0, 0x7E, 0x3E, 0x03, 0xF3, 0xE0, 0x1F, 0xBC, 0x00, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x01, 0xF3,
  0xFE, 0x07, 0x9F, 0xF8, 0x1E, 0xFF, 0xF0, 0x7B, 0x0F, 0xC3, 0xF8, 0x1F,
  0x0F, 0xC0, 0x7C, 0x3E, 0x01, 0xE0, 0xF8, 0x07, 0x83, 0xC0, 0x7C, 0x0F,
  0x07, 0xC0, 0x7C, 0xFC, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x81, 0x1E, 0x3E,
  0x0E, 0x78, 0x7C, 0x79, 0xE1, 0xF7, 0xFF, 0x83, 0xFF, 0x3E, 0x0F, 0xF8,
  0xF8, 0x1F, 0xC3, 0xC0, 0x3C, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x03, 0x07, 0xC1, 0xE1, 0xF0, 0xFC, 0x78, 0x7C,
  0x1E, 0x7E, 0x07, 0xBF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x03,
  0xE0, 0x00, 0x0E, 0x3C, 0x3C, 0x1E, 0xFC, 0x7E, 0x1E, 0xFE, 0xFF, 0x1F,
  0xFF, 0xFF, 0x1F, 0x1F, 0x8F, 0x1E, 0x1F, 0x0F, 0x3E, 0x1E, 0x0F, 0x3C,
  0x1E, 0x0E, 0x3C, 0x1E, 0x0E, 0x3C, 0x1C, 0x1E, 0x3C, 0x1C, 0x1E, 0x3C,
  0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1C, 0x78, 0x3C, 0x3C, 0x78,
  0x38, 0x3C, 0x78, 0x78, 0x3C, 0x70, 0x78, 0x3C, 0xF0, 0x78, 0x38, 0xF0,
  0x78, 0x38, 0xF0, 0x70, 0x78, 0x1F, 0x0F, 0x81, 0xF3, 0xFC, 0x1E, 0x7F,
  0xE1, 0xEF, 0xFE, 0x1E, 0xC3, 0xF3, 0xF8, 0x1F, 0x3F, 0x01, 0xF3, 0xE0,
  0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x1E, 0x7C,
  0x01, 0xE7, 0xC0, 0x3E, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0x78, 0x03, 0xCF,
  0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF0, 0x07, 0xC0, 0x00, 0xFE,
  0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0x83, 0xF3, 0xE0,
  0x1F, 0x7C, 0x00, 0xF7, 0xC0, 0x0F, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xE7,
  0x80, 0x7E, 0x7E, 0x0F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0,
  0x07, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x0F, 0x1F, 0xF0, 0x1E, 0x7F, 0xE0,
  0x3D, 0xFF, 0xE0, 0xFF, 0x07, 0xC1, 0xFC, 0x07, 0x83, 0xF0, 0x0F, 0x87,
  0xC0, 0x1F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0xF8,
  0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x3E, 0x0F, 0x80,
  0x7C, 0x3F, 0x83, 0xF0, 0x7F, 0xFF, 0xE0, 0xF7, 0xFF, 0x81, 0xE7, 0xFE,
  0x03, 0xC3, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0xF8, 0x3F, 0xE7, 0xC3, 0xFF, 0xBE, 0x3F,
  0xFF, 0xE3, 0xF8, 0x3F, 0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E,
  0x78, 0x01, 0xF7, 0xC0, 0x0F, 0x3E, 0x00, 0x79, 0xF0, 0x03, 0xCF, 0x00,
  0x3E, 0x78, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x01, 0xF8, 0xFC, 0x1B, 0xC3,
  0xFF, 0xBE, 0x1F, 0xFD, 0xF0, 0x7F, 0xCF, 0x80, 0xF8, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xE1, 0xF7, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0x03, 0xD8, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F,
  0x01, 0xE1, 0xE0, 0x08, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE2, 0x00, 0x3C, 0x7C, 0x0F, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF,
  0x83, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x18, 0x1E, 0x07, 0x83, 0xC3,
  0xF8, 0x78, 0xFE, 0x0F, 0x7F, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x01, 0xF3, 0xC0, 0x1F, 0x3C, 0x01, 0xE3, 0xC0,
  0x1E, 0x7C, 0x01, 0xE7, 0xC0, 0x3E, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0x78,
  0x03, 0xC7, 0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF0, 0x07, 0xCF,
  0x00, 0xFC, 0xF0, 0x0F, 0x8F, 0x81, 0x78, 0xF8, 0x77, 0x8F, 0xFE, 0xF8,
  0x7F, 0xEF, 0x87, 0xFC, 0xF8, 0x1F, 0x0F, 0x00, 0x7F, 0x80, 0x67, 0xF8,
  0x1E, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xF0, 0x1F, 0x1E, 0x01, 0xF1,
  0xE0, 0x1E, 0x1E, 0x03, 0xE1, 0xE0, 0x7C, 0x1E, 0x0F, 0xC3, 0xE1, 0xF8,
  0x3E, 0x7F, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xC0,
  0x00, 0x1E, 0x1E, 0x08, 0x70, 0x78, 0xF3, 0xC1, 0xC3, 0xCF, 0x07, 0x07,
  0x3C, 0x3C, 0x1C, 0xF0, 0xF0, 0x73, 0x83, 0xC1, 0xCE, 0x0F, 0x07, 0x78,
  0x38, 0x1D, 0xE0, 0xE0, 0x77, 0x87, 0x83, 0xDC, 0x1E, 0x0F, 0x70, 0x78,
  0x3D, 0xC1, 0xE0, 0xEF, 0x0F, 0x87, 0xBC, 0x3C, 0x1E, 0xF1, 0xF0, 0xF3,
  0xFF, 0xE7, 0x8F, 0xF3, 0xFE, 0x1F, 0x8F, 0xF0, 0x3C, 0x1F, 0x00, 0x00,
  0xF0, 0x3C, 0x01, 0xFC, 0x7F, 0x01, 0xFE, 0x3F, 0xC1, 0xFF, 0xBF, 0xE1,
  0xFB, 0xD8, 0xF1, 0xF1, 0xF8, 0x38, 0xF0, 0xFC, 0x1E, 0x20, 0x7C, 0x0E,
  0x00, 0x3E, 0x06, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x03, 0x03, 0xC0, 0x07, 0x83, 0xE0, 0x63, 0xC1, 0xF0, 0x71, 0xE1, 0xB8,
  0xFC, 0xF1, 0xDE, 0xFC, 0x7F, 0xEF, 0xFC, 0x1F, 0xE7, 0xFC, 0x0F, 0xE1,
  0xF8, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x80, 0x7C, 0x3C, 0x01, 0xF0, 0xF0,
  0x07, 0x83, 0xC0, 0x1E, 0x1F, 0x00, 0x78, 0x7C, 0x03, 0xE1, 0xE0, 0x0F,
  0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xE0, 0x0F, 0x0F,
  0x80, 0x7C, 0x3C, 0x01, 0xF0, 0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x0F, 0x81,
  0x78, 0x3F, 0x1D, 0xE0, 0xFF, 0xEF, 0x81, 0xFF, 0xBE, 0x03, 0xFC, 0xF0,
  0x07, 0xC3, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x08, 0x03, 0xE0, 0x78,
  0x1F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x3C, 0x1F, 0xF8, 0xF0, 0xFF, 0xFB, 0xC7, 0xFF, 0xFF,
  0x1E, 0x0F, 0xFC, 0x70, 0x07, 0xE1, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x60, 0x1F, 0x03, 0xC1, 0xF8, 0x07, 0x0F, 0xE0, 0x1E, 0x7F, 0xFC, 0x79,
  0xFF, 0xFF, 0xE7, 0xBF, 0xFF, 0x9E, 0x1F, 0xFC, 0xF8, 0x0F, 0xE0, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xC0, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x18, 0x1F, 0xC0, 0x3C, 0x7F, 0xC0,
  0x70, 0xFF, 0xC1, 0xE3, 0xC7, 0x83, 0x87, 0x87, 0x8F, 0x1E, 0x0F, 0xFC,
  0x3C, 0x0F, 0xF8, 0x70, 0x0F, 0xE1, 0x60, 0x0F, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 11, 29, 25, 7, -29 },
  { 41, 14, 12, 25, 8, -30 },
  { 62, 26, 29, 25, 0, -29 },
  { 157, 23, 37, 25, 1, -33 },
  { 264, 28, 29, 25, -1, -29 },
  { 366, 24, 29, 25, 0, -29 },
  { 453, 6, 12, 25, 12, -30 },
  { 462, 16, 37, 25, 8, -31 },
  { 536, 17, 37, 25, 1, -31 },
  { 615, 21, 20, 25, 2, -23 },
  { 668, 20, 20, 25, 3, -23 },
  { 718, 11, 12, 25, 5, -6 },
  { 735, 13, 4, 25, 6, -14 },
  { 742, 8, 7, 25, 7, -7 },
  { 749, 23, 37, 25, 1, -31 },
  { 856, 22, 29, 25, 2, -29 },
  { 936, 20, 29, 25, 2, -29 },
  { 1009, 22, 29, 25, 1, -29 },
  { 1089, 22, 29, 25, 1, -29 },
  { 1169, 23, 29, 25, 0, -29 },
  { 1253, 23, 29, 25, 1, -29 },
  { 1337, 20, 29, 25, 2, -29 },
  { 1410, 21, 29, 25, 4, -29 },
  { 1487, 23, 29, 25, 1, -29 },
  { 1571, 21, 29, 25, 3, -29 },
  { 1648, 10, 22, 25, 7, -22 },
  { 1676, 12, 28, 25, 5, -22 },
  { 1718, 20, 24, 25, 3, -25 },
  { 1778, 21, 13, 25, 2, -19 },
  { 1813, 20, 24, 25, 2, -25 },
  { 1873, 18, 29, 25, 5, -29 },
  { 1939, 22, 34, 25, 2, -29 },
  { 2033, 23, 29, 25, -1, -29 },
  { 2117, 21, 29, 25, 2, -29 },
  { 2194, 21, 29, 25, 3, -29 },
  { 2271, 22, 29, 25, 2, -29 },
  { 2351, 22, 29, 25, 2, -29 },
  { 2431, 23, 29, 25, 2, -29 },
  { 2515, 22, 29, 25, 2, -29 },
  { 2595, 24, 29, 25, 1, -29 },
  { 2682, 22, 29, 25, 2, -29 },
  { 2762, 21, 29, 25, 2, -29 },
  { 2839, 26, 29, 25, 1, -29 },
  { 2934, 18, 29, 25, 3, -29 },
  { 3000, 24, 29, 25, 1, -29 },
  { 3087, 24, 29, 25, 1, -29 },
  { 3174, 22, 29, 25, 2, -29 },
  { 3254, 22, 29, 25, 2, -29 },
  { 3334, 22, 37, 25, 2, -29 },
  { 3436, 22, 29, 25, 2, -29 },
  { 3516, 23, 29, 25, 1, -29 },
  { 3600, 24, 29, 25, 3, -29 },
  { 3687, 22, 29, 25, 3, -29 },
  { 3767, 22, 29, 25, 4, -29 },
  { 3847, 26, 29, 25, 1, -29 },
  { 3942, 27, 29, 25, -1, -29 },
  { 4040, 24, 29, 25, 3, -29 },
  { 4127, 25, 29, 25, 0, -29 },
  { 4218, 18, 37, 25, 6, -31 },
  { 4302, 11, 37, 25, 7, -31 },
  { 4353, 18, 37, 25, 1, -31 },
  { 4437, 22, 17, 25, 2, -29 },
  { 4484, 20, 4, 25, 0, 3 },
  { 4494, 6, 9, 25, 9, -33 },
  { 4501, 21, 21, 25, 2, -21 },
  { 4557, 21, 30, 25, 2, -30 },
  { 4636, 19, 21, 25, 3, -21 },
  { 4686, 22, 30, 25, 2, -30 },
  { 4769, 19, 21, 25, 3, -21 },
  { 4819, 27, 38, 25, -1, -30 },
  { 4948, 22, 29, 25, 1, -21 },
  { 5028, 20, 30, 25, 2, -30 },
  { 5103, 19, 31, 25, 3, -31 },
  { 5177, 20, 39, 25, 1, -31 },
  { 5275, 22, 30, 25, 2, -30 },
  { 5358, 18, 30, 25, 4, -30 },
  { 5426, 24, 21, 25, 0, -21 },
  { 5489, 20, 21, 25, 2, -21 },
  { 5542, 20, 21, 25, 2, -21 },
  { 5595, 23, 29, 25, 0, -21 },
  { 5679, 21, 29, 25, 2, -21 },
  { 5756, 20, 21, 25, 4, -21 },
  { 5809, 20, 21, 25, 2, -21 },
  { 5862, 19, 29, 25, 3, -29 },
  { 5931, 20, 21, 25, 3, -21 },
  { 5984, 20, 21, 25, 2, -21 },
  { 6037, 22, 21, 25, 1, -21 },
  { 6095, 25, 21, 25, 0, -21 },
  { 6161, 22, 29, 25, 1, -21 },
  { 6241, 22, 21, 25, 1, -21 },
  { 6299, 20, 37, 25, 4, -31 },
  { 6392, 10, 37, 25, 8, -31 },
  { 6439, 20, 37, 25, 1, -31 },
  { 6532, 23, 10, 25, 1, -17 },
};

const GFXfont IBMPlexMono_MediumItalic41pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic41pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic41pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _IBMPLEXMONO_MEDIUMITALIC41PT7B_H_
