#ifndef _IBMPLEXMONO_MEDIUMITALIC26PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC7, 0x38, 0xE3, 0x8C, 0x30, 0xC2, 0x00, 0x00, 0x0F,
  0x3C, 0xF3, 0x80, 0x73, 0xB1, 0x98, 0xCC, 0x6E, 0x77, 0x3B, 0x9D, 0x8C,
  0x00, 0xCE, 0x01, 0xCC, 0x01, 0x8C, 0x03, 0x9C, 0x03, 0x18, 0x3F, 0x1F,
  0x3F, 0x3F, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x70, 0x0C, 0x60, 0xFC, 0x7C,
  0xFC, 0xFC, 0x18, 0xC0, 0x18, 0xC0, 0x39, 0xC0, 0x31, 0x80, 0x73, 0x80,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x01, 0xFC, 0x1F, 0xF8, 0xF6, 0x73, 0x98,
  0x8C, 0x60, 0x31, 0x80, 0xE6, 0x03, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x0D,
  0xE0, 0x33, 0x80, 0xCE, 0x02, 0x3B, 0x18, 0xEF, 0x67, 0x1F, 0xF8, 0x3F,
  0x80, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x07, 0x80, 0xC3, 0xF0, 0x61, 0xCC,
  0x38, 0x63, 0x8C, 0x18, 0xE6, 0x06, 0x33, 0x81, 0x9C, 0xC0, 0x7E, 0x60,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x77, 0xE0, 0x19, 0x8C, 0x0C, 0xC3, 0x07,
  0x30, 0xC1, 0x8C, 0x70, 0xC3, 0x18, 0x70, 0xFE, 0x38, 0x1E, 0x00, 0x01,
  0xE0, 0x0F, 0xF0, 0x1C, 0xE0, 0x70, 0xE0, 0xE1, 0xC1, 0xC3, 0x03, 0x86,
  0x03, 0x1C, 0x1F, 0xE0, 0x67, 0x01, 0x8E, 0x07, 0x0C, 0x0E, 0x1C, 0x1C,
  0x38, 0xF8, 0x79, 0xF9, 0xB6, 0x7E, 0x7C, 0x78, 0x70, 0x37, 0x77, 0x66,
  0x6E, 0x01, 0xC0, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0x60,
  0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x06,
  0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E,
  0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0,
  0x70, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x83,
  0x80, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x73, 0x9F, 0xFF, 0xF3,
  0xFF, 0x01, 0xE0, 0x0F, 0x80, 0x77, 0x03, 0x8C, 0x1C, 0x38, 0x20, 0x40,
  0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xF0, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1E, 0x78, 0xE1, 0xC7, 0x0E, 0x18,
  0x70, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xC3, 0x8E, 0x07,
  0x38, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x73, 0x9F, 0x9E, 0x7E, 0x01,
  0xF8, 0x0E, 0xE0, 0x3B, 0x80, 0xE6, 0x07, 0x1C, 0x38, 0x3F, 0xC0, 0x7E,
  0x00, 0x03, 0xE0, 0x3F, 0x03, 0xB8, 0x39, 0xC3, 0x9C, 0x38, 0xE0, 0x87,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x7F, 0xC3, 0xC3,
  0x8E, 0x0F, 0x10, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x00, 0xFF,
  0xF3, 0xFF, 0xC0, 0x03, 0xF0, 0x1F, 0xF8, 0x78, 0x70, 0x40, 0xF0, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x03, 0xF0, 0x0F, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x07, 0x18, 0x0E, 0x78, 0x3C, 0x3F, 0xF0, 0x3F,
  0x80, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x06, 0xE0, 0x1D, 0x80, 0x77,
  0x01, 0xCE, 0x07, 0x1C, 0x1C, 0x38, 0x70, 0x60, 0xC0, 0xC3, 0x83, 0x87,
  0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x0F,
  0xFC, 0x7F, 0xF1, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C,
  0xF8, 0x37, 0xF1, 0xE1, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE6,
  0x07, 0x3C, 0x3C, 0x7F, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x0F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x7C, 0x77, 0xF3, 0xC3, 0xFC,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1D, 0x81, 0xEE, 0x1E, 0x3F, 0xE0, 0xFC,
  0x00, 0x7F, 0xFD, 0xFF, 0xF6, 0x03, 0x98, 0x0E, 0xE0, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x3F,
  0xE1, 0xC3, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0x87, 0x0E, 0x0F,
  0xE0, 0x7F, 0x87, 0x87, 0x38, 0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xBC,
  0x3C, 0x7F, 0xE0, 0x7E, 0x00, 0x0F, 0xC1, 0xFF, 0x1E, 0x1C, 0xE0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xF0, 0xFB, 0xFB, 0x8F, 0xBC, 0x01,
  0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x07, 0xC0, 0x00, 0x39,
  0xF7, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0xF3, 0x80, 0x0E, 0x1F,
  0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x38, 0x38,
  0x70, 0x70, 0x60, 0xE0, 0x00, 0x08, 0x01, 0xC0, 0x3C, 0x07, 0xC0, 0xF8,
  0x1F, 0x01, 0xE0, 0x1C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x70, 0x01, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0x10, 0x01, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0xF0, 0x1F, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0x70, 0x02, 0x00, 0x00, 0x1F, 0x83, 0xFC, 0x70,
  0xEE, 0x0E, 0x20, 0x70, 0x0E, 0x00, 0xE0, 0x3C, 0x1F, 0x81, 0xE0, 0x1C,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x07, 0xC0, 0x7C, 0x03, 0x80, 0x03,
  0xE0, 0x3F, 0xE1, 0xC1, 0x8E, 0x07, 0x30, 0x0C, 0xC7, 0x37, 0x3F, 0xD9,
  0xC7, 0x67, 0x19, 0x98, 0x66, 0x61, 0xB9, 0x86, 0xE6, 0x3B, 0x98, 0xEE,
  0x7F, 0x39, 0xEC, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x19, 0x80, 0x73, 0x00,
  0xE7, 0x03, 0x8E, 0x07, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xFF, 0xE1, 0xFF,
  0xC3, 0x01, 0x8E, 0x03, 0x9C, 0x07, 0x70, 0x0F, 0xE0, 0x1C, 0x1F, 0xF0,
  0x7F, 0xE1, 0x83, 0x8E, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x83, 0x8E, 0x1E,
  0x3F, 0xE1, 0xFF, 0x87, 0x07, 0x1C, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03,
  0xB8, 0x1C, 0xFF, 0xE3, 0xFF, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0x0E, 0x70,
  0x77, 0x01, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x3B, 0x81, 0xCE, 0x1C, 0x7F, 0xC0, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0xC1, 0xC3, 0x86, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81,
  0xCE, 0x07, 0x38, 0x1C, 0xC0, 0x77, 0x03, 0xDC, 0x0E, 0x70, 0x39, 0xC0,
  0xE7, 0x07, 0x38, 0x38, 0xFF, 0xC3, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xF1,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xF8,
  0xFF, 0xE7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xFF, 0xF3, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xF8, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0xF8, 0x7F, 0xE1, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xE3, 0xCF, 0x07, 0x38, 0x19, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC7, 0xE7, 0x1F, 0xB8, 0x0E, 0x60,
  0x39, 0x80, 0xE7, 0x07, 0x1E, 0x2C, 0x3F, 0xF0, 0x79, 0xC0, 0x1C, 0x0E,
  0x30, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C,
  0x0C, 0x7F, 0xF8, 0xFF, 0xF1, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8C, 0x0E,
  0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0xFF, 0xF3, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x81, 0x8E, 0x0E, 0x1C, 0x78, 0x7F, 0xC0, 0x7C, 0x00,
  0x1C, 0x0F, 0x1C, 0x1E, 0x18, 0x3C, 0x38, 0x78, 0x38, 0xF0, 0x39, 0xE0,
  0x3B, 0xC0, 0x3B, 0x80, 0x37, 0x80, 0x7F, 0x80, 0x7D, 0xC0, 0x79, 0xC0,
  0x70, 0xE0, 0x70, 0xE0, 0x60, 0xF0, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x38,
  0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF,
  0xFC, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1F, 0x1F, 0x1E, 0x1F, 0x36, 0x3B,
  0x76, 0x3B, 0x6E, 0x3B, 0xEE, 0x3B, 0xCE, 0x31, 0xCC, 0x31, 0x8C, 0x71,
  0x0C, 0x71, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x60, 0x18, 0x60, 0x18, 0xE0,
  0x38, 0x1E, 0x0E, 0x3C, 0x18, 0xF8, 0x31, 0xF0, 0xE3, 0xF1, 0xC6, 0xE3,
  0x8D, 0xC7, 0x19, 0x8C, 0x73, 0x18, 0xE7, 0x71, 0xCE, 0xE3, 0x1D, 0xC6,
  0x1B, 0x8C, 0x36, 0x38, 0x7C, 0x70, 0xF8, 0xE0, 0xF1, 0x81, 0xE0, 0x03,
  0xE0, 0x3F, 0xE1, 0xC3, 0x8E, 0x07, 0x38, 0x1D, 0xC0, 0x77, 0x01, 0xDC,
  0x07, 0x70, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0E, 0xE0, 0x3B, 0x80, 0xE7,
  0x07, 0x1C, 0x38, 0x3F, 0xC0, 0x7E, 0x00, 0x1F, 0xF0, 0x7F, 0xE1, 0xC1,
  0xC6, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0E, 0x3F, 0xF8, 0xFF,
  0x87, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xC3, 0x8E, 0x07, 0x38, 0x1D,
  0xC0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0E,
  0xE0, 0x3B, 0x80, 0xE7, 0x07, 0x1C, 0x38, 0x3F, 0xC0, 0x7E, 0x00, 0x70,
  0x00, 0xE6, 0x03, 0xBC, 0x07, 0xC0, 0x0E, 0x00, 0x1F, 0xF0, 0x7F, 0xE1,
  0xC1, 0xC6, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0E, 0x3F, 0xF8,
  0xFF, 0x87, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC3, 0x86, 0x0E, 0x18, 0x38,
  0xE0, 0x73, 0x81, 0xC0, 0x07, 0xF0, 0x7F, 0xE3, 0xC1, 0xCE, 0x02, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xEC, 0x07, 0xBC, 0x3C, 0x7F, 0xE0, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x1D,
  0xC0, 0x67, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0xB8, 0x0C,
  0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x63, 0x03, 0x8E, 0x0E,
  0x38, 0x70, 0x7F, 0xC0, 0xFC, 0x00, 0xE0, 0x1F, 0x80, 0xEE, 0x03, 0xB8,
  0x1C, 0xE0, 0x73, 0x83, 0x8E, 0x0E, 0x38, 0x30, 0x61, 0xC1, 0x87, 0x07,
  0x38, 0x1C, 0xE0, 0x77, 0x01, 0xDC, 0x07, 0x60, 0x1F, 0x80, 0x3C, 0x00,
  0xF0, 0x00, 0x70, 0x07, 0x70, 0x06, 0x70, 0x06, 0x70, 0x06, 0x73, 0x8E,
  0x63, 0x8E, 0x63, 0x8C, 0x66, 0x8C, 0x66, 0xDC, 0x66, 0xDC, 0x6C, 0xD8,
  0xEC, 0xD8, 0xEC, 0xF8, 0xF8, 0xF8, 0xF8, 0xF0, 0xF8, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x0E, 0x03, 0xC3, 0xC1, 0xE0, 0x70, 0x70, 0x1C, 0x38, 0x03,
  0x9C, 0x00, 0xEF, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3F, 0x00, 0x1D, 0xC0, 0x07, 0x38, 0x03, 0x8E, 0x01, 0xC3, 0xC0,
  0xF0, 0x70, 0x38, 0x1C, 0x3C, 0x03, 0x80, 0xE0, 0x0E, 0xE0, 0x39, 0xC0,
  0xE3, 0xC1, 0xC3, 0x87, 0x07, 0x1C, 0x06, 0x78, 0x0E, 0xE0, 0x1F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xFF, 0xFC, 0xFF, 0xF8, 0x1F, 0xE3, 0xFC, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x3F,
  0xC7, 0xF0, 0xE0, 0x60, 0x60, 0x60, 0x70, 0x30, 0x30, 0x30, 0x30, 0x38,
  0x18, 0x18, 0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0E, 0x06, 0x06,
  0x06, 0x07, 0x0F, 0xF0, 0xFF, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x7F,
  0x0F, 0xF0, 0x01, 0xC0, 0x0F, 0x80, 0x7E, 0x01, 0xDC, 0x0E, 0x70, 0x70,
  0xC1, 0xC3, 0x8E, 0x0E, 0x70, 0x19, 0x80, 0x7A, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0x27, 0x1C, 0xE3, 0x0C, 0x0F, 0x38, 0xFF, 0xCE, 0x1E, 0xE0,
  0x77, 0x03, 0xB0, 0x1B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x07, 0x9C, 0x5C,
  0xFE, 0xF3, 0xC7, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x1C, 0x00, 0xE7, 0x87, 0x7F, 0x3C, 0x39, 0xC1, 0xDE, 0x06, 0xE0, 0x77,
  0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x0E, 0xF0, 0xF7, 0x7F, 0x39, 0xE0, 0x0F,
  0xC3, 0xFE, 0x78, 0x77, 0x06, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x6E, 0x0F, 0xF1, 0xC7, 0xF8, 0x3F, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x83, 0xE6, 0x0F, 0xEC, 0x38, 0x78,
  0xE0, 0x71, 0xC0, 0xE3, 0x01, 0xCE, 0x03, 0x1C, 0x0E, 0x38, 0x1C, 0x70,
  0x78, 0x71, 0xF0, 0xFE, 0xE0, 0xF9, 0x80, 0x0F, 0xC1, 0xFE, 0x78, 0x77,
  0x07, 0xE0, 0x7E, 0x1E, 0xFF, 0xCF, 0xE0, 0xE0, 0x0E, 0x06, 0xE0, 0xF7,
  0xFC, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x02, 0x18, 0x03, 0xC6, 0x00,
  0x73, 0x80, 0x0E, 0xE0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x9C, 0x7F,
  0x63, 0x87, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xEE, 0x03, 0x38, 0x1C, 0xE0,
  0x73, 0x83, 0xC7, 0x1F, 0x1F, 0xDC, 0x3E, 0x60, 0x03, 0x80, 0x0E, 0x30,
  0x70, 0xFF, 0x81, 0xFC, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE7, 0x87, 0x7E, 0x3C, 0x79, 0xC1, 0xCE, 0x0E, 0xE0,
  0x77, 0x03, 0x38, 0x19, 0xC1, 0xCE, 0x0E, 0x60, 0x77, 0x03, 0xB8, 0x18,
  0x03, 0x80, 0x78, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC2, 0x1C, 0x71, 0xCE,
  0x1D, 0xC1, 0xF8, 0x0E, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x10, 0xE1,
  0xC7, 0x07, 0x38, 0x1D, 0xC0, 0x7C, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x9E, 0x0E, 0xFC, 0x3C, 0x38,
  0xE0, 0xE3, 0x83, 0x9C, 0x1C, 0x71, 0xE1, 0xDC, 0x07, 0x70, 0x9C, 0xE7,
  0x63, 0xBB, 0x87, 0xCE, 0x0E, 0x00, 0xFE, 0x1F, 0xC0, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x71, 0x8C, 0x7B, 0x9C, 0x77, 0x0F, 0xC0, 0xF0, 0x00, 0x3B, 0x9C, 0x6F,
  0x7C, 0xE7, 0x39, 0x8E, 0x33, 0x18, 0xEE, 0x31, 0xDC, 0x63, 0xB1, 0xC6,
  0x63, 0x8C, 0xC6, 0x1B, 0x8C, 0x77, 0x18, 0xEE, 0x71, 0x80, 0x39, 0xE1,
  0xDF, 0x8F, 0x1E, 0x70, 0x73, 0x83, 0xB8, 0x1D, 0xC0, 0xCE, 0x06, 0x70,
  0x73, 0x83, 0x98, 0x1D, 0xC0, 0xEE, 0x06, 0x00, 0x07, 0xC0, 0xFF, 0x8F,
  0x1E, 0xE0, 0x77, 0x03, 0xB8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3B, 0x03,
  0x9C, 0x38, 0x7F, 0x81, 0xF8, 0x00, 0x1C, 0xF0, 0x77, 0xF1, 0xE1, 0xC7,
  0x07, 0x1C, 0x0C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0xE7,
  0x87, 0x9D, 0xFC, 0x73, 0xC1, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x0F, 0x9C, 0x7F, 0x63, 0x87, 0x9C, 0x0E, 0x70, 0x39, 0x80,
  0xEE, 0x03, 0x38, 0x1C, 0xE0, 0x73, 0x83, 0xC7, 0x1F, 0x1F, 0xDC, 0x3E,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0xFC, 0x7F,
  0xDF, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x00, 0x70, 0x00, 0x07, 0xE0, 0xFF, 0xCE, 0x0C, 0x70,
  0x03, 0x80, 0x1F, 0x80, 0x7F, 0x80, 0x7E, 0x00, 0x72, 0x03, 0x9C, 0x3D,
  0xFF, 0xC1, 0xF8, 0x00, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x0F,
  0xFF, 0xFF, 0xF1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03,
  0x86, 0x38, 0xF3, 0xBC, 0x3F, 0x01, 0xE0, 0x70, 0x37, 0x07, 0x70, 0x76,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0xE0, 0xEE, 0x1E, 0xE2, 0xEF,
  0xCC, 0x79, 0xC0, 0x7C, 0x17, 0xE1, 0xC7, 0x0E, 0x38, 0x71, 0x83, 0x9C,
  0x1C, 0xE0, 0xE7, 0x0E, 0x38, 0x71, 0xC7, 0x0C, 0xF0, 0x7F, 0x03, 0xE0,
  0x00, 0x71, 0x99, 0xC6, 0x76, 0x39, 0xD8, 0xE3, 0x63, 0x0F, 0x8C, 0x7E,
  0x31, 0xF0, 0xC6, 0xC7, 0x1B, 0x1C, 0x6C, 0xB3, 0x3E, 0xD8, 0x73, 0xC0,
  0x07, 0x1E, 0x1F, 0x3E, 0x3B, 0xE7, 0x71, 0xC7, 0x01, 0xC7, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0xE3, 0x88, 0xC7, 0x8C, 0xE5, 0xBE, 0xFD, 0xF8,
  0x78, 0xE0, 0x1C, 0x0C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x18, 0x1C, 0xE0,
  0x63, 0x81, 0x8E, 0x0E, 0x38, 0x38, 0xE1, 0xE3, 0x8B, 0x8F, 0xEC, 0x1E,
  0x70, 0x01, 0xC0, 0x07, 0x18, 0x38, 0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0x1C,
  0xFF, 0x73, 0x0F, 0x9C, 0x1C, 0x70, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x84,
  0x1C, 0x30, 0xE0, 0xEF, 0xF1, 0xBB, 0xFE, 0xE3, 0xF0, 0x03, 0xF0, 0x7F,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30,
  0x07, 0x0F, 0xC0, 0xFC, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x0C, 0x01, 0xC0,
  0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3F, 0x83, 0xF0, 0x0C, 0x31, 0xC7,
  0x18, 0x61, 0x86, 0x38, 0xE3, 0x0C, 0x30, 0xC7, 0x1C, 0x71, 0x86, 0x18,
  0xE3, 0x8E, 0x30, 0x0F, 0xC0, 0xFE, 0x10, 0xE0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x07, 0x00, 0x3F, 0x03, 0xF0, 0xE0,
  0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60,
  0xFE, 0x0F, 0xC0, 0x1C, 0x0C, 0xF8, 0x77, 0x71, 0x98, 0xEE, 0xC1, 0xF3,
  0x03, 0x80,
};

const GFXglyph IBMPlexMono_MediumItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 18, 16, 5, -18 },
  { 15, 9, 8, 16, 5, -19 },
  { 24, 16, 18, 16, 0, -18 },
  { 60, 14, 24, 16, 1, -21 },
  { 102, 18, 18, 16, -1, -18 },
  { 143, 15, 18, 16, 0, -18 },
  { 177, 4, 8, 16, 7, -19 },
  { 181, 10, 24, 16, 5, -20 },
  { 211, 10, 24, 16, 1, -20 },
  { 241, 14, 13, 16, 1, -14 },
  { 264, 12, 12, 16, 2, -14 },
  { 282, 7, 8, 16, 3, -4 },
  { 289, 8, 2, 16, 4, -9 },
  { 291, 4, 4, 16, 5, -4 },
  { 293, 16, 24, 16, 0, -20 },
  { 341, 14, 18, 16, 1, -18 },
  { 373, 13, 18, 16, 1, -18 },
  { 403, 14, 18, 16, 1, -18 },
  { 435, 15, 18, 16, 0, -18 },
  { 469, 15, 18, 16, 0, -18 },
  { 503, 14, 18, 16, 1, -18 },
  { 535, 13, 18, 16, 1, -18 },
  { 565, 14, 18, 16, 2, -18 },
  { 597, 14, 18, 16, 1, -18 },
  { 629, 13, 18, 16, 2, -18 },
  { 659, 6, 14, 16, 5, -14 },
  { 670, 8, 18, 16, 3, -14 },
  { 688, 13, 15, 16, 2, -15 },
  { 713, 14, 8, 16, 1, -12 },
  { 727, 13, 15, 16, 1, -15 },
  { 752, 12, 18, 16, 3, -18 },
  { 779, 14, 21, 16, 1, -18 },
  { 816, 15, 18, 16, -1, -18 },
  { 850, 14, 18, 16, 1, -18 },
  { 882, 13, 18, 16, 2, -18 },
  { 912, 14, 18, 16, 1, -18 },
  { 944, 14, 18, 16, 1, -18 },
  { 976, 15, 18, 16, 1, -18 },
  { 1010, 14, 18, 16, 1, -18 },
  { 1042, 15, 18, 16, 1, -18 },
  { 1076, 14, 18, 16, 1, -18 },
  { 1108, 14, 18, 16, 1, -18 },
  { 1140, 16, 18, 16, 1, -18 },
  { 1176, 11, 18, 16, 2, -18 },
  { 1201, 16, 18, 16, 0, -18 },
  { 1237, 15, 18, 16, 1, -18 },
  { 1271, 14, 18, 16, 1, -18 },
  { 1303, 14, 18, 16, 1, -18 },
  { 1335, 14, 23, 16, 1, -18 },
  { 1376, 14, 18, 16, 1, -18 },
  { 1408, 14, 18, 16, 1, -18 },
  { 1440, 15, 18, 16, 2, -18 },
  { 1474, 14, 18, 16, 2, -18 },
  { 1506, 14, 18, 16, 3, -18 },
  { 1538, 16, 18, 16, 1, -18 },
  { 1574, 18, 18, 16, -1, -18 },
  { 1615, 15, 18, 16, 2, -18 },
  { 1649, 16, 18, 16, 0, -18 },
  { 1685, 11, 24, 16, 4, -20 },
  { 1718, 8, 24, 16, 4, -20 },
  { 1742, 12, 24, 16, 0, -20 },
  { 1778, 14, 11, 16, 1, -18 },
  { 1798, 13, 2, 16, 0, 2 },
  { 1802, 5, 6, 16, 5, -21 },
  { 1806, 13, 13, 16, 1, -13 },
  { 1828, 13, 19, 16, 1, -19 },
  { 1859, 12, 13, 16, 2, -13 },
  { 1879, 15, 19, 16, 1, -19 },
  { 1915, 12, 13, 16, 2, -13 },
  { 1935, 18, 24, 16, -1, -19 },
  { 1989, 14, 18, 16, 1, -13 },
  { 2021, 13, 19, 16, 1, -19 },
  { 2052, 12, 19, 16, 2, -19 },
  { 2081, 13, 24, 16, 1, -19 },
  { 2120, 14, 19, 16, 1, -19 },
  { 2154, 11, 19, 16, 3, -19 },
  { 2181, 15, 13, 16, 0, -13 },
  { 2206, 13, 13, 16, 1, -13 },
  { 2228, 13, 13, 16, 1, -13 },
  { 2250, 14, 18, 16, 0, -13 },
  { 2282, 14, 18, 16, 1, -13 },
  { 2314, 12, 13, 16, 3, -13 },
  { 2334, 13, 13, 16, 1, -13 },
  { 2356, 12, 18, 16, 2, -18 },
  { 2383, 12, 13, 16, 2, -13 },
  { 2403, 13, 13, 16, 1, -13 },
  { 2425, 14, 13, 16, 1, -13 },
  { 2448, 16, 13, 16, 0, -13 },
  { 2474, 14, 18, 16, 0, -13 },
  { 2506, 14, 13, 16, 1, -13 },
  { 2529, 12, 24, 16, 3, -20 },
  { 2565, 6, 24, 16, 5, -20 },
  { 2583, 12, 24, 16, 1, -20 },
  { 2619, 14, 6, 16, 1, -11 },
};

const GFXfont IBMPlexMono_MediumItalic26pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic26pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _IBMPLEXMONO_MEDIUMITALIC26PT7B_H_
