#ifndef _IBMPLEXMONO_MEDIUMITALIC12PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0xA4, 0x36, 0x55, 0xD9, 0x1A, 0x29, 0xD9, 0x22, 0x9D, 0xD6,
  0x28, 0x08, 0x79, 0xAA, 0x43, 0x03, 0x85, 0xEA, 0x78, 0x40, 0x73, 0x52,
  0x54, 0x78, 0x0E, 0x32, 0x52, 0x8C, 0x1C, 0x48, 0x91, 0xED, 0x12, 0x26,
  0xB6, 0x57, 0x19, 0x18, 0x84, 0x62, 0x10, 0x42, 0x08, 0x30, 0x82, 0x10,
  0x84, 0x22, 0x11, 0x30, 0x10, 0x8F, 0xC8, 0x52, 0x60, 0x30, 0x8F, 0xC8,
  0x20, 0x36, 0x4C, 0xF0, 0xF0, 0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10,
  0x20, 0x83, 0x00, 0x39, 0x38, 0x6D, 0xAE, 0x28, 0xBC, 0x3A, 0xA4, 0x23,
  0x18, 0x9F, 0x3C, 0xCC, 0x18, 0x20, 0x86, 0x18, 0x7E, 0x3C, 0xCC, 0x10,
  0xC2, 0x40, 0xB3, 0x3C, 0x0E, 0x38, 0x51, 0x24, 0xDF, 0xC2, 0x04, 0x3E,
  0x40, 0x82, 0xE6, 0x40, 0xD1, 0x7C, 0x18, 0x84, 0x2E, 0xCE, 0x38, 0xBC,
  0xFE, 0x30, 0x86, 0x10, 0x86, 0x30, 0x3C, 0xC5, 0x99, 0xC4, 0x58, 0xF1,
  0x3C, 0x7B, 0x38, 0x63, 0x78, 0x63, 0x38, 0x6C, 0x0D, 0x80, 0x33, 0x00,
  0x36, 0x4C, 0x04, 0x66, 0x20, 0x60, 0xC0, 0x80, 0xFC, 0x0F, 0x80, 0x43,
  0x06, 0x13, 0x62, 0x00, 0x79, 0x38, 0xCE, 0x20, 0x06, 0x18, 0x39, 0x1B,
  0xE9, 0xAE, 0xAB, 0xA0, 0x70, 0x18, 0x73, 0xC9, 0x65, 0xFC, 0x61, 0x3C,
  0x4D, 0x9B, 0xC4, 0x48, 0x91, 0x7C, 0x39, 0x1C, 0x20, 0x82, 0x28, 0xDC,
  0x3C, 0x4D, 0x8B, 0x34, 0x68, 0xD3, 0x7C, 0x3E, 0x41, 0x83, 0xE4, 0x08,
  0x10, 0x7E, 0x3E, 0x41, 0x83, 0xE4, 0x08, 0x10, 0x60, 0x39, 0x3C, 0x20,
  0x9E, 0x28, 0xBE, 0x22, 0x45, 0x9B, 0xF4, 0x48, 0x91, 0x66, 0x3E, 0x10,
  0x60, 0xC1, 0x02, 0x04, 0x7E, 0x7C, 0x30, 0x82, 0x08, 0x69, 0xBC, 0x23,
  0x24, 0x68, 0x70, 0x68, 0x48, 0x4C, 0xC6, 0x62, 0x10, 0x8C, 0x62, 0x1F,
  0x62, 0xCD, 0x6A, 0xD5, 0x6A, 0xB1, 0x42, 0x32, 0x65, 0xCA, 0xB5, 0x49,
  0x93, 0x66, 0x39, 0x38, 0x61, 0x8E, 0x28, 0xBC, 0x79, 0x1C, 0x73, 0xFA,
  0x08, 0x20, 0x39, 0x38, 0x61, 0x8E, 0x28, 0xBC, 0x24, 0x60, 0x79, 0x1C,
  0x73, 0xFA, 0x49, 0x22, 0x3C, 0xC5, 0x81, 0x80, 0xC0, 0xB1, 0x3C, 0xFE,
  0x20, 0xC1, 0x82, 0x04, 0x08, 0x30, 0x47, 0x1C, 0xE3, 0x8A, 0x28, 0xBC,
  0xC7, 0x8B, 0x32, 0x45, 0x8A, 0x1C, 0x30, 0x41, 0x42, 0x5A, 0x5A, 0x6A,
  0x6C, 0x6C, 0xCC, 0x63, 0x26, 0x3C, 0x18, 0x18, 0x28, 0x4C, 0xC4, 0xC6,
  0x99, 0x23, 0x83, 0x04, 0x08, 0x30, 0x3E, 0x8C, 0x30, 0xC3, 0x04, 0x10,
  0x7E, 0x7A, 0x10, 0x84, 0x23, 0x10, 0x84, 0x38, 0x91, 0x24, 0x91, 0x24,
  0x80, 0x3C, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x4F, 0x00, 0x30, 0xE4,
  0xB2, 0x84, 0xFC, 0x74, 0x7F, 0x28, 0xA2, 0xBB, 0xF0, 0x20, 0x40, 0x83,
  0xE6, 0x68, 0xD1, 0x22, 0xF8, 0x7E, 0x61, 0x08, 0xB8, 0x04, 0x10, 0xDF,
  0xCA, 0x28, 0xAE, 0xF8, 0x7C, 0x7F, 0x28, 0xB8, 0x0F, 0x08, 0x08, 0x7E,
  0x18, 0x10, 0x10, 0x10, 0x90, 0xF0, 0x60, 0x3E, 0xC9, 0x12, 0x24, 0xCF,
  0xA2, 0x3C, 0x42, 0x11, 0xBE, 0xC6, 0x31, 0x98, 0x30, 0xC0, 0x38, 0x20,
  0x86, 0x9F, 0x70, 0x04, 0x30, 0x0F, 0x08, 0x20, 0x82, 0x5B, 0x63, 0x00,
  0x41, 0x04, 0x3E, 0xCA, 0x2B, 0x2D, 0x98, 0xF1, 0x08, 0x42, 0x31, 0x2A,
  0x60, 0x56, 0xF5, 0x4E, 0x99, 0x52, 0x80, 0xDF, 0x63, 0x18, 0xCC, 0x7B,
  0x28, 0xE2, 0x89, 0xC0, 0x7C, 0xCD, 0x1A, 0x24, 0x4F, 0x30, 0x40, 0x7F,
  0x28, 0xA2, 0x9B, 0xE1, 0x84, 0xEC, 0xC2, 0x18, 0x61, 0x00, 0x7E, 0x78,
  0x78, 0xF8, 0x20, 0x8F, 0xD8, 0x61, 0x25, 0x98, 0xCF, 0x28, 0xA2, 0xBB,
  0xE0, 0xC9, 0x34, 0xB2, 0xDB, 0x80, 0x4A, 0xA5, 0x4A, 0x99, 0x4F, 0x00,
  0x37, 0xB4, 0x40, 0x8B, 0x7B, 0x80, 0x66, 0xC9, 0x12, 0x25, 0xCF, 0xA2,
  0x38, 0x3A, 0x88, 0x61, 0xA6, 0x5B, 0x80, 0x1C, 0xC2, 0x04, 0x13, 0x81,
  0x08, 0x61, 0x07, 0x00, 0x24, 0xB4, 0x92, 0x4A, 0x00, 0x38, 0x20, 0x84,
  0x10, 0x33, 0x0C, 0x10, 0x4F, 0x00, 0x72, 0xAB, 0x30,
};

const GFXglyph IBMPlexMono_MediumItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 8, 7, 2, -8 },
  { 4, 4, 4, 7, 2, -9 },
  { 6, 7, 8, 7, 0, -8 },
  { 13, 7, 10, 7, 0, -9 },
  { 22, 8, 8, 7, 0, -8 },
  { 30, 7, 8, 7, 0, -8 },
  { 37, 2, 4, 7, 3, -9 },
  { 38, 5, 11, 7, 2, -9 },
  { 45, 5, 11, 7, 0, -9 },
  { 52, 6, 6, 7, 1, -7 },
  { 57, 6, 5, 7, 1, -6 },
  { 61, 4, 4, 7, 1, -2 },
  { 63, 4, 1, 7, 2, -4 },
  { 64, 2, 2, 7, 2, -2 },
  { 65, 7, 11, 7, 0, -9 },
  { 75, 6, 8, 7, 1, -8 },
  { 81, 5, 8, 7, 1, -8 },
  { 86, 7, 8, 7, 0, -8 },
  { 93, 7, 8, 7, 0, -8 },
  { 100, 7, 8, 7, 0, -8 },
  { 107, 7, 8, 7, 0, -8 },
  { 114, 6, 8, 7, 1, -8 },
  { 120, 6, 8, 7, 1, -8 },
  { 126, 7, 8, 7, 0, -8 },
  { 133, 6, 8, 7, 1, -8 },
  { 139, 3, 6, 7, 2, -6 },
  { 142, 4, 8, 7, 1, -6 },
  { 146, 6, 7, 7, 1, -7 },
  { 152, 6, 3, 7, 1, -5 },
  { 155, 5, 7, 7, 1, -7 },
  { 160, 6, 8, 7, 1, -8 },
  { 166, 6, 9, 7, 1, -8 },
  { 173, 6, 8, 7, 0, -8 },
  { 179, 7, 8, 7, 0, -8 },
  { 186, 6, 8, 7, 1, -8 },
  { 192, 7, 8, 7, 0, -8 },
  { 199, 7, 8, 7, 0, -8 },
  { 206, 7, 8, 7, 0, -8 },
  { 213, 6, 8, 7, 1, -8 },
  { 219, 7, 8, 7, 0, -8 },
  { 226, 7, 8, 7, 0, -8 },
  { 233, 6, 8, 7, 1, -8 },
  { 239, 8, 8, 7, 0, -8 },
  { 247, 5, 8, 7, 1, -8 },
  { 252, 7, 8, 7, 0, -8 },
  { 259, 7, 8, 7, 0, -8 },
  { 266, 6, 8, 7, 1, -8 },
  { 272, 6, 8, 7, 1, -8 },
  { 278, 6, 10, 7, 1, -8 },
  { 286, 6, 8, 7, 1, -8 },
  { 292, 7, 8, 7, 0, -8 },
  { 299, 7, 8, 7, 1, -8 },
  { 306, 6, 8, 7, 1, -8 },
  { 312, 7, 8, 7, 1, -8 },
  { 319, 8, 8, 7, 0, -8 },
  { 327, 8, 8, 7, 0, -8 },
  { 335, 7, 8, 7, 1, -8 },
  { 342, 7, 8, 7, 0, -8 },
  { 349, 5, 11, 7, 2, -9 },
  { 356, 3, 11, 7, 2, -9 },
  { 361, 6, 11, 7, 0, -9 },
  { 370, 6, 5, 7, 1, -8 },
  { 374, 6, 1, 7, 0, 1 },
  { 375, 2, 3, 7, 2, -10 },
  { 376, 6, 6, 7, 1, -6 },
  { 381, 7, 9, 7, 0, -9 },
  { 389, 5, 6, 7, 1, -6 },
  { 393, 6, 9, 7, 1, -9 },
  { 400, 5, 6, 7, 1, -6 },
  { 404, 8, 11, 7, 0, -9 },
  { 415, 7, 8, 7, 0, -6 },
  { 422, 5, 9, 7, 1, -9 },
  { 428, 6, 9, 7, 1, -9 },
  { 435, 6, 11, 7, 0, -9 },
  { 444, 6, 9, 7, 1, -9 },
  { 451, 5, 9, 7, 1, -9 },
  { 457, 7, 6, 7, 0, -6 },
  { 463, 5, 6, 7, 1, -6 },
  { 467, 6, 6, 7, 1, -6 },
  { 472, 7, 8, 7, 0, -6 },
  { 479, 6, 8, 7, 1, -6 },
  { 485, 6, 6, 7, 1, -6 },
  { 490, 5, 6, 7, 1, -6 },
  { 494, 6, 8, 7, 1, -8 },
  { 500, 6, 6, 7, 1, -6 },
  { 505, 6, 6, 7, 1, -6 },
  { 510, 7, 6, 7, 0, -6 },
  { 516, 7, 6, 7, 0, -6 },
  { 522, 7, 8, 7, 0, -6 },
  { 529, 7, 6, 7, 0, -6 },
  { 535, 6, 11, 7, 1, -9 },
  { 544, 3, 11, 7, 2, -9 },
  { 549, 6, 11, 7, 0, -9 },
  { 558, 7, 3, 7, 0, -5 },
};

const GFXfont IBMPlexMono_MediumItalic12pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic12pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _IBMPLEXMONO_MEDIUMITALIC12PT7B_H_
