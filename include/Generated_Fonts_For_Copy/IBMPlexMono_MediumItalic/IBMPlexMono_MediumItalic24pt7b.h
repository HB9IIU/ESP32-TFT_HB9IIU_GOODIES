#ifndef _IBMPLEXMONO_MEDIUMITALIC24PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC7, 0x1C, 0x61, 0x84, 0x10, 0x40, 0x00, 0x01, 0xC7,
  0x3C, 0x70, 0x33, 0xB9, 0x9C, 0xCC, 0x66, 0x33, 0x3B, 0x9C, 0x01, 0x9C,
  0x03, 0x30, 0x0C, 0x60, 0x19, 0xC0, 0x33, 0x07, 0xC7, 0xCF, 0x9F, 0x83,
  0x30, 0x0C, 0x60, 0x19, 0xC3, 0xF3, 0xE7, 0xC7, 0xC1, 0x9C, 0x03, 0x30,
  0x0C, 0x60, 0x19, 0xC0, 0x73, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x3F, 0x03,
  0xFE, 0x1C, 0x9C, 0x62, 0x23, 0x98, 0x0E, 0x60, 0x1D, 0x80, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x03, 0x38, 0x0C, 0xE0, 0x33, 0x98, 0xCE, 0xF3, 0x71,
  0xFF, 0x81, 0xFC, 0x01, 0x80, 0x06, 0x00, 0x07, 0x83, 0x87, 0xC1, 0x86,
  0x31, 0x83, 0x19, 0x83, 0x0C, 0xC1, 0x86, 0xC0, 0xE6, 0xC0, 0x3F, 0x00,
  0x0F, 0x38, 0x00, 0x3E, 0x01, 0xB1, 0x81, 0x98, 0xC1, 0xD8, 0x60, 0xCC,
  0x70, 0xC6, 0x30, 0xC1, 0xF8, 0xE0, 0x70, 0x00, 0x03, 0xE0, 0x1F, 0xC0,
  0xE3, 0x03, 0x0C, 0x0C, 0x38, 0x30, 0xC0, 0xE3, 0x01, 0x98, 0x3F, 0xC1,
  0xDC, 0x0E, 0x30, 0x38, 0xE0, 0xE1, 0x8B, 0x87, 0x3E, 0x2D, 0x9F, 0xBE,
  0x3C, 0x70, 0x6D, 0xFF, 0xB0, 0x03, 0x87, 0x03, 0x03, 0x03, 0x03, 0x81,
  0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0x06, 0x01, 0x80, 0x1C, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x0C, 0x0E,
  0x06, 0x06, 0x06, 0x0E, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x86, 0x27,
  0xF7, 0xFF, 0xF8, 0x3E, 0x01, 0xE0, 0x1F, 0x81, 0xCC, 0x1C, 0x70, 0x41,
  0x00, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x61, 0xFF, 0xFF, 0xF8, 0x60,
  0x0C, 0x01, 0x80, 0x70, 0x0E, 0x00, 0x3C, 0xE3, 0x9C, 0x63, 0x8C, 0x00,
  0xFF, 0xFC, 0x77, 0xFC, 0xE0, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0x1C, 0x70,
  0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xEC, 0xE7, 0xE7, 0x3F, 0x39, 0xF8, 0x0D,
  0xC0, 0xEE, 0x07, 0x70, 0x71, 0xC7, 0x0F, 0xF8, 0x1F, 0x00, 0x07, 0xC0,
  0xFC, 0x1F, 0xC3, 0xDC, 0x79, 0x87, 0x18, 0x23, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xC0, 0xFF, 0x0E, 0x1C, 0xE0, 0x61, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x1F, 0xFC, 0xFF, 0xE0, 0x03, 0xE0, 0x3F, 0xE1, 0xC3, 0x82, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x07, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x31, 0x81, 0xCF, 0x0F, 0x1F, 0xF8, 0x1F, 0x80, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x03, 0x60, 0x3B, 0x03, 0x98, 0x19, 0xC1, 0x8E, 0x1C,
  0x71, 0xC3, 0x9C, 0x18, 0xC0, 0xCF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x1F, 0xF8, 0xFF, 0xC6, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00,
  0xDF, 0x07, 0xFC, 0x70, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x20,
  0x73, 0x87, 0x8F, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x33, 0xC7, 0xFE, 0x78, 0xFF, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x06, 0x70, 0xE7, 0xFC, 0x1F, 0x00, 0x7F, 0xFB, 0xFF, 0x98,
  0x1D, 0xC0, 0xEE, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x00,
  0x07, 0xE0, 0xFF, 0x8F, 0x0E, 0x70, 0x73, 0x03, 0x98, 0x18, 0xE1, 0xC3,
  0xF8, 0x1F, 0xC3, 0x87, 0x38, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x83,
  0x8F, 0xF8, 0x3F, 0x00, 0x0F, 0x83, 0xFE, 0x70, 0xE6, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0F, 0xF1, 0xE7, 0xEE, 0x3D, 0xC0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x03, 0xC0, 0xF8, 0x00, 0x1C, 0xF3, 0xCE, 0x00, 0x00, 0x00,
  0x01, 0xCF, 0xBC, 0x70, 0x0E, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x78, 0xE1, 0xC7, 0x0C, 0x38, 0x60, 0x00, 0x10, 0x06, 0x01, 0xE0, 0x7C,
  0x1F, 0x07, 0xC0, 0xF0, 0x0E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xC0, 0x08, 0x7F, 0xFB, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFB, 0xFF, 0xC0, 0x20, 0x03, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0x70, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0x80, 0xE0, 0x08, 0x00,
  0x1F, 0x1F, 0xFE, 0x1F, 0x83, 0x40, 0xC0, 0x70, 0x3C, 0x7E, 0x1E, 0x0E,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x00, 0x07, 0xC0,
  0x7F, 0x87, 0x0C, 0x70, 0x73, 0x01, 0xB9, 0xED, 0x9F, 0xEC, 0xC6, 0x66,
  0x37, 0x71, 0xBB, 0x0D, 0x98, 0x6C, 0xC7, 0x67, 0xF3, 0x1D, 0x98, 0x00,
  0x60, 0x03, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x6C, 0x03, 0xB0, 0x0C, 0xC0, 0x73, 0x81, 0x8E, 0x0E, 0x38, 0x30,
  0xE1, 0xFF, 0x87, 0xFE, 0x18, 0x18, 0xE0, 0x63, 0x01, 0xDC, 0x07, 0xE0,
  0x1C, 0x1F, 0xE0, 0xFF, 0x8E, 0x1C, 0x70, 0x73, 0x83, 0x18, 0x38, 0xC1,
  0xC7, 0xF8, 0x7F, 0xC3, 0x83, 0x1C, 0x1C, 0xC0, 0xE6, 0x07, 0x30, 0x3B,
  0x83, 0x9F, 0xF8, 0xFF, 0x80, 0x07, 0xC1, 0xFE, 0x38, 0x77, 0x07, 0x70,
  0x4E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x6E, 0x0E, 0xE1, 0xC7, 0xF8, 0x3F, 0x00, 0x1F, 0xC0, 0xFF, 0x0E, 0x1C,
  0x70, 0x63, 0x83, 0x9C, 0x1C, 0xC0, 0xE6, 0x07, 0x70, 0x3B, 0x81, 0xDC,
  0x1C, 0xE0, 0xE6, 0x07, 0x30, 0x73, 0x87, 0x9F, 0xF0, 0xFF, 0x00, 0x1F,
  0xF8, 0xFF, 0xCE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x07, 0xFE,
  0x7F, 0xF3, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1F,
  0xFC, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xE3, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x0F, 0xFC, 0x7F, 0xE1, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x7F,
  0x87, 0x1C, 0x70, 0x73, 0x02, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x63, 0xF7,
  0x1F, 0xB8, 0x1D, 0xC0, 0xEE, 0x06, 0x30, 0x71, 0xC5, 0x8F, 0xEC, 0x1E,
  0xE0, 0x38, 0x19, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x03, 0x98, 0x1D, 0xC0,
  0xCF, 0xFE, 0x7F, 0xF3, 0x83, 0x98, 0x1C, 0xC0, 0xEE, 0x06, 0x70, 0x33,
  0x83, 0x9C, 0x1C, 0xC0, 0xE0, 0x1F, 0xF9, 0xFF, 0xC0, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x1F, 0xFC, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC2, 0x0C, 0x70, 0xE3, 0x87, 0x0F, 0xF0, 0x3F,
  0x00, 0x18, 0x1E, 0x70, 0x70, 0xE1, 0xC1, 0xC7, 0x83, 0x9E, 0x06, 0x78,
  0x0C, 0xE0, 0x3B, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xEE, 0x03, 0x8E, 0x06,
  0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x30, 0xE0, 0x70, 0x38, 0x0E, 0x03,
  0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0x1C, 0x1E, 0x3C, 0x3C, 0x78,
  0xF0, 0xF1, 0xE3, 0xE6, 0xC7, 0xCD, 0x8C, 0xF7, 0x19, 0xEE, 0x33, 0x98,
  0x67, 0x31, 0xCC, 0x63, 0x88, 0xC6, 0x23, 0x8C, 0x07, 0x18, 0x0C, 0x30,
  0x18, 0xE0, 0x30, 0x3C, 0x19, 0xE0, 0xCF, 0x06, 0x7C, 0x73, 0x63, 0x9B,
  0x1D, 0xD8, 0xCE, 0xC6, 0x77, 0x33, 0x1B, 0x98, 0xDC, 0xC6, 0xEE, 0x3E,
  0x71, 0xF3, 0x87, 0x98, 0x3C, 0xC1, 0xE0, 0x07, 0xC0, 0x7F, 0x87, 0x1C,
  0x70, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xEC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x71, 0xC7, 0x0F, 0xF8, 0x1F, 0x00, 0x1F,
  0xE0, 0xFF, 0x8E, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xC0, 0xE6, 0x0E,
  0x7F, 0xF3, 0xFE, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0x1C, 0x70, 0x77, 0x03, 0xB8,
  0x1D, 0xC0, 0xEC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1D, 0xC0, 0xEE, 0x07,
  0x70, 0x71, 0xC7, 0x8F, 0xF8, 0x1F, 0x00, 0x30, 0x01, 0xCC, 0x06, 0xF0,
  0x3E, 0x00, 0xE0, 0x1F, 0xE0, 0xFF, 0x8E, 0x0E, 0x70, 0x73, 0x83, 0x9C,
  0x1C, 0xC0, 0xE6, 0x0E, 0x7F, 0xF3, 0xFE, 0x1C, 0xE0, 0xE3, 0x06, 0x1C,
  0x30, 0xE3, 0x83, 0x1C, 0x1C, 0xE0, 0xE0, 0x03, 0xF0, 0x3F, 0xE1, 0xC1,
  0xC6, 0x02, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x03,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x39, 0x80, 0xEF, 0x07, 0x1F, 0xF8, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x37, 0x03, 0x70, 0x77,
  0x07, 0x60, 0x76, 0x07, 0xE0, 0x6E, 0x06, 0xE0, 0xEE, 0x0E, 0xC0, 0xEC,
  0x0E, 0xC0, 0xCC, 0x1C, 0xE3, 0xCF, 0xF8, 0x3E, 0x00, 0xE0, 0x3D, 0x80,
  0xE6, 0x03, 0x18, 0x1C, 0x70, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x71,
  0xC1, 0xC6, 0x03, 0x38, 0x0C, 0xC0, 0x37, 0x00, 0xDC, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0x70, 0x0E, 0xC0, 0x19, 0x80, 0x33, 0x00, 0xE6, 0x39,
  0x8C, 0xF3, 0x19, 0xE6, 0x33, 0xCC, 0x6D, 0xB9, 0xDB, 0x63, 0xB6, 0xC6,
  0xCD, 0x8D, 0x9F, 0x1B, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE0, 0x0E,
  0x07, 0x87, 0x07, 0x01, 0x83, 0x80, 0xE3, 0x80, 0x73, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xCE,
  0x00, 0xE7, 0x00, 0xE1, 0x80, 0xE0, 0xE0, 0x70, 0x70, 0xF0, 0x1C, 0x00,
  0xE0, 0x3D, 0x80, 0xE7, 0x07, 0x1C, 0x18, 0x30, 0xE0, 0xE7, 0x03, 0x98,
  0x06, 0xE0, 0x1F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0xFC,
  0xFF, 0xF0, 0x0F, 0xE1, 0xFC, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x3F, 0x8F, 0xF0, 0xC1, 0xC1, 0x83, 0x06, 0x0C,
  0x0C, 0x18, 0x30, 0x60, 0xC0, 0xC1, 0x83, 0x06, 0x0E, 0x0C, 0x18, 0x30,
  0x60, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x3F, 0x8F, 0xF0, 0x03, 0xC0, 0x1E, 0x01, 0xB0,
  0x1D, 0xC1, 0xC6, 0x0C, 0x30, 0xE1, 0xCE, 0x06, 0x60, 0x3F, 0x01, 0x80,
  0xFF, 0xFF, 0xFE, 0x4E, 0x67, 0x20, 0x0F, 0x33, 0xFF, 0x78, 0xF7, 0x07,
  0x60, 0x6E, 0x06, 0xE0, 0x6E, 0x0E, 0xE0, 0xEE, 0x3E, 0x7E, 0xF3, 0xC7,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3B, 0xE3, 0x7F,
  0x7C, 0x77, 0x83, 0x70, 0x37, 0x03, 0x60, 0x76, 0x07, 0x60, 0x6F, 0x0E,
  0xFF, 0xCE, 0xF8, 0x0F, 0x87, 0xF9, 0xC3, 0xF0, 0x4E, 0x01, 0xC0, 0x30,
  0x06, 0x04, 0xC0, 0xDC, 0x39, 0xFE, 0x1F, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x3C, 0xC7, 0xF6, 0x78, 0x73, 0x83,
  0x98, 0x1D, 0xC0, 0xCE, 0x06, 0x70, 0x73, 0x83, 0x9C, 0x3C, 0x7E, 0xE1,
  0xE6, 0x00, 0x0F, 0x87, 0xF9, 0xC3, 0xF0, 0x7E, 0x1F, 0xFF, 0xBF, 0x86,
  0x00, 0xC0, 0xDC, 0x3D, 0xFE, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x3F, 0xFC, 0x1F, 0xFC,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x21, 0xC0, 0x18, 0xE0, 0x1E,
  0x70, 0x03, 0xB0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x0F, 0x33, 0xFB, 0x78,
  0xF7, 0x07, 0x60, 0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0xE0, 0xEF, 0x1E, 0x7E,
  0xE3, 0xCC, 0x00, 0xC0, 0x1C, 0xC3, 0x8F, 0xF8, 0x7E, 0x00, 0x1C, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x39, 0xC3, 0xBE, 0x34, 0x77,
  0x87, 0x70, 0x77, 0x07, 0x70, 0x66, 0x06, 0x60, 0xEE, 0x0E, 0xE0, 0xEE,
  0x0E, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF0,
  0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC4, 0x31, 0xC6, 0x71, 0xDC, 0x1F,
  0x03, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC1, 0xFC, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x84, 0x30, 0xE3, 0x07, 0x30, 0x3F, 0x03, 0xF0, 0x1E,
  0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE7,
  0x86, 0xFC, 0x34, 0x73, 0xC3, 0x9C, 0x18, 0xE1, 0x87, 0x78, 0x37, 0x01,
  0x9C, 0x5C, 0x6F, 0xE3, 0xE7, 0x0E, 0x00, 0x7E, 0x1F, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03,
  0x84, 0x71, 0xCE, 0x61, 0xB8, 0x3E, 0x03, 0x80, 0x37, 0x38, 0xDF, 0xF3,
  0xBC, 0xCC, 0x63, 0x73, 0x9D, 0x8C, 0x66, 0x31, 0x98, 0xC6, 0x63, 0x1B,
  0x9C, 0x6E, 0x73, 0xB1, 0x8C, 0x39, 0xC3, 0xBE, 0x34, 0x73, 0x87, 0x70,
  0x77, 0x07, 0x70, 0x66, 0x06, 0x60, 0xE6, 0x0E, 0xE0, 0xEE, 0x0E, 0x0F,
  0x81, 0xFE, 0x38, 0x77, 0x07, 0x60, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xE7, 0x0E, 0x7F, 0xC1, 0xF0, 0x1D, 0xF0, 0xDF, 0xC7, 0x8E, 0x78, 0x33,
  0x81, 0x9C, 0x0C, 0xC0, 0xE6, 0x07, 0x30, 0x33, 0xC3, 0x9F, 0xF8, 0xEF,
  0x86, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x0F, 0x33, 0xFB,
  0x78, 0x77, 0x07, 0x60, 0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0xE0, 0xEE, 0x1E,
  0x7E, 0xE3, 0xCE, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x7E,
  0xF7, 0xDF, 0x8F, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x0F, 0xC1, 0xFF, 0x38, 0x63, 0x00, 0x38,
  0x03, 0xF8, 0x0F, 0xE0, 0x0E, 0x00, 0x66, 0x0E, 0xFF, 0xC3, 0xF0, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC1, 0xFF, 0xFF, 0xF8, 0xE0, 0x18, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x8C, 0x73, 0xCC, 0xE1, 0xF8, 0x1C, 0x00, 0x70,
  0x6C, 0x0D, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xB0, 0x36, 0x0E, 0xC1, 0xDC,
  0xFB, 0xF7, 0x3C, 0xC0, 0x7C, 0x6F, 0x87, 0x18, 0x73, 0x83, 0x38, 0x73,
  0x87, 0x38, 0x73, 0x0E, 0x31, 0xE3, 0x3C, 0x3F, 0x83, 0xE0, 0x63, 0x33,
  0x19, 0xD8, 0xCE, 0xC6, 0x3E, 0x71, 0xE3, 0x1F, 0x18, 0xD8, 0xC6, 0xC6,
  0x36, 0x73, 0x3D, 0x91, 0xC7, 0x00, 0x0E, 0x38, 0x7D, 0xF7, 0xB4, 0xD8,
  0xE3, 0x03, 0x8C, 0x0E, 0x00, 0x30, 0x31, 0xC0, 0xC7, 0x1B, 0x3E, 0xEF,
  0x9F, 0x1C, 0x70, 0x1C, 0x18, 0xC0, 0xC6, 0x0E, 0x70, 0x73, 0x83, 0x9C,
  0x18, 0xE0, 0xC6, 0x0E, 0x30, 0x71, 0xCF, 0x8F, 0xDC, 0x3C, 0xC0, 0x0E,
  0x00, 0x71, 0x87, 0x1F, 0xF8, 0x3F, 0x00, 0x1F, 0x39, 0xFF, 0x9C, 0x7C,
  0xC1, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x8C, 0x38, 0x77, 0xF1, 0xB7,
  0xFD, 0x87, 0xC0, 0x07, 0xE1, 0xFC, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x30, 0x0E, 0x1F, 0x83, 0xE0, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x3F, 0x83, 0xF0, 0x18, 0xC6, 0x33, 0x98,
  0xC6, 0x31, 0x9C, 0xC6, 0x31, 0x9C, 0xE6, 0x31, 0x8C, 0x00, 0x1F, 0x83,
  0xF8, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x70, 0x0E, 0x00, 0xFC,
  0x1F, 0x86, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x7F, 0x0F, 0xC0, 0x3C, 0x1B, 0xF1, 0x99, 0xCD, 0x87, 0xCC, 0x1C, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 17, 14, 4, -17 },
  { 14, 9, 7, 14, 4, -18 },
  { 22, 15, 17, 14, 0, -17 },
  { 54, 14, 21, 14, 0, -19 },
  { 91, 17, 17, 14, -1, -17 },
  { 128, 14, 17, 14, 0, -17 },
  { 158, 3, 7, 14, 7, -18 },
  { 161, 9, 21, 14, 5, -18 },
  { 185, 9, 21, 14, 1, -18 },
  { 209, 13, 12, 14, 1, -13 },
  { 229, 11, 12, 14, 2, -13 },
  { 246, 6, 7, 14, 3, -4 },
  { 252, 7, 2, 14, 4, -8 },
  { 254, 5, 4, 14, 4, -4 },
  { 257, 14, 21, 14, 0, -18 },
  { 294, 13, 17, 14, 1, -17 },
  { 322, 12, 17, 14, 1, -17 },
  { 348, 13, 17, 14, 1, -17 },
  { 376, 14, 17, 14, 0, -17 },
  { 406, 13, 17, 14, 0, -17 },
  { 434, 13, 17, 14, 1, -17 },
  { 462, 12, 17, 14, 1, -17 },
  { 488, 13, 17, 14, 2, -17 },
  { 516, 13, 17, 14, 1, -17 },
  { 544, 12, 17, 14, 2, -17 },
  { 570, 6, 13, 14, 4, -13 },
  { 580, 7, 16, 14, 3, -13 },
  { 594, 12, 14, 14, 2, -14 },
  { 615, 13, 7, 14, 1, -11 },
  { 627, 12, 14, 14, 1, -14 },
  { 648, 10, 17, 14, 3, -17 },
  { 670, 13, 20, 14, 1, -17 },
  { 703, 14, 17, 14, -1, -17 },
  { 733, 13, 17, 14, 1, -17 },
  { 761, 12, 17, 14, 2, -17 },
  { 787, 13, 17, 14, 1, -17 },
  { 815, 13, 17, 14, 1, -17 },
  { 843, 14, 17, 14, 1, -17 },
  { 873, 13, 17, 14, 1, -17 },
  { 901, 13, 17, 14, 1, -17 },
  { 929, 13, 17, 14, 1, -17 },
  { 957, 13, 17, 14, 1, -17 },
  { 985, 15, 17, 14, 1, -17 },
  { 1017, 10, 17, 14, 2, -17 },
  { 1039, 15, 17, 14, 0, -17 },
  { 1071, 13, 17, 14, 1, -17 },
  { 1099, 13, 17, 14, 1, -17 },
  { 1127, 13, 17, 14, 1, -17 },
  { 1155, 13, 22, 14, 1, -17 },
  { 1191, 13, 17, 14, 1, -17 },
  { 1219, 14, 17, 14, 0, -17 },
  { 1249, 14, 17, 14, 2, -17 },
  { 1279, 12, 17, 14, 2, -17 },
  { 1305, 14, 17, 14, 2, -17 },
  { 1335, 15, 17, 14, 1, -17 },
  { 1367, 17, 17, 14, -1, -17 },
  { 1404, 14, 17, 14, 2, -17 },
  { 1434, 15, 17, 14, 0, -17 },
  { 1466, 11, 21, 14, 3, -18 },
  { 1495, 7, 21, 14, 4, -18 },
  { 1514, 11, 21, 14, 0, -18 },
  { 1543, 13, 10, 14, 1, -17 },
  { 1560, 12, 2, 14, 0, 2 },
  { 1563, 4, 5, 14, 5, -19 },
  { 1566, 12, 12, 14, 1, -12 },
  { 1584, 12, 18, 14, 1, -18 },
  { 1611, 11, 12, 14, 2, -12 },
  { 1628, 13, 18, 14, 1, -18 },
  { 1658, 11, 12, 14, 2, -12 },
  { 1675, 17, 23, 14, -1, -18 },
  { 1724, 12, 17, 14, 1, -12 },
  { 1750, 12, 18, 14, 1, -18 },
  { 1777, 11, 18, 14, 2, -18 },
  { 1802, 12, 23, 14, 1, -18 },
  { 1837, 13, 18, 14, 1, -18 },
  { 1867, 11, 18, 14, 2, -18 },
  { 1892, 14, 12, 14, 0, -12 },
  { 1913, 12, 12, 14, 1, -12 },
  { 1931, 12, 12, 14, 1, -12 },
  { 1949, 13, 17, 14, 0, -12 },
  { 1977, 12, 17, 14, 1, -12 },
  { 2003, 12, 12, 14, 2, -12 },
  { 2021, 12, 12, 14, 1, -12 },
  { 2039, 11, 17, 14, 2, -17 },
  { 2063, 11, 12, 14, 2, -12 },
  { 2080, 12, 12, 14, 1, -12 },
  { 2098, 13, 12, 14, 1, -12 },
  { 2118, 14, 12, 14, 0, -12 },
  { 2139, 13, 17, 14, 0, -12 },
  { 2167, 13, 12, 14, 1, -12 },
  { 2187, 11, 21, 14, 3, -18 },
  { 2216, 5, 21, 14, 5, -18 },
  { 2230, 11, 21, 14, 1, -18 },
  { 2259, 13, 5, 14, 1, -10 },
};

const GFXfont IBMPlexMono_MediumItalic24pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic24pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic24pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _IBMPLEXMONO_MEDIUMITALIC24PT7B_H_
