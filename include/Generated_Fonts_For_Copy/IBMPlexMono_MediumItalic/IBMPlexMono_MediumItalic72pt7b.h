#ifndef _IBMPLEXMONO_MEDIUMITALIC72PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x87,
  0xF0, 0x1F, 0xC7, 0xF8, 0x1F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0xFF,
  0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xF0,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE7, 0xEF, 0xFF, 0x01,
  0xFF, 0x07, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xC0, 0xFE, 0x03, 0xFC, 0x07,
  0xC0, 0x7C, 0x07, 0xF8, 0x07, 0xC0, 0x30, 0x07, 0xF8, 0x07, 0xC0, 0x20,
  0x07, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xF8,
  0x0F, 0x80, 0x00, 0x07, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xF8, 0x0F, 0x80,
  0x00, 0x07, 0xFC, 0x0F, 0x80, 0x00, 0x03, 0xFE, 0x1F, 0x80, 0x00, 0x03,
  0xFF, 0x9F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x3E, 0x7F, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0xF8, 0x00,
  0x00, 0x7C, 0x0F, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xF8, 0x00, 0x00, 0x7C,
  0x07, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xF8,
  0x00, 0x00, 0xFC, 0x07, 0xF8, 0x08, 0x00, 0xF8, 0x07, 0xF8, 0x0C, 0x00,
  0xF8, 0x07, 0xF8, 0x3E, 0x00, 0xF8, 0x0F, 0xF8, 0x7F, 0x00, 0xF8, 0x0F,
  0xF0, 0xFF, 0x81, 0xF8, 0x1F, 0xF0, 0xFF, 0xC1, 0xF8, 0x7F, 0xE0, 0xFF,
  0xF9, 0xF1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x07, 0xC0, 0x07, 0xE0, 0x01, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0xFE, 0x00,
  0x00, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xC3, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xE1, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0x87, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x3F, 0x80, 0x00, 0x07,
  0xE1, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x80, 0x00,
  0x3F, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80,
  0x01, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE3, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xC7, 0xF8, 0x00, 0x3F,
  0xC0, 0x3E, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0xE0, 0x01, 0xBF, 0x03,
  0xF9, 0xFE, 0x00, 0x37, 0xF0, 0x7E, 0x3F, 0xC0, 0x0E, 0xFE, 0x1F, 0xC7,
  0xFC, 0x03, 0x9F, 0xE7, 0xF0, 0xFF, 0xC1, 0xF1, 0xFC, 0xFC, 0x0F, 0xFF,
  0xFE, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0C, 0x00,
  0x3F, 0x80, 0x0C, 0x7C, 0x01, 0xFC, 0x03, 0xE7, 0xFC, 0x0F, 0xC0, 0xFF,
  0x3F, 0xFC, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0x00, 0x0F, 0xC1, 0xFF, 0x9F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0x1F, 0xF0, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x0F, 0xF7,
  0xF8, 0x0F, 0xC0, 0x7F, 0xDF, 0xE0, 0x7F, 0x81, 0xFE, 0xFF, 0x83, 0xFE,
  0x07, 0xFB, 0xFE, 0x0F, 0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0xE0, 0x7F, 0xBF,
  0xC0, 0xFF, 0x81, 0xFE, 0xFF, 0x03, 0xFC, 0x0F, 0xFB, 0xFC, 0x07, 0xE0,
  0x3F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0xCF, 0xE0, 0x00, 0x01,
  0xFE, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0xE3, 0xF8,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFC, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xC7,
  0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xE0, 0x03, 0xFF,
  0x03, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xE0, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x03, 0xC0, 0x0F, 0xF0,
  0x00, 0x70, 0x01, 0xFE, 0x00, 0x04, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0x00, 0x00, 0x7F, 0xC0, 0x04, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x00, 0x18,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x04, 0x00, 0x00, 0x0F,
  0xF0, 0x06, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0xF0, 0x3F,
  0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0x9F, 0xC0,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0x87, 0xFF, 0xC0, 0x00,
  0x7F, 0x1F, 0xFF, 0xE0, 0x00, 0xFC, 0x7F, 0xFF, 0xE0, 0x01, 0xF9, 0xFF,
  0xFF, 0xE0, 0x03, 0xF7, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0x80,
  0x01, 0xFF, 0x81, 0x1C, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x80,
  0x00, 0x03, 0xFC, 0x03, 0x80, 0x00, 0x0F, 0xF8, 0x0F, 0x00, 0x00, 0x1F,
  0xF0, 0x7F, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xFC, 0x01, 0xFE,
  0x3F, 0xFF, 0xE0, 0x3F, 0xCF, 0xFF, 0xFE, 0x0F, 0xF3, 0xFF, 0xFF, 0xE1,
  0xFE, 0xFF, 0xFF, 0xFC, 0x3F, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xC0, 0x3F,
  0xF9, 0xFF, 0xE0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF,
  0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x01,
  0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xF1, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x07, 0xF8,
  0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0,
  0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFE,
  0xFF, 0xC0, 0x03, 0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0xFE, 0x1F, 0xFF, 0xFF, 0xBF, 0xC3, 0xFF, 0xFF, 0xE7, 0xF8, 0x3F, 0xFF,
  0xF9, 0xFE, 0x03, 0xFF, 0xFE, 0x3F, 0xC0, 0x1F, 0xFF, 0x0F, 0xF0, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xF8, 0x0F, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x1F, 0xE1,
  0x80, 0x00, 0x3F, 0xC1, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC3, 0xF8, 0x07, 0xFE, 0x3F, 0x0F,
  0xE0, 0x3F, 0xFC, 0xFC, 0x3F, 0x01, 0xFF, 0xF3, 0xF1, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC7, 0xF0, 0x3F, 0xFF, 0xFF, 0x1F, 0x81, 0xFF, 0x07, 0xFC, 0x7E,
  0x07, 0xF0, 0x0F, 0xE3, 0xF8, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0xFE, 0x00,
  0x7E, 0x3F, 0x83, 0xF0, 0x01, 0xF8, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3, 0xF0,
  0x7F, 0x00, 0x3F, 0x9F, 0xC1, 0xFC, 0x00, 0xFC, 0x7F, 0x07, 0xF0, 0x03,
  0xF1, 0xFC, 0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xC3,
  0xF8, 0x01, 0xFC, 0x7E, 0x0F, 0xE0, 0x07, 0xF1, 0xF8, 0x3F, 0x80, 0x1F,
  0x87, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0x83, 0xF8, 0x03, 0xF8, 0x7E, 0x0F,
  0xE0, 0x1F, 0xE3, 0xF8, 0x1F, 0xC0, 0xFF, 0x8F, 0xE0, 0x7F, 0x8E, 0xFE,
  0x3F, 0x81, 0xFF, 0xFB, 0xF0, 0xFE, 0x07, 0xFF, 0xCF, 0xC3, 0xF8, 0x0F,
  0xFF, 0x3F, 0x07, 0xE0, 0x3F, 0xF9, 0xFC, 0x1F, 0x80, 0x7F, 0xC7, 0xF0,
  0x7E, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xE0,
  0x00, 0x0F, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x03, 0xFF,
  0x07, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE,
  0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xD1, 0xFF, 0x00,
  0x00, 0x30, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1C, 0x03, 0xFC,
  0x00, 0x00, 0x7C, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xFC,
  0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x01, 0xFF, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00,
  0xFF, 0x87, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F,
  0x80, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0x80, 0x01, 0xFF,
  0x81, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x03,
  0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xD1, 0xFF, 0x00, 0x00, 0x30, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0xFE, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8,
  0xFF, 0x80, 0x3F, 0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0xFF, 0x8F, 0xF8, 0x03,
  0xFF, 0xFE, 0x3F, 0xC0, 0x0F, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7D,
  0xFC, 0x01, 0xFF, 0xFF, 0xE7, 0xF0, 0x03, 0xFF, 0xFF, 0x9F, 0xC0, 0x0F,
  0xFF, 0xFC, 0x7F, 0x00, 0x1F, 0xFF, 0xE3, 0xFC, 0x00, 0x1F, 0xFE, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0x00, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x01, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x83,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x8F, 0xFC,
  0x00, 0x00, 0x0F, 0xF1, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xE1, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFD, 0xF8, 0x07, 0xEF, 0xE0,
  0x3F, 0xBF, 0x01, 0xF9, 0xF8, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x00, 0xFE,
  0x7E, 0x0F, 0xCF, 0xE0, 0x1F, 0xCF, 0xC3, 0xF9, 0xFC, 0x03, 0xF9, 0xF8,
  0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x9F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF3, 0xF1,
  0xFC, 0x03, 0xF8, 0x7E, 0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xFF, 0x87, 0xF0,
  0x0F, 0xE1, 0xFF, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0xFC, 0x1F, 0xC0, 0x7F,
  0x03, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0xE0, 0xFE, 0x01, 0xFC, 0x0F,
  0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x03, 0xFC,
  0x07, 0xF0, 0x0F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1C, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0x60, 0x07, 0xF0, 0x1F, 0xC0, 0x0C, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0xF0, 0x00, 0x1F, 0xC0, 0x3F,
  0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0x00,
  0x07, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x01, 0xFC,
  0x03, 0xFF, 0xF0, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xBF, 0x00,
  0x1F, 0xC0, 0x3F, 0xDF, 0xC0, 0x0F, 0xE0, 0x1F, 0xCF, 0xE0, 0x07, 0xF0,
  0x0F, 0xE7, 0xF0, 0x03, 0xF8, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0x03, 0xF8,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x83, 0xF0, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x00,
  0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x80,
  0xFE, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC7,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0x07, 0xF3, 0xF8, 0x03,
  0xF8, 0x03, 0xF9, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0x00,
  0x7F, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x7F, 0x00, 0x1F, 0xFF,
  0xC0, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xC0, 0x03, 0xFF, 0xE0, 0x1F,
  0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0xF8, 0x07, 0xF0, 0x00,
  0x7F, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x7F,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFE, 0x00,
  0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xE1,
  0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xDF,
  0xF0, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00,
  0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x01, 0xFE, 0xFF,
  0x80, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00,
  0xFF, 0xBF, 0xE0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xFB, 0xFC,
  0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x3F,
  0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xFC,
  0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x81,
  0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xE1, 0xFF,
  0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xF0,
  0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x1F,
  0xF7, 0xF8, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x01, 0xFE, 0xFF, 0x80,
  0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xFB, 0xFC, 0x00,
  0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xE3,
  0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x07,
  0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x1F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x80, 0x00, 0x1F, 0xE0, 0x07, 0x00, 0x00, 0x3F, 0xC0,
  0x7E, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00,
  0x03, 0xFC, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFF,
  0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x00,
  0x0F, 0x80, 0x3F, 0xC0, 0x00, 0x03, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x10, 0x00, 0x00, 0x1F,
  0xE0, 0x0C, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0xF8, 0x1F,
  0xC0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xFE, 0x00,
  0x0F, 0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFF, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF,
  0x80, 0xFE, 0x03, 0xF8, 0x07, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xFF, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xF8, 0x0F,
  0xC0, 0x3F, 0x81, 0xFF, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xFE, 0x07, 0xF0,
  0x0F, 0xE0, 0xFD, 0xF0, 0x3F, 0x00, 0x7F, 0x07, 0xEF, 0x81, 0xF8, 0x03,
  0xF0, 0x3E, 0x7C, 0x1F, 0xC0, 0x1F, 0x83, 0xF3, 0xE0, 0xFE, 0x00, 0xFC,
  0x1F, 0x1F, 0x07, 0xE0, 0x0F, 0xE0, 0xF8, 0xF8, 0x3F, 0x00, 0x7F, 0x0F,
  0xC7, 0xC3, 0xF8, 0x03, 0xF8, 0x7C, 0x3E, 0x1F, 0xC0, 0x1F, 0xC3, 0xE1,
  0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0x0F, 0x87, 0xE0, 0x07, 0xF1, 0xF0, 0x7C,
  0x3F, 0x00, 0x3F, 0x8F, 0x83, 0xE3, 0xF8, 0x01, 0xF8, 0xFC, 0x1F, 0x1F,
  0xC0, 0x0F, 0xC7, 0xC0, 0xF8, 0xFC, 0x00, 0x7E, 0x3E, 0x07, 0xC7, 0xE0,
  0x03, 0xF3, 0xF0, 0x3E, 0x7F, 0x00, 0x3F, 0x9F, 0x01, 0xF3, 0xF8, 0x01,
  0xFC, 0xF8, 0x0F, 0x9F, 0x80, 0x0F, 0xEF, 0xC0, 0x7C, 0xFC, 0x00, 0x7F,
  0x7C, 0x03, 0xE7, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0x7F, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x9F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xDF, 0xE0, 0x00, 0x00,
  0x7F, 0xE7, 0xF8, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x0F,
  0xF7, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF3, 0xE0, 0x00,
  0x00, 0x3E, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x06, 0x03, 0xC3, 0xFC, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xE0,
  0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0x80, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x3F, 0xC0, 0x1F, 0xFF, 0xE1,
  0xFC, 0x01, 0xFF, 0xFF, 0x8F, 0xE0, 0x1F, 0xFF, 0xFC, 0xFF, 0x01, 0xFF,
  0xFF, 0xF7, 0xF8, 0x1F, 0xFC, 0x07, 0xBF, 0xC0, 0xFF, 0x80, 0x0F, 0xFE,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xFC, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xF0, 0x3F, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0x3B, 0xFC, 0x0F, 0xF8,
  0x03, 0xDF, 0xE0, 0x3F, 0xF0, 0x7C, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF,
  0x87, 0xFF, 0xFE, 0x3F, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0xFC, 0x00,
  0xFE, 0x1F, 0xFF, 0xF0, 0x0F, 0xF1, 0xFF, 0xFF, 0x80, 0x7F, 0x9F, 0xFF,
  0xFE, 0x03, 0xFD, 0xF0, 0x3F, 0xF0, 0x1F, 0xEE, 0x00, 0x7F, 0xC0, 0xFF,
  0xE0, 0x01, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F,
  0x83, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00,
  0x7F, 0xC7, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x07,
  0xFC, 0x0F, 0xEF, 0x81, 0xFF, 0xE0, 0x7F, 0x3F, 0xFF, 0xFE, 0x07, 0xF9,
  0xFF, 0xFF, 0xE0, 0x3F, 0xC7, 0xFF, 0xFE, 0x01, 0xFE, 0x1F, 0xFF, 0xE0,
  0x0F, 0xF0, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x8F,
  0xF8, 0x00, 0x1F, 0x07, 0xF8, 0x00, 0x0E, 0x07, 0xF8, 0x00, 0x04, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x20, 0x7F, 0x80, 0x00, 0x1C, 0x3F, 0xC0, 0x00,
  0x0F, 0x9F, 0xE0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x1F, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0x87, 0xF8, 0x00, 0xFF, 0xFF,
  0xC7, 0xF8, 0x01, 0xFF, 0xFF, 0xE7, 0xF8, 0x03, 0xFF, 0xFF, 0xE7, 0xF8,
  0x03, 0xFF, 0x80, 0xF7, 0xF0, 0x07, 0xFC, 0x00, 0x37, 0xF0, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFF, 0x80,
  0x7F, 0xC0, 0x07, 0x7F, 0x00, 0x7F, 0xC0, 0x0F, 0x7F, 0x00, 0x3F, 0xF0,
  0x3E, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC7,
  0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F,
  0xF9, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xFF, 0x3F, 0xC0, 0x7F,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x04, 0x0F,
  0xF0, 0x00, 0x01, 0x83, 0xFC, 0x00, 0x00, 0xF8, 0xFF, 0x00, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x0F,
  0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF7, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x07, 0xF0, 0x03, 0xFF, 0xFC, 0x3F, 0xC0, 0x1F, 0xFF, 0xF8, 0xFF, 0x00,
  0xFF, 0xFF, 0xF3, 0xFC, 0x07, 0xFF, 0xFF, 0xEF, 0xF0, 0x3F, 0xFC, 0x07,
  0xBF, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x01,
  0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xC1, 0xFE,
  0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0x80,
  0x0E, 0xFF, 0x01, 0xFF, 0x00, 0x7B, 0xF8, 0x07, 0xFE, 0x07, 0xCF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x7F, 0x80, 0x3F, 0xFF, 0xF9, 0xFE, 0x00, 0x7F, 0xFF,
  0xC7, 0xF8, 0x00, 0xFF, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x02, 0x00, 0x00, 0xFF, 0x00, 0x1C, 0x00, 0x07,
  0xFC, 0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0x87, 0xFF, 0xE0, 0x0F,
  0xF1, 0xFF, 0xFE, 0x01, 0xFE, 0x7F, 0xFF, 0xE0, 0x3F, 0x9F, 0xFF, 0xFC,
  0x0F, 0xF3, 0xC0, 0xFF, 0xC1, 0xFE, 0xF0, 0x0F, 0xF8, 0x3F, 0xD8, 0x00,
  0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0xC0, 0x03, 0xFC, 0x1F, 0xF0,
  0x00, 0x3F, 0x87, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x01, 0xFC, 0x3F,
  0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00,
  0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x02, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x01, 0x00, 0x03, 0xFC, 0x00, 0x60, 0x00, 0xFF, 0x00, 0x3C, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xC1, 0xFF, 0x00,
  0x07, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x3F, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x04, 0x00, 0x1F,
  0xC0, 0x01, 0xC0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07,
  0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x81, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0x80,
  0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x3F,
  0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x0F, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xFF, 0x00, 0x0F, 0xF1, 0xFF, 0xFF,
  0x00, 0x1F, 0xE7, 0xFF, 0xFE, 0x00, 0x3F, 0x9F, 0xFF, 0xFE, 0x00, 0xFF,
  0x3C, 0x0F, 0xFC, 0x01, 0xFE, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x0F,
  0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x1F,
  0xF0, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x80, 0x01,
  0xFE, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x20,
  0x7F, 0x83, 0xFC, 0x00, 0xE0, 0xFF, 0x07, 0xF8, 0x03, 0xE1, 0xFE, 0x07,
  0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xF0, 0x3F, 0xEF, 0xF0, 0x0F, 0xF0, 0xFF,
  0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x3F, 0xC0, 0x1F, 0xCF, 0xF0, 0x7F, 0x80,
  0x3F, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0xFC,
  0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x02, 0x00, 0x7F, 0x80, 0x0E, 0x00, 0xFF, 0x00, 0x3E, 0x01,
  0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0xFF,
  0x1F, 0xF0, 0x01, 0xFC, 0x7F, 0xC0, 0x03, 0xF9, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0x9F, 0xF8,
  0x3F, 0xF8, 0x0F, 0xCF, 0xFF, 0x1F, 0xFE, 0x03, 0xF7, 0xFF, 0xCF, 0xFF,
  0x80, 0xFD, 0xFF, 0xF7, 0xFF, 0xF0, 0x7F, 0xE1, 0xFD, 0xC3, 0xFC, 0x1F,
  0xF0, 0x7F, 0x60, 0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x03,
  0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x80,
  0x7E, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x03, 0xF8,
  0x03, 0xF0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x03,
  0xF8, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC1, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x01, 0xF8,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0x83, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0xFC, 0x01, 0xFE, 0x3F, 0xFF, 0xC0,
  0x3F, 0xCF, 0xFF, 0xFC, 0x07, 0xF3, 0xFF, 0xFF, 0x81, 0xFE, 0x78, 0x1F,
  0xF8, 0x3F, 0xDE, 0x01, 0xFF, 0x07, 0xFB, 0x00, 0x1F, 0xE0, 0xFF, 0xC0,
  0x03, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x07, 0xF0, 0xFF,
  0x80, 0x00, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x03,
  0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x03, 0xFB, 0xFC,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x83, 0xFF, 0xE0, 0x00, 0x7F, 0x87, 0xFF, 0xF0, 0x00,
  0x7F, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0x7C, 0x0F, 0xFC, 0x00, 0xFF, 0x70, 0x03, 0xFE,
  0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x01, 0xFF,
  0x80, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0,
  0x0F, 0xEF, 0x81, 0xFF, 0xE0, 0x0F, 0xE7, 0xFF, 0xFF, 0xC0, 0x1F, 0xE7,
  0xFF, 0xFF, 0x80, 0x1F, 0xE3, 0xFF, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0xFE,
  0x00, 0x1F, 0xE0, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x1F, 0xC0, 0x0F, 0xFF, 0xE1, 0xFE, 0x01, 0xFF, 0xFF, 0x8F, 0xF0, 0x1F,
  0xFF, 0xFE, 0x7F, 0x81, 0xFF, 0xFF, 0xF3, 0xFC, 0x0F, 0xFE, 0x03, 0xDF,
  0xC0, 0xFF, 0x80, 0x06, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE3,
  0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0xC1, 0xFF,
  0x00, 0x1D, 0xFC, 0x0F, 0xF8, 0x01, 0xEF, 0xE0, 0x3F, 0xF0, 0x3E, 0xFF,
  0x01, 0xFF, 0xFF, 0xE7, 0xF8, 0x07, 0xFF, 0xFE, 0x3F, 0xC0, 0x3F, 0xFF,
  0xE1, 0xFC, 0x00, 0xFF, 0xFE, 0x0F, 0xE0, 0x01, 0xFF, 0xE0, 0xFF, 0x00,
  0x03, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xF7, 0xFF, 0xFE,
  0x07, 0xFE, 0x7F, 0xFF, 0xC1, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xFE, 0x7F,
  0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFE, 0x80, 0x3F, 0xDF, 0xFF,
  0xE0, 0x03, 0xF9, 0xF0, 0x00, 0x00, 0x3F, 0xBC, 0x00, 0x00, 0x07, 0xFB,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x3F, 0xE0, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0x00, 0x7F, 0x80, 0x00,
  0x20, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x04, 0x00,
  0x00, 0x7F, 0x81, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0x00, 0x00, 0xFF, 0x87,
  0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x10, 0x00, 0xFE, 0x00,
  0x1E, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x03, 0xFF, 0x00, 0x1F,
  0xC1, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0xC0, 0x03, 0xFC, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x01, 0xFC, 0x3F,
  0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE,
  0x1F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00,
  0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xF8, 0x7F,
  0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x01,
  0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xF8, 0x7F,
  0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xDF, 0xC1, 0xFF, 0x00, 0x3F, 0xF8,
  0x3F, 0xE0, 0x0E, 0xFF, 0x03, 0xFF, 0x07, 0x9F, 0xE0, 0x7F, 0xFF, 0xF3,
  0xFC, 0x0F, 0xFF, 0xFC, 0x7F, 0x00, 0xFF, 0xFF, 0x0F, 0xE0, 0x0F, 0xFF,
  0xC3, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x8F, 0xFF, 0xE0, 0x01, 0xF1, 0xFF, 0xF8, 0x01,
  0xFF, 0x7F, 0xFF, 0x00, 0x1F, 0xEF, 0xFF, 0xE0, 0x03, 0xFD, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x3F, 0xF0, 0x03,
  0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0x07, 0xFF, 0x00, 0x0F, 0xE3, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x0F, 0xC0, 0x3F, 0x81,
  0xF8, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0xFE,
  0x01, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x1F, 0xC3, 0xF0, 0x07, 0xE0,
  0x3F, 0x87, 0xE0, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x3F,
  0x80, 0x7F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0xFE, 0x01, 0xF8,
  0x03, 0xF1, 0xF8, 0x03, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xE0, 0x0F, 0xC7,
  0xE0, 0x1F, 0xC0, 0x1F, 0x9F, 0xC0, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x7E,
  0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0x03, 0xF9,
  0xF8, 0x03, 0xF0, 0x07, 0xF3, 0xF0, 0x0F, 0xE0, 0x0F, 0xCF, 0xE0, 0x1F,
  0xC0, 0x1F, 0x9F, 0xC0, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7E, 0x00, 0xFE,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x03, 0xF1, 0xF8, 0x07,
  0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE0, 0x1F, 0x8F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x1F, 0xC0, 0x7F, 0x80, 0xFC, 0x3F, 0x81, 0xFF, 0x01, 0xF8, 0x7F, 0x03,
  0xFE, 0x07, 0xE0, 0xFF, 0x1E, 0xFC, 0x1F, 0xC1, 0xFF, 0xFD, 0xFC, 0x7F,
  0x01, 0xFF, 0xF1, 0xFF, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xF0, 0x07, 0xFF,
  0x87, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF,
  0xDF, 0xC7, 0x87, 0xF8, 0x7F, 0xE1, 0xF9, 0xE0, 0x7F, 0x1F, 0xF8, 0x3F,
  0x38, 0x0F, 0xE1, 0xFC, 0x07, 0xEF, 0x01, 0xFC, 0x3F, 0x00, 0xFD, 0xC0,
  0x3F, 0x83, 0x80, 0x1F, 0xB8, 0x07, 0xF0, 0x40, 0x03, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x03,
  0xFE, 0x00, 0x30, 0x7F, 0x00, 0x7F, 0xC0, 0x0E, 0x0F, 0xE0, 0x1D, 0xF8,
  0x07, 0xE1, 0xFC, 0x03, 0xBF, 0x01, 0xFE, 0x3F, 0x80, 0xF7, 0xF0, 0xFF,
  0xC7, 0xF0, 0x3C, 0xFE, 0x3F, 0xF0, 0xFF, 0x0F, 0x8F, 0xCF, 0xFC, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x07,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x06, 0xFE,
  0x00, 0xFF, 0x80, 0x1D, 0xFC, 0x00, 0xFF, 0x00, 0x77, 0xF8, 0x01, 0xFF,
  0x83, 0xEF, 0xF0, 0x03, 0xFF, 0xFF, 0x9F, 0xE0, 0x03, 0xFF, 0xFE, 0x3F,
  0xC0, 0x07, 0xFF, 0xF8, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0xFE, 0x00, 0x07,
  0xFF, 0x83, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x20, 0x00, 0x07,
  0xF8, 0x00, 0x60, 0x00, 0x1F, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0xFF, 0xE3, 0xF8, 0x1F, 0xFF,
  0xFF, 0xEF, 0xE0, 0x7F, 0x81, 0xFF, 0xFF, 0x83, 0xF8, 0x01, 0xFF, 0xFE,
  0x0F, 0xE0, 0x01, 0xFF, 0xF0, 0x3F, 0x00, 0x01, 0xFF, 0x80, 0xFC, 0x00,
  0x0F, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xC0, 0x03, 0xFE, 0x00,
  0x3E, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x38, 0x00,
  0x0F, 0xF8, 0x03, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x0F,
  0xF8, 0x00, 0x07, 0xE0, 0x7F, 0xE0, 0x00, 0x1F, 0x83, 0xFF, 0xF8, 0x00,
  0x7E, 0x1F, 0xFF, 0xFF, 0x01, 0xF8, 0x7F, 0xFF, 0xFF, 0xE7, 0xE3, 0xF8,
  0xFF, 0xFF, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0xFE, 0x3F, 0x80, 0x7F, 0xFF,
  0xF0, 0xFE, 0x00, 0x7F, 0xFF, 0x83, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x30, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x01,
  0xFF, 0xF0, 0x00, 0x7E, 0x03, 0xFF, 0xF8, 0x00, 0x7E, 0x07, 0xFF, 0xF8,
  0x00, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0xFC, 0x0F, 0xE1, 0xFE, 0x01, 0xFC,
  0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xF8, 0x3F, 0x80,
  0x7F, 0x87, 0xF0, 0x3F, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0x00, 0x1F, 0xFF,
  0xE0, 0x7E, 0x00, 0x1F, 0xFF, 0xC0, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x0C, 0x00, 0x01, 0xFC, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 18, 51, 43, 13, -50 },
  { 116, 25, 21, 43, 13, -53 },
  { 182, 45, 50, 43, 0, -50 },
  { 464, 40, 66, 43, 2, -58 },
  { 794, 50, 52, 43, -2, -51 },
  { 1119, 43, 52, 43, 0, -51 },
  { 1399, 11, 21, 43, 20, -53 },
  { 1428, 28, 65, 43, 14, -55 },
  { 1656, 28, 65, 43, 3, -55 },
  { 1884, 37, 36, 43, 4, -40 },
  { 2051, 35, 34, 43, 5, -39 },
  { 2200, 18, 21, 43, 9, -11 },
  { 2248, 23, 7, 43, 11, -25 },
  { 2269, 13, 12, 43, 13, -11 },
  { 2289, 42, 65, 43, 1, -55 },
  { 2631, 38, 52, 43, 4, -51 },
  { 2878, 35, 50, 43, 3, -50 },
  { 3097, 39, 51, 43, 2, -51 },
  { 3346, 40, 52, 43, 1, -51 },
  { 3606, 39, 50, 43, 1, -50 },
  { 3850, 39, 51, 43, 3, -50 },
  { 4099, 35, 51, 43, 4, -50 },
  { 4323, 37, 50, 43, 7, -50 },
  { 4555, 40, 52, 43, 2, -51 },
  { 4815, 35, 51, 43, 6, -51 },
  { 5039, 17, 39, 43, 13, -38 },
  { 5122, 21, 48, 43, 9, -38 },
  { 5248, 35, 42, 43, 6, -43 },
  { 5432, 38, 22, 43, 3, -33 },
  { 5537, 35, 42, 43, 3, -43 },
  { 5721, 31, 52, 43, 9, -51 },
  { 5923, 38, 59, 43, 3, -51 },
  { 6204, 41, 50, 43, -2, -50 },
  { 6461, 38, 50, 43, 3, -50 },
  { 6699, 38, 52, 43, 5, -51 },
  { 6946, 38, 50, 43, 3, -50 },
  { 7184, 40, 50, 43, 3, -50 },
  { 7434, 41, 50, 43, 3, -50 },
  { 7691, 38, 52, 43, 4, -51 },
  { 7938, 41, 50, 43, 2, -50 },
  { 8195, 40, 50, 43, 3, -50 },
  { 8445, 38, 51, 43, 3, -50 },
  { 8688, 44, 50, 43, 3, -50 },
  { 8963, 32, 50, 43, 5, -50 },
  { 9163, 43, 50, 43, 1, -50 },
  { 9432, 41, 50, 43, 2, -50 },
  { 9689, 38, 52, 43, 4, -51 },
  { 9936, 39, 50, 43, 3, -50 },
  { 10180, 38, 65, 43, 4, -51 },
  { 10489, 39, 50, 43, 3, -50 },
  { 10733, 41, 52, 43, 1, -51 },
  { 11000, 41, 50, 43, 6, -50 },
  { 11257, 38, 51, 43, 5, -50 },
  { 11500, 40, 50, 43, 7, -50 },
  { 11750, 45, 50, 43, 2, -50 },
  { 12032, 49, 50, 43, -2, -50 },
  { 12339, 42, 50, 43, 6, -50 },
  { 12602, 44, 50, 43, 0, -50 },
  { 12877, 32, 65, 43, 10, -55 },
  { 13137, 20, 65, 43, 12, -55 },
  { 13300, 32, 65, 43, 1, -55 },
  { 13560, 37, 30, 43, 4, -50 },
  { 13699, 35, 7, 43, 0, 6 },
  { 13730, 11, 15, 43, 15, -57 },
  { 13751, 37, 39, 43, 3, -38 },
  { 13932, 37, 54, 43, 3, -53 },
  { 14182, 33, 39, 43, 5, -38 },
  { 14343, 40, 54, 43, 3, -53 },
  { 14613, 34, 39, 43, 5, -38 },
  { 14779, 49, 68, 43, -2, -53 },
  { 15196, 38, 53, 43, 2, -38 },
  { 15448, 35, 53, 43, 3, -53 },
  { 15680, 34, 55, 43, 5, -54 },
  { 15914, 35, 69, 43, 3, -54 },
  { 16216, 39, 54, 43, 3, -53 },
  { 16480, 31, 54, 43, 7, -53 },
  { 16690, 42, 38, 43, 0, -38 },
  { 16890, 35, 38, 43, 3, -38 },
  { 17057, 35, 39, 43, 4, -38 },
  { 17228, 40, 52, 43, 0, -38 },
  { 17488, 37, 52, 43, 3, -38 },
  { 17729, 36, 37, 43, 7, -37 },
  { 17896, 36, 39, 43, 3, -38 },
  { 18072, 34, 51, 43, 5, -50 },
  { 18289, 35, 38, 43, 5, -37 },
  { 18456, 35, 39, 43, 4, -38 },
  { 18627, 39, 39, 43, 2, -38 },
  { 18818, 43, 39, 43, 0, -38 },
  { 19028, 39, 52, 43, 1, -37 },
  { 19282, 38, 39, 43, 3, -38 },
  { 19468, 34, 65, 43, 8, -55 },
  { 19745, 17, 65, 43, 14, -55 },
  { 19884, 34, 65, 43, 3, -55 },
  { 20161, 40, 16, 43, 2, -30 },
};

const GFXfont IBMPlexMono_MediumItalic72pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic72pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic72pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _IBMPLEXMONO_MEDIUMITALIC72PT7B_H_
