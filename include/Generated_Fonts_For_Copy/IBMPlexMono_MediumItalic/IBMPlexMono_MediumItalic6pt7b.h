#ifndef _IBMPLEXMONO_MEDIUMITALIC6PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0xEA, 0xC0, 0x6F, 0xAC, 0x2F, 0x46, 0xE4, 0xDE, 0xEE, 0x66, 0xCF,
  0x80, 0x72, 0x49, 0x80, 0x48, 0xA5, 0x00, 0x5E, 0x80, 0x5D, 0x00, 0xC0,
  0xC0, 0x80, 0x12, 0x44, 0x88, 0x77, 0xF0, 0x75, 0x70, 0xE5, 0x70, 0xE5,
  0xF0, 0x2E, 0xB0, 0xF5, 0xF0, 0x77, 0xF0, 0xEA, 0x40, 0x6E, 0xF0, 0xF5,
  0xA0, 0xC8, 0xCA, 0x69, 0x7C, 0x8C, 0xE0, 0xDA, 0xFF, 0xE6, 0x6D, 0xD0,
  0xF7, 0xF0, 0x69, 0x86, 0xF6, 0xF0, 0xF8, 0xEE, 0xF8, 0xE8, 0x72, 0xB0,
  0xFA, 0xEA, 0x74, 0x4E, 0x64, 0xF0, 0xFC, 0xAA, 0x52, 0x70, 0x5E, 0xEA,
  0x7E, 0xEA, 0x76, 0xB0, 0x6B, 0xC8, 0x76, 0xB6, 0x6B, 0xCA, 0xF4, 0x2E,
  0xF4, 0x44, 0xDA, 0xAE, 0xBB, 0x40, 0x9E, 0xEA, 0x76, 0x6A, 0xFA, 0x40,
  0x72, 0x4E, 0x72, 0x49, 0x80, 0xAA, 0x90, 0x65, 0x25, 0x80, 0x74, 0xE0,
  0xC0, 0xF7, 0x80, 0xCE, 0xF0, 0x71, 0x80, 0x3E, 0xAE, 0xFF, 0x80, 0x35,
  0x44, 0xC0, 0xF7, 0xF0, 0xCE, 0xD0, 0x47, 0x26, 0x21, 0x95, 0x80, 0xCE,
  0xF0, 0xAB, 0xFF, 0x80, 0x76, 0x80, 0xF7, 0x80, 0x76, 0xE0, 0xF6, 0xB0,
  0xF2, 0x00, 0xEF, 0x80, 0x5D, 0x30, 0xB7, 0x80, 0xF7, 0x80, 0xFE, 0x80,
  0xF4, 0xA0, 0xB5, 0xF0, 0xEB, 0x80, 0x71, 0x49, 0x80, 0x6A, 0xA0, 0x45,
  0x35, 0x80, 0x54,
};

const GFXglyph IBMPlexMono_MediumItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 4, 4, 1, -4 },
  { 2, 2, 1, 4, 1, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 4, 6, 4, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 4, 2, -4 },
  { 13, 3, 6, 4, 1, -5 },
  { 16, 3, 6, 4, 0, -5 },
  { 19, 3, 3, 4, 0, -3 },
  { 21, 3, 3, 4, 0, -3 },
  { 23, 1, 2, 4, 1, -1 },
  { 24, 2, 1, 4, 1, -2 },
  { 25, 1, 1, 4, 1, -1 },
  { 26, 4, 6, 4, 0, -5 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 3, 4, 4, 0, -4 },
  { 35, 3, 4, 4, 0, -4 },
  { 37, 3, 4, 4, 0, -4 },
  { 39, 3, 4, 4, 0, -4 },
  { 41, 3, 4, 4, 0, -4 },
  { 43, 3, 4, 4, 1, -4 },
  { 45, 3, 4, 4, 0, -4 },
  { 47, 3, 4, 4, 0, -4 },
  { 49, 2, 3, 4, 1, -3 },
  { 50, 2, 4, 4, 1, -3 },
  { 51, 2, 4, 4, 1, -4 },
  { 52, 3, 2, 4, 0, -3 },
  { 53, 3, 4, 4, 0, -4 },
  { 55, 2, 4, 4, 1, -4 },
  { 56, 3, 5, 4, 0, -4 },
  { 58, 3, 4, 4, 0, -4 },
  { 60, 3, 4, 4, 0, -4 },
  { 62, 4, 4, 4, 0, -4 },
  { 64, 3, 4, 4, 0, -4 },
  { 66, 4, 4, 4, 0, -4 },
  { 68, 4, 4, 4, 0, -4 },
  { 70, 3, 4, 4, 0, -4 },
  { 72, 4, 4, 4, 0, -4 },
  { 74, 4, 4, 4, 0, -4 },
  { 76, 3, 4, 4, 0, -4 },
  { 78, 4, 4, 4, 0, -4 },
  { 80, 3, 4, 4, 0, -4 },
  { 82, 4, 4, 4, 0, -4 },
  { 84, 4, 4, 4, 0, -4 },
  { 86, 3, 4, 4, 0, -4 },
  { 88, 4, 4, 4, 0, -4 },
  { 90, 3, 5, 4, 0, -4 },
  { 92, 4, 4, 4, 0, -4 },
  { 94, 4, 4, 4, 0, -4 },
  { 96, 4, 4, 4, 0, -4 },
  { 98, 4, 4, 4, 0, -4 },
  { 100, 3, 4, 4, 1, -4 },
  { 102, 4, 4, 4, 0, -4 },
  { 104, 4, 4, 4, 0, -4 },
  { 106, 3, 4, 4, 1, -4 },
  { 108, 4, 4, 4, 0, -4 },
  { 110, 3, 6, 4, 1, -5 },
  { 113, 2, 6, 4, 1, -5 },
  { 115, 3, 6, 4, 0, -5 },
  { 118, 3, 2, 4, 0, -4 },
  { 119, 3, 1, 4, 0, 0 },
  { 120, 1, 2, 4, 1, -5 },
  { 121, 3, 3, 4, 0, -3 },
  { 123, 3, 4, 4, 0, -4 },
  { 125, 3, 3, 4, 0, -3 },
  { 127, 4, 4, 4, 0, -4 },
  { 129, 3, 3, 4, 0, -3 },
  { 131, 4, 5, 4, 0, -4 },
  { 134, 3, 4, 4, 0, -3 },
  { 136, 3, 4, 4, 0, -4 },
  { 138, 3, 5, 4, 0, -5 },
  { 140, 3, 6, 4, 0, -5 },
  { 143, 3, 4, 4, 0, -4 },
  { 145, 2, 4, 4, 1, -4 },
  { 146, 3, 3, 4, 0, -3 },
  { 148, 3, 3, 4, 0, -3 },
  { 150, 3, 3, 4, 0, -3 },
  { 152, 3, 4, 4, 0, -3 },
  { 154, 3, 4, 4, 0, -3 },
  { 156, 3, 3, 4, 1, -3 },
  { 158, 3, 3, 4, 0, -3 },
  { 160, 3, 4, 4, 0, -4 },
  { 162, 3, 3, 4, 0, -3 },
  { 164, 3, 3, 4, 0, -3 },
  { 166, 3, 3, 4, 0, -3 },
  { 168, 4, 3, 4, 0, -3 },
  { 170, 3, 4, 4, 0, -3 },
  { 172, 3, 3, 4, 0, -3 },
  { 174, 3, 6, 4, 1, -5 },
  { 177, 2, 6, 4, 1, -5 },
  { 179, 3, 6, 4, 0, -5 },
  { 182, 3, 2, 4, 0, -3 },
};

const GFXfont IBMPlexMono_MediumItalic6pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic6pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _IBMPLEXMONO_MEDIUMITALIC6PT7B_H_
