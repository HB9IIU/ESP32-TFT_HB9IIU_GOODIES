#ifndef _IBMPLEXMONO_MEDIUMITALIC55PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x07,
  0xE3, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xE3, 0xF0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x7E, 0x3E, 0x0F, 0xCF, 0xC1, 0xF1, 0xF8, 0x3E,
  0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xE7, 0xE0, 0xF8,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x1F,
  0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xFF, 0x81,
  0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xF3, 0xDF, 0xF0, 0x3F, 0x87, 0x8F, 0xE0, 0xFE, 0x0F, 0x07,
  0x01, 0xF8, 0x3C, 0x04, 0x03, 0xF0, 0x78, 0x00, 0x0F, 0xC0, 0xF0, 0x00,
  0x1F, 0x81, 0xE0, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0x7F, 0x07, 0x80, 0x00,
  0x7E, 0x1E, 0x00, 0x00, 0xFF, 0x3C, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x79, 0xFE, 0x00, 0x00, 0xF0, 0xFE, 0x00, 0x01, 0xE1, 0xFC, 0x00, 0x07,
  0x81, 0xF8, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x1E, 0x07, 0xE0, 0x00, 0x3C,
  0x0F, 0xC0, 0x80, 0x78, 0x1F, 0x87, 0x00, 0xF0, 0x7E, 0x1F, 0x03, 0xC1,
  0xFC, 0x7F, 0x87, 0x87, 0xF0, 0x7F, 0xCF, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x01, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0x80, 0x3F, 0xFE, 0x00, 0x3E, 0x01,
  0xF8, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x80, 0x3E, 0x03, 0xC0,
  0x3E, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x03, 0xC0, 0x3C, 0x0F, 0x80, 0x1F,
  0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x1F, 0x0F,
  0x80, 0x07, 0xC0, 0x7C, 0x7C, 0x00, 0x1F, 0x01, 0xE1, 0xF0, 0x00, 0x7C,
  0x0F, 0x8F, 0x80, 0x00, 0xF8, 0x7C, 0x7C, 0x00, 0x03, 0xFF, 0xF1, 0xF0,
  0x00, 0x07, 0xFF, 0x88, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xE7, 0xFF, 0xE0, 0x00, 0x1E,
  0x3F, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x1E, 0x00, 0x07, 0xC7, 0xC0, 0x7C,
  0x00, 0x3E, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x7C, 0x07, 0xC0, 0x07, 0xC1,
  0xE0, 0x1F, 0x00, 0x3E, 0x07, 0x80, 0x78, 0x00, 0xF8, 0x1E, 0x01, 0xE0,
  0x07, 0xC0, 0x78, 0x0F, 0x80, 0x3E, 0x01, 0xE0, 0x3E, 0x00, 0xF0, 0x07,
  0x81, 0xF0, 0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x3E, 0x00, 0x7F, 0xFE, 0x01,
  0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xC0, 0x01, 0xFF, 0x80, 0x20, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x3F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0x80,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x07, 0xE0, 0x07, 0xC0, 0x73, 0xF0, 0x03, 0xF0, 0x3D, 0xF8, 0x03,
  0xF8, 0x3F, 0xFE, 0x01, 0xFE, 0x3F, 0x3F, 0x01, 0xDF, 0x1F, 0x1F, 0xC1,
  0xCF, 0xDF, 0x0F, 0xFF, 0xE7, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0x80, 0xFF,
  0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xC0, 0x07, 0xE0, 0x07, 0x80, 0x3F,
  0x3E, 0x3E, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC, 0xFC, 0xFC,
  0xF8, 0xF8, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x0F, 0x80, 0x77, 0xF0,
  0xF8, 0x7F, 0xFF, 0xCF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC1, 0xF8, 0x03,
  0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x01, 0xE0, 0x07, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x03,
  0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x1F, 0x1F,
  0xE7, 0xFF, 0xFF, 0xFF, 0xBF, 0xEF, 0xFB, 0xFC, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFD, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x7C, 0x1F, 0xFF,
  0x87, 0xF0, 0xFF, 0xFC, 0x3F, 0x87, 0xFF, 0xE1, 0xFC, 0x3F, 0x7E, 0x0F,
  0xC1, 0xFB, 0xF0, 0x3C, 0x0F, 0xDF, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x7F,
  0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x01, 0xFE, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xF0,
  0xFC, 0x03, 0xFC, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x07, 0x80, 0x7E, 0x00,
  0x60, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x07, 0xE0,
  0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x0C, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0x78, 0x00,
  0x7F, 0x00, 0xC0, 0x01, 0xFC, 0x02, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x80, 0x00, 0x7E, 0x0F, 0x00, 0x03, 0xF8, 0x7C, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7E, 0x01,
  0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x3F, 0x80, 0x03, 0xE3, 0xFF, 0x80,
  0x0F, 0x9F, 0xFF, 0x80, 0x3E, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x3C, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x20, 0x00, 0x3F, 0x81, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xF0,
  0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x7F, 0xF0, 0x3F, 0x3F, 0xFF,
  0x07, 0xEF, 0xFF, 0xF1, 0xFB, 0xFF, 0xFF, 0x3F, 0xF0, 0x1F, 0xE7, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x8F, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xC0, 0x00, 0x7E,
  0x7C, 0x00, 0x0F, 0xE7, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0xCF, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x3F,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7F,
  0x3F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x07,
  0xF8, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8,
  0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01,
  0xFE, 0x7F, 0x00, 0x3F, 0xE7, 0xFC, 0x0F, 0xFC, 0x3F, 0xFF, 0xEF, 0xC3,
  0xFF, 0xFD, 0xFC, 0x1F, 0xFF, 0x9F, 0x80, 0xFF, 0xF3, 0xF8, 0x01, 0xF8,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF1, 0xFF, 0x8F,
  0xFC, 0x7F, 0xC1, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x81, 0xFE, 0x0F, 0xF8, 0xFF, 0xC7, 0xFC, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xC0, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x7F, 0x81, 0xFE, 0xFE, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0x38, 0x00, 0x7F, 0x08, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xC1,
  0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0x3E, 0x3E, 0x03, 0xE1, 0xF3, 0xE0, 0x3F, 0xCF, 0x1F, 0x03, 0xFE,
  0xF8, 0xF8, 0x3F, 0xFF, 0xCF, 0xC3, 0xF0, 0xFE, 0x7C, 0x1F, 0x03, 0xF3,
  0xE1, 0xF0, 0x0F, 0x9F, 0x0F, 0x80, 0x7C, 0xF8, 0x7C, 0x07, 0xCF, 0xC7,
  0xC0, 0x3E, 0x7C, 0x3E, 0x01, 0xF3, 0xE1, 0xF0, 0x0F, 0x9F, 0x0F, 0x80,
  0x7C, 0xF8, 0x7C, 0x07, 0xE7, 0xC3, 0xE0, 0x3E, 0x3E, 0x1F, 0x01, 0xF1,
  0xF0, 0xF8, 0x1F, 0x8F, 0x07, 0xC1, 0xFC, 0x78, 0x3F, 0xBB, 0xE3, 0xC1,
  0xFF, 0xDF, 0x1E, 0x07, 0xFD, 0xF0, 0xF0, 0x3F, 0xEF, 0x87, 0xC0, 0xFE,
  0x7C, 0x3E, 0x01, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x1F,
  0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80,
  0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xF8, 0x03, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0,
  0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x01,
  0xF8, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0xFC, 0x1F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8,
  0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF1, 0xF8,
  0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0xC3, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFE,
  0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x62, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x60, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x07,
  0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFC, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8,
  0x7E, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFE, 0x1F,
  0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x01,
  0xFC, 0x1F, 0x80, 0x1F, 0xE0, 0x7E, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x70, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x07, 0xFF,
  0xCF, 0xE0, 0x3F, 0xFE, 0x7F, 0x01, 0xFF, 0xF3, 0xF8, 0x0F, 0xFF, 0x9F,
  0xC0, 0x7F, 0xF8, 0xFC, 0x04, 0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x3F, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x83,
  0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x77, 0xE0, 0x7F, 0xFF, 0xBF, 0x01, 0xFF,
  0xF9, 0xF0, 0x07, 0xFF, 0x8F, 0x80, 0x1F, 0xF8, 0x7C, 0x00, 0x3F, 0x04,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01,
  0xF8, 0x3F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFE, 0x0F,
  0xE0, 0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xE0,
  0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03,
  0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x08,
  0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xF0, 0x03, 0xFC, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x3F, 0x80,
  0x07, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0x07, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0xFE, 0x00, 0x01,
  0xFF, 0x1F, 0x80, 0x00, 0xFF, 0x87, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFE, 0x07, 0xFF, 0x03, 0xEF, 0x07, 0xDF, 0x03, 0xF7, 0xC3, 0xEF, 0x81,
  0xF3, 0xE3, 0xE7, 0xC0, 0xF9, 0xF1, 0xF3, 0xE0, 0x7C, 0x79, 0xF3, 0xF0,
  0x3E, 0x3F, 0xF1, 0xF8, 0x1F, 0x1F, 0xF8, 0xF8, 0x1F, 0x8F, 0xF8, 0x7C,
  0x0F, 0xC7, 0xFC, 0x3E, 0x07, 0xC1, 0xFC, 0x3F, 0x03, 0xE0, 0xFE, 0x1F,
  0x81, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xFC, 0x0F, 0x03,
  0xE0, 0x7E, 0x07, 0x01, 0xF0, 0x3E, 0x03, 0x81, 0xF8, 0x1F, 0x01, 0x80,
  0xFC, 0x0F, 0x80, 0x40, 0x7E, 0x07, 0xC0, 0x40, 0x3E, 0x07, 0xE0, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3E, 0x07, 0xF8, 0x00, 0xFC, 0x0F,
  0xF8, 0x01, 0xF8, 0x3F, 0xF0, 0x03, 0xE0, 0x7F, 0xE0, 0x07, 0xC0, 0xFF,
  0xC0, 0x0F, 0x81, 0xFF, 0x80, 0x1F, 0x03, 0xFF, 0x80, 0x7E, 0x07, 0xDF,
  0x00, 0xFC, 0x1F, 0xBE, 0x01, 0xF0, 0x3F, 0x7C, 0x03, 0xE0, 0x7E, 0xF8,
  0x07, 0xC0, 0xF9, 0xF8, 0x1F, 0x81, 0xF1, 0xF0, 0x3F, 0x03, 0xE3, 0xE0,
  0x7E, 0x0F, 0xC7, 0xC0, 0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0x3F, 0x1F, 0x83,
  0xE0, 0x7C, 0x1F, 0x0F, 0xC0, 0xF8, 0x3E, 0x1F, 0x81, 0xF0, 0x7C, 0x3F,
  0x07, 0xE0, 0xF8, 0x7C, 0x0F, 0xC1, 0xF8, 0xF8, 0x1F, 0x81, 0xF1, 0xF0,
  0x3E, 0x03, 0xE7, 0xE0, 0x7C, 0x07, 0xCF, 0xC0, 0xF8, 0x0F, 0xDF, 0x83,
  0xF0, 0x0F, 0xBE, 0x07, 0xE0, 0x1F, 0x7C, 0x0F, 0xC0, 0x3E, 0xF8, 0x1F,
  0x00, 0x7F, 0xF0, 0x3E, 0x00, 0xFF, 0xE0, 0x7C, 0x00, 0xFF, 0xC1, 0xF8,
  0x01, 0xFF, 0x03, 0xF0, 0x03, 0xFE, 0x07, 0xE0, 0x07, 0xFC, 0x0F, 0x80,
  0x0F, 0xF8, 0x1F, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x7F,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFD, 0xFC, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0x7F,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFE, 0xFC, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xE0,
  0x7F, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x0F, 0xF0, 0x3F, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF8,
  0x3F, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x7F,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFD, 0xFC, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x7F,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFE, 0xFC, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7F, 0x1F,
  0x80, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x1F, 0xE0,
  0x7F, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x80,
  0x01, 0xFC, 0x0E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x0F, 0xF0, 0x3F, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x80,
  0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xF8, 0x3F, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xE0,
  0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFE, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x1C, 0x07, 0xE0, 0x00, 0x30, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x02, 0x00, 0x00, 0xFC, 0x1C, 0x00, 0x03, 0xF8,
  0x7E, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xC1, 0xFF, 0x00, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0,
  0x7E, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xFC, 0x3F,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0,
  0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7E,
  0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00,
  0x7E, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC,
  0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03,
  0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C,
  0x7E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0xFC, 0x0F,
  0x83, 0xF0, 0x7F, 0x03, 0xE0, 0xF8, 0x1F, 0xC0, 0xF8, 0x3E, 0x07, 0xF0,
  0x3E, 0x0F, 0x83, 0xFC, 0x1F, 0x03, 0xE0, 0xFF, 0x07, 0xC0, 0xF8, 0x3F,
  0xC1, 0xF0, 0x3E, 0x1E, 0xF0, 0x7C, 0x0F, 0x87, 0xBC, 0x3E, 0x03, 0xE1,
  0xEF, 0x0F, 0x81, 0xF8, 0xF3, 0xC3, 0xE0, 0x7C, 0x3C, 0xF0, 0xF8, 0x1F,
  0x1F, 0x3C, 0x7C, 0x07, 0xC7, 0x8F, 0x1F, 0x01, 0xF1, 0xE3, 0xC7, 0xC0,
  0x7C, 0xF8, 0xF1, 0xF0, 0x1F, 0x3C, 0x3C, 0xF8, 0x07, 0xCF, 0x0F, 0x3E,
  0x01, 0xF7, 0xC3, 0xCF, 0x80, 0x7D, 0xE0, 0xF3, 0xE0, 0x3F, 0x78, 0x3C,
  0xF8, 0x0F, 0xBE, 0x0F, 0x7C, 0x03, 0xEF, 0x03, 0xDF, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC,
  0x3F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x3F,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00,
  0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0xF8, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xFC,
  0x60, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x04, 0x0E, 0x1F,
  0x1F, 0xC7, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xF8, 0xFC, 0x0F, 0xFF, 0x9F, 0x83, 0xFF, 0xF3,
  0xF0, 0xFF, 0xFF, 0x7E, 0x3F, 0xC0, 0xEF, 0xCF, 0xF0, 0x07, 0xF1, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xEF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3,
  0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xF1, 0xF8, 0x01,
  0xFE, 0x3F, 0x00, 0x3F, 0xC7, 0xF0, 0x0D, 0xF8, 0xFF, 0x07, 0x7F, 0xEF,
  0xFF, 0xEF, 0xFD, 0xFF, 0xF8, 0xFF, 0x1F, 0xFE, 0x1F, 0xE1, 0xFF, 0x80,
  0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x7E, 0x1F, 0xF8, 0x07, 0xE7, 0xFF, 0xC0, 0xFC, 0xFF,
  0xFE, 0x0F, 0xCF, 0xFF, 0xE0, 0xFD, 0xE0, 0xFF, 0x0F, 0xF8, 0x07, 0xF0,
  0xFF, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F,
  0x1F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x7F, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF8, 0x03, 0xF8, 0x7F,
  0xC0, 0xFF, 0x87, 0xEF, 0xFF, 0xF0, 0x7E, 0xFF, 0xFE, 0x0F, 0xC7, 0xFF,
  0xC0, 0xFC, 0x3F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0xFF, 0x03, 0xFC, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x1E, 0x3F, 0x00, 0x0C,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x02, 0x1F, 0x80, 0x01, 0x8F, 0xC0,
  0x01, 0xF7, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x7F,
  0x83, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xFF, 0x0F, 0xC0, 0x3F,
  0xFE, 0x3E, 0x01, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0xF7, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0,
  0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8, 0x3F,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x01,
  0xFC, 0x0F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x6F, 0xC0, 0xFF, 0x07, 0xBF,
  0x01, 0xFF, 0xFC, 0xFC, 0x07, 0xFF, 0xE3, 0xE0, 0x0F, 0xFF, 0x1F, 0x80,
  0x1F, 0xF8, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x83, 0xFC, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x00,
  0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0xFE, 0xFC,
  0x00, 0xFF, 0x3F, 0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x0C, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x03, 0xFB, 0xF8,
  0x01, 0xFC, 0x7F, 0x81, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x18, 0x07, 0xE0, 0x00, 0x01, 0xC0, 0x3F, 0x00, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x01,
  0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xC3, 0xF0,
  0x0F, 0xFF, 0x8F, 0xC0, 0x7F, 0xFF, 0x3E, 0x03, 0xFF, 0xFD, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xC0,
  0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xE0, 0xFC,
  0x00, 0xFF, 0x03, 0xF8, 0x07, 0xFC, 0x07, 0xF0, 0x7B, 0xF0, 0x1F, 0xFF,
  0xEF, 0xC0, 0x7F, 0xFF, 0x3F, 0x00, 0xFF, 0xF8, 0xFC, 0x01, 0xFF, 0xC7,
  0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x40, 0x01, 0xFC, 0x03,
  0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC3,
  0xFE, 0x01, 0xF8, 0xFF, 0xE0, 0x3F, 0x3F, 0xFE, 0x0F, 0xEF, 0xFF, 0xE1,
  0xFB, 0xC3, 0xFC, 0x3F, 0x60, 0x3F, 0x87, 0xF8, 0x03, 0xF0, 0xFE, 0x00,
  0x7E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F,
  0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xE1, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x02, 0x00, 0x7E, 0x01, 0xC0, 0x1F,
  0x80, 0xF8, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x1F, 0xC0,
  0x1F, 0x0F, 0xE0, 0x0F, 0xC7, 0xF0, 0x03, 0xF3, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x80, 0x1F, 0x80, 0x38, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xF8, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x0F,
  0xC0, 0x07, 0xF1, 0xF8, 0x00, 0x7F, 0x3E, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x1F, 0x87, 0xFE, 0x00, 0x7E, 0x3F, 0xFC, 0x01, 0xF9, 0xFF,
  0xF8, 0x0F, 0xCF, 0xFF, 0xE0, 0x3F, 0x78, 0x3F, 0x80, 0xFD, 0x80, 0x7E,
  0x03, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x80,
  0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0x7E,
  0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x1F,
  0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0,
  0x08, 0x3F, 0x0F, 0xC0, 0x70, 0xFC, 0x3F, 0x03, 0xE3, 0xE0, 0x7E, 0x1F,
  0xDF, 0x81, 0xF8, 0xFE, 0x7E, 0x03, 0xF7, 0xF1, 0xF8, 0x0F, 0xFF, 0x87,
  0xE0, 0x3F, 0xFC, 0x1F, 0x80, 0x7F, 0xE0, 0x7C, 0x00, 0xFE, 0x02, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x08, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x3E,
  0x07, 0xE0, 0x7F, 0x07, 0xC0, 0xFE, 0x0F, 0xC1, 0xFC, 0x0F, 0xC3, 0xF8,
  0x0F, 0xCF, 0xF0, 0x0F, 0xDF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0xF8, 0x07, 0xCF, 0xE1, 0xFE, 0x07, 0xDF, 0xE3, 0xFE, 0x0F, 0x9F, 0xF7,
  0xFF, 0x0F, 0xBF, 0xF7, 0xFF, 0x0F, 0xA3, 0xFE, 0x3F, 0x0F, 0xC1, 0xFC,
  0x1F, 0x0F, 0xC1, 0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0x1F, 0x1F, 0x81, 0xF0,
  0x3E, 0x1F, 0x01, 0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0x3E, 0x1F, 0x03, 0xE0,
  0x3E, 0x1F, 0x03, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0x3E, 0x3E, 0x03, 0xE0,
  0x7C, 0x3E, 0x03, 0xE0, 0x7C, 0x3E, 0x03, 0xE0, 0x7C, 0x3E, 0x07, 0xC0,
  0x7C, 0x3E, 0x07, 0xC0, 0x7C, 0x3E, 0x07, 0xC0, 0x7C, 0x7C, 0x07, 0xC0,
  0xF8, 0x7C, 0x07, 0xC0, 0xF8, 0x7C, 0x07, 0xC0, 0xF8, 0x7C, 0x0F, 0x80,
  0xF8, 0x7C, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x81,
  0xF0, 0xF8, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x3F, 0xE0,
  0x1F, 0x8F, 0xFE, 0x03, 0xF3, 0xFF, 0xE0, 0x7E, 0xFF, 0xFE, 0x1F, 0xBC,
  0x3F, 0xC3, 0xF6, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x0F, 0xE0, 0x07, 0xE1,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F,
  0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE3, 0xF0,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E,
  0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x0F,
  0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x81, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xE1, 0xFF, 0x80, 0x1F, 0x9F, 0xFF,
  0x00, 0xFC, 0xFF, 0xFE, 0x03, 0xF3, 0xFF, 0xF8, 0x0F, 0xDE, 0x0F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFC, 0x1F,
  0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7E,
  0xFF, 0xFF, 0x01, 0xFB, 0xFF, 0xF8, 0x0F, 0xC7, 0xFF, 0xC0, 0x3F, 0x0F,
  0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xFC, 0x3F, 0x03, 0xFF, 0xE3, 0xF0, 0x7F, 0xFF, 0x7E, 0x0F, 0xFF, 0xF7,
  0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0xFC, 0xFE, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF,
  0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF0,
  0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xF0, 0xFF, 0x07, 0xBF, 0x07, 0xFF,
  0xF3, 0xF0, 0x7F, 0xFF, 0x3F, 0x03, 0xFF, 0xE7, 0xE0, 0x1F, 0xF8, 0x7E,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFB, 0xFF, 0xE3,
  0xFF, 0x7F, 0xFC, 0xFF, 0xEF, 0xFF, 0x9F, 0xFC, 0x03, 0xF7, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xA0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF0, 0x1F, 0x81, 0xF8,
  0x00, 0xE0, 0x7E, 0x00, 0x08, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x20, 0x00, 0x1F, 0x86, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x7F,
  0x80, 0x7F, 0x9F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x40,
  0x0F, 0xC0, 0x18, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xE0, 0x7E, 0x07,
  0xF8, 0x1F, 0x87, 0xF8, 0x07, 0xE3, 0xFC, 0x01, 0xFB, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x7C, 0x00,
  0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF0, 0xFC,
  0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0,
  0x0F, 0xE1, 0xF8, 0x03, 0xFC, 0x3F, 0x80, 0xDF, 0x87, 0xF8, 0x7B, 0xF0,
  0xFF, 0xFE, 0x7C, 0x0F, 0xFF, 0x9F, 0x80, 0xFF, 0xE3, 0xF0, 0x0F, 0xF8,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0x8F, 0xFE, 0x01, 0xFB,
  0xFF, 0xC0, 0x7F, 0x7F, 0xF8, 0x07, 0xEF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x7C, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0xC1, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0xFE, 0x0F, 0xC0, 0x1F,
  0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x7F, 0x00, 0xFC,
  0x3F, 0xE0, 0x1F, 0x1F, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0xF8, 0x1F, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x3E, 0x07,
  0xC1, 0xF1, 0xF0, 0x3E, 0x0F, 0x9F, 0x01, 0xF0, 0x7C, 0xF8, 0x0F, 0x03,
  0xE7, 0xC0, 0xF8, 0x1F, 0x3E, 0x07, 0xC0, 0xF9, 0xF0, 0x3E, 0x07, 0xCF,
  0x81, 0xF0, 0x3E, 0xF8, 0x0F, 0x81, 0xF7, 0xC0, 0x78, 0x0F, 0xBE, 0x07,
  0xC0, 0x7D, 0xF0, 0x3E, 0x03, 0xEF, 0x81, 0xF0, 0x1F, 0x78, 0x0F, 0x80,
  0xFF, 0xC0, 0x7C, 0x0F, 0xBE, 0x03, 0xE0, 0x7D, 0xF0, 0x3E, 0x03, 0xEF,
  0x81, 0xF0, 0x1F, 0x7C, 0x0F, 0x81, 0xF3, 0xE0, 0xFC, 0x0F, 0x9F, 0x07,
  0xE0, 0xF8, 0xF8, 0xFF, 0x07, 0xC7, 0xFF, 0x7C, 0x7C, 0x3F, 0xFB, 0xFF,
  0xC1, 0xFF, 0x8F, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x7F, 0xF8, 0xFF, 0xE0, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xBE, 0x78,
  0xFC, 0x7F, 0x0F, 0x38, 0x3E, 0x7F, 0x07, 0xB8, 0x1F, 0x1E, 0x03, 0xF8,
  0x0F, 0x86, 0x01, 0xFC, 0x07, 0xC0, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x01, 0xFC, 0x02, 0x0F, 0x80,
  0xFE, 0x01, 0x87, 0xC0, 0x6F, 0x03, 0xE3, 0xE0, 0x77, 0x83, 0xF9, 0xF8,
  0x73, 0xE3, 0xF8, 0xFC, 0x79, 0xF7, 0xF8, 0x7F, 0xFC, 0xFF, 0xF8, 0x1F,
  0xFC, 0x7F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0x3E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F,
  0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xC0,
  0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7E,
  0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0xC0, 0x7F,
  0x01, 0xBF, 0x01, 0xFE, 0x1E, 0xFC, 0x03, 0xFF, 0xF3, 0xF0, 0x0F, 0xFF,
  0x8F, 0x80, 0x1F, 0xFE, 0x7E, 0x00, 0x3F, 0xE1, 0xF8, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x10, 0x00, 0x7F, 0x00, 0xE0, 0x03, 0xF8, 0x07,
  0xE0, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x07, 0xC1, 0xFF, 0xF8, 0x3E, 0x1F, 0xFF, 0xF3,
  0xF0, 0xFF, 0xFF, 0xDF, 0x87, 0xE0, 0xFF, 0xFC, 0x7C, 0x01, 0xFF, 0xC3,
  0xE0, 0x03, 0xFC, 0x1F, 0x00, 0x1F, 0xC0, 0xF8, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x0C, 0x00, 0x7F, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0x80, 0x7F,
  0x00, 0x3E, 0x0F, 0xE0, 0x01, 0xF0, 0xFF, 0x80, 0x0F, 0x8F, 0xFF, 0xC0,
  0x3C, 0x7F, 0xFF, 0xF1, 0xE3, 0xE7, 0xFF, 0xFF, 0x3F, 0x0F, 0xFF, 0xF9,
  0xF8, 0x0F, 0xFF, 0x8F, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x40, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x60, 0x0F, 0xF0, 0x01,
  0xF0, 0xFF, 0xE0, 0x0F, 0x83, 0xFF, 0xC0, 0x3E, 0x1F, 0xFF, 0x00, 0xF8,
  0xFC, 0x7E, 0x07, 0xC3, 0xE0, 0xFC, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x7C,
  0x07, 0xFF, 0xE1, 0xE0, 0x0F, 0xFF, 0x0F, 0x80, 0x3F, 0xF8, 0x3E, 0x00,
  0x7F, 0xC0, 0x30, 0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 14, 39, 33, 10, -38 },
  { 70, 19, 16, 33, 10, -41 },
  { 108, 34, 38, 33, 0, -38 },
  { 270, 31, 52, 33, 1, -45 },
  { 472, 38, 40, 33, -2, -39 },
  { 662, 33, 40, 33, 0, -39 },
  { 827, 8, 16, 33, 16, -41 },
  { 843, 22, 50, 33, 10, -42 },
  { 981, 22, 50, 33, 2, -42 },
  { 1119, 28, 27, 33, 3, -30 },
  { 1214, 26, 27, 33, 4, -30 },
  { 1302, 14, 16, 33, 7, -8 },
  { 1330, 18, 5, 33, 8, -19 },
  { 1342, 10, 9, 33, 10, -8 },
  { 1354, 32, 50, 33, 1, -42 },
  { 1554, 29, 40, 33, 3, -39 },
  { 1699, 27, 38, 33, 2, -38 },
  { 1828, 30, 39, 33, 1, -39 },
  { 1975, 30, 40, 33, 1, -39 },
  { 2125, 30, 38, 33, 1, -38 },
  { 2268, 30, 39, 33, 2, -38 },
  { 2415, 27, 39, 33, 3, -38 },
  { 2547, 28, 38, 33, 5, -38 },
  { 2680, 30, 40, 33, 2, -39 },
  { 2830, 28, 39, 33, 4, -39 },
  { 2967, 13, 30, 33, 10, -29 },
  { 3016, 16, 37, 33, 7, -29 },
  { 3090, 26, 32, 33, 5, -33 },
  { 3194, 28, 17, 33, 3, -25 },
  { 3254, 26, 32, 33, 3, -33 },
  { 3358, 24, 40, 33, 7, -39 },
  { 3478, 29, 45, 33, 3, -39 },
  { 3642, 31, 38, 33, -1, -38 },
  { 3790, 29, 38, 33, 2, -38 },
  { 3928, 29, 40, 33, 4, -39 },
  { 4073, 30, 38, 33, 2, -38 },
  { 4216, 31, 38, 33, 2, -38 },
  { 4364, 31, 38, 33, 2, -38 },
  { 4512, 29, 40, 33, 3, -39 },
  { 4657, 31, 38, 33, 2, -38 },
  { 4805, 31, 38, 33, 2, -38 },
  { 4953, 28, 39, 33, 3, -38 },
  { 5090, 34, 38, 33, 2, -38 },
  { 5252, 24, 38, 33, 4, -38 },
  { 5366, 33, 38, 33, 1, -38 },
  { 5523, 31, 38, 33, 2, -38 },
  { 5671, 29, 40, 33, 3, -39 },
  { 5816, 30, 38, 33, 2, -38 },
  { 5959, 29, 50, 33, 3, -39 },
  { 6141, 30, 38, 33, 2, -38 },
  { 6284, 31, 40, 33, 1, -39 },
  { 6439, 31, 38, 33, 5, -38 },
  { 6587, 30, 39, 33, 3, -38 },
  { 6734, 31, 38, 33, 5, -38 },
  { 6882, 34, 38, 33, 2, -38 },
  { 7044, 37, 38, 33, -1, -38 },
  { 7220, 31, 38, 33, 5, -38 },
  { 7368, 34, 38, 33, 0, -38 },
  { 7530, 24, 50, 33, 8, -42 },
  { 7680, 15, 50, 33, 10, -42 },
  { 7774, 24, 50, 33, 1, -42 },
  { 7924, 29, 23, 33, 3, -38 },
  { 8008, 27, 5, 33, 0, 5 },
  { 8025, 9, 12, 33, 11, -44 },
  { 8039, 27, 30, 33, 3, -29 },
  { 8141, 28, 42, 33, 2, -41 },
  { 8288, 25, 30, 33, 4, -29 },
  { 8382, 30, 42, 33, 3, -41 },
  { 8540, 26, 30, 33, 4, -29 },
  { 8638, 37, 53, 33, -1, -41 },
  { 8884, 30, 41, 33, 1, -29 },
  { 9038, 27, 41, 33, 2, -41 },
  { 9177, 26, 42, 33, 4, -41 },
  { 9314, 27, 53, 33, 2, -41 },
  { 9493, 30, 42, 33, 2, -41 },
  { 9651, 24, 42, 33, 5, -41 },
  { 9777, 32, 29, 33, 0, -29 },
  { 9893, 27, 29, 33, 2, -29 },
  { 9991, 27, 30, 33, 3, -29 },
  { 10093, 30, 40, 33, 0, -29 },
  { 10243, 28, 40, 33, 3, -29 },
  { 10383, 27, 28, 33, 6, -28 },
  { 10478, 27, 30, 33, 2, -29 },
  { 10580, 26, 39, 33, 4, -38 },
  { 10707, 27, 29, 33, 4, -28 },
  { 10805, 27, 30, 33, 3, -29 },
  { 10907, 29, 30, 33, 2, -29 },
  { 11016, 33, 30, 33, 0, -29 },
  { 11140, 30, 40, 33, 1, -28 },
  { 11290, 29, 30, 33, 2, -29 },
  { 11399, 26, 50, 33, 6, -42 },
  { 11562, 14, 50, 33, 10, -42 },
  { 11650, 26, 50, 33, 2, -42 },
  { 11813, 30, 13, 33, 2, -23 },
};

const GFXfont IBMPlexMono_MediumItalic55pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic55pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic55pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _IBMPLEXMONO_MEDIUMITALIC55PT7B_H_
