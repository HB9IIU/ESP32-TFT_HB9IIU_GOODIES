#ifndef _IBMPLEXMONO_MEDIUMITALIC25PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x73, 0x8E, 0x38, 0xE3, 0x0C, 0x20, 0x80, 0x00, 0x03, 0x8F,
  0x3C, 0xE0, 0x63, 0x67, 0xE7, 0xE7, 0xE6, 0xC6, 0xCE, 0x01, 0xCC, 0x01,
  0x8C, 0x03, 0x98, 0x03, 0x18, 0x03, 0x38, 0x3F, 0x3F, 0x3E, 0x3E, 0x06,
  0x70, 0x0E, 0x60, 0x0C, 0x60, 0xFC, 0xFC, 0xFC, 0xFC, 0x18, 0xC0, 0x19,
  0xC0, 0x39, 0x80, 0x31, 0x80, 0x73, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x1C,
  0x01, 0xF8, 0x1F, 0xF8, 0xE6, 0xF3, 0x19, 0x1C, 0x60, 0x71, 0x00, 0xEC,
  0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF0, 0x09, 0xC0, 0x63, 0x81, 0x8E, 0xC6,
  0x73, 0x9B, 0xC7, 0xFE, 0x0F, 0xE0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x07, 0x81, 0xC3, 0xF0, 0xC1, 0x8C, 0x30, 0x63, 0x18, 0x38, 0xCC, 0x0C,
  0x37, 0x01, 0x9D, 0x80, 0x7E, 0x80, 0x0F, 0x3C, 0x00, 0x1F, 0x80, 0x7E,
  0x60, 0x33, 0x18, 0x0C, 0xC6, 0x06, 0x31, 0x83, 0x0C, 0xE1, 0xC3, 0xF0,
  0xE0, 0x78, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x38, 0xE0, 0x70, 0xC0, 0xC1,
  0x81, 0xC7, 0x03, 0x8C, 0x03, 0x38, 0x3F, 0xC0, 0xE6, 0x03, 0x8E, 0x07,
  0x0C, 0x0E, 0x1C, 0x5C, 0x39, 0xF8, 0xBB, 0x3F, 0x3C, 0x3C, 0x70, 0x76,
  0x66, 0x6E, 0xE0, 0x03, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x01,
  0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x0E, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80,
  0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x38, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0xC1, 0x06, 0x17, 0x33, 0xFF, 0xFC, 0x7F, 0x01, 0xE0,
  0x1F, 0x81, 0xCE, 0x0E, 0x30, 0xE1, 0xC0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x3C, 0xF3, 0x8E, 0x71, 0xC6, 0x30, 0xFF, 0xFE, 0x7B, 0xFE, 0xE0,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0x0E, 0x70,
  0x33, 0x01, 0xB8, 0x0D, 0xC0, 0x6E, 0x63, 0xE7, 0xBF, 0x39, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0x30, 0x39, 0xC3, 0x87, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0xFC, 0x1F, 0xC3, 0xDC, 0x79, 0xC3, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xC0, 0xFF, 0x8F, 0x1E, 0x70, 0x75, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x1F, 0xFE, 0xFF, 0xF0, 0x03, 0xF0, 0x3F, 0xE1, 0xC3, 0xC2, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0x81, 0xF8, 0x07, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x39, 0x80, 0xEF, 0x0F, 0x0F, 0xF8, 0x1F, 0x80, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xB8, 0x0C, 0xE0, 0x63, 0x83, 0x8C,
  0x1C, 0x30, 0xE1, 0xC3, 0x07, 0x18, 0x1C, 0x7F, 0xFF, 0xFF, 0xF0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x1F, 0xFC, 0x7F, 0xE1, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x3C, 0x0D, 0xFC, 0x78, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x71, 0x81, 0xCF, 0x0E, 0x1F, 0xF0, 0x1F, 0x00, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xEF, 0x0E, 0xFE, 0x78,
  0x73, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0x70, 0x39, 0xC3, 0x87, 0xF8,
  0x1F, 0x80, 0x7F, 0xFB, 0xFF, 0xD8, 0x0E, 0xC0, 0xEE, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x07, 0xE0, 0xFF, 0xCF, 0x0E, 0x70,
  0x33, 0x01, 0x9C, 0x1C, 0xE1, 0xC3, 0xFC, 0x1F, 0xE3, 0x83, 0xB8, 0x0D,
  0xC0, 0x7E, 0x03, 0xF0, 0x3B, 0xC3, 0xCF, 0xFC, 0x1F, 0x80, 0x0F, 0xC3,
  0xFE, 0x78, 0x77, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xF0, 0xF7,
  0xFE, 0x3C, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0xF8, 0x00,
  0x1C, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x01, 0xE7, 0xBE, 0x70, 0x0E, 0x3C,
  0x78, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF1, 0xC3, 0x8E, 0x1C, 0x30,
  0xC0, 0x00, 0x10, 0x07, 0x00, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x0E,
  0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1C, 0x00, 0x40,
  0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xC0,
  0x20, 0x03, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x03,
  0x00, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x0E, 0x00, 0x80, 0x00, 0x1F,
  0x8F, 0xF9, 0xC7, 0xF0, 0x74, 0x0E, 0x01, 0xC0, 0x70, 0xFC, 0x1F, 0x03,
  0x00, 0x60, 0x10, 0x00, 0x00, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x07,
  0xE0, 0x7F, 0x87, 0x0E, 0x70, 0x33, 0x01, 0xB8, 0xED, 0x8F, 0xEC, 0xE7,
  0x66, 0x1B, 0x71, 0xFB, 0x8D, 0xDC, 0x6C, 0xE7, 0x63, 0xDB, 0x1E, 0xDC,
  0x08, 0x60, 0x03, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x80, 0x6E, 0x03, 0xB8, 0x0E, 0xE0, 0x73, 0x81, 0xC6, 0x0E, 0x18,
  0x38, 0x60, 0xFF, 0xC7, 0xFF, 0x18, 0x1C, 0xE0, 0x73, 0x01, 0xDC, 0x07,
  0xF0, 0x0C, 0x1F, 0xE0, 0xFF, 0x86, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C,
  0xC1, 0xC7, 0xFC, 0x7F, 0xE3, 0x83, 0x9C, 0x0C, 0xE0, 0x66, 0x07, 0x30,
  0x3B, 0x83, 0xDF, 0xFC, 0xFF, 0x80, 0x07, 0xC0, 0xFF, 0x8F, 0x1C, 0xE0,
  0x77, 0x02, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x06, 0x70, 0x7B, 0xC7, 0x8F, 0xF8, 0x3F, 0x00, 0x1F, 0xC0,
  0xFF, 0x86, 0x1E, 0x70, 0x73, 0x81, 0x9C, 0x0C, 0xE0, 0x66, 0x07, 0x30,
  0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x07, 0x30, 0x3B, 0x87, 0x9F, 0xF8,
  0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0xFC, 0x3F, 0xF1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF1,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFC, 0x3F, 0xF1,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0x0E, 0x70, 0x33, 0x81, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x71, 0xFF, 0x0F, 0xB8, 0x8D, 0xC0, 0x6E, 0x07, 0x38,
  0x39, 0xC3, 0xC7, 0xEE, 0x1E, 0x60, 0x18, 0x1C, 0xE0, 0x73, 0x81, 0xCE,
  0x06, 0x38, 0x38, 0xC0, 0xE3, 0x03, 0x9F, 0xFE, 0x7F, 0xF9, 0xC0, 0xC7,
  0x07, 0x18, 0x1C, 0x60, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x18, 0xE0, 0xE0,
  0x1F, 0xFC, 0x7F, 0xF0, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x01, 0xC2, 0x0E, 0x70, 0x73, 0xC7, 0x0F, 0xF0, 0x3F, 0x00, 0x1C, 0x0E,
  0x30, 0x38, 0xE0, 0xE1, 0xC3, 0x83, 0x8E, 0x07, 0x38, 0x0C, 0xE0, 0x3B,
  0x80, 0x7F, 0x80, 0xFF, 0x01, 0xE7, 0x03, 0x8E, 0x06, 0x0E, 0x1C, 0x1C,
  0x38, 0x38, 0x70, 0x38, 0xE0, 0x78, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xC0, 0x1E, 0x0E, 0x3C, 0x3C, 0x78, 0x78,
  0xF1, 0xF3, 0xF7, 0xE7, 0x6D, 0xCE, 0xFB, 0x19, 0xE6, 0x33, 0x8C, 0x63,
  0x39, 0xC4, 0x73, 0x88, 0xC7, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x1C,
  0xE0, 0x38, 0x1C, 0x1C, 0xF8, 0x73, 0xE1, 0xCF, 0x86, 0x36, 0x18, 0xD8,
  0x63, 0x73, 0x9D, 0xCE, 0x73, 0x39, 0xCC, 0xC6, 0x3B, 0x18, 0xEC, 0x61,
  0xF3, 0x87, 0xCE, 0x1F, 0x30, 0x78, 0xC1, 0xE0, 0x07, 0xE0, 0x7F, 0x87,
  0x0E, 0x70, 0x73, 0x01, 0xB8, 0x0D, 0xC0, 0x6E, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0x30, 0x39, 0xC3, 0x87, 0xF8, 0x1F, 0x00,
  0x1F, 0xF0, 0x7F, 0xE1, 0x83, 0x8E, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x83,
  0x8C, 0x0E, 0x3F, 0xF1, 0xFF, 0x87, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0x0E, 0x70,
  0x73, 0x01, 0xB8, 0x0D, 0xC0, 0x6E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0x30, 0x39, 0xC3, 0x87, 0xF8, 0x1F, 0x80, 0x38, 0x00,
  0xC6, 0x07, 0x70, 0x1F, 0x00, 0x60, 0x1F, 0xF0, 0x7F, 0xE1, 0x83, 0x8E,
  0x07, 0x38, 0x1C, 0xE0, 0x73, 0x83, 0x8C, 0x0E, 0x3F, 0xF1, 0xFF, 0x07,
  0x38, 0x1C, 0x70, 0x71, 0xC1, 0x83, 0x0E, 0x0E, 0x38, 0x38, 0xE0, 0x70,
  0x03, 0xF0, 0x1F, 0xF8, 0x78, 0x78, 0xE0, 0x41, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0x8C, 0x07, 0x3C, 0x1E, 0x3F, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x67, 0x03, 0x30, 0x3B,
  0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0x38, 0x19, 0x81, 0xCC, 0x0E, 0x60,
  0x63, 0x87, 0x1F, 0xF0, 0x3F, 0x00, 0xE0, 0x1D, 0x80, 0x67, 0x03, 0x9C,
  0x0E, 0x70, 0x71, 0xC1, 0xC7, 0x0E, 0x1C, 0x38, 0x71, 0xC0, 0xC7, 0x03,
  0x18, 0x0C, 0xE0, 0x3B, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0x70, 0x06, 0xE0, 0x1D, 0xC0, 0x3B, 0x00, 0x66, 0x38, 0xCC, 0x71, 0x99,
  0xE7, 0x33, 0xCC, 0x67, 0x99, 0xDB, 0x33, 0xB6, 0xE7, 0x4D, 0x8F, 0x9B,
  0x1B, 0x36, 0x3C, 0x7C, 0x78, 0xF0, 0xF1, 0xE0, 0x0E, 0x03, 0x87, 0x03,
  0x81, 0xC3, 0x80, 0xE3, 0x80, 0x39, 0xC0, 0x1D, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xDC, 0x00, 0xEE, 0x00, 0xE3, 0x80,
  0xE1, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0xF0, 0x1E, 0x00, 0xE0, 0x1E, 0xE0,
  0x71, 0xC0, 0xE3, 0x83, 0x83, 0x8E, 0x07, 0x1C, 0x06, 0x70, 0x0F, 0xC0,
  0x1F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0xFC, 0xFF,
  0xF8, 0x1F, 0xE3, 0xF8, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0x60, 0x0F, 0xE1, 0xFC, 0x00, 0xE0, 0xC1, 0x83, 0x06,
  0x0E, 0x0C, 0x18, 0x30, 0x70, 0x60, 0xC1, 0x83, 0x07, 0x06, 0x0C, 0x18,
  0x30, 0x70, 0x60, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x7F, 0x0F,
  0xF0, 0x01, 0xC0, 0x1E, 0x01, 0xF8, 0x1D, 0xC0, 0xC6, 0x0E, 0x38, 0xE0,
  0xC6, 0x07, 0x70, 0x3F, 0x00, 0xD0, 0x08, 0xFF, 0xFF, 0xFF, 0x6E, 0x73,
  0x30, 0x0F, 0x39, 0xFD, 0xCE, 0x1C, 0xE0, 0xE7, 0x07, 0x70, 0x3B, 0x81,
  0xDC, 0x0E, 0xE0, 0xE7, 0x07, 0x3C, 0x78, 0xFD, 0xF3, 0xC7, 0x00, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE7, 0x87, 0x7E,
  0x34, 0x71, 0xC1, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x19, 0x81, 0xCC,
  0x0E, 0xF0, 0xE7, 0x7E, 0x39, 0xE0, 0x0F, 0x87, 0xFD, 0xE3, 0xB8, 0x2E,
  0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x5C, 0x1F, 0x87, 0x3F, 0xC3, 0xF0,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0xF3,
  0x87, 0xEE, 0x38, 0x79, 0xC0, 0xC7, 0x03, 0x38, 0x1C, 0xE0, 0x73, 0x81,
  0xCE, 0x07, 0x38, 0x38, 0x71, 0x61, 0xFF, 0x83, 0xCE, 0x00, 0x0F, 0xC3,
  0xFE, 0x78, 0xE7, 0x06, 0xE0, 0x7E, 0x1E, 0xFF, 0xCF, 0xE0, 0xC0, 0x0E,
  0x06, 0xE1, 0xC7, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x08, 0xE0, 0x1C, 0x70,
  0x07, 0x38, 0x01, 0xDC, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x0F, 0x38, 0xFD,
  0xCE, 0x1E, 0xE0, 0x67, 0x03, 0x30, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77,
  0x07, 0x1C, 0x58, 0xFF, 0xC3, 0xCE, 0x00, 0x70, 0x03, 0x18, 0x38, 0xFF,
  0x83, 0xF0, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x39, 0xE3, 0xBF, 0x3C, 0x73, 0x83, 0x78, 0x37, 0x07, 0x70, 0x77, 0x07,
  0x70, 0x76, 0x06, 0x60, 0x6E, 0x0E, 0xE0, 0xE0, 0x07, 0x00, 0x78, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x0E, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0xC2, 0x1C, 0xF1, 0x9C, 0x1B, 0x81, 0xF0, 0x1E,
  0x00, 0x00, 0x70, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x38, 0x43, 0x8E, 0x38, 0x73, 0x03, 0xB0, 0x1F, 0x00,
  0xE0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE7,
  0x87, 0x7E, 0x3C, 0x71, 0xC1, 0x9C, 0x1C, 0xE0, 0xC7, 0x1C, 0x3B, 0x81,
  0xDC, 0x4C, 0x63, 0x63, 0xBF, 0x1F, 0xB8, 0x70, 0x7F, 0x0F, 0xE2, 0x18,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x30, 0x8E, 0x39, 0xCE, 0x3B, 0x87, 0xE0, 0x70, 0x00, 0x33,
  0x1C, 0xDE, 0xF3, 0x9C, 0xCC, 0x63, 0x71, 0x8D, 0xC6, 0x36, 0x38, 0xD8,
  0xC7, 0x63, 0x1D, 0x8C, 0x6E, 0x31, 0xB8, 0xC6, 0xC7, 0x18, 0x39, 0xE3,
  0xBF, 0x3C, 0x73, 0x83, 0x38, 0x37, 0x07, 0x70, 0x77, 0x07, 0x70, 0x76,
  0x06, 0x60, 0x6E, 0x0E, 0xE0, 0xE0, 0x07, 0xC0, 0xFF, 0x0E, 0x1C, 0xE0,
  0x67, 0x03, 0xB0, 0x1F, 0x80, 0xFC, 0x06, 0xE0, 0x73, 0x03, 0x9C, 0x38,
  0x7F, 0x81, 0xF0, 0x00, 0x1C, 0xF0, 0x77, 0xE1, 0xA3, 0x87, 0x07, 0x38,
  0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x06, 0x30, 0x38, 0xC0, 0xE7, 0x87, 0x1D,
  0xF8, 0x73, 0xC1, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x0F, 0x38, 0xFD, 0xCE, 0x1E, 0xE0, 0x67, 0x03, 0x70, 0x3B, 0x81, 0xDC,
  0x0E, 0xE0, 0x77, 0x07, 0x1C, 0x58, 0xFD, 0xC3, 0xCE, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0xFC, 0xFF, 0xDF, 0x1E, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x00, 0x0F, 0xC1, 0xFF, 0x38, 0x33, 0x00, 0x38, 0x03, 0xF0, 0x1F,
  0xE0, 0x3E, 0x00, 0x74, 0x07, 0xE0, 0xE7, 0xFC, 0x1F, 0x80, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFE, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x38, 0x63, 0x9E, 0x3B, 0x83, 0xF0, 0x1C, 0x00,
  0x70, 0x77, 0x07, 0x60, 0x76, 0x06, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E,
  0xC0, 0xEC, 0x3C, 0xE3, 0xCF, 0xDC, 0x79, 0xC0, 0x7C, 0x37, 0xE3, 0x86,
  0x0E, 0x30, 0x73, 0x83, 0x9C, 0x1C, 0xE1, 0xC7, 0x0E, 0x38, 0xE1, 0x87,
  0x0C, 0xF0, 0x7F, 0x03, 0xE0, 0x00, 0x73, 0x9B, 0x18, 0xD8, 0xC6, 0xC6,
  0x36, 0x31, 0xF1, 0x8F, 0x9C, 0x78, 0xE3, 0xC6, 0x3E, 0x31, 0xB3, 0x8D,
  0xFC, 0xC7, 0x3C, 0x00, 0x0F, 0x1C, 0x3E, 0x7D, 0xED, 0x3B, 0x1A, 0x30,
  0x38, 0x60, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0xC3, 0x89, 0x8B, 0x3B, 0x96,
  0xE7, 0xCF, 0x87, 0x8E, 0x00, 0x1C, 0x1C, 0x70, 0x71, 0x81, 0xC6, 0x06,
  0x38, 0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x30, 0xE3, 0xC3, 0x8F,
  0x0F, 0xDC, 0x1E, 0x70, 0x01, 0xC0, 0x0E, 0x18, 0x78, 0xFF, 0xC0, 0xFC,
  0x00, 0x1F, 0x19, 0xFF, 0xCC, 0x7E, 0xC1, 0xE6, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC4, 0x1C, 0x73, 0xC1, 0xBF, 0xCD, 0xDF, 0xEC, 0x3E, 0x00, 0x07,
  0xF0, 0x7E, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07,
  0x00, 0x60, 0xFC, 0x0F, 0xC0, 0x0E, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38,
  0x03, 0x00, 0x30, 0x07, 0x00, 0x7F, 0x03, 0xF0, 0x1C, 0x71, 0x86, 0x18,
  0x63, 0x8C, 0x30, 0xC3, 0x1C, 0x71, 0x86, 0x18, 0x63, 0x8E, 0x30, 0xC3,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x03, 0xF0, 0x7F, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFE, 0x0F, 0xC0, 0x1C, 0x19,
  0xF0, 0xD9, 0xC7, 0xC6, 0x6C, 0x3F, 0x60, 0xF0,
};

const GFXglyph IBMPlexMono_MediumItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 6, 17, 15, 5, -17 },
  { 14, 8, 7, 15, 5, -19 },
  { 21, 16, 17, 15, 0, -17 },
  { 55, 14, 23, 15, 1, -20 },
  { 96, 18, 17, 15, -1, -17 },
  { 135, 15, 17, 15, 0, -17 },
  { 167, 4, 7, 15, 7, -19 },
  { 171, 10, 22, 15, 5, -19 },
  { 199, 10, 22, 15, 1, -19 },
  { 227, 13, 12, 15, 1, -14 },
  { 247, 12, 12, 15, 2, -14 },
  { 265, 6, 8, 15, 3, -4 },
  { 271, 8, 2, 15, 4, -9 },
  { 273, 5, 4, 15, 4, -4 },
  { 276, 15, 22, 15, 0, -19 },
  { 318, 13, 17, 15, 1, -17 },
  { 346, 12, 17, 15, 1, -17 },
  { 372, 13, 17, 15, 1, -17 },
  { 400, 14, 17, 15, 0, -17 },
  { 430, 14, 17, 15, 0, -17 },
  { 460, 14, 17, 15, 1, -17 },
  { 490, 13, 17, 15, 1, -17 },
  { 518, 13, 17, 15, 2, -17 },
  { 546, 13, 17, 15, 1, -17 },
  { 574, 12, 17, 15, 2, -17 },
  { 600, 6, 13, 15, 4, -13 },
  { 610, 7, 17, 15, 3, -13 },
  { 625, 12, 15, 15, 2, -15 },
  { 648, 13, 7, 15, 1, -11 },
  { 660, 12, 15, 15, 1, -15 },
  { 683, 11, 17, 15, 3, -17 },
  { 707, 13, 20, 15, 1, -17 },
  { 740, 14, 17, 15, -1, -17 },
  { 770, 13, 17, 15, 1, -17 },
  { 798, 13, 17, 15, 2, -17 },
  { 826, 13, 17, 15, 1, -17 },
  { 854, 14, 17, 15, 1, -17 },
  { 884, 14, 17, 15, 1, -17 },
  { 914, 13, 17, 15, 1, -17 },
  { 942, 14, 17, 15, 1, -17 },
  { 972, 14, 17, 15, 1, -17 },
  { 1002, 13, 17, 15, 1, -17 },
  { 1030, 15, 17, 15, 1, -17 },
  { 1062, 11, 17, 15, 2, -17 },
  { 1086, 15, 17, 15, 0, -17 },
  { 1118, 14, 17, 15, 1, -17 },
  { 1148, 13, 17, 15, 1, -17 },
  { 1176, 14, 17, 15, 1, -17 },
  { 1206, 13, 22, 15, 1, -17 },
  { 1242, 14, 17, 15, 1, -17 },
  { 1272, 15, 17, 15, 0, -17 },
  { 1304, 14, 17, 15, 2, -17 },
  { 1334, 13, 17, 15, 2, -17 },
  { 1362, 14, 17, 15, 2, -17 },
  { 1392, 15, 17, 15, 1, -17 },
  { 1424, 17, 17, 15, -1, -17 },
  { 1461, 15, 17, 15, 2, -17 },
  { 1493, 15, 17, 15, 0, -17 },
  { 1525, 11, 22, 15, 4, -19 },
  { 1556, 7, 22, 15, 4, -19 },
  { 1576, 12, 22, 15, 0, -19 },
  { 1609, 13, 11, 15, 1, -17 },
  { 1627, 12, 2, 15, 0, 2 },
  { 1630, 4, 5, 15, 5, -19 },
  { 1633, 13, 13, 15, 1, -13 },
  { 1655, 13, 19, 15, 1, -19 },
  { 1686, 11, 13, 15, 2, -13 },
  { 1704, 14, 19, 15, 1, -19 },
  { 1738, 12, 13, 15, 2, -13 },
  { 1758, 17, 24, 15, -1, -19 },
  { 1809, 13, 18, 15, 1, -13 },
  { 1839, 12, 19, 15, 1, -19 },
  { 1868, 12, 19, 15, 2, -19 },
  { 1897, 12, 24, 15, 1, -19 },
  { 1933, 13, 19, 15, 1, -19 },
  { 1964, 11, 19, 15, 2, -19 },
  { 1991, 14, 13, 15, 0, -13 },
  { 2014, 12, 13, 15, 1, -13 },
  { 2034, 13, 13, 15, 1, -13 },
  { 2056, 14, 18, 15, 0, -13 },
  { 2088, 13, 18, 15, 1, -13 },
  { 2118, 12, 13, 15, 3, -13 },
  { 2138, 12, 13, 15, 1, -13 },
  { 2158, 12, 17, 15, 2, -17 },
  { 2184, 12, 13, 15, 2, -13 },
  { 2204, 13, 13, 15, 1, -13 },
  { 2226, 13, 13, 15, 1, -13 },
  { 2248, 15, 13, 15, 0, -13 },
  { 2273, 14, 18, 15, 0, -13 },
  { 2305, 13, 13, 15, 1, -13 },
  { 2327, 12, 22, 15, 3, -19 },
  { 2360, 6, 22, 15, 5, -19 },
  { 2377, 12, 22, 15, 1, -19 },
  { 2410, 13, 6, 15, 1, -10 },
};

const GFXfont IBMPlexMono_MediumItalic25pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic25pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _IBMPLEXMONO_MEDIUMITALIC25PT7B_H_
