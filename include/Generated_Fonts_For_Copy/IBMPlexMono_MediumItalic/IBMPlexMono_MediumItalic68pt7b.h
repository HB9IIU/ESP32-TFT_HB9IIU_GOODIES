#ifndef _IBMPLEXMONO_MEDIUMITALIC68PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x80,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x3F, 0x01,
  0xFC, 0x7E, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F,
  0x8F, 0xE0, 0x7F, 0x1F, 0x80, 0xFE, 0x3F, 0x01, 0xF8, 0xFE, 0x03, 0xF1,
  0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xC0, 0x7F, 0x1F,
  0x80, 0xFC, 0x7F, 0x01, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8,
  0x1F, 0xC7, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x20, 0x1F,
  0x81, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0xFB, 0xFF, 0xC0, 0x7F, 0xC1, 0xF0,
  0xFF, 0x00, 0xFF, 0x03, 0xE0, 0xFC, 0x03, 0xFC, 0x07, 0xC0, 0xF0, 0x07,
  0xF8, 0x1F, 0x00, 0xC0, 0x0F, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x7C,
  0x00, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0x00,
  0xFE, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0x80, 0x00, 0x03, 0xFC, 0x1F,
  0x00, 0x00, 0x07, 0xFC, 0x3E, 0x00, 0x00, 0x07, 0xFE, 0x7C, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE7, 0xFF, 0x00, 0x00, 0x07, 0xC3, 0xFE,
  0x00, 0x00, 0x0F, 0x83, 0xFE, 0x00, 0x00, 0x1F, 0x03, 0xFC, 0x00, 0x00,
  0x3E, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x0F,
  0xE0, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x7F, 0x80, 0x40,
  0x0F, 0x80, 0xFF, 0x03, 0xC0, 0x1F, 0x01, 0xFC, 0x0F, 0xC0, 0x3E, 0x07,
  0xF8, 0x3F, 0xC0, 0xF8, 0x1F, 0xF0, 0xFF, 0xE1, 0xF0, 0x7F, 0xC0, 0xFF,
  0xF3, 0xE7, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0x80, 0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x3F, 0x00,
  0x01, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x1F, 0x80, 0x00,
  0x0F, 0xFF, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x83, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0x83, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xFF, 0xF0, 0x00, 0x01,
  0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0xFE, 0x0F, 0xE0, 0x00, 0x0F,
  0xC1, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x07,
  0xC0, 0x0F, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x07, 0xF0, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F,
  0xFB, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xF9, 0xFF, 0xC0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x18, 0xFF, 0x00, 0x1F, 0xE0,
  0x1C, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0x7F,
  0x00, 0x1F, 0xF0, 0x7E, 0x7F, 0x00, 0x3B, 0xF8, 0xFE, 0x7F, 0x80, 0x73,
  0xF8, 0xFC, 0x7F, 0xC0, 0xF3, 0xF9, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF0, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F,
  0xE3, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0x00,
  0x0F, 0xC0, 0x02, 0x1C, 0x00, 0xFC, 0x01, 0xE3, 0xF8, 0x1F, 0xC0, 0xFE,
  0x3F, 0xF1, 0xFC, 0x7F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x0F, 0xC3, 0xFE,
  0x7F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xE0,
  0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xF3,
  0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00,
  0x7F, 0x3F, 0xC0, 0xFC, 0x07, 0xF7, 0xF8, 0x1F, 0xE0, 0xFF, 0x7F, 0x83,
  0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xE0, 0xFF, 0x7F, 0x83, 0xFE, 0x0F, 0xF7,
  0xF8, 0x3F, 0xC0, 0xFF, 0x7F, 0x83, 0xFC, 0x0F, 0xF7, 0xF0, 0x1F, 0x81,
  0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xBF, 0xC0, 0x01, 0xFF, 0x9F, 0xC0, 0x01, 0xFF, 0x8F,
  0xE0, 0x01, 0xFF, 0x07, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x03,
  0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0x00,
  0x7F, 0x00, 0x06, 0x00, 0x3F, 0x80, 0x02, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F,
  0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x07, 0x80,
  0x00, 0x7F, 0x80, 0x08, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0xFE, 0x00,
  0x0F, 0xF8, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x0E, 0x00, 0x01, 0xFE, 0x00,
  0x20, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x02,
  0x00, 0x00, 0x1F, 0xE0, 0x78, 0x00, 0x01, 0xFF, 0x07, 0xE0, 0x00, 0x0F,
  0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xFC,
  0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0xFE,
  0x00, 0x07, 0xE3, 0xFF, 0xF8, 0x00, 0x7F, 0x3F, 0xFF, 0xE0, 0x03, 0xF3,
  0xFF, 0xFF, 0x80, 0x1F, 0xBF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x30, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x60, 0x00, 0x03, 0xFC,
  0x07, 0x00, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xFF, 0x00,
  0x3F, 0xCF, 0xFF, 0xF0, 0x1F, 0xE7, 0xFF, 0xFE, 0x07, 0xFB, 0xFF, 0xFF,
  0xC3, 0xFD, 0xFF, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x00,
  0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFD, 0xFF, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xF7, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xC0, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x01, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x1F, 0xE1, 0xF8,
  0x00, 0x03, 0xFC, 0x3F, 0x00, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0x80,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xDF,
  0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00,
  0x3F, 0xE7, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0,
  0x1F, 0x7F, 0x0F, 0xFF, 0xFF, 0xBF, 0xC1, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F,
  0xFF, 0xF7, 0xF8, 0x07, 0xFF, 0xF1, 0xFE, 0x00, 0xFF, 0xF8, 0xFF, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0x07, 0xFC,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0x7F, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0,
  0x7F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x9F,
  0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xCF, 0x80, 0x00, 0xFF, 0x04, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0xFC, 0x03, 0xFE,
  0x3F, 0x1F, 0xC0, 0x7F, 0xF3, 0xF1, 0xF8, 0x0F, 0xFF, 0xBF, 0x1F, 0x81,
  0xFF, 0xFF, 0xE3, 0xF8, 0x3F, 0xC1, 0xFE, 0x3F, 0x83, 0xF8, 0x0F, 0xE3,
  0xF0, 0x7F, 0x00, 0x7E, 0x3F, 0x07, 0xE0, 0x07, 0xE3, 0xF0, 0x7E, 0x00,
  0x7E, 0x7F, 0x0F, 0xE0, 0x0F, 0xC7, 0xF0, 0xFE, 0x00, 0xFC, 0x7F, 0x0F,
  0xC0, 0x0F, 0xC7, 0xE0, 0xFC, 0x00, 0xFC, 0x7E, 0x0F, 0xC0, 0x0F, 0xC7,
  0xE0, 0xFC, 0x00, 0xFC, 0x7E, 0x0F, 0xC0, 0x1F, 0x87, 0xE1, 0xFC, 0x01,
  0xF8, 0xFE, 0x1F, 0xC0, 0x1F, 0x8F, 0xC1, 0xFC, 0x03, 0xF8, 0xFC, 0x0F,
  0xC0, 0x7F, 0x8F, 0xC0, 0xFC, 0x0F, 0xF8, 0xFC, 0x0F, 0xE1, 0xFF, 0x0F,
  0xC0, 0xFF, 0xFB, 0xF0, 0xFC, 0x0F, 0xFF, 0xBF, 0x0F, 0xC0, 0x7F, 0xF3,
  0xF0, 0xFC, 0x07, 0xFE, 0x3F, 0x0F, 0xC0, 0x3F, 0xC3, 0xF0, 0x7E, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x03, 0xFB, 0xFC,
  0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0x00, 0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x07, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0xFF, 0x00,
  0x00, 0x40, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x10,
  0x07, 0xF0, 0x00, 0x03, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC0,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0x80,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x07,
  0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xF8, 0x3F, 0xC0, 0x00, 0x10, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x9F,
  0xE0, 0x0F, 0xFF, 0xF3, 0xFC, 0x01, 0xFF, 0xFE, 0x7F, 0x80, 0x3F, 0xFF,
  0xCF, 0xF0, 0x07, 0xFF, 0xF9, 0xFE, 0x01, 0xFF, 0xFE, 0x3F, 0xC0, 0x00,
  0x0F, 0xC7, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0x0F,
  0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xFE, 0x0F, 0xF8, 0x01,
  0xDF, 0x80, 0xFF, 0xC0, 0xFB, 0xF0, 0x1F, 0xFF, 0xFE, 0xFE, 0x01, 0xFF,
  0xFF, 0x9F, 0xC0, 0x1F, 0xFF, 0xE3, 0xF8, 0x01, 0xFF, 0xF8, 0x7F, 0x00,
  0x1F, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x7F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x03,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xC0, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0xFF,
  0x80, 0x00, 0x0F, 0xE0, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x00, 0x01, 0xFD, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x0F, 0xEF,
  0xC0, 0x3F, 0x3F, 0x07, 0xEF, 0xE0, 0x1F, 0x9F, 0x87, 0xE7, 0xF0, 0x1F,
  0xCF, 0xC3, 0xF3, 0xF8, 0x0F, 0xE7, 0xE3, 0xF1, 0xF8, 0x07, 0xF1, 0xF3,
  0xF8, 0xFC, 0x03, 0xF0, 0xFD, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0xFC, 0x7F,
  0x00, 0xFC, 0x3F, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xFC, 0x1F, 0xC0, 0x7F,
  0x07, 0xFE, 0x0F, 0xC0, 0x3F, 0x83, 0xFE, 0x07, 0xE0, 0x1F, 0xC1, 0xFF,
  0x07, 0xF0, 0x0F, 0xC0, 0xFF, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x81, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0x80, 0x7E, 0x01, 0xFC,
  0x07, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0x60, 0x0F, 0xE0, 0x3F, 0x80, 0x20, 0x07, 0xF0,
  0x1F, 0xC0, 0x10, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFC, 0x03, 0xFF,
  0x00, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0x07, 0xE0, 0x1F, 0xFE, 0x00, 0x1F,
  0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0xFF,
  0xF0, 0x00, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x03,
  0xF0, 0x0F, 0xEF, 0xC0, 0x0F, 0xE0, 0x1F, 0xDF, 0x80, 0x1F, 0xC0, 0x3F,
  0xBF, 0x00, 0x3F, 0x80, 0x7E, 0x7F, 0x00, 0x7F, 0x00, 0xFC, 0xFE, 0x00,
  0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0x07, 0xF1, 0xF8, 0x07, 0xF0, 0x0F,
  0xE3, 0xF0, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0,
  0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x03,
  0xF8, 0x3F, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0x3F, 0x01, 0xF8, 0x3F, 0x00,
  0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0x0F,
  0xE3, 0xF8, 0x07, 0xF0, 0x0F, 0xC7, 0xF0, 0x0F, 0xC0, 0x1F, 0x8F, 0xE0,
  0x1F, 0x80, 0x3F, 0x9F, 0x80, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x00,
  0x7E, 0xFE, 0x01, 0xFC, 0x00, 0xFD, 0xFC, 0x03, 0xF8, 0x01, 0xFB, 0xF8,
  0x07, 0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0x80,
  0x07, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xFE,
  0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0xF8, 0x07, 0xE0,
  0x00, 0x7F, 0xE0, 0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x07, 0xF1, 0xFE, 0x00,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x0F,
  0xF7, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFC, 0x7F,
  0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x07, 0xF3, 0xFC,
  0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xF7, 0xF8,
  0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x10, 0x00, 0x07, 0xF8, 0x03, 0x80, 0x00,
  0x3F, 0xC0, 0x7C, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xC0,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xE0, 0x0F,
  0xF0, 0x00, 0x01, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x80,
  0x00, 0x03, 0xFC, 0x07, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0x80, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF,
  0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x7F, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x3F,
  0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x7F,
  0x01, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x80, 0x7E, 0x07, 0xF0, 0x1F,
  0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xFE, 0x03,
  0xF0, 0x1F, 0x80, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0xE0, 0x3F, 0x01,
  0xF8, 0x1F, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xFE, 0x07, 0xE0, 0x1F, 0x83,
  0xEF, 0x81, 0xF8, 0x07, 0xE0, 0xFB, 0xE0, 0x7E, 0x03, 0xF8, 0x3E, 0xF8,
  0x3F, 0x80, 0xFE, 0x1F, 0x3E, 0x0F, 0xC0, 0x3F, 0x87, 0xCF, 0x83, 0xF0,
  0x0F, 0xC1, 0xF3, 0xF0, 0xFC, 0x03, 0xF0, 0xF8, 0xFC, 0x7F, 0x00, 0xFC,
  0x3E, 0x3F, 0x1F, 0x80, 0x3F, 0x0F, 0x8F, 0xC7, 0xE0, 0x0F, 0xC7, 0xC3,
  0xF1, 0xF8, 0x03, 0xF1, 0xF0, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x3F, 0x3F,
  0x00, 0x7F, 0x3E, 0x0F, 0xCF, 0xC0, 0x1F, 0xCF, 0x83, 0xF3, 0xF0, 0x07,
  0xF7, 0xE0, 0xFC, 0xFC, 0x01, 0xF9, 0xF0, 0x3F, 0x7E, 0x00, 0x7E, 0x7C,
  0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0x80, 0xFD,
  0xF8, 0x01, 0xFB, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00, 0x1F, 0xDF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xBF,
  0x80, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x3F,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x80, 0x00, 0x00, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF8, 0x06, 0x07,
  0xC3, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8,
  0x3F, 0x03, 0xF0, 0x3C, 0x06, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x07, 0xF0, 0x07, 0xFF, 0xE1, 0xFC, 0x07, 0xFF, 0xFC, 0x7F, 0x03,
  0xFF, 0xFF, 0x9F, 0xC1, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F, 0xE0, 0x3F, 0xFC,
  0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0x7F, 0x8F, 0xE0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x07, 0xF1, 0xFE, 0x00,
  0x01, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0xFE, 0x3F,
  0xC0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F,
  0xC1, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0x80, 0x1D, 0xFC, 0x1F, 0xE0, 0x0F,
  0xFF, 0x07, 0xFE, 0x0F, 0xBF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0x3F, 0xFF,
  0xF3, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xFC, 0x0F, 0xF8, 0x1F,
  0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0xE0, 0x07, 0xF8, 0x7F, 0xFE, 0x00, 0xFE,
  0x1F, 0xFF, 0xE0, 0x1F, 0xC7, 0xFF, 0xFE, 0x03, 0xF9, 0xFF, 0xFF, 0xC0,
  0x7F, 0x7C, 0x0F, 0xF8, 0x1F, 0xEE, 0x00, 0xFF, 0x83, 0xFF, 0x80, 0x0F,
  0xF0, 0x7F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xF7, 0x81, 0xFF,
  0xC1, 0xFE, 0xFF, 0xFF, 0xF0, 0x3F, 0xDF, 0xFF, 0xFC, 0x07, 0xF1, 0xFF,
  0xFF, 0x00, 0xFE, 0x1F, 0xFF, 0xC0, 0x1F, 0xC1, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xF0, 0xFF, 0x00, 0x01, 0x81, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x20, 0xFE, 0x00, 0x00, 0xF1, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFE,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x83, 0xF8, 0x00, 0x7F, 0xFF, 0x0F,
  0xE0, 0x03, 0xFF, 0xFE, 0x7F, 0x80, 0x3F, 0xFF, 0xF9, 0xFE, 0x00, 0xFF,
  0xFF, 0xF7, 0xF0, 0x07, 0xFF, 0x03, 0xDF, 0xC0, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x07,
  0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xF0, 0x07, 0x7F, 0x00, 0x7F, 0xE0, 0x7D,
  0xFC, 0x00, 0xFF, 0xFF, 0xE7, 0xF0, 0x03, 0xFF, 0xFF, 0x1F, 0xC0, 0x07,
  0xFF, 0xF8, 0xFF, 0x00, 0x0F, 0xFF, 0xC3, 0xFC, 0x00, 0x1F, 0xFE, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x1F,
  0xFC, 0x7F, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x20, 0x3F, 0x80, 0x00, 0x1C, 0x1F, 0xC0, 0x00, 0x1F, 0x0F, 0xF0,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x78, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF3, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x1F, 0xC0, 0x07, 0xFF,
  0xF0, 0xFE, 0x00, 0xFF, 0xFF, 0xCF, 0xF0, 0x0F, 0xFF, 0xFE, 0x7F, 0x80,
  0xFF, 0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0x03, 0xDF, 0xC0, 0x7F, 0xC0, 0x07,
  0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x07, 0xFC,
  0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0x00,
  0x77, 0xF0, 0x0F, 0xFC, 0x0F, 0xBF, 0x80, 0x3F, 0xFF, 0xF9, 0xFC, 0x01,
  0xFF, 0xFF, 0x8F, 0xE0, 0x07, 0xFF, 0xF8, 0x7F, 0x00, 0x1F, 0xFF, 0x87,
  0xF8, 0x00, 0x7F, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x08, 0x00, 0x03, 0xFC, 0x00, 0x60, 0x00,
  0x3F, 0xC0, 0x07, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0xF0, 0x03, 0xF8,
  0x7F, 0xFC, 0x03, 0xFC, 0x7F, 0xFF, 0x01, 0xFE, 0x7F, 0xFF, 0xC0, 0xFF,
  0x7F, 0xFF, 0xE0, 0x7F, 0x3C, 0x1F, 0xF8, 0x3F, 0xB8, 0x03, 0xFC, 0x1F,
  0xD8, 0x01, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0x0F, 0xF8, 0x00, 0x3F, 0x87,
  0xFC, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE,
  0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x7F, 0x8F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x03, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x10, 0x00, 0x7F, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x7C, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x10, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x7F, 0x80, 0x0F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xF8, 0x1F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x00, 0xFF, 0x3F,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F,
  0x83, 0xFF, 0xC0, 0x03, 0xF8, 0x7F, 0xFE, 0x00, 0x7F, 0x8F, 0xFF, 0xF0,
  0x07, 0xF9, 0xFF, 0xFF, 0x00, 0x7F, 0x3F, 0xFF, 0xF8, 0x07, 0xF3, 0xC1,
  0xFF, 0x80, 0x7F, 0x70, 0x07, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0xFF,
  0xC0, 0x03, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xFC, 0x00,
  0x1F, 0xC7, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x83, 0xF8,
  0x3F, 0xC0, 0x1C, 0x3F, 0x81, 0xFC, 0x03, 0xE7, 0xF8, 0x1F, 0xE0, 0x7F,
  0x7F, 0x81, 0xFE, 0x0F, 0xE7, 0xF0, 0x0F, 0xE1, 0xFC, 0x7F, 0x00, 0xFF,
  0x7F, 0x87, 0xF0, 0x07, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0xFF, 0x0F, 0xF0,
  0x03, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xE0, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x20,
  0x07, 0xF0, 0x03, 0x80, 0x7F, 0x80, 0x3E, 0x03, 0xF8, 0x03, 0xF8, 0x1F,
  0xC0, 0x3F, 0xE0, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x87,
  0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xC7, 0xFC, 0x00, 0xFE, 0x7F, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x03, 0xF0, 0x07, 0xE3, 0xFC, 0x0F, 0xF8, 0x0F, 0xCF, 0xFC, 0x3F,
  0xF0, 0x1F, 0xBF, 0xF8, 0xFF, 0xF0, 0x7F, 0x7F, 0xFB, 0xFF, 0xE0, 0xFD,
  0xFF, 0xF7, 0xFF, 0xC1, 0xFB, 0x0F, 0xFC, 0x3F, 0x83, 0xFC, 0x1F, 0xF0,
  0x3F, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x3F,
  0x80, 0x7E, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF8,
  0x07, 0xE1, 0xF8, 0x07, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xC0, 0x3F, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFE,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x0F, 0xE1,
  0xF8, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x01, 0xF8,
  0x7E, 0x01, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x07,
  0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x80, 0x7E,
  0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE0, 0x1F,
  0x87, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x1F, 0xFC, 0x00, 0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0x1F, 0xFF, 0xC0, 0x7F,
  0x9F, 0xFF, 0xF0, 0x3F, 0x9F, 0xFF, 0xF8, 0x1F, 0xCF, 0x07, 0xFE, 0x0F,
  0xEE, 0x00, 0xFF, 0x07, 0xF6, 0x00, 0x7F, 0x87, 0xFE, 0x00, 0x1F, 0xC3,
  0xFE, 0x00, 0x0F, 0xE1, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x80,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x03, 0xFD, 0xFC, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x3F, 0x80,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x7F, 0xC3, 0xFC,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0xFC, 0x00, 0x3F,
  0x87, 0xFF, 0xF8, 0x00, 0xFE, 0x3F, 0xFF, 0xF0, 0x03, 0xF9, 0xFF, 0xFF,
  0xC0, 0x0F, 0xEF, 0x81, 0xFF, 0x00, 0x7F, 0xB8, 0x03, 0xFE, 0x01, 0xFF,
  0xC0, 0x07, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFE, 0xF0, 0x3F, 0xF8, 0x03,
  0xFB, 0xFF, 0xFF, 0xC0, 0x1F, 0xEF, 0xFF, 0xFE, 0x00, 0x7F, 0x1F, 0xFF,
  0xF0, 0x01, 0xFC, 0x3F, 0xFF, 0x80, 0x07, 0xF0, 0x7F, 0xFC, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xC1, 0xFC, 0x01, 0xFF, 0xFC, 0x3F, 0x80, 0x7F, 0xFF, 0xCF, 0xF0,
  0x3F, 0xFF, 0xF9, 0xFE, 0x07, 0xFF, 0xFF, 0xBF, 0x81, 0xFF, 0xC0, 0xF7,
  0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0x07, 0xF1, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0xC3,
  0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0x80, 0x03, 0xFF, 0x07, 0xF8, 0x00, 0xFF,
  0xE0, 0xFF, 0x80, 0x3B, 0xF8, 0x1F, 0xF8, 0x1F, 0x7F, 0x01, 0xFF, 0xFF,
  0xCF, 0xE0, 0x3F, 0xFF, 0xF1, 0xFC, 0x03, 0xFF, 0xFC, 0x7F, 0x80, 0x3F,
  0xFF, 0x0F, 0xF0, 0x03, 0xFF, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xBF, 0xFF, 0xC0, 0xFF, 0xDF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xF8, 0x01, 0xFC,
  0xFF, 0xFC, 0x00, 0xFE, 0xF8, 0x00, 0x00, 0x7F, 0x70, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x0C, 0x03,
  0xF8, 0x00, 0x04, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x02, 0x00, 0x00,
  0x3F, 0x81, 0x80, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x1F, 0xE3, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x10, 0x01, 0xFC, 0x00, 0x30, 0x01,
  0xFC, 0x00, 0x78, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x1F, 0xF8, 0x03, 0xF8, 0x3F, 0xF0, 0x03,
  0xF8, 0xFF, 0xC0, 0x03, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x0F, 0xF8, 0x7F, 0x00, 0x0F, 0xFC, 0x3F, 0x80, 0x07, 0xFC, 0x1F, 0xE0,
  0x06, 0xFE, 0x0F, 0xF0, 0x07, 0x7F, 0x07, 0xFE, 0x0F, 0x3F, 0x83, 0xFF,
  0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0x9F, 0xE0, 0x3F, 0xFF, 0x8F, 0xE0, 0x1F,
  0xFF, 0x87, 0xF0, 0x03, 0xFF, 0x83, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x3F, 0xFF, 0x00, 0x1F, 0x3F, 0xFF, 0x00, 0x3F,
  0xDF, 0xFF, 0x80, 0x1F, 0xEF, 0xFF, 0xC0, 0x07, 0xF7, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x1F,
  0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x03,
  0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xFE, 0x01, 0xFC, 0x07, 0xFE, 0x00,
  0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x7F, 0x01, 0xF8, 0x1F, 0x03, 0xF0, 0x0F, 0xC1, 0xFC, 0x1F,
  0x80, 0x7E, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x1F, 0x81,
  0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xE3, 0xF0, 0x0F, 0xC0, 0x3F, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xE0, 0x1F, 0x9F, 0x80, 0x7E,
  0x00, 0xFC, 0xFC, 0x03, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x80, 0x3F, 0x3F,
  0x00, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xE0, 0x1F, 0x8F, 0xC0, 0x7F, 0x00,
  0xFC, 0xFC, 0x03, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x80, 0x3F, 0x3F, 0x00,
  0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x00, 0xFC,
  0x7E, 0x03, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC,
  0x03, 0xF1, 0xF8, 0x0F, 0xE0, 0x1F, 0x8F, 0xC0, 0x7F, 0x01, 0xF8, 0x7E,
  0x07, 0xF8, 0x1F, 0xC3, 0xF8, 0x77, 0xE0, 0xFC, 0x1F, 0xFF, 0xBF, 0x1F,
  0xC0, 0xFF, 0xF8, 0xFF, 0xFC, 0x03, 0xFF, 0xC7, 0xFF, 0xE0, 0x1F, 0xFC,
  0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x1F, 0xF9, 0xF9, 0xF1,
  0xFC, 0x1F, 0xF0, 0xFC, 0xE0, 0x7F, 0x1F, 0xF0, 0x7E, 0xF0, 0x3F, 0x8F,
  0xE0, 0x3F, 0x70, 0x1F, 0xC3, 0xE0, 0x1F, 0xB0, 0x0F, 0xE0, 0xC0, 0x0F,
  0xF8, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x01,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3C,
  0x01, 0xFE, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x20, 0x7E, 0x00, 0xFF,
  0x80, 0x38, 0x3F, 0x00, 0xEF, 0xC0, 0x3E, 0x1F, 0xC0, 0x77, 0xE0, 0x7F,
  0x8F, 0xE0, 0x7B, 0xF0, 0x7F, 0xC7, 0xF0, 0x39, 0xF8, 0xFF, 0xC3, 0xFC,
  0x7C, 0xFC, 0xFF, 0xC0, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x1F,
  0xFF, 0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x1F, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xFC, 0x03,
  0xFC, 0x00, 0xDF, 0xC0, 0x1F, 0xF0, 0x0E, 0xFE, 0x00, 0xFF, 0xC1, 0xE7,
  0xF0, 0x03, 0xFF, 0xFF, 0x3F, 0x80, 0x1F, 0xFF, 0xF3, 0xFC, 0x00, 0x7F,
  0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0xFE, 0x00, 0x07, 0xFF, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01,
  0x00, 0x00, 0x7F, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x00, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0xC0, 0xFC,
  0x03, 0xFF, 0xFF, 0x07, 0xE0, 0x3F, 0xFF, 0xFE, 0x7F, 0x03, 0xFF, 0xFF,
  0xFB, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFC, 0x00, 0xFF, 0xFC, 0x0F,
  0xE0, 0x01, 0xFF, 0xC0, 0x7E, 0x00, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x7F,
  0xC0, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x03,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x00, 0xFC, 0x01, 0xFF,
  0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0x81, 0xFF, 0xF0, 0x00, 0xFC,
  0x1F, 0xFF, 0xFC, 0x07, 0xE1, 0xFF, 0xFF, 0xFF, 0x3F, 0x0F, 0xEF, 0xFF,
  0xFF, 0xF8, 0x7F, 0x0F, 0xFF, 0xFF, 0xC3, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F,
  0x80, 0x1F, 0xFF, 0xC0, 0xFC, 0x00, 0x1F, 0xFC, 0x08, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xC0, 0x07, 0xFC, 0x00,
  0x0F, 0xC0, 0x7F, 0xF8, 0x00, 0x7E, 0x07, 0xFF, 0xC0, 0x03, 0xF0, 0x7F,
  0xFF, 0x00, 0x3F, 0x07, 0xFF, 0xFC, 0x01, 0xF8, 0x7F, 0x8F, 0xE0, 0x1F,
  0x83, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xE1, 0xF8, 0x07,
  0xF8, 0xFE, 0x0F, 0xC0, 0x1F, 0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0xFF, 0x07,
  0xE0, 0x03, 0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0xFF, 0x03, 0xF0, 0x00, 0x3F,
  0xF0, 0x01, 0x80, 0x00, 0x7E, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 17, 48, 41, 12, -47 },
  { 103, 23, 20, 41, 13, -50 },
  { 161, 42, 47, 41, 0, -47 },
  { 408, 39, 63, 41, 1, -55 },
  { 716, 47, 49, 41, -2, -48 },
  { 1004, 40, 49, 41, 0, -48 },
  { 1249, 10, 20, 41, 19, -50 },
  { 1274, 27, 61, 41, 13, -52 },
  { 1480, 27, 61, 41, 2, -52 },
  { 1686, 36, 34, 41, 3, -37 },
  { 1839, 34, 34, 41, 4, -38 },
  { 1984, 18, 20, 41, 8, -10 },
  { 2029, 22, 7, 41, 10, -24 },
  { 2049, 12, 11, 41, 12, -10 },
  { 2066, 40, 61, 41, 1, -52 },
  { 2371, 36, 49, 41, 3, -48 },
  { 2592, 33, 47, 41, 3, -47 },
  { 2786, 37, 48, 41, 1, -48 },
  { 3008, 37, 49, 41, 1, -48 },
  { 3235, 37, 47, 41, 1, -47 },
  { 3453, 37, 48, 41, 2, -47 },
  { 3675, 34, 48, 41, 3, -47 },
  { 3879, 35, 47, 41, 6, -47 },
  { 4085, 37, 49, 41, 2, -48 },
  { 4312, 34, 48, 41, 5, -48 },
  { 4516, 16, 36, 41, 12, -35 },
  { 4588, 20, 45, 41, 8, -35 },
  { 4701, 33, 40, 41, 6, -41 },
  { 4866, 36, 20, 41, 3, -31 },
  { 4956, 33, 40, 41, 3, -41 },
  { 5121, 30, 49, 41, 8, -48 },
  { 5305, 36, 56, 41, 3, -48 },
  { 5557, 38, 47, 41, -1, -47 },
  { 5781, 35, 47, 41, 3, -47 },
  { 5987, 36, 49, 41, 4, -48 },
  { 6208, 36, 47, 41, 3, -47 },
  { 6420, 37, 47, 41, 3, -47 },
  { 6638, 38, 47, 41, 3, -47 },
  { 6862, 35, 49, 41, 4, -48 },
  { 7077, 39, 47, 41, 2, -47 },
  { 7307, 37, 47, 41, 3, -47 },
  { 7525, 35, 48, 41, 3, -47 },
  { 7735, 42, 47, 41, 2, -47 },
  { 7982, 30, 47, 41, 5, -47 },
  { 8159, 41, 47, 41, 1, -47 },
  { 8400, 39, 47, 41, 2, -47 },
  { 8630, 36, 49, 41, 3, -48 },
  { 8851, 37, 47, 41, 3, -47 },
  { 9069, 36, 61, 41, 3, -48 },
  { 9344, 37, 47, 41, 3, -47 },
  { 9562, 39, 49, 41, 1, -48 },
  { 9801, 38, 47, 41, 6, -47 },
  { 10025, 37, 48, 41, 4, -47 },
  { 10247, 37, 47, 41, 7, -47 },
  { 10465, 42, 47, 41, 2, -47 },
  { 10712, 46, 47, 41, -2, -47 },
  { 10983, 39, 47, 41, 6, -47 },
  { 11213, 41, 47, 41, 0, -47 },
  { 11454, 30, 61, 41, 10, -52 },
  { 11683, 18, 61, 41, 12, -52 },
  { 11821, 30, 61, 41, 1, -52 },
  { 12050, 35, 29, 41, 4, -47 },
  { 12177, 33, 6, 41, 0, 6 },
  { 12202, 11, 14, 41, 14, -53 },
  { 12222, 34, 37, 41, 3, -36 },
  { 12380, 35, 51, 41, 3, -50 },
  { 12604, 31, 37, 41, 5, -36 },
  { 12748, 38, 51, 41, 3, -50 },
  { 12991, 33, 37, 41, 4, -36 },
  { 13144, 46, 64, 41, -2, -50 },
  { 13512, 37, 50, 41, 1, -36 },
  { 13744, 33, 50, 41, 3, -50 },
  { 13951, 32, 51, 41, 5, -50 },
  { 14155, 34, 64, 41, 2, -50 },
  { 14427, 36, 51, 41, 3, -50 },
  { 14657, 29, 51, 41, 7, -50 },
  { 14842, 39, 36, 41, 0, -36 },
  { 15018, 33, 36, 41, 3, -36 },
  { 15167, 33, 37, 41, 4, -36 },
  { 15320, 38, 50, 41, 0, -36 },
  { 15558, 35, 50, 41, 3, -36 },
  { 15777, 33, 35, 41, 7, -35 },
  { 15922, 33, 37, 41, 3, -36 },
  { 16075, 32, 48, 41, 5, -47 },
  { 16267, 33, 36, 41, 5, -35 },
  { 16416, 33, 37, 41, 4, -36 },
  { 16569, 37, 37, 41, 2, -36 },
  { 16741, 41, 37, 41, 0, -36 },
  { 16931, 37, 49, 41, 1, -35 },
  { 17158, 37, 37, 41, 2, -36 },
  { 17330, 33, 61, 41, 7, -52 },
  { 17582, 16, 61, 41, 13, -52 },
  { 17704, 33, 61, 41, 2, -52 },
  { 17956, 37, 16, 41, 2, -29 },
};

const GFXfont IBMPlexMono_MediumItalic68pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic68pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic68pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _IBMPLEXMONO_MEDIUMITALIC68PT7B_H_
