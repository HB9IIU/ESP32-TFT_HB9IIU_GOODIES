#ifndef _IBMPLEXMONO_MEDIUMITALIC54PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF0, 0x7F, 0x81, 0xF8, 0x00, 0x1F, 0x07, 0xCF, 0xC1, 0xF3, 0xF0, 0x7C,
  0xF8, 0x1F, 0x3E, 0x0F, 0xCF, 0x83, 0xF3, 0xE0, 0xF9, 0xF8, 0x3E, 0x7E,
  0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xF9, 0xF0, 0x7E, 0x7C, 0x1F, 0x3F, 0x07,
  0xCF, 0xC1, 0xF3, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0xF8, 0x1E, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F,
  0x07, 0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xE3, 0x9F, 0xF0, 0x7F, 0x0F,
  0x0F, 0xC0, 0xFC, 0x1E, 0x0F, 0x01, 0xF8, 0x3C, 0x0C, 0x07, 0xE0, 0x78,
  0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x1F, 0x81, 0xC0, 0x00, 0x3F, 0x07, 0x80,
  0x00, 0x7F, 0x0F, 0x00, 0x00, 0x7F, 0x1E, 0x00, 0x00, 0xFF, 0xBC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x70, 0xFE, 0x00, 0x01, 0xE0, 0xFC, 0x00,
  0x03, 0xC1, 0xF8, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x1E, 0x0F, 0xC0, 0x80, 0x38, 0x1F, 0x83, 0x80, 0xF0, 0x3F, 0x0F, 0x81,
  0xE0, 0xFE, 0x3F, 0xC3, 0xC3, 0xF8, 0x3F, 0xE7, 0x9F, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0xFF,
  0xC0, 0x03, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xFE, 0x00, 0x78,
  0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0x3E, 0x03,
  0xC0, 0x78, 0x00, 0xF0, 0x0F, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x1F, 0x00,
  0x1F, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x1E,
  0x1F, 0x00, 0x07, 0x80, 0xF8, 0xF8, 0x00, 0x1F, 0x03, 0xE3, 0xC0, 0x00,
  0x3E, 0x1F, 0x1F, 0x00, 0x00, 0xFF, 0xFC, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xF1, 0xFF, 0xF0, 0x00, 0x0F, 0x8F, 0xC3, 0xE0, 0x00,
  0x3E, 0x3C, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x1E, 0x00, 0x0F, 0x87, 0x80,
  0x78, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x01, 0xF0, 0xF8, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x03,
  0xC0, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x7C, 0x01, 0xF0,
  0x07, 0xC3, 0xE0, 0x0F, 0x80, 0x1F, 0xFF, 0x00, 0x7C, 0x00, 0x3F, 0xFC,
  0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x08, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x0C, 0xFC, 0x00, 0xF8, 0x1E, 0xFC,
  0x01, 0xFC, 0x1F, 0xFC, 0x01, 0xFC, 0x3E, 0x7E, 0x03, 0x7E, 0x7E, 0x7F,
  0x07, 0x3E, 0x7C, 0x7F, 0xFF, 0x3F, 0xF8, 0x3F, 0xFE, 0x1F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x1F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C,
  0x7C, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x04, 0x00, 0xF8,
  0x02, 0x78, 0x0F, 0x80, 0xE7, 0xF0, 0xF8, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x3E, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC,
  0x01, 0xC0, 0x07, 0x00, 0x08, 0x00, 0x20, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFE, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0x80, 0xFC, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xF0, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0xFC,
  0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03,
  0xF3, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF7, 0xF0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0xF8,
  0x3F, 0xFE, 0x1F, 0x83, 0xFF, 0xC1, 0xFC, 0x3F, 0xFC, 0x1F, 0x87, 0xFF,
  0xC3, 0xF8, 0x7F, 0xFC, 0x1F, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0xFE, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFC,
  0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x87, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFD, 0xF8, 0x00,
  0x7F, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x1F,
  0x80, 0x7F, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x00, 0xE0, 0x1F, 0x80, 0x08,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x1E, 0x00, 0x0F,
  0xC0, 0x30, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFE, 0x07, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x3C, 0x00, 0x3F, 0x00,
  0xC0, 0x01, 0xF8, 0x04, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x04, 0x00, 0x07, 0xF0, 0xE0, 0x00, 0x3F, 0x0F, 0x80,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x07, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0xC0,
  0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xE0,
  0x01, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x0F, 0xE0, 0x01, 0xF1, 0xFF, 0xC0, 0x0F, 0x9F, 0xFF, 0x00,
  0x7D, 0xFF, 0xFC, 0x07, 0xDF, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFC,
  0x01, 0xFE, 0x07, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x04, 0x00, 0x07, 0xE0, 0x70,
  0x00, 0x7F, 0x0F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x07,
  0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0xFC,
  0xFF, 0xE0, 0x3F, 0x3F, 0xFF, 0x07, 0xEF, 0xFF, 0xF1, 0xFB, 0xFF, 0xFE,
  0x3F, 0xF0, 0x3F, 0xE7, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0x1F, 0xBF, 0x80,
  0x03, 0xF7, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00,
  0x3F, 0xBF, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xE7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xFC,
  0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xF8, 0x00, 0x3F, 0x0F, 0x80,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8,
  0x1F, 0x80, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC,
  0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x3F, 0x9F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x07, 0xFC,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x3F, 0xE0, 0x7F, 0x87, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x7F, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0xFF, 0x3F,
  0xE0, 0x77, 0xE7, 0xFF, 0xFD, 0xF8, 0x7F, 0xFF, 0xBF, 0x07, 0xFF, 0xEF,
  0xC0, 0x7F, 0xF1, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x83, 0xFC, 0x3F, 0xF1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xFE, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFF,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xF8,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0xC1, 0xFE, 0x7F, 0x00, 0x7F, 0x7E,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x1C, 0x00, 0x3F, 0x08, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFE, 0x07, 0xE0, 0x03, 0xE0,
  0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x01, 0xF3, 0xF0, 0x1F, 0x1F, 0x3E, 0x07, 0xF9, 0xF3, 0xE0, 0xFF, 0xDF,
  0x3E, 0x1F, 0xFD, 0xF7, 0xC1, 0xF8, 0x7E, 0x7C, 0x3F, 0x03, 0xE7, 0xC3,
  0xE0, 0x3E, 0x7C, 0x7E, 0x03, 0xE7, 0xC7, 0xC0, 0x3E, 0xF8, 0x7C, 0x03,
  0xEF, 0x87, 0xC0, 0x3C, 0xF8, 0x7C, 0x07, 0xCF, 0x87, 0xC0, 0x7C, 0xF8,
  0xF8, 0x07, 0xCF, 0x8F, 0x80, 0xFC, 0xF0, 0x7C, 0x0F, 0xCF, 0x07, 0xC1,
  0xF8, 0xF0, 0x7E, 0x7F, 0x8F, 0x07, 0xFE, 0xF8, 0xF0, 0x7F, 0xEF, 0x8F,
  0x03, 0xFC, 0xF8, 0xF0, 0x1F, 0x8F, 0x8F, 0x80, 0x70, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x7C, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E,
  0x1F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x03,
  0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x01,
  0xF8, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x3E, 0x00, 0xFF, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xF8, 0x01,
  0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xE3, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xFC,
  0x7E, 0x00, 0x7F, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00,
  0x7E, 0x1F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0x83,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xC0, 0xFC,
  0x00, 0x0F, 0x0F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03,
  0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xF8, 0x0F, 0xF0,
  0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xF0, 0x7E, 0x01,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x07, 0xE0,
  0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0x80,
  0x01, 0x83, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xFE, 0xFE, 0x03, 0xFF,
  0xCF, 0xE0, 0x3F, 0xFC, 0xFC, 0x07, 0xFF, 0xCF, 0xC0, 0x7F, 0xFC, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x1D, 0xF0, 0x3F, 0xFF,
  0xDF, 0x01, 0xFF, 0xF9, 0xF0, 0x1F, 0xFF, 0x3F, 0x00, 0x7F, 0xE3, 0xF0,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0,
  0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F,
  0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xC0,
  0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFC,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03,
  0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8,
  0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x40, 0x03, 0xF0, 0x7E,
  0x00, 0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00,
  0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x3F,
  0x80, 0x03, 0xF0, 0x3F, 0xC0, 0x03, 0xF0, 0x3F, 0xC0, 0x01, 0xF8, 0x3F,
  0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x1F,
  0xC0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x0F, 0xDF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xDF, 0x80, 0x00, 0xFF, 0xCF, 0xE0, 0x00, 0x7F,
  0xC3, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07,
  0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xBE, 0x0F, 0xFE, 0x0F, 0xBE, 0x0F,
  0x9E, 0x1F, 0x7E, 0x0F, 0x9F, 0x1F, 0x7C, 0x0F, 0x9F, 0x3E, 0x7C, 0x0F,
  0x9F, 0x3E, 0x7C, 0x0F, 0x8F, 0x7C, 0x7C, 0x1F, 0x8F, 0xF8, 0x7C, 0x1F,
  0x8F, 0xF8, 0xFC, 0x1F, 0x0F, 0xF0, 0xF8, 0x1F, 0x0F, 0xF0, 0xF8, 0x1F,
  0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3F,
  0x07, 0xC1, 0xF8, 0x3E, 0x03, 0x81, 0xF0, 0x3E, 0x03, 0x01, 0xF0, 0x3E,
  0x03, 0x01, 0xF0, 0x3E, 0x02, 0x01, 0xF0, 0x7E, 0x02, 0x03, 0xF0, 0x7E,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0x7C, 0x0F, 0xF0, 0x01, 0xF0, 0x3F,
  0xC0, 0x07, 0xC1, 0xFF, 0x00, 0x1F, 0x07, 0xFE, 0x00, 0xFC, 0x1F, 0xF8,
  0x03, 0xF0, 0x7F, 0xE0, 0x0F, 0x81, 0xFF, 0x80, 0x3E, 0x07, 0xFE, 0x00,
  0xF8, 0x3F, 0x7C, 0x03, 0xE0, 0xFD, 0xF0, 0x1F, 0x83, 0xE7, 0xC0, 0x7E,
  0x0F, 0x9F, 0x01, 0xF0, 0x3E, 0x7C, 0x07, 0xC0, 0xF8, 0xF8, 0x1F, 0x07,
  0xE3, 0xE0, 0x7C, 0x1F, 0x8F, 0x83, 0xF0, 0x7C, 0x3E, 0x0F, 0xC1, 0xF0,
  0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x07, 0xC3, 0xE0, 0xFC, 0x1F,
  0x0F, 0x83, 0xF0, 0x7C, 0x7E, 0x0F, 0x81, 0xF1, 0xF8, 0x3E, 0x03, 0xE7,
  0xC0, 0xF8, 0x0F, 0x9F, 0x03, 0xE0, 0x3E, 0x7C, 0x1F, 0x80, 0xF9, 0xF0,
  0x7E, 0x03, 0xEF, 0xC1, 0xF0, 0x07, 0xFF, 0x07, 0xC0, 0x1F, 0xF8, 0x1F,
  0x00, 0x7F, 0xE0, 0x7C, 0x01, 0xFF, 0x83, 0xF0, 0x07, 0xFE, 0x0F, 0xC0,
  0x0F, 0xF8, 0x3E, 0x00, 0x3F, 0xE0, 0xF8, 0x00, 0xFF, 0x03, 0xE0, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x81, 0xFE, 0x07,
  0xF0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF1, 0xF8, 0x00,
  0x3F, 0x3F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x3E, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x3F,
  0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x1F, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x3F,
  0x3F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xF0, 0x7F, 0x81,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x08, 0x00, 0x1F, 0x81, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x3E, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0,
  0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x3F,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC0,
  0x07, 0xF0, 0x3F, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x03,
  0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F,
  0xE0, 0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFE, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0x30, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x02, 0x00, 0x00, 0x7E, 0x0E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xD0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0,
  0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F,
  0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xC0,
  0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x7E,
  0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x9F,
  0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x3F, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x07,
  0xC0, 0x7E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F,
  0x80, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x3E, 0x7E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3E,
  0x1F, 0x03, 0xF8, 0x1F, 0x0F, 0x81, 0xFC, 0x1F, 0x07, 0xC0, 0xFE, 0x0F,
  0x83, 0xE0, 0xFF, 0x07, 0xC1, 0xF0, 0x7F, 0x83, 0xE0, 0xF8, 0x3F, 0xC1,
  0xF0, 0x7C, 0x3F, 0xE1, 0xF0, 0x3E, 0x1E, 0xF0, 0xF8, 0x1F, 0x0F, 0x78,
  0x7C, 0x1F, 0x8F, 0x3C, 0x3E, 0x0F, 0x87, 0x9E, 0x3E, 0x07, 0xC3, 0xCF,
  0x1F, 0x03, 0xE3, 0xC7, 0x8F, 0x81, 0xF1, 0xE3, 0xC7, 0xC0, 0xF8, 0xF1,
  0xE3, 0xC0, 0x7C, 0xF0, 0xF3, 0xE0, 0x3E, 0x78, 0x79, 0xF0, 0x1F, 0x3C,
  0x3C, 0xF8, 0x0F, 0xBC, 0x1E, 0x78, 0x07, 0xDE, 0x0F, 0x7C, 0x07, 0xCF,
  0x07, 0xBE, 0x03, 0xEF, 0x03, 0xDF, 0x01, 0xF7, 0x81, 0xEF, 0x80, 0xFF,
  0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0xFE, 0x1F,
  0x80, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF9, 0xF8,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7F, 0x07, 0xE0,
  0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0xFE,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x3E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x83,
  0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xF3, 0x80, 0x00, 0x1C, 0x10, 0x00, 0x01, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x3E, 0x3F, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C,
  0x3E, 0x0F, 0x07, 0xC1, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xF0, 0xFC,
  0x0F, 0xFF, 0x1F, 0x83, 0xFF, 0xF3, 0xE0, 0xFF, 0xFE, 0xFC, 0x3F, 0xC0,
  0xFF, 0x8F, 0xE0, 0x0F, 0xF1, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xCF, 0xC0, 0x01,
  0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xF8, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x3F,
  0x8F, 0xC0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x87, 0xF0,
  0x1F, 0xF0, 0xFF, 0x07, 0x7F, 0xCF, 0xFF, 0xCF, 0xF9, 0xFF, 0xF9, 0xFF,
  0x1F, 0xFE, 0x1F, 0xE1, 0xFF, 0x81, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE3, 0xFF, 0x00, 0x7C, 0x7F, 0xF8,
  0x0F, 0xCF, 0xFF, 0xC0, 0xFD, 0xFF, 0xFE, 0x0F, 0xDE, 0x1F, 0xE0, 0xFF,
  0x80, 0x7E, 0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x03,
  0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F,
  0x80, 0x03, 0xF1, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE3,
  0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xF8, 0x7F, 0x80,
  0x3F, 0x87, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xCF, 0xFF, 0xE0,
  0xFC, 0x7F, 0xFC, 0x0F, 0xC3, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0xFF, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x3F, 0x00, 0x08, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x03, 0x8F, 0xC0, 0x01, 0xE7, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0xFE, 0x07, 0xC0, 0x1F, 0xFC, 0x7E, 0x01, 0xFF, 0xF3, 0xF0,
  0x1F, 0xFF, 0x9F, 0x81, 0xFF, 0xFE, 0xFC, 0x1F, 0xE0, 0x77, 0xE1, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF0,
  0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x05, 0xF8,
  0x3F, 0x80, 0x6F, 0xC1, 0xFE, 0x0E, 0xFC, 0x07, 0xFF, 0xF7, 0xE0, 0x3F,
  0xFF, 0x3F, 0x00, 0xFF, 0xF1, 0xF8, 0x03, 0xFF, 0x0F, 0xC0, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0x81, 0xFC, 0x7F, 0x00, 0x7E,
  0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07,
  0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x0F, 0xF7, 0xE0, 0x7F, 0xF3, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xC7, 0xE0, 0x00, 0xF3, 0xF0,
  0x00, 0xFD, 0xFC, 0x00, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x10, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x7E, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x01, 0xFC,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0x8F, 0xC0, 0x3F, 0xFE,
  0x7E, 0x03, 0xFF, 0xF3, 0xF0, 0x3F, 0xFF, 0xDF, 0x83, 0xFC, 0x0E, 0xFC,
  0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x3E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC,
  0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E,
  0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xE0, 0xFE, 0x01,
  0xBF, 0x07, 0xF8, 0x3D, 0xF0, 0x1F, 0xFF, 0xCF, 0x80, 0xFF, 0xFC, 0xFC,
  0x03, 0xFF, 0xE7, 0xE0, 0x0F, 0xFC, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x10, 0x00,
  0x7E, 0x01, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x3F, 0xF0, 0x0F,
  0xCF, 0xFF, 0x01, 0xF3, 0xFF, 0xF0, 0x7E, 0x7F, 0xFE, 0x0F, 0xDC, 0x1F,
  0xC1, 0xFB, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFC,
  0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3E,
  0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x1F, 0x80,
  0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F,
  0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x40, 0x0F, 0xC0, 0x30, 0x07, 0xE0, 0x3C, 0x03, 0xF0, 0x3F, 0x01, 0xF0,
  0x3F, 0x00, 0xF8, 0x7F, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x3F,
  0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0x00, 0x3E,
  0x00, 0x60, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x07, 0xE0,
  0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x87, 0xC0, 0x07, 0xF3, 0xF0, 0x00,
  0xFE, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x7E, 0x1F, 0xF0, 0x03, 0xF3, 0xFF, 0xC0, 0x1F, 0x3F,
  0xFF, 0x01, 0xF9, 0xFF, 0xF8, 0x0F, 0xDC, 0x1F, 0xE0, 0x7E, 0xC0, 0x7F,
  0x03, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x0F,
  0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0xFE, 0x00, 0x7E, 0x3F, 0xC0,
  0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x01, 0x07,
  0xE1, 0xF8, 0x0C, 0x3E, 0x0F, 0xC0, 0xF3, 0xF0, 0x7E, 0x0F, 0xDF, 0x81,
  0xF8, 0xFC, 0xFC, 0x0F, 0xCF, 0xC7, 0xE0, 0x3F, 0xFC, 0x3F, 0x01, 0xFF,
  0xC1, 0xF0, 0x07, 0xFC, 0x0F, 0x80, 0x3F, 0xC0, 0x80, 0x00, 0x78, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x80, 0x7E, 0x01, 0x80,
  0xFC, 0x07, 0x81, 0xF0, 0x1F, 0x87, 0xE0, 0xFE, 0x0F, 0xC3, 0xF8, 0x1F,
  0x8F, 0xE0, 0x3F, 0x3F, 0x80, 0x7C, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0xF8, 0x0F, 0x9F, 0xC3, 0xF8, 0x3E, 0x7F, 0x8F, 0xF8, 0x7D, 0xFF,
  0x3F, 0xF0, 0xFB, 0xFF, 0xFF, 0xE1, 0xFC, 0x7F, 0x8F, 0xC3, 0xF0, 0x7E,
  0x0F, 0x87, 0xC0, 0xFC, 0x1F, 0x1F, 0x81, 0xF0, 0x3E, 0x3E, 0x03, 0xE0,
  0x7C, 0x7C, 0x0F, 0x80, 0xF8, 0xF8, 0x1F, 0x01, 0xF1, 0xF0, 0x3E, 0x03,
  0xC3, 0xE0, 0x7C, 0x0F, 0x8F, 0x80, 0xF8, 0x1F, 0x1F, 0x01, 0xF0, 0x3E,
  0x3E, 0x07, 0xC0, 0x7C, 0x7C, 0x0F, 0x80, 0xF8, 0xF8, 0x1F, 0x01, 0xE1,
  0xF0, 0x3E, 0x07, 0xC7, 0xC0, 0x7C, 0x0F, 0x8F, 0x80, 0xF8, 0x1F, 0x1F,
  0x03, 0xE0, 0x3E, 0x3E, 0x07, 0xC0, 0x7C, 0x7C, 0x0F, 0x80, 0xF0, 0xF8,
  0x1F, 0x03, 0xE1, 0xE0, 0x3E, 0x07, 0xC7, 0xC0, 0x7C, 0x0F, 0x8F, 0x81,
  0xF0, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x7F, 0xE0, 0x1F, 0x9F,
  0xFE, 0x03, 0xE7, 0xFF, 0xE0, 0xFC, 0xFF, 0xFC, 0x1F, 0xB8, 0x3F, 0x83,
  0xF6, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xF8, 0x00,
  0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x3F,
  0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0,
  0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFC, 0x1F,
  0xE1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0xC0,
  0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0xBF, 0x00, 0x0F, 0xE7, 0xE0, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0x7F,
  0x81, 0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xE3, 0xFF, 0x00, 0x1F, 0x1F, 0xFE, 0x00, 0xFC, 0xFF, 0xFC, 0x03, 0xF7,
  0xFF, 0xF8, 0x0F, 0xDE, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0x80, 0xFF, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0,
  0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0x80,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x07, 0xF8, 0x03,
  0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xF3, 0xFF, 0xF8,
  0x0F, 0xC7, 0xFF, 0xC0, 0x3F, 0x0F, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xF8, 0xFC, 0x0F, 0xFF, 0x9F, 0x83,
  0xFF, 0xF3, 0xF0, 0xFF, 0xFF, 0x7E, 0x3F, 0xC0, 0xEF, 0xCF, 0xF0, 0x07,
  0xF1, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8,
  0x00, 0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80,
  0x03, 0xF3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xF1,
  0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0xC7, 0xF0, 0x0D, 0xF8, 0xFF, 0x07,
  0xBE, 0x0F, 0xFF, 0xEF, 0xC1, 0xFF, 0xF9, 0xF8, 0x1F, 0xFE, 0x3F, 0x01,
  0xFF, 0x87, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE7, 0xFE, 0xFF, 0xFB, 0xFF, 0x80, 0x7C, 0xE0, 0x00,
  0x3F, 0x60, 0x00, 0x0F, 0xD0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x00, 0xE0, 0x7E,
  0x00, 0x08, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x20, 0x00,
  0x3F, 0x06, 0x00, 0x07, 0xE1, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0xFF, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x01, 0x00, 0xFC, 0x01, 0xC0, 0x7E, 0x01, 0xF0,
  0x3F, 0x01, 0xF8, 0x1F, 0x83, 0xFE, 0x0F, 0xC3, 0xFC, 0x07, 0xC7, 0xFC,
  0x03, 0xE7, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x0F, 0xC7, 0xC0,
  0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F,
  0x9F, 0x80, 0x07, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x1F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xF8, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF8,
  0xFC, 0x01, 0xFE, 0x3F, 0x00, 0x5F, 0x0F, 0xC0, 0x3F, 0xC3, 0xF8, 0x3B,
  0xF0, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0x3F, 0x07, 0xFF, 0x8F, 0xC0, 0xFF,
  0xC3, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xBF, 0xFC, 0x03,
  0xEF, 0xFE, 0x01, 0xFB, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC1,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x0F, 0x80,
  0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x1F,
  0x80, 0xFE, 0x07, 0xC0, 0x7F, 0x01, 0xF0, 0x7F, 0x80, 0x7C, 0x7F, 0xC0,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x20, 0xF8, 0x1F, 0x0F,
  0x87, 0xC0, 0xF8, 0x7C, 0x3C, 0x07, 0x81, 0xE3, 0xE0, 0x7C, 0x0F, 0x9F,
  0x03, 0xE0, 0x7C, 0xF8, 0x1F, 0x03, 0xE7, 0xC0, 0xF8, 0x1F, 0x3E, 0x07,
  0xC0, 0xF9, 0xE0, 0x3C, 0x07, 0xDF, 0x03, 0xE0, 0x3E, 0xF8, 0x1F, 0x01,
  0xF7, 0xC0, 0xF8, 0x0F, 0xBE, 0x07, 0xC0, 0x7D, 0xF0, 0x3E, 0x03, 0xCF,
  0x01, 0xF0, 0x3E, 0xF8, 0x1F, 0x01, 0xF7, 0xC0, 0xF8, 0x0F, 0xBE, 0x07,
  0xC0, 0x79, 0xF0, 0x3E, 0x07, 0xCF, 0x83, 0xF0, 0x3E, 0x7C, 0x1F, 0x83,
  0xE3, 0xE1, 0xFC, 0x1F, 0x1F, 0x1D, 0xE1, 0xF0, 0xFF, 0xEF, 0x1F, 0x87,
  0xFE, 0x7F, 0xF8, 0x3F, 0xF3, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0xFF, 0x87, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0x07, 0xFF, 0xCF, 0xFF, 0x0F,
  0xF7, 0xCE, 0x3F, 0x1F, 0xC7, 0xDC, 0x1F, 0x3F, 0x07, 0xDC, 0x1F, 0x1E,
  0x03, 0xD8, 0x1F, 0x08, 0x03, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x0F, 0xE0, 0x00, 0xF8,
  0x0F, 0xE0, 0x18, 0xF8, 0x1F, 0xE0, 0x78, 0xF8, 0x1F, 0xE0, 0xFC, 0xF8,
  0x3B, 0xE3, 0xF8, 0xFC, 0x79, 0xE7, 0xF0, 0xFF, 0xF1, 0xFF, 0xE0, 0x7F,
  0xF1, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01,
  0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0,
  0x7E, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC,
  0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0,
  0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x02, 0xFC, 0x0F, 0xE0, 0x37, 0xC0, 0x7F,
  0x87, 0x7E, 0x03, 0xFF, 0xFB, 0xF0, 0x0F, 0xFF, 0x9F, 0x80, 0x3F, 0xF8,
  0xFC, 0x00, 0xFF, 0x87, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x02, 0x00, 0x0F, 0xC0, 0x38,
  0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x0F, 0xC1, 0xFF, 0xF8, 0x7C,
  0x1F, 0xFF, 0xF3, 0xE0, 0xFF, 0xFF, 0xDF, 0x0F, 0xC0, 0xFF, 0xF8, 0x7C,
  0x01, 0xFF, 0x83, 0xE0, 0x03, 0xF8, 0x1E, 0x00, 0x3F, 0x80, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x1C, 0x00, 0x7F, 0x01, 0xE0, 0x07, 0xF0,
  0x0F, 0x80, 0x7E, 0x00, 0x7C, 0x0F, 0xE0, 0x01, 0xE0, 0xFF, 0x00, 0x0F,
  0x8F, 0xFF, 0xC0, 0x7C, 0x7F, 0xFF, 0xF3, 0xE7, 0xEF, 0xFF, 0xFF, 0x3F,
  0x0F, 0xFF, 0xF1, 0xF8, 0x1F, 0xFF, 0x8F, 0x80, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x60,
  0x3F, 0xE0, 0x07, 0xC3, 0xFF, 0x80, 0x3E, 0x3F, 0xFC, 0x01, 0xE1, 0xFF,
  0xF0, 0x1F, 0x1F, 0x8F, 0xC0, 0xF8, 0xF8, 0x3E, 0x0F, 0x8F, 0x81, 0xF8,
  0xFC, 0x7C, 0x07, 0xFF, 0xC3, 0xC0, 0x3F, 0xFE, 0x3E, 0x00, 0xFF, 0xE1,
  0xF0, 0x03, 0xFE, 0x03, 0x00, 0x07, 0xC0, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 13, 39, 32, 10, -38 },
  { 65, 18, 16, 32, 10, -40 },
  { 101, 34, 38, 32, 0, -38 },
  { 263, 31, 51, 32, 1, -44 },
  { 461, 38, 39, 32, -2, -38 },
  { 647, 32, 39, 32, 0, -38 },
  { 803, 8, 16, 32, 15, -40 },
  { 819, 22, 48, 32, 10, -41 },
  { 951, 21, 48, 32, 2, -41 },
  { 1077, 28, 27, 32, 3, -30 },
  { 1172, 27, 27, 32, 3, -30 },
  { 1264, 13, 16, 32, 7, -8 },
  { 1290, 17, 5, 32, 8, -19 },
  { 1301, 9, 9, 32, 10, -8 },
  { 1312, 31, 48, 32, 1, -41 },
  { 1498, 28, 39, 32, 3, -38 },
  { 1635, 27, 38, 32, 2, -38 },
  { 1764, 29, 38, 32, 1, -38 },
  { 1902, 29, 39, 32, 1, -38 },
  { 2044, 29, 38, 32, 1, -38 },
  { 2182, 29, 39, 32, 2, -38 },
  { 2324, 27, 39, 32, 3, -38 },
  { 2456, 28, 38, 32, 5, -38 },
  { 2589, 29, 39, 32, 2, -38 },
  { 2731, 27, 38, 32, 4, -38 },
  { 2860, 13, 29, 32, 10, -28 },
  { 2908, 16, 36, 32, 7, -28 },
  { 2980, 26, 31, 32, 5, -32 },
  { 3081, 28, 17, 32, 3, -25 },
  { 3141, 26, 31, 32, 3, -32 },
  { 3242, 24, 39, 32, 6, -38 },
  { 3359, 28, 44, 32, 3, -38 },
  { 3513, 30, 38, 32, -1, -38 },
  { 3656, 28, 38, 32, 2, -38 },
  { 3789, 28, 39, 32, 4, -38 },
  { 3926, 29, 38, 32, 2, -38 },
  { 4064, 30, 38, 32, 2, -38 },
  { 4207, 31, 38, 32, 2, -38 },
  { 4355, 28, 39, 32, 3, -38 },
  { 4492, 30, 38, 32, 2, -38 },
  { 4635, 30, 38, 32, 2, -38 },
  { 4778, 29, 39, 32, 2, -38 },
  { 4920, 33, 38, 32, 2, -38 },
  { 5077, 24, 38, 32, 4, -38 },
  { 5191, 32, 38, 32, 1, -38 },
  { 5343, 30, 38, 32, 2, -38 },
  { 5486, 28, 39, 32, 3, -38 },
  { 5623, 30, 38, 32, 2, -38 },
  { 5766, 28, 49, 32, 3, -38 },
  { 5938, 30, 38, 32, 2, -38 },
  { 6081, 31, 39, 32, 1, -38 },
  { 6233, 31, 38, 32, 4, -38 },
  { 6381, 30, 39, 32, 3, -38 },
  { 6528, 30, 38, 32, 5, -38 },
  { 6671, 33, 38, 32, 2, -38 },
  { 6828, 36, 38, 32, -1, -38 },
  { 6999, 31, 38, 32, 5, -38 },
  { 7147, 33, 38, 32, 0, -38 },
  { 7304, 24, 48, 32, 8, -41 },
  { 7448, 15, 48, 32, 9, -41 },
  { 7538, 24, 48, 32, 1, -41 },
  { 7682, 28, 23, 32, 3, -38 },
  { 7763, 26, 5, 32, 0, 5 },
  { 7780, 9, 11, 32, 11, -42 },
  { 7793, 27, 30, 32, 3, -29 },
  { 7895, 28, 41, 32, 2, -40 },
  { 8039, 25, 30, 32, 4, -29 },
  { 8133, 29, 41, 32, 3, -40 },
  { 8282, 25, 30, 32, 4, -29 },
  { 8376, 36, 51, 32, -1, -40 },
  { 8606, 29, 40, 32, 1, -29 },
  { 8751, 27, 40, 32, 2, -40 },
  { 8886, 25, 42, 32, 4, -41 },
  { 9018, 26, 52, 32, 2, -41 },
  { 9187, 29, 41, 32, 2, -40 },
  { 9336, 23, 41, 32, 5, -40 },
  { 9454, 31, 29, 32, 0, -29 },
  { 9567, 27, 29, 32, 2, -29 },
  { 9665, 26, 30, 32, 3, -29 },
  { 9763, 30, 40, 32, 0, -29 },
  { 9913, 27, 40, 32, 3, -29 },
  { 10048, 26, 28, 32, 6, -28 },
  { 10139, 27, 30, 32, 2, -29 },
  { 10241, 25, 39, 32, 4, -38 },
  { 10363, 26, 29, 32, 4, -28 },
  { 10458, 26, 29, 32, 3, -28 },
  { 10553, 29, 29, 32, 2, -28 },
  { 10659, 32, 30, 32, 0, -29 },
  { 10779, 29, 39, 32, 1, -28 },
  { 10921, 29, 30, 32, 2, -29 },
  { 11030, 26, 48, 32, 6, -41 },
  { 11186, 13, 48, 32, 10, -41 },
  { 11264, 26, 48, 32, 2, -41 },
  { 11420, 29, 13, 32, 2, -23 },
};

const GFXfont IBMPlexMono_MediumItalic54pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic54pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic54pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _IBMPLEXMONO_MEDIUMITALIC54PT7B_H_
