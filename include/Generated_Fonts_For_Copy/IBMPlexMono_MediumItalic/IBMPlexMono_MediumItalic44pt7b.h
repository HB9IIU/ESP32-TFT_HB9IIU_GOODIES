#ifndef _IBMPLEXMONO_MEDIUMITALIC44PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x0F,
  0xC3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x00, 0x3E, 0x1E, 0x78, 0x3C,
  0xF0, 0xF9, 0xE1, 0xF3, 0xC3, 0xCF, 0x87, 0x9F, 0x0F, 0x3C, 0x1E, 0x78,
  0x7C, 0xF0, 0xF9, 0xE1, 0xE7, 0xC3, 0xCF, 0x87, 0x80, 0x00, 0x07, 0x87,
  0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x3C, 0x01, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC,
  0x3F, 0xF1, 0xFF, 0x87, 0xFE, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x3C, 0x00,
  0x07, 0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x3C, 0x01, 0xFF, 0x87,
  0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x3F, 0xF1, 0xFF, 0x87, 0xFE, 0x01,
  0xE0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xE7, 0x3F, 0x87, 0xC3,
  0x87, 0x83, 0xE1, 0xC1, 0x83, 0xE0, 0xE0, 0x01, 0xF0, 0x70, 0x00, 0xF8,
  0x78, 0x00, 0x7C, 0x38, 0x00, 0x1F, 0x1C, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x73, 0xF8, 0x00, 0x38, 0x7C, 0x00, 0x1C, 0x3E,
  0x00, 0x1E, 0x1F, 0x00, 0x0E, 0x0F, 0x82, 0x07, 0x07, 0xC7, 0x03, 0x87,
  0xC7, 0xE1, 0xC7, 0xE3, 0xFD, 0xE7, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x3C,
  0x07, 0xFC, 0x01, 0xE0, 0x3F, 0xF0, 0x07, 0x81, 0xFF, 0xE0, 0x3C, 0x07,
  0x87, 0x81, 0xE0, 0x3C, 0x0E, 0x07, 0x80, 0xF0, 0x38, 0x3C, 0x03, 0x81,
  0xE1, 0xE0, 0x0E, 0x07, 0x87, 0x80, 0x38, 0x1E, 0x3C, 0x00, 0xE0, 0x79,
  0xE0, 0x03, 0xC3, 0xC7, 0x80, 0x0F, 0xFF, 0x3C, 0x00, 0x3F, 0xF8, 0xE0,
  0x00, 0x7F, 0xC4, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0x9F, 0xF8, 0x00, 0x3C, 0xFF, 0xF0, 0x01,
  0xE3, 0xC3, 0xC0, 0x0F, 0x1E, 0x07, 0x00, 0x38, 0x78, 0x1C, 0x01, 0xE1,
  0xE0, 0x70, 0x0F, 0x07, 0x03, 0xC0, 0x38, 0x1C, 0x0F, 0x01, 0xE0, 0x70,
  0x3C, 0x0F, 0x01, 0xE1, 0xE0, 0x78, 0x07, 0xFF, 0x81, 0xE0, 0x1F, 0xFC,
  0x0F, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xF8, 0x7C,
  0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0,
  0x1E, 0x00, 0x78, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x9F, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x0F, 0x8F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x78,
  0x00, 0x78, 0x1F, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xE0,
  0x3E, 0x04, 0xF8, 0x07, 0xC3, 0xFE, 0x03, 0xF1, 0xFF, 0xC0, 0xBE, 0x79,
  0xF0, 0x6F, 0xBC, 0x7F, 0xF9, 0xFF, 0x0F, 0xFC, 0x7F, 0x81, 0xFE, 0x0F,
  0xC0, 0x3F, 0x01, 0xE0, 0x3E, 0x7C, 0xF1, 0xE3, 0xC7, 0x9F, 0x3E, 0x78,
  0xF1, 0xE3, 0xCF, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x08, 0x0F, 0x01, 0xBE, 0x1E, 0x1F, 0x7F, 0xBD, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xEF, 0x80, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0xFC,
  0x1F, 0x01, 0xF0, 0x1E, 0x05, 0xC0, 0x38, 0x01, 0x00, 0x20, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0xFE,
  0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x7C, 0x07, 0x80, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0x3E, 0x7E, 0xFF, 0xFF, 0xFE, 0xFE, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x7C,
  0x00, 0x3C, 0xF8, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x87,
  0x87, 0xDF, 0x1F, 0x8F, 0xBE, 0x3F, 0x1F, 0xFC, 0x7E, 0x3F, 0xF0, 0xF8,
  0x7F, 0xE0, 0xE0, 0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F,
  0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0xF8, 0x03, 0xE1,
  0xF0, 0x0F, 0xC1, 0xF0, 0x7F, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x80, 0x3F, 0x7C, 0x03, 0xF3, 0xE0, 0x3F, 0x1E, 0x03,
  0xF1, 0xF0, 0x3F, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0x03, 0xE0, 0x10, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3F,
  0x1F, 0x00, 0x1F, 0x03, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x0F, 0xE0, 0x7E, 0x07, 0x80, 0x3F, 0x03, 0x00, 0x3F, 0x02, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x10, 0x00, 0xFC, 0x70, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xFE, 0x07, 0xF0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x0F, 0x81, 0xE0, 0x0F,
  0x80, 0xF0, 0x07, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0x80, 0x3E, 0x07,
  0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x03, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x40, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x1F, 0x80, 0x1E, 0x7F, 0xE0, 0x1E, 0xFF, 0xF0, 0x3D, 0xFF,
  0xF8, 0x3F, 0x83, 0xF8, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x10, 0x00, 0xF8, 0x70, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0xFE, 0x07,
  0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x1F,
  0x80, 0xF9, 0xFF, 0x83, 0xEF, 0xFF, 0x1F, 0x7F, 0xFE, 0x7F, 0x81, 0xF9,
  0xF8, 0x03, 0xF7, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xF9, 0xE0, 0x03,
  0xE7, 0xC0, 0x1F, 0x1F, 0x81, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0x80, 0x07, 0xCF, 0x00, 0x1F, 0x1E, 0x00,
  0x3E, 0x7C, 0x00, 0xF8, 0xF0, 0x03, 0xF1, 0xE0, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07,
  0xF0, 0x3F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x3E, 0x07,
  0xC0, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x1F, 0x81, 0xFC, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7F, 0x03, 0xF8, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xC1,
  0xF8, 0xFC, 0x03, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D,
  0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7D, 0xF0,
  0x03, 0xF7, 0xC0, 0x1F, 0xDF, 0xC1, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFB,
  0xE1, 0xFF, 0x9F, 0x01, 0xF8, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0x87, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x1F, 0x8F,
  0xF3, 0xFC, 0xFE, 0x3F, 0x87, 0xC0, 0x00, 0xF0, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x03,
  0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0,
  0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x7F, 0x07, 0xE7, 0xC0, 0x3E, 0xF8, 0x03, 0xF3, 0x80, 0x1F, 0x10, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7E, 0x07, 0xC1, 0xF0,
  0x07, 0xC3, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x7C, 0x1F,
  0x3C, 0xF0, 0x7F, 0x79, 0xE1, 0xFE, 0xF3, 0xC7, 0xFF, 0xEF, 0x0F, 0x87,
  0xDE, 0x3E, 0x0F, 0x3C, 0x78, 0x1E, 0x78, 0xF0, 0x3C, 0xF1, 0xE0, 0x7B,
  0xE7, 0xC0, 0xF7, 0x8F, 0x01, 0xEF, 0x1E, 0x07, 0x9E, 0x3C, 0x0F, 0x3C,
  0x7C, 0x3E, 0x78, 0x7D, 0xFC, 0xF0, 0xFF, 0x79, 0xE1, 0xFE, 0xF3, 0xC1,
  0xF9, 0xC7, 0x80, 0xC4, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7B, 0xC0, 0x00,
  0x7D, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0xC1, 0xE0,
  0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80,
  0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0xFB, 0xE0, 0x00, 0x3E, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x07, 0xC3, 0xE0,
  0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01,
  0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x1F, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x03, 0xE1,
  0xE0, 0x03, 0xC3, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x3F, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF0, 0x03, 0xF1, 0xE0, 0x0F, 0xC7, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x0F, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00,
  0x30, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x20, 0x7C, 0x00, 0x78, 0xF8, 0x00, 0xF9, 0xF0,
  0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xF0, 0x7F, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xF8, 0x1F, 0xC1, 0xF0, 0x0F,
  0x83, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7,
  0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8,
  0x01, 0xF9, 0xF0, 0x03, 0xE3, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xE0, 0x3F,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE1,
  0xFC, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x0F, 0x3E, 0x00, 0x31,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xFE, 0xF8, 0x1F, 0xFB, 0xE0, 0xFF,
  0xEF, 0x83, 0xFF, 0xBE, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF,
  0x00, 0x0F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0xC0,
  0x7E, 0x1F, 0x83, 0x78, 0x7F, 0xFD, 0xE0, 0xFF, 0xEF, 0x81, 0xFF, 0x3E,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x07, 0xC1, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0x00, 0x1F, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x07,
  0xC3, 0xE0, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x04, 0x01, 0xF0, 0xF8, 0x03,
  0xE1, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x03, 0xF0, 0xFE, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x0F,
  0xE1, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x80, 0xF8,
  0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x03, 0xC0, 0x7E, 0x00, 0xF8, 0x1F, 0x80,
  0x1F, 0x07, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x9F,
  0x80, 0x01, 0xE7, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xBF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFB, 0xE0, 0x00, 0xFE, 0x7E,
  0x00, 0x3F, 0x87, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x1F,
  0x01, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7E,
  0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x81, 0xF0,
  0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x0F, 0xC3,
  0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xDE, 0x1E, 0x70,
  0xF7, 0x87, 0x9C, 0x7B, 0xE1, 0xE7, 0x9E, 0xF0, 0x79, 0xEF, 0x3C, 0x1E,
  0x7B, 0x8F, 0x0F, 0x8F, 0xE3, 0xC3, 0xE3, 0xF1, 0xF0, 0xF0, 0xFC, 0x7C,
  0x3C, 0x3E, 0x1E, 0x0F, 0x0F, 0x87, 0x83, 0xC1, 0xC1, 0xE1, 0xF0, 0x70,
  0x78, 0x7C, 0x18, 0x3E, 0x1E, 0x06, 0x0F, 0x87, 0x81, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xF0, 0x07, 0x83, 0xF8, 0x03, 0xC1, 0xFC, 0x01, 0xE0, 0xFE,
  0x00, 0xF0, 0x7F, 0x80, 0xF8, 0x3F, 0xC0, 0x7C, 0x3F, 0xE0, 0x3C, 0x1F,
  0xF0, 0x1E, 0x0F, 0x7C, 0x0F, 0x07, 0x9E, 0x07, 0x83, 0xCF, 0x07, 0xC1,
  0xE7, 0x83, 0xE1, 0xF3, 0xC1, 0xE0, 0xF9, 0xF0, 0xF0, 0x78, 0x78, 0x78,
  0x3C, 0x3C, 0x3C, 0x1E, 0x1E, 0x3E, 0x0F, 0x0F, 0x1F, 0x0F, 0x87, 0xCF,
  0x07, 0xC1, 0xE7, 0x83, 0xC0, 0xF3, 0xC1, 0xE0, 0x79, 0xE0, 0xF0, 0x3D,
  0xF0, 0x78, 0x1F, 0xF8, 0x7C, 0x07, 0xF8, 0x3E, 0x03, 0xFC, 0x1E, 0x01,
  0xFE, 0x0F, 0x00, 0xFF, 0x07, 0x80, 0x7F, 0x83, 0xC0, 0x1F, 0xC3, 0xE0,
  0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0xC7, 0xE0, 0x0F, 0x8F, 0x80,
  0x1F, 0x3F, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0xF8, 0x00, 0x7B, 0xF0, 0x00,
  0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xEF,
  0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x7C, 0x78,
  0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC1, 0xF8, 0x7F, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0x80,
  0x7E, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x7E, 0x1F, 0x00, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F,
  0xC7, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x3C,
  0xF8, 0x00, 0x7B, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF,
  0x00, 0x0F, 0xBE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xF8, 0x3F,
  0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x08, 0x00, 0xF8, 0x38, 0x00, 0xF8, 0xF8,
  0x00, 0xF3, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3F, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0xF8,
  0x03, 0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x7F, 0x03, 0xF8, 0x7E, 0x00, 0x78, 0x3E, 0x00, 0x18, 0x1F, 0x00, 0x08,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x10, 0x00, 0x7C, 0x38, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x1F,
  0xE0, 0x7F, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x3C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3C, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07,
  0xE0, 0xFC, 0x0F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x3C, 0x01,
  0xF0, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3E, 0x07,
  0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1F, 0x3C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00,
  0xF0, 0xF0, 0xFC, 0x1E, 0x3E, 0x1F, 0x87, 0x87, 0xC3, 0xF0, 0xF0, 0xF0,
  0xFE, 0x1E, 0x1E, 0x1F, 0xC3, 0xC3, 0xC3, 0xF8, 0xF8, 0x78, 0xFF, 0x1E,
  0x0F, 0x1D, 0xE3, 0xC1, 0xE3, 0xBC, 0x78, 0x3C, 0xF7, 0x8F, 0x07, 0x9C,
  0xF3, 0xC0, 0xF3, 0x8E, 0x78, 0x3C, 0xF1, 0xCF, 0x07, 0x9C, 0x39, 0xE0,
  0xF3, 0x87, 0x78, 0x1E, 0xF0, 0xEF, 0x03, 0xDC, 0x1D, 0xE0, 0x7B, 0x83,
  0xBC, 0x0F, 0xF0, 0x77, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x1F,
  0x80, 0x07, 0xC0, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x0F,
  0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0xF8, 0x07,
  0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x03, 0xC1,
  0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0xF0, 0xF8, 0x03, 0xE0,
  0xF0, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x03, 0xC1, 0xF0, 0x07,
  0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x1E,
  0x70, 0x00, 0x38, 0x40, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x39, 0xF1, 0xE3, 0xE3, 0xC7, 0x87, 0x8F,
  0x08, 0x00, 0xF8, 0x7C, 0x0F, 0xF9, 0xF0, 0xFF, 0xF7, 0xC7, 0xFF, 0xDF,
  0x1F, 0x83, 0xFC, 0xFC, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C,
  0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xBE, 0x00, 0x3C, 0xF8, 0x00,
  0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xF3,
  0xE0, 0x1F, 0x8F, 0xC0, 0xDE, 0x1F, 0x87, 0xFF, 0x7F, 0xFB, 0xFC, 0xFF,
  0xC7, 0xE3, 0xFE, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x7C, 0x07, 0xC7, 0xFC, 0x1F, 0x3F, 0xF8, 0x7D, 0xFF, 0xE1, 0xFE, 0x0F,
  0xC7, 0xB0, 0x1F, 0x3F, 0x80, 0x7C, 0xFC, 0x01, 0xF3, 0xE0, 0x03, 0xCF,
  0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00,
  0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x7E,
  0xFC, 0x03, 0xF3, 0xFC, 0x1F, 0xCF, 0xBF, 0xFE, 0x3E, 0xFF, 0xF0, 0xF9,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x1F, 0x83, 0xF3, 0xF0, 0x1F, 0x3E, 0x00, 0xC7, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x0C, 0xF8, 0x01, 0xFF,
  0x80, 0x3E, 0x7C, 0x07, 0xE7, 0xE0, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0xFC, 0x3E, 0x03, 0xFE, 0x3C, 0x07, 0xFF, 0x3C, 0x0F, 0xFF, 0xFC, 0x1F,
  0xC1, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x7C,
  0x00, 0x78, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8,
  0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0x7E, 0x1D, 0xE0, 0x7F,
  0xF9, 0xE0, 0x3F, 0xFB, 0xE0, 0x1F, 0xF3, 0xE0, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xF8, 0x1F,
  0x9F, 0x00, 0x7C, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0,
  0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0x7F, 0xF0, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x10, 0xF8, 0x00, 0xC7, 0xC0, 0x0F, 0x9F, 0x00,
  0xF8, 0xFC, 0x0F, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x04, 0x03, 0xE0, 0x00, 0x30, 0x1E,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x7C, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xDE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x1F, 0x01, 0xFF, 0x1E, 0x07, 0xFF, 0x9E, 0x0F, 0xFF, 0xFE, 0x0F,
  0xE0, 0xFE, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3E,
  0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C,
  0x01, 0xF8, 0x3E, 0x03, 0xF8, 0x3F, 0x0E, 0xF8, 0x3F, 0xFE, 0xF0, 0x1F,
  0xFC, 0xF0, 0x0F, 0xF9, 0xF0, 0x07, 0xE1, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x30, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE1, 0xF0, 0x3E, 0x3F, 0xE1, 0xF3, 0xFF, 0x0F, 0x9F, 0xFC,
  0x7D, 0x87, 0xE3, 0xF8, 0x1F, 0x1F, 0x80, 0x78, 0xF8, 0x03, 0xCF, 0xC0,
  0x1E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7,
  0x80, 0x1F, 0x7C, 0x00, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03,
  0xE7, 0x80, 0x1F, 0x3C, 0x00, 0xFB, 0xE0, 0x07, 0x9F, 0x00, 0x7C, 0xF8,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x0C, 0x03, 0xE0, 0xF0, 0x1F, 0x0F, 0xC0, 0xF0,
  0xFC, 0x0F, 0x8F, 0xC0, 0x7C, 0xFC, 0x03, 0xEF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x04, 0x03, 0xC0, 0x70, 0x3E, 0x07, 0xC1,
  0xF0, 0x3F, 0x0F, 0x80, 0xFC, 0x7C, 0x03, 0xF3, 0xE0, 0x0F, 0x9E, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0xF8, 0xFF, 0x81, 0xF3, 0xFF,
  0x83, 0xEF, 0xFF, 0x07, 0xD8, 0x7E, 0x0F, 0xE0, 0x7C, 0x1F, 0x80, 0x7C,
  0x3E, 0x00, 0xF0, 0xFC, 0x03, 0xE1, 0xF0, 0x07, 0x83, 0xE0, 0x1F, 0x07,
  0xC0, 0xF8, 0x0F, 0x87, 0xE0, 0x1E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xF8,
  0xF8, 0x11, 0xF1, 0xF0, 0x33, 0xE1, 0xE0, 0xF7, 0x83, 0xE3, 0xEF, 0x07,
  0xCF, 0xBE, 0x07, 0xFE, 0x7C, 0x0F, 0xF8, 0xF8, 0x0F, 0xE0, 0x00, 0x0F,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x04, 0x0F, 0x81,
  0xC1, 0xF0, 0xFC, 0x3C, 0x3F, 0x0F, 0x8F, 0xC1, 0xF3, 0xF0, 0x3E, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x1C,
  0x1F, 0x07, 0xBF, 0x1F, 0xC7, 0xDF, 0xDF, 0xE3, 0xDF, 0xEF, 0xF1, 0xE8,
  0xFC, 0x78, 0xF8, 0x7C, 0x3C, 0x78, 0x3E, 0x1E, 0x3C, 0x1E, 0x0F, 0x3E,
  0x0F, 0x07, 0x9E, 0x07, 0x83, 0xCF, 0x07, 0x81, 0xE7, 0x83, 0xC0, 0xF3,
  0xC1, 0xE0, 0xF1, 0xE0, 0xF0, 0x79, 0xF0, 0x78, 0x3C, 0xF0, 0x3C, 0x1E,
  0x78, 0x3C, 0x0F, 0x3C, 0x1E, 0x07, 0x9E, 0x0F, 0x07, 0x8F, 0x07, 0x83,
  0xCF, 0x83, 0xC1, 0xE7, 0x81, 0xE0, 0xF3, 0xC1, 0xE0, 0x78, 0x0F, 0x07,
  0xC0, 0xF8, 0xFF, 0x87, 0xCF, 0xFC, 0x3E, 0x7F, 0xF1, 0xF6, 0x1F, 0x8F,
  0xE0, 0x7C, 0x7E, 0x01, 0xE3, 0xE0, 0x0F, 0x3F, 0x00, 0x79, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9E, 0x00, 0x7D, 0xF0,
  0x03, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9E, 0x00, 0x7C,
  0xF0, 0x03, 0xEF, 0x80, 0x1E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x80, 0x00,
  0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xC1,
  0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0x7D,
  0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0x78, 0x00, 0xF9, 0xF0, 0x07,
  0xC7, 0xC0, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC1, 0xF0, 0x07, 0xC7, 0xFC, 0x07,
  0xCF, 0xFE, 0x07, 0xDF, 0xFE, 0x07, 0xF8, 0x3F, 0x07, 0xB0, 0x1F, 0x0F,
  0xE0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F,
  0x00, 0xFC, 0x3F, 0xC1, 0xFC, 0x3E, 0xFF, 0xF8, 0x3E, 0xFF, 0xF0, 0x3E,
  0x7F, 0xE0, 0x3C, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x3E, 0x07, 0xFC, 0x78, 0x1F,
  0xFC, 0xF0, 0x7F, 0xFF, 0xE1, 0xFC, 0x1F, 0xC7, 0xE0, 0x1F, 0x8F, 0x80,
  0x1F, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF8, 0x01, 0xF1, 0xF0, 0x03,
  0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1E, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xE3, 0xF0, 0x1F, 0xC3,
  0xF0, 0xEF, 0x07, 0xFF, 0x9E, 0x07, 0xFF, 0x7C, 0x07, 0xFC, 0xF8, 0x07,
  0xE1, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xE0,
  0x7D, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x83, 0xFF,
  0xFF, 0x0F, 0x80, 0xF8, 0x7C, 0x00, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x80, 0x07, 0xC7, 0x00, 0x1F, 0x3F, 0x81, 0xF8, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x01, 0x80, 0xF0, 0x1E, 0x0F,
  0x83, 0xF0, 0x7C, 0x3F, 0x03, 0xE3, 0xF0, 0x1F, 0x7F, 0x00, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x79, 0xF0,
  0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9E, 0x00, 0x7D,
  0xF0, 0x03, 0xCF, 0x80, 0x1E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0x7C, 0xF0, 0x03, 0xE7, 0x80, 0x1E, 0x7C, 0x00, 0xF3, 0xE0, 0x0F, 0x9F,
  0x00, 0x7C, 0xF8, 0x07, 0xE7, 0xC0, 0x5F, 0x3E, 0x02, 0xF1, 0xF8, 0x6F,
  0x87, 0xFF, 0x7C, 0x3F, 0xF3, 0xE0, 0xFF, 0x1F, 0x03, 0xF0, 0x00, 0x7F,
  0xC0, 0x19, 0xFF, 0x03, 0xE7, 0xFC, 0x0F, 0xBF, 0xE0, 0x1F, 0x07, 0x80,
  0x7C, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C,
  0x07, 0xE1, 0xF0, 0x1F, 0x07, 0xC0, 0xFC, 0x1E, 0x07, 0xE0, 0x78, 0x3F,
  0x01, 0xE7, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x00,
  0xFC, 0x00, 0x00, 0x1E, 0x0F, 0x06, 0x1E, 0x0F, 0x1E, 0x1E, 0x0F, 0x0F,
  0x1E, 0x0E, 0x0F, 0x3C, 0x1E, 0x0F, 0x3C, 0x1E, 0x0F, 0x3C, 0x1E, 0x0F,
  0x3C, 0x1E, 0x0F, 0x3C, 0x1E, 0x0F, 0x38, 0x1E, 0x0F, 0x78, 0x3C, 0x0F,
  0x78, 0x3C, 0x0F, 0x78, 0x3C, 0x0F, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1E,
  0x70, 0x7C, 0x1E, 0xF0, 0x78, 0x3C, 0xF0, 0xF8, 0x3C, 0xF8, 0xF8, 0x78,
  0xFF, 0xBC, 0xF8, 0x7F, 0xBF, 0xF0, 0x7F, 0x1F, 0xE0, 0x3E, 0x0F, 0x80,
  0x00, 0x78, 0x1F, 0x00, 0x7F, 0x0F, 0xE0, 0x3F, 0xC7, 0xFC, 0x3F, 0xFB,
  0xFF, 0x1F, 0x9E, 0xE3, 0xCF, 0xC7, 0xB0, 0xF3, 0xC1, 0xF8, 0x3C, 0x60,
  0x7E, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x3E, 0x06, 0x3C, 0x1B, 0x83, 0xCF, 0x06,
  0xF1, 0xFB, 0xE3, 0x3D, 0xF8, 0xFF, 0xCF, 0xFC, 0x1F, 0xE3, 0xFE, 0x07,
  0xF8, 0x7F, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xE0, 0x07, 0xC7,
  0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x07, 0x87, 0xC0, 0x1F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x7C, 0x05, 0xF0, 0xFC, 0x3B,
  0xC0, 0xFF, 0xEF, 0x81, 0xFF, 0x9F, 0x01, 0xFE, 0x3E, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xC0, 0x1F, 0x03,
  0xC0, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x1E, 0x1F, 0xFC, 0x7C, 0x7F, 0xFE, 0xF8, 0xFF,
  0xFF, 0xF3, 0xE0, 0xFF, 0xC7, 0x80, 0x7F, 0x8F, 0x00, 0x7C, 0x1E, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x06, 0x01, 0xF0, 0x3C, 0x0F, 0xC0, 0x3C,
  0x3F, 0x00, 0x78, 0xFF, 0x80, 0x73, 0xFF, 0xF8, 0xE7, 0xFF, 0xFF, 0xCF,
  0x3F, 0xFF, 0x9E, 0x0F, 0xFE, 0x3C, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x06, 0x07, 0xF0, 0x0F, 0x0F,
  0xF8, 0x0F, 0x1F, 0xFC, 0x1E, 0x3E, 0x7E, 0x1E, 0x3C, 0x3E, 0x3E, 0x78,
  0x1F, 0xFC, 0x78, 0x0F, 0xF8, 0x78, 0x07, 0xF0, 0xB0, 0x03, 0xE0,
};

const GFXglyph IBMPlexMono_MediumItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 11, 31, 26, 8, -31 },
  { 44, 15, 13, 26, 8, -33 },
  { 69, 27, 31, 26, 0, -31 },
  { 174, 25, 39, 26, 1, -35 },
  { 296, 30, 32, 26, -1, -31 },
  { 416, 26, 32, 26, 0, -31 },
  { 520, 7, 13, 26, 12, -33 },
  { 532, 18, 39, 26, 8, -33 },
  { 620, 17, 39, 26, 2, -33 },
  { 703, 23, 22, 26, 2, -24 },
  { 767, 21, 22, 26, 3, -24 },
  { 825, 12, 13, 26, 5, -7 },
  { 845, 14, 4, 26, 7, -15 },
  { 852, 8, 7, 26, 8, -7 },
  { 859, 25, 39, 26, 1, -33 },
  { 981, 23, 32, 26, 2, -31 },
  { 1073, 21, 31, 26, 2, -31 },
  { 1155, 24, 31, 26, 1, -31 },
  { 1248, 24, 32, 26, 1, -31 },
  { 1344, 25, 31, 26, 0, -31 },
  { 1441, 24, 32, 26, 2, -31 },
  { 1537, 22, 32, 26, 2, -31 },
  { 1625, 23, 31, 26, 4, -31 },
  { 1715, 24, 32, 26, 1, -31 },
  { 1811, 22, 31, 26, 3, -31 },
  { 1897, 10, 23, 26, 8, -23 },
  { 1926, 13, 29, 26, 5, -23 },
  { 1974, 21, 26, 26, 4, -26 },
  { 2043, 23, 13, 26, 2, -20 },
  { 2081, 21, 26, 26, 2, -26 },
  { 2150, 20, 31, 26, 5, -31 },
  { 2228, 23, 36, 26, 2, -31 },
  { 2332, 25, 31, 26, -1, -31 },
  { 2429, 23, 31, 26, 2, -31 },
  { 2519, 23, 32, 26, 3, -31 },
  { 2611, 23, 31, 26, 2, -31 },
  { 2701, 24, 31, 26, 2, -31 },
  { 2794, 25, 31, 26, 2, -31 },
  { 2891, 22, 32, 26, 3, -31 },
  { 2979, 25, 31, 26, 1, -31 },
  { 3076, 24, 31, 26, 2, -31 },
  { 3169, 23, 32, 26, 2, -31 },
  { 3261, 27, 31, 26, 2, -31 },
  { 3366, 19, 31, 26, 3, -31 },
  { 3440, 26, 31, 26, 1, -31 },
  { 3541, 25, 31, 26, 1, -31 },
  { 3638, 23, 32, 26, 2, -31 },
  { 3730, 24, 31, 26, 2, -31 },
  { 3823, 23, 40, 26, 2, -31 },
  { 3938, 24, 31, 26, 2, -31 },
  { 4031, 25, 32, 26, 1, -31 },
  { 4131, 25, 31, 26, 4, -31 },
  { 4228, 24, 32, 26, 3, -31 },
  { 4324, 24, 31, 26, 4, -31 },
  { 4417, 27, 31, 26, 1, -31 },
  { 4522, 29, 31, 26, -1, -31 },
  { 4635, 25, 31, 26, 4, -31 },
  { 4732, 27, 31, 26, 0, -31 },
  { 4837, 20, 39, 26, 6, -33 },
  { 4935, 12, 39, 26, 8, -33 },
  { 4994, 19, 39, 26, 1, -33 },
  { 5087, 23, 19, 26, 2, -31 },
  { 5142, 21, 4, 26, 0, 4 },
  { 5153, 7, 9, 26, 9, -34 },
  { 5161, 22, 24, 26, 2, -23 },
  { 5227, 22, 34, 26, 2, -33 },
  { 5321, 20, 24, 26, 3, -23 },
  { 5381, 24, 34, 26, 2, -33 },
  { 5483, 21, 24, 26, 3, -23 },
  { 5546, 29, 42, 26, -1, -33 },
  { 5699, 24, 32, 26, 1, -23 },
  { 5795, 21, 33, 26, 2, -33 },
  { 5882, 21, 34, 26, 3, -33 },
  { 5972, 21, 42, 26, 2, -33 },
  { 6083, 23, 34, 26, 2, -33 },
  { 6181, 19, 34, 26, 4, -33 },
  { 6262, 25, 23, 26, 0, -23 },
  { 6334, 21, 23, 26, 2, -23 },
  { 6395, 22, 24, 26, 2, -23 },
  { 6461, 24, 32, 26, 0, -23 },
  { 6557, 23, 32, 26, 2, -23 },
  { 6649, 21, 23, 26, 5, -23 },
  { 6710, 22, 24, 26, 2, -23 },
  { 6776, 21, 32, 26, 3, -31 },
  { 6860, 21, 24, 26, 3, -23 },
  { 6923, 22, 23, 26, 2, -23 },
  { 6987, 24, 23, 26, 1, -23 },
  { 7056, 26, 24, 26, 0, -23 },
  { 7134, 23, 32, 26, 1, -23 },
  { 7226, 23, 23, 26, 2, -23 },
  { 7293, 21, 39, 26, 5, -33 },
  { 7396, 11, 39, 26, 8, -33 },
  { 7450, 21, 39, 26, 2, -33 },
  { 7553, 24, 10, 26, 1, -19 },
};

const GFXfont IBMPlexMono_MediumItalic44pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic44pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic44pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _IBMPLEXMONO_MEDIUMITALIC44PT7B_H_
