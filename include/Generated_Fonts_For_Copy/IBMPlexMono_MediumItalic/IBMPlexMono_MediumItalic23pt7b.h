#ifndef _IBMPLEXMONO_MEDIUMITALIC23PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x0C, 0x20, 0x00, 0x00, 0x73, 0xCF,
  0x38, 0x73, 0x63, 0x67, 0x67, 0x66, 0xE6, 0xE6, 0x01, 0x98, 0x0C, 0x60,
  0x33, 0x00, 0xCC, 0x06, 0x30, 0xF9, 0xF3, 0xE7, 0xC3, 0x18, 0x0C, 0xC3,
  0xF3, 0xEF, 0x8F, 0x86, 0x60, 0x39, 0x80, 0xCE, 0x03, 0x30, 0x1C, 0xC0,
  0x00, 0xC0, 0x03, 0x00, 0x7E, 0x03, 0xFE, 0x1D, 0xBC, 0xE6, 0x43, 0x98,
  0x0E, 0x60, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xDC, 0x03, 0x38, 0x0C,
  0xE2, 0x23, 0x3C, 0x9C, 0x7F, 0xE0, 0x7E, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x03, 0x1F, 0x86, 0x19, 0x86, 0x30, 0x8C, 0x31, 0x98, 0x31, 0xB8, 0x1F,
  0x30, 0x0E, 0x40, 0x00, 0x78, 0x06, 0xFC, 0x0C, 0xCC, 0x19, 0x8C, 0x19,
  0x8C, 0x31, 0x8C, 0x61, 0xF8, 0xE0, 0xF0, 0x03, 0xC0, 0x1F, 0x80, 0xE7,
  0x03, 0x0C, 0x0C, 0x30, 0x31, 0xC0, 0xE6, 0x07, 0xF0, 0x77, 0x01, 0x9C,
  0x0E, 0x30, 0x38, 0xE4, 0xE1, 0x9F, 0x8F, 0x67, 0xCF, 0x0E, 0x18, 0x37,
  0x66, 0x66, 0xE0, 0x03, 0x83, 0x83, 0x03, 0x81, 0x81, 0x80, 0xC0, 0xC0,
  0x60, 0x30, 0x38, 0x1C, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0E,
  0x03, 0x80, 0x1C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x0C, 0x1C,
  0x00, 0x03, 0x00, 0x30, 0x07, 0x04, 0x61, 0xFE, 0xF7, 0xFE, 0x0F, 0x01,
  0xF0, 0x3B, 0x87, 0x18, 0x61, 0xC0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70,
  0x06, 0x07, 0xFF, 0x7F, 0xE8, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x3C, 0xE7, 0x18, 0xE3, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0x07, 0xC1, 0xFE, 0x38,
  0x73, 0x03, 0x70, 0x36, 0x03, 0x67, 0x3E, 0x73, 0xE6, 0x7E, 0x07, 0xE0,
  0x7E, 0x06, 0xE0, 0xE7, 0x1C, 0x7F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x76,
  0x1C, 0xC7, 0x38, 0x47, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x80, 0x70, 0x0C, 0x3F, 0xFF, 0xFF, 0x07, 0xE0, 0x7F, 0x87, 0x0E, 0x70,
  0x71, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x38, 0x01, 0xFF, 0xDF, 0xFE, 0x07, 0xE0, 0x7F, 0x87,
  0x0E, 0x10, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0xF8, 0x07, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0xE6, 0x07, 0x78, 0x71, 0xFF, 0x03, 0xF0, 0x00, 0x70,
  0x07, 0x80, 0x7C, 0x07, 0xE0, 0x37, 0x03, 0x38, 0x31, 0x83, 0x8C, 0x38,
  0x61, 0x87, 0x18, 0x38, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x03, 0x00, 0x38,
  0x1F, 0xF1, 0xFF, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x37, 0x87, 0xFE,
  0x70, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x40, 0xEE, 0x1C, 0x7F, 0xC3, 0xF0,
  0x01, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x77, 0xC7, 0xFE,
  0x70, 0xEE, 0x07, 0xE0, 0x7E, 0x06, 0xE0, 0xE7, 0x1E, 0x7F, 0xC1, 0xF0,
  0x7F, 0xF7, 0xFF, 0x60, 0x6E, 0x0E, 0xC0, 0xC0, 0x1C, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x07, 0xC1, 0xFF, 0x38, 0x73, 0x03, 0x30, 0x33, 0x07, 0x38, 0x61, 0xFC,
  0x3F, 0xC7, 0x0E, 0xE0, 0x6C, 0x07, 0xC0, 0x6E, 0x1E, 0x7F, 0xC3, 0xF0,
  0x1F, 0x87, 0xF9, 0xC3, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3F, 0x0F, 0x7F,
  0xE7, 0xB8, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x07, 0xC0, 0x38, 0xF3,
  0x8E, 0x00, 0x00, 0x00, 0x01, 0xCF, 0x3C, 0xE0, 0x1C, 0x3C, 0x70, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF1, 0xC7, 0x0C, 0x38, 0x60, 0x00, 0x20,
  0x1C, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x30, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xC0, 0x08, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xEF,
  0xFE, 0x20, 0x07, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x18, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0x70, 0x08, 0x00, 0x1F, 0x1F, 0xEE, 0x1F, 0x07,
  0x01, 0xC0, 0x60, 0x78, 0xF8, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x1E,
  0x07, 0x81, 0xC0, 0x07, 0xC1, 0xFE, 0x18, 0x73, 0x03, 0x70, 0x36, 0x3B,
  0x67, 0xF6, 0x63, 0xEC, 0x3C, 0xC6, 0xCC, 0x6C, 0xC6, 0xCF, 0xEC, 0x76,
  0xC0, 0x0E, 0x00, 0x70, 0x07, 0xF8, 0x1F, 0x00, 0x01, 0xC0, 0x3E, 0x03,
  0xE0, 0x7E, 0x06, 0x60, 0xE6, 0x0C, 0x61, 0xC6, 0x1C, 0x61, 0x87, 0x3F,
  0xF3, 0xFF, 0x70, 0x76, 0x07, 0xE0, 0x3C, 0x03, 0x1F, 0xC3, 0xFE, 0x38,
  0x73, 0x87, 0x30, 0x73, 0x07, 0x30, 0xE7, 0xFC, 0x7F, 0xC7, 0x0E, 0x60,
  0x66, 0x06, 0x60, 0xEE, 0x0E, 0xFF, 0xCF, 0xF8, 0x0F, 0x81, 0xFE, 0x38,
  0xE7, 0x07, 0x60, 0x4E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x0C, 0xC0, 0xCE, 0x1C, 0x7F, 0x83, 0xE0, 0x1F, 0x83, 0xFE, 0x38,
  0x73, 0x87, 0x30, 0x33, 0x03, 0x30, 0x37, 0x07, 0x70, 0x77, 0x07, 0x60,
  0x76, 0x06, 0x60, 0xEE, 0x1C, 0xFF, 0x8F, 0xF0, 0x1F, 0xF9, 0xFF, 0x8E,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0F, 0xFC, 0x7F, 0xE3, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xF9,
  0xFF, 0xCE, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0F, 0xFC, 0x7F,
  0xE3, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0x07, 0xC1, 0xFE, 0x1C, 0x73, 0x83, 0x70, 0x47, 0x00, 0x60, 0x06, 0x00,
  0xE3, 0xFE, 0x3E, 0xE0, 0x6E, 0x06, 0x60, 0xE7, 0x1E, 0x7F, 0xE3, 0xCC,
  0x38, 0x39, 0xC1, 0xCE, 0x0C, 0x60, 0x63, 0x03, 0x38, 0x39, 0xC1, 0xCF,
  0xFE, 0x7F, 0xE3, 0x03, 0x18, 0x19, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x83,
  0x18, 0x18, 0x3F, 0xF9, 0xFF, 0x80, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0x10, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0xE1, 0xCE,
  0x38, 0x7F, 0x83, 0xE0, 0x38, 0x1C, 0xE0, 0xE3, 0x87, 0x0C, 0x38, 0x31,
  0xC0, 0xCE, 0x07, 0x70, 0x1F, 0xC0, 0x7F, 0x01, 0xEE, 0x07, 0x38, 0x18,
  0x70, 0xE1, 0xC3, 0x83, 0x0E, 0x0E, 0x30, 0x38, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0F, 0xFF, 0xFE, 0x1C, 0x1C, 0x70, 0xF1, 0xE3, 0xCF, 0x9F, 0x36,
  0x78, 0xDB, 0x63, 0x6D, 0x8C, 0xE6, 0x33, 0x99, 0xCC, 0xE6, 0x23, 0x18,
  0x8C, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x38, 0x1C, 0x3C, 0x39, 0xE1, 0xCF,
  0x0C, 0x78, 0x63, 0xE3, 0x3B, 0x19, 0xD9, 0xCC, 0xCE, 0x66, 0x63, 0x3B,
  0x18, 0xD9, 0xC6, 0xCE, 0x3E, 0x61, 0xF3, 0x07, 0x18, 0x38, 0x07, 0xC1,
  0xFE, 0x38, 0x73, 0x03, 0x70, 0x37, 0x03, 0x60, 0x3E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x06, 0xE0, 0xE7, 0x1C, 0x7F, 0x81, 0xF0, 0x1F, 0xE1,
  0xFF, 0x8E, 0x0C, 0x70, 0x73, 0x03, 0x98, 0x18, 0xC1, 0xCF, 0xFC, 0x7F,
  0xC3, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0x07, 0xC1, 0xFE, 0x38, 0x73, 0x03, 0x70, 0x37, 0x03, 0x60, 0x3E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x06, 0xE0, 0xE7, 0x1C, 0x7F, 0x83, 0xF0,
  0x06, 0x20, 0x77, 0x03, 0xE0, 0x1C, 0x1F, 0xE1, 0xFF, 0x8E, 0x0C, 0x70,
  0x73, 0x03, 0x98, 0x18, 0xC1, 0xCF, 0xFC, 0x7F, 0x83, 0x98, 0x18, 0xE0,
  0xC3, 0x06, 0x18, 0x70, 0xE3, 0x83, 0x1C, 0x1C, 0x07, 0xE0, 0x3F, 0xE1,
  0xC3, 0xCE, 0x04, 0x38, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x01, 0xC0, 0x03, 0x00, 0x0C, 0x20, 0x73, 0xC3, 0xC7, 0xFE, 0x07, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC1, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x39, 0xC1, 0xCC, 0x0C, 0x60, 0x63, 0x03, 0x38, 0x39,
  0xC1, 0xCE, 0x0E, 0x60, 0x63, 0x03, 0x18, 0x19, 0xC1, 0xCE, 0x0E, 0x30,
  0xE1, 0xFE, 0x07, 0xE0, 0xE0, 0x3F, 0x01, 0x98, 0x1C, 0xC0, 0xC6, 0x0E,
  0x30, 0x61, 0xC7, 0x0E, 0x30, 0x71, 0x83, 0x9C, 0x0C, 0xC0, 0x6E, 0x03,
  0x60, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x60, 0x0D, 0x80, 0x76, 0x01, 0x98,
  0x06, 0x67, 0x19, 0x9C, 0xE6, 0x73, 0x1B, 0x4C, 0xED, 0x33, 0x24, 0xCD,
  0x96, 0x36, 0x58, 0xD1, 0x63, 0xC5, 0x8F, 0x1C, 0x38, 0x70, 0x1C, 0x07,
  0x0E, 0x0E, 0x06, 0x1C, 0x07, 0x38, 0x07, 0x30, 0x03, 0x70, 0x03, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0x60, 0x1C, 0x70,
  0x38, 0x30, 0x30, 0x38, 0xF0, 0x38, 0xE0, 0x3B, 0x03, 0x9C, 0x18, 0xE1,
  0xC3, 0x1C, 0x1C, 0xC0, 0xEE, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x03, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x1F, 0xFC, 0x7F, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xFF, 0x3F, 0xFC,
  0x0F, 0xE3, 0xF8, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0xF8, 0x7F, 0x00, 0xC3, 0x06, 0x18, 0x61, 0x86, 0x0C, 0x30, 0xC3,
  0x0C, 0x18, 0x61, 0x86, 0x0C, 0x30, 0xC3, 0x0F, 0xE1, 0xF8, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x61, 0xF8, 0x7F, 0x00, 0x03,
  0x80, 0x78, 0x07, 0xC0, 0xCC, 0x1C, 0xE3, 0x86, 0x30, 0x67, 0x07, 0xE0,
  0x34, 0x02, 0xFF, 0xFF, 0xFC, 0x59, 0xB2, 0x1E, 0x73, 0xF6, 0x70, 0xE7,
  0x06, 0x60, 0xEE, 0x0E, 0xE0, 0xEE, 0x0C, 0xE1, 0xCE, 0x2C, 0x7E, 0xE3,
  0xCE, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x3C, 0x37, 0xE3,
  0x86, 0x70, 0x77, 0x07, 0x60, 0x76, 0x07, 0x60, 0x66, 0x0E, 0xF1, 0xCF,
  0xFC, 0xCF, 0x00, 0x1F, 0x0F, 0xF7, 0x1F, 0x82, 0xE0, 0x30, 0x0C, 0x03,
  0x02, 0xC1, 0xF8, 0xE7, 0xF0, 0xF8, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x0F, 0xB8, 0xFF, 0xCF, 0x1C, 0x70, 0x63, 0x03, 0x38, 0x19,
  0xC1, 0xCE, 0x0E, 0x70, 0xE3, 0x8F, 0x0F, 0xD8, 0x3D, 0xC0, 0x0F, 0x8F,
  0xF7, 0x0F, 0x83, 0xC1, 0xFF, 0xEF, 0xE3, 0x00, 0xC0, 0xF8, 0x67, 0xF8,
  0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x0F,
  0xFE, 0x0F, 0xFE, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x43, 0x80, 0x63,
  0x00, 0xF3, 0x00, 0x3B, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x0F, 0xB8, 0xFF,
  0xCF, 0x1C, 0x70, 0x63, 0x03, 0x38, 0x19, 0xC1, 0xCE, 0x0E, 0x70, 0xE3,
  0x8F, 0x0F, 0xD8, 0x3C, 0xC0, 0x0E, 0x00, 0x61, 0x87, 0x1F, 0xF0, 0x3F,
  0x00, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x77, 0x8D, 0xF9, 0xA7,
  0x78, 0x6E, 0x0D, 0xC1, 0xB0, 0x76, 0x0E, 0xC1, 0xF8, 0x37, 0x06, 0xE1,
  0xC0, 0x07, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x0C,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x86, 0x33, 0x9C, 0xEE, 0x3F, 0x07, 0x00,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x21,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x08,
  0x63, 0x9C, 0x33, 0x87, 0x70, 0x7C, 0x07, 0x00, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x3C, 0x37, 0xE3, 0x8E, 0x78, 0x67, 0x0E, 0x71,
  0xC6, 0x70, 0x6E, 0x06, 0x63, 0xE7, 0x7E, 0x3E, 0xE3, 0x80, 0x7E, 0x3F,
  0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80,
  0xE2, 0x39, 0xCC, 0xE3, 0x70, 0xF8, 0x3C, 0x00, 0x37, 0x39, 0xBB, 0xCE,
  0xE6, 0xE7, 0x36, 0x31, 0xB1, 0x8D, 0x8C, 0x6C, 0x67, 0x67, 0x37, 0x31,
  0xB1, 0x8D, 0x8C, 0x60, 0x33, 0xC6, 0xFC, 0xD3, 0xBC, 0x37, 0x06, 0xE0,
  0xD8, 0x3B, 0x07, 0x60, 0xFC, 0x1B, 0x83, 0x70, 0xE0, 0x0F, 0x81, 0xFC,
  0x38, 0xE7, 0x06, 0x60, 0x7E, 0x07, 0xE0, 0x6E, 0x06, 0xE0, 0xE7, 0x1C,
  0x7F, 0x81, 0xF0, 0x19, 0xE0, 0xDF, 0x8F, 0x0C, 0x70, 0x73, 0x83, 0x98,
  0x1C, 0xC0, 0xE6, 0x06, 0x30, 0x73, 0xC7, 0x1F, 0xF8, 0xCF, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x1F, 0x73, 0xFF, 0x78, 0xE7,
  0x06, 0x60, 0x6E, 0x06, 0xE0, 0xEE, 0x0E, 0xE1, 0xEE, 0x3C, 0x7E, 0xC3,
  0xCC, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x7C, 0xFF, 0xDE,
  0x1E, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x0F, 0xC7, 0xFC, 0xE1, 0x98, 0x03, 0x80, 0x7F, 0x07,
  0xF0, 0x07, 0x00, 0xEC, 0x3B, 0xFF, 0x1F, 0x80, 0x0C, 0x01, 0x80, 0x30,
  0x0E, 0x0F, 0xFF, 0xFF, 0x86, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18,
  0x63, 0x1C, 0x6F, 0x0F, 0x81, 0xE0, 0x60, 0xEC, 0x1F, 0x83, 0x70, 0x6E,
  0x0D, 0x83, 0xB0, 0x76, 0x0E, 0xC3, 0x9C, 0xB3, 0xE6, 0x3D, 0xC0, 0xF8,
  0x6F, 0x8E, 0x38, 0x63, 0x87, 0x38, 0x73, 0x06, 0x30, 0xE3, 0x0E, 0x31,
  0xC7, 0x38, 0x7F, 0x03, 0xC0, 0x63, 0x36, 0x33, 0x67, 0x36, 0x63, 0xC6,
  0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xCE, 0x6C, 0xE6, 0xF6, 0xCE, 0x38, 0x0E,
  0x38, 0x7D, 0xE7, 0x3D, 0xD8, 0xE3, 0x03, 0x88, 0x0C, 0x00, 0x30, 0x11,
  0xC0, 0xC7, 0x13, 0x3D, 0xEF, 0xBE, 0x1C, 0x70, 0x18, 0x38, 0xC1, 0xCE,
  0x0C, 0x70, 0x63, 0x83, 0x18, 0x38, 0xC1, 0xC6, 0x0E, 0x30, 0xE1, 0xCB,
  0x0F, 0xD8, 0x3D, 0xC0, 0x0E, 0x00, 0x61, 0x87, 0x1F, 0xF0, 0x3F, 0x00,
  0x1F, 0x33, 0xFB, 0x61, 0xF6, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC6,
  0x70, 0x6F, 0xE6, 0xDF, 0xEC, 0x3C, 0x03, 0xE0, 0xFC, 0x18, 0x03, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x07, 0x0F, 0xC1, 0xF0, 0x43, 0x00, 0x60,
  0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xFC, 0x1F, 0x80, 0x0C, 0x31,
  0x86, 0x18, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0x31, 0xC6, 0x18, 0x61, 0x86,
  0x38, 0x1F, 0x83, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x0E, 0x00, 0xFC, 0x1F, 0x86, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06,
  0x01, 0xC3, 0xF0, 0x7E, 0x00, 0x3C, 0x37, 0xE3, 0x66, 0x6C, 0x7E, 0xC3,
  0xC0,
};

const GFXglyph IBMPlexMono_MediumItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 16, 14, 4, -16 },
  { 13, 8, 7, 14, 4, -17 },
  { 20, 14, 16, 14, 0, -16 },
  { 48, 14, 20, 14, 0, -18 },
  { 83, 16, 16, 14, -1, -16 },
  { 115, 14, 16, 14, 0, -16 },
  { 143, 4, 7, 14, 6, -17 },
  { 147, 9, 20, 14, 4, -17 },
  { 170, 9, 20, 14, 1, -17 },
  { 193, 12, 11, 14, 1, -13 },
  { 210, 12, 12, 14, 1, -13 },
  { 228, 6, 6, 14, 3, -3 },
  { 233, 8, 2, 14, 3, -8 },
  { 235, 4, 4, 14, 4, -4 },
  { 237, 14, 20, 14, 0, -17 },
  { 272, 12, 16, 14, 1, -16 },
  { 296, 11, 16, 14, 1, -16 },
  { 318, 13, 16, 14, 0, -16 },
  { 344, 13, 16, 14, 0, -16 },
  { 370, 13, 16, 14, 0, -16 },
  { 396, 12, 16, 14, 1, -16 },
  { 420, 12, 16, 14, 1, -16 },
  { 444, 12, 16, 14, 2, -16 },
  { 468, 12, 16, 14, 1, -16 },
  { 492, 11, 16, 14, 2, -16 },
  { 514, 6, 13, 14, 4, -13 },
  { 524, 7, 16, 14, 3, -13 },
  { 538, 11, 13, 14, 2, -14 },
  { 556, 12, 6, 14, 1, -10 },
  { 565, 11, 13, 14, 1, -14 },
  { 583, 10, 16, 14, 3, -16 },
  { 603, 12, 19, 14, 1, -16 },
  { 632, 12, 16, 14, 0, -16 },
  { 656, 12, 16, 14, 1, -16 },
  { 680, 12, 16, 14, 2, -16 },
  { 704, 12, 16, 14, 1, -16 },
  { 728, 13, 16, 14, 1, -16 },
  { 754, 13, 16, 14, 1, -16 },
  { 780, 12, 16, 14, 1, -16 },
  { 804, 13, 16, 14, 1, -16 },
  { 830, 13, 16, 14, 1, -16 },
  { 856, 12, 16, 14, 1, -16 },
  { 880, 14, 16, 14, 1, -16 },
  { 908, 10, 16, 14, 2, -16 },
  { 928, 14, 16, 14, 0, -16 },
  { 956, 13, 16, 14, 1, -16 },
  { 982, 12, 16, 14, 1, -16 },
  { 1006, 13, 16, 14, 1, -16 },
  { 1032, 12, 20, 14, 1, -16 },
  { 1062, 13, 16, 14, 1, -16 },
  { 1088, 14, 16, 14, 0, -16 },
  { 1116, 13, 16, 14, 2, -16 },
  { 1142, 13, 16, 14, 1, -16 },
  { 1168, 13, 16, 14, 2, -16 },
  { 1194, 14, 16, 14, 1, -16 },
  { 1222, 16, 16, 14, -1, -16 },
  { 1254, 13, 16, 14, 2, -16 },
  { 1280, 14, 16, 14, 0, -16 },
  { 1308, 11, 20, 14, 3, -17 },
  { 1336, 6, 20, 14, 4, -17 },
  { 1351, 11, 20, 14, 0, -17 },
  { 1379, 12, 10, 14, 1, -16 },
  { 1394, 11, 2, 14, 0, 2 },
  { 1397, 3, 5, 14, 5, -18 },
  { 1399, 12, 12, 14, 1, -12 },
  { 1417, 12, 17, 14, 1, -17 },
  { 1443, 10, 12, 14, 2, -12 },
  { 1458, 13, 17, 14, 1, -17 },
  { 1486, 10, 12, 14, 2, -12 },
  { 1501, 16, 22, 14, -1, -17 },
  { 1545, 13, 17, 14, 0, -12 },
  { 1573, 11, 17, 14, 1, -17 },
  { 1597, 10, 18, 14, 2, -18 },
  { 1620, 11, 23, 14, 1, -18 },
  { 1652, 12, 17, 14, 1, -17 },
  { 1678, 10, 17, 14, 2, -17 },
  { 1700, 13, 12, 14, 0, -12 },
  { 1720, 11, 12, 14, 1, -12 },
  { 1737, 12, 12, 14, 1, -12 },
  { 1755, 13, 17, 14, 0, -12 },
  { 1783, 12, 17, 14, 1, -12 },
  { 1809, 12, 12, 14, 2, -12 },
  { 1827, 11, 12, 14, 1, -12 },
  { 1844, 11, 16, 14, 2, -16 },
  { 1866, 11, 12, 14, 2, -12 },
  { 1883, 12, 12, 14, 1, -12 },
  { 1901, 12, 12, 14, 1, -12 },
  { 1919, 14, 12, 14, 0, -12 },
  { 1940, 13, 17, 14, 0, -12 },
  { 1968, 12, 12, 14, 1, -12 },
  { 1986, 11, 20, 14, 2, -17 },
  { 2014, 6, 20, 14, 4, -17 },
  { 2029, 11, 20, 14, 1, -17 },
  { 2057, 12, 5, 14, 1, -10 },
};

const GFXfont IBMPlexMono_MediumItalic23pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic23pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _IBMPLEXMONO_MEDIUMITALIC23PT7B_H_
