#ifndef _IBMPLEXMONO_MEDIUMITALIC13PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x24, 0x06, 0xC0, 0x5A, 0xD5, 0xA0, 0x0A, 0x1A, 0x16,
  0x77, 0x24, 0xEE, 0x28, 0x48, 0x58, 0x0C, 0x1E, 0x2B, 0x68, 0x68, 0x1C,
  0x16, 0x12, 0xD6, 0x7C, 0x10, 0x31, 0xA5, 0x13, 0x0B, 0x07, 0xE0, 0x50,
  0xE8, 0xB4, 0x8E, 0x00, 0x1C, 0x36, 0x26, 0x34, 0x78, 0xD8, 0x88, 0xDB,
  0x66, 0xEA, 0x0C, 0x42, 0x18, 0x41, 0x04, 0x30, 0x41, 0x06, 0x0C, 0x30,
  0x20, 0x82, 0x0C, 0x30, 0x82, 0x08, 0x42, 0x38, 0x10, 0x4F, 0xDE, 0x73,
  0x60, 0x10, 0x41, 0x3F, 0x20, 0x82, 0x00, 0x7B, 0x40, 0xF0, 0x78, 0x03,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x60, 0x40, 0xC0, 0x3C,
  0x8B, 0x15, 0xBB, 0x50, 0xA3, 0x44, 0x70, 0x39, 0xED, 0x84, 0x10, 0x41,
  0x0C, 0xFC, 0x1C, 0x45, 0x08, 0x10, 0x41, 0x0C, 0x30, 0xFE, 0x3E, 0x44,
  0x08, 0x31, 0x80, 0xC1, 0xE2, 0x78, 0x06, 0x1C, 0x79, 0xA6, 0x48, 0xBF,
  0x86, 0x0C, 0x3F, 0x20, 0x20, 0x7C, 0x66, 0x02, 0x06, 0x44, 0xF8, 0x1C,
  0xC6, 0x3E, 0xCE, 0x18, 0x63, 0x70, 0x7F, 0x8F, 0x30, 0x41, 0x82, 0x0C,
  0x30, 0x40, 0x1E, 0x22, 0x63, 0x22, 0x1C, 0x66, 0xC2, 0x46, 0x7C, 0x39,
  0x1C, 0x61, 0xCD, 0xF0, 0x84, 0xE0, 0x6C, 0x00, 0xF0, 0x6C, 0x00, 0xF6,
  0x80, 0x04, 0x33, 0x30, 0xC1, 0xC1, 0x82, 0xFC, 0x00, 0x3F, 0x41, 0x83,
  0x83, 0x0C, 0xCC, 0x20, 0x74, 0x42, 0x37, 0x20, 0x18, 0xC0, 0x3D, 0x1C,
  0x67, 0xA6, 0x9A, 0x6F, 0x89, 0xC0, 0x0C, 0x38, 0x51, 0xA2, 0x4F, 0xD1,
  0xE3, 0x86, 0x7D, 0x14, 0x71, 0xFB, 0x38, 0xE3, 0xF8, 0x3C, 0xCF, 0x06,
  0x08, 0x10, 0x22, 0x66, 0x78, 0x79, 0x14, 0x71, 0xC7, 0x18, 0xE2, 0xF0,
  0x7E, 0x81, 0x06, 0x0F, 0xD8, 0x20, 0x40, 0xF8, 0x7E, 0x81, 0x06, 0x0F,
  0xD8, 0x20, 0x40, 0x80, 0x3C, 0x8B, 0x0E, 0x09, 0xD0, 0xA3, 0x66, 0x78,
  0x23, 0x23, 0x62, 0x62, 0x7E, 0x46, 0x46, 0x46, 0xC4, 0x3F, 0x08, 0x08,
  0x08, 0x18, 0x18, 0x10, 0x10, 0xFC, 0x3C, 0x10, 0xC3, 0x0C, 0x20, 0xA6,
  0xF0, 0x23, 0x93, 0x0B, 0x0F, 0x07, 0x83, 0x61, 0x30, 0x88, 0xC6, 0x00,
  0x61, 0x84, 0x10, 0x43, 0x0C, 0x30, 0xFC, 0x23, 0x73, 0x77, 0x56, 0x5A,
  0x5A, 0x52, 0xC6, 0xC6, 0x33, 0x33, 0x72, 0x7A, 0x5A, 0x4A, 0x4E, 0x4E,
  0xCC, 0x3C, 0x8B, 0x1C, 0x38, 0x50, 0xA3, 0x44, 0x70, 0x7C, 0x8D, 0x1E,
  0x2F, 0x98, 0x20, 0x40, 0x80, 0x3C, 0x8B, 0x14, 0x38, 0x50, 0xA3, 0x44,
  0x70, 0x68, 0x60, 0x7C, 0x8D, 0x1E, 0x2F, 0x9A, 0x26, 0x44, 0x8C, 0x1E,
  0x23, 0x60, 0x60, 0x3C, 0x06, 0x02, 0xC6, 0x7C, 0xFE, 0x20, 0x40, 0x83,
  0x06, 0x08, 0x10, 0x20, 0x46, 0x8F, 0x16, 0x2C, 0x51, 0xA3, 0x44, 0x78,
  0xC3, 0x8D, 0x12, 0x64, 0x89, 0x14, 0x38, 0x70, 0x61, 0x41, 0x49, 0x5B,
  0x5A, 0x5A, 0x6A, 0x6E, 0xEC, 0x63, 0x32, 0x34, 0x1C, 0x18, 0x38, 0x2C,
  0x44, 0xC6, 0xC3, 0x46, 0x6C, 0x68, 0x30, 0x30, 0x20, 0x20, 0x20, 0x3F,
  0x02, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x40, 0xFE, 0x3C, 0x86, 0x10, 0x41,
  0x04, 0x10, 0xC2, 0x08, 0x3C, 0x84, 0x44, 0x44, 0x22, 0x22, 0x21, 0x3C,
  0x10, 0xC2, 0x08, 0x20, 0x82, 0x18, 0x41, 0x3C, 0x18, 0xA6, 0xD1, 0x84,
  0xFC, 0xA4, 0x77, 0x38, 0xE3, 0x8A, 0x6E, 0xC0, 0x61, 0x04, 0x17, 0xE7,
  0x18, 0x63, 0x8B, 0xE0, 0x39, 0x1C, 0x20, 0x8B, 0x37, 0x00, 0x06, 0x0C,
  0x13, 0xAC, 0xD1, 0xA3, 0x46, 0x99, 0xD0, 0x39, 0x18, 0xFE, 0x8B, 0x37,
  0x00, 0x07, 0x0C, 0x08, 0x3F, 0x48, 0x08, 0x18, 0x18, 0x10, 0x10, 0x90,
  0x50, 0x70, 0x3A, 0xCD, 0x0A, 0x34, 0x69, 0x9D, 0x02, 0x8C, 0xF0, 0x61,
  0x04, 0x16, 0xEF, 0x3C, 0xE3, 0x8A, 0x20, 0x10, 0x40, 0x3C, 0x30, 0x82,
  0x09, 0x68, 0xC0, 0x06, 0x0C, 0x01, 0xE0, 0x41, 0x83, 0x04, 0x08, 0x13,
  0x23, 0xC3, 0x00, 0x60, 0x81, 0x02, 0xEE, 0xD9, 0xB6, 0x58, 0x97, 0x30,
  0xF0, 0xC3, 0x08, 0x20, 0x86, 0x1B, 0x79, 0xC0, 0x56, 0x6B, 0x5A, 0x52,
  0xD2, 0x92, 0x96, 0x5B, 0xBC, 0xF3, 0x8E, 0x28, 0x80, 0x7B, 0x38, 0x61,
  0x8E, 0x27, 0x00, 0x2E, 0xE5, 0x8A, 0x14, 0x68, 0x9F, 0x60, 0xC1, 0x80,
  0x77, 0x38, 0xE3, 0x8E, 0x6E, 0x82, 0x08, 0x60, 0xFE, 0x60, 0x81, 0x02,
  0x0C, 0x18, 0x00, 0x79, 0x3C, 0x1E, 0x0E, 0x2F, 0x80, 0x30, 0x8F, 0xC8,
  0x21, 0x86, 0x56, 0x70, 0x47, 0x1C, 0xE3, 0x8E, 0x6E, 0x80, 0xED, 0x14,
  0x53, 0x4F, 0x67, 0x00, 0x4A, 0x95, 0x2A, 0xD5, 0x3A, 0x5F, 0x00, 0x36,
  0xD9, 0x1A, 0x18, 0x18, 0x9A, 0xEC, 0x22, 0xC5, 0x9B, 0x34, 0x69, 0x9D,
  0x02, 0x8C, 0xF0, 0x3A, 0x8C, 0x30, 0xC3, 0x6C, 0x77, 0x80, 0x1E, 0x20,
  0x40, 0x81, 0x9C, 0x04, 0x08, 0x20, 0xC1, 0x03, 0xC0, 0x32, 0x22, 0x22,
  0x64, 0x44, 0x4C, 0x3C, 0x08, 0x20, 0xC1, 0x01, 0xC4, 0x18, 0x10, 0x20,
  0x47, 0x80, 0x33, 0x5A, 0xCC,
};

const GFXglyph IBMPlexMono_MediumItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 9, 8, 2, -9 },
  { 6, 5, 4, 8, 2, -10 },
  { 9, 8, 9, 8, 0, -9 },
  { 18, 8, 11, 8, 0, -10 },
  { 29, 9, 9, 8, 0, -9 },
  { 40, 8, 9, 8, 0, -9 },
  { 49, 2, 4, 8, 4, -10 },
  { 50, 6, 12, 8, 2, -10 },
  { 59, 6, 12, 8, 0, -10 },
  { 68, 6, 6, 8, 1, -7 },
  { 73, 6, 7, 8, 1, -7 },
  { 79, 3, 4, 8, 2, -2 },
  { 81, 4, 1, 8, 2, -4 },
  { 82, 3, 2, 8, 2, -2 },
  { 83, 8, 12, 8, 0, -10 },
  { 95, 7, 9, 8, 1, -9 },
  { 103, 6, 9, 8, 1, -9 },
  { 110, 7, 9, 8, 0, -9 },
  { 118, 7, 9, 8, 0, -9 },
  { 126, 7, 9, 8, 0, -9 },
  { 134, 8, 9, 8, 0, -9 },
  { 143, 6, 9, 8, 1, -9 },
  { 150, 7, 9, 8, 1, -9 },
  { 158, 8, 9, 8, 0, -9 },
  { 167, 6, 9, 8, 1, -9 },
  { 174, 3, 7, 8, 2, -7 },
  { 177, 3, 9, 8, 2, -7 },
  { 181, 6, 8, 8, 1, -8 },
  { 187, 6, 4, 8, 1, -6 },
  { 190, 6, 8, 8, 1, -8 },
  { 196, 5, 9, 8, 2, -9 },
  { 202, 6, 10, 8, 1, -9 },
  { 210, 7, 9, 8, 0, -9 },
  { 218, 6, 9, 8, 1, -9 },
  { 225, 7, 9, 8, 1, -9 },
  { 233, 6, 9, 8, 1, -9 },
  { 240, 7, 9, 8, 1, -9 },
  { 248, 7, 9, 8, 1, -9 },
  { 256, 7, 9, 8, 1, -9 },
  { 264, 8, 9, 8, 0, -9 },
  { 273, 8, 9, 8, 0, -9 },
  { 282, 6, 9, 8, 1, -9 },
  { 289, 9, 9, 8, 0, -9 },
  { 300, 6, 9, 8, 1, -9 },
  { 307, 8, 9, 8, 0, -9 },
  { 316, 8, 9, 8, 0, -9 },
  { 325, 7, 9, 8, 1, -9 },
  { 333, 7, 9, 8, 1, -9 },
  { 341, 7, 11, 8, 1, -9 },
  { 351, 7, 9, 8, 1, -9 },
  { 359, 8, 9, 8, 0, -9 },
  { 368, 7, 9, 8, 1, -9 },
  { 376, 7, 9, 8, 1, -9 },
  { 384, 7, 9, 8, 1, -9 },
  { 392, 8, 9, 8, 0, -9 },
  { 401, 8, 9, 8, 0, -9 },
  { 410, 8, 9, 8, 1, -9 },
  { 419, 8, 9, 8, 0, -9 },
  { 428, 6, 12, 8, 2, -10 },
  { 437, 4, 12, 8, 2, -10 },
  { 443, 6, 12, 8, 0, -10 },
  { 452, 6, 5, 8, 1, -9 },
  { 456, 6, 1, 8, 0, 1 },
  { 457, 2, 3, 8, 3, -11 },
  { 458, 6, 7, 8, 1, -7 },
  { 464, 6, 10, 8, 1, -10 },
  { 472, 6, 7, 8, 1, -7 },
  { 478, 7, 10, 8, 1, -10 },
  { 487, 6, 7, 8, 1, -7 },
  { 493, 8, 13, 8, 0, -10 },
  { 506, 7, 10, 8, 0, -7 },
  { 515, 6, 10, 8, 1, -10 },
  { 523, 6, 10, 8, 1, -10 },
  { 531, 7, 13, 8, 0, -10 },
  { 543, 7, 10, 8, 1, -10 },
  { 552, 6, 10, 8, 1, -10 },
  { 560, 8, 7, 8, 0, -7 },
  { 567, 6, 7, 8, 1, -7 },
  { 573, 6, 7, 8, 1, -7 },
  { 579, 7, 10, 8, 0, -7 },
  { 588, 6, 10, 8, 1, -7 },
  { 596, 7, 7, 8, 1, -7 },
  { 603, 6, 7, 8, 1, -7 },
  { 609, 6, 9, 8, 1, -9 },
  { 616, 6, 7, 8, 1, -7 },
  { 622, 6, 7, 8, 1, -7 },
  { 628, 7, 7, 8, 0, -7 },
  { 635, 8, 7, 8, 0, -7 },
  { 642, 7, 10, 8, 0, -7 },
  { 651, 7, 7, 8, 0, -7 },
  { 658, 7, 12, 8, 1, -10 },
  { 669, 4, 12, 8, 2, -10 },
  { 675, 7, 12, 8, 0, -10 },
  { 686, 8, 3, 8, 0, -5 },
};

const GFXfont IBMPlexMono_MediumItalic13pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic13pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _IBMPLEXMONO_MEDIUMITALIC13PT7B_H_
