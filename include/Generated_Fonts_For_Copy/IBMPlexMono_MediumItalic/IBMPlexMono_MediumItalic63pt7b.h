#ifndef _IBMPLEXMONO_MEDIUMITALIC63PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF,
  0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0xFC, 0x0F,
  0xCF, 0xE0, 0x7E, 0x7E, 0x07, 0xF3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC,
  0x0F, 0xC7, 0xE0, 0x7E, 0x7F, 0x03, 0xF3, 0xF0, 0x3F, 0x9F, 0x81, 0xF8,
  0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF3, 0xF8, 0x1F, 0x9F, 0x81,
  0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0xFF, 0x03, 0xFF,
  0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x83, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF,
  0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x80, 0xF8, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0x9F, 0x7F, 0xF0, 0x1F, 0xE1, 0xF0, 0xFE, 0x03,
  0xFC, 0x1F, 0x07, 0xC0, 0x3F, 0x81, 0xF0, 0x38, 0x07, 0xF0, 0x1E, 0x01,
  0x00, 0x7F, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0x7F, 0x03,
  0xE0, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x07,
  0xF8, 0x3C, 0x00, 0x00, 0x3F, 0xC3, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0x8F, 0xF8, 0x00, 0x00, 0xF0, 0x7F, 0x80, 0x00, 0x0F,
  0x03, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0x03, 0xF8, 0x08, 0x01, 0xE0, 0x3F,
  0x80, 0xC0, 0x1E, 0x03, 0xF8, 0x3E, 0x03, 0xE0, 0x7F, 0x87, 0xF0, 0x3E,
  0x0F, 0xF0, 0xFF, 0x83, 0xE1, 0xFF, 0x07, 0xFF, 0x3E, 0x7F, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x00, 0x3E, 0x00, 0xF8, 0x0F, 0xC0,
  0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x1F, 0x80, 0x03,
  0xE0, 0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xE0,
  0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xE0, 0x3F,
  0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x3F,
  0x00, 0x00, 0x1F, 0xFF, 0xC3, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x40, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xE3, 0xFF, 0xF8, 0x00, 0x00, 0xFC,
  0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0xF8,
  0x07, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xE1, 0xF8, 0x07,
  0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x07, 0xC0,
  0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x03,
  0xE0, 0x1F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x01, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x01, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x02, 0x3F, 0x80, 0x0F, 0xE0, 0x3D,
  0xFC, 0x00, 0x7F, 0x03, 0xFF, 0xE0, 0x03, 0xFC, 0x1F, 0xBF, 0x80, 0x37,
  0xE1, 0xF9, 0xFC, 0x03, 0xBF, 0x9F, 0xCF, 0xF8, 0x3C, 0xFC, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x8F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x7F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x1C, 0x01, 0xF8, 0x03, 0x8F, 0xC0, 0xFC, 0x0F, 0xCF, 0xFC, 0x7E, 0x3F,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF8,
  0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC7, 0xFD, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xC7, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xF8,
  0xFE, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x1F, 0x03, 0xFB, 0xF8, 0x1F, 0xC1,
  0xFD, 0xFC, 0x1F, 0xE0, 0xFE, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0x07, 0xF8,
  0x7F, 0xFF, 0x83, 0xF8, 0x3F, 0xFF, 0x80, 0xF8, 0x1F, 0xDF, 0xC0, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xEF, 0xE0, 0x00, 0xFF, 0x9F, 0xC0, 0x03,
  0xFE, 0x3F, 0x80, 0x0F, 0xF8, 0x7F, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0xFF,
  0x81, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xF0, 0x0F, 0xE0, 0x01, 0xC0,
  0x1F, 0xC0, 0x01, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F,
  0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x20,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x1C, 0x00,
  0x07, 0xF0, 0x02, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x40, 0x00, 0x0F, 0xE0,
  0x30, 0x00, 0x03, 0xF8, 0x3E, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFF,
  0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07,
  0xF1, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0xFC,
  0x00, 0x1F, 0x9F, 0xFF, 0xC0, 0x03, 0xE7, 0xFF, 0xFC, 0x00, 0x7D, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0x80, 0x0F, 0xF8, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x80, 0x00, 0x1F, 0xC0, 0x38,
  0x00, 0x07, 0xF8, 0x1F, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xC1,
  0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xE3, 0xFF, 0xC0, 0x1F,
  0xC7, 0xFF, 0xF0, 0x1F, 0xDF, 0xFF, 0xF8, 0x3F, 0xBF, 0xFF, 0xFC, 0x3F,
  0xBF, 0xFF, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F,
  0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x7F,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7E,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0xFF,
  0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFE,
  0x03, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF,
  0x9F, 0xF8, 0x0F, 0xFF, 0x3F, 0xFF, 0xFE, 0xFC, 0x3F, 0xFF, 0xFB, 0xF8,
  0x3F, 0xFF, 0xE7, 0xF0, 0x3F, 0xFF, 0x9F, 0xC0, 0x3F, 0xFC, 0x3F, 0x80,
  0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xC0, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFE, 0x3F, 0xF0, 0x3F, 0xE3, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xF7,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF0, 0xE0, 0x00, 0x7F, 0x04, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF0,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0x7C, 0x7E, 0x03, 0xFE, 0x7E, 0x3F,
  0x03, 0xFF, 0xBF, 0x3F, 0x03, 0xFF, 0xDF, 0x9F, 0x81, 0xF8, 0x3F, 0xCF,
  0xC1, 0xF8, 0x0F, 0xC7, 0xE1, 0xF8, 0x07, 0xE3, 0xE0, 0xFC, 0x03, 0xF3,
  0xF0, 0x7C, 0x01, 0xF9, 0xF8, 0x7E, 0x00, 0xFC, 0xFC, 0x3F, 0x00, 0x7E,
  0x7E, 0x1F, 0x80, 0x3E, 0x3F, 0x0F, 0xC0, 0x1F, 0x1F, 0x07, 0xE0, 0x1F,
  0x9F, 0x87, 0xE0, 0x0F, 0xCF, 0xC3, 0xF0, 0x07, 0xE7, 0xE1, 0xF8, 0x03,
  0xF3, 0xF0, 0xFC, 0x03, 0xF1, 0xF8, 0x7E, 0x01, 0xF8, 0xFC, 0x1F, 0x01,
  0xFC, 0x7E, 0x0F, 0xC1, 0xFE, 0x3F, 0x07, 0xF1, 0xFF, 0x1F, 0x83, 0xFF,
  0xDF, 0x8F, 0xC0, 0xFF, 0xCF, 0x87, 0xE0, 0x7F, 0xE7, 0xC3, 0xF0, 0x1F,
  0xE3, 0xE1, 0xF8, 0x03, 0x82, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x81, 0xFE, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0,
  0x07, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x1F,
  0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x03,
  0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01,
  0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07,
  0xF1, 0xFE, 0x00, 0x01, 0x80, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xC0, 0x7F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x80,
  0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0,
  0x1F, 0xF8, 0x07, 0xF0, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFF,
  0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x01,
  0xFF, 0x07, 0xF0, 0x01, 0xFF, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x30, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0xFE, 0xFE, 0x00, 0xFF, 0xFC, 0xFE, 0x01, 0xFF, 0xFC, 0xFE,
  0x01, 0xFF, 0xFC, 0xFE, 0x01, 0xFF, 0xFC, 0xFE, 0x01, 0xFF, 0xFC, 0xFE,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x01, 0xF8, 0xFE,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x7B, 0xF0, 0x3F,
  0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xF7, 0xE0, 0x1F, 0xFF, 0xE7, 0xE0, 0x0F,
  0xFF, 0xC7, 0xE0, 0x07, 0xFF, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x04, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0,
  0x03, 0xFC, 0x03, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xF0,
  0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x7F,
  0x01, 0xFF, 0x00, 0x00, 0xFE, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xF0,
  0x00, 0x03, 0xF8, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x00, 0x7F, 0x3F, 0xE0,
  0x00, 0x00, 0xFE, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0xF1, 0xFE, 0x00, 0x00,
  0xFF, 0xC1, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFE, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F,
  0xBF, 0x01, 0xFB, 0xF0, 0x7E, 0xFC, 0x07, 0xE7, 0xC3, 0xF3, 0xF0, 0x1F,
  0x9F, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x7E, 0x7E, 0x01, 0xF9, 0xF9, 0xF9,
  0xF8, 0x0F, 0xE3, 0xEF, 0xC7, 0xE0, 0x3F, 0x0F, 0xFE, 0x1F, 0x80, 0xFC,
  0x3F, 0xF8, 0x7E, 0x03, 0xF0, 0xFF, 0xC1, 0xF8, 0x0F, 0xC1, 0xFF, 0x0F,
  0xC0, 0x3F, 0x07, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0xE0, 0xFC, 0x07, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x7F,
  0x01, 0xF8, 0x0F, 0x01, 0xF8, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3F, 0x80,
  0xE0, 0x1F, 0x80, 0xFC, 0x01, 0x80, 0x7E, 0x03, 0xF0, 0x04, 0x01, 0xF8,
  0x0F, 0xC0, 0x20, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0x01,
  0xFF, 0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x00, 0x7E, 0x03, 0xFF, 0x80, 0x07,
  0xE0, 0x3F, 0xF8, 0x00, 0x7E, 0x03, 0xFF, 0xC0, 0x07, 0xE0, 0x3F, 0xFC,
  0x00, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x3F, 0xFC, 0x00, 0xFC, 0x03,
  0xF7, 0xC0, 0x0F, 0xC0, 0x7F, 0x7E, 0x00, 0xFC, 0x07, 0xE7, 0xE0, 0x0F,
  0xC0, 0x7E, 0x7E, 0x01, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x80, 0x7E, 0x3F,
  0x01, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x80, 0xFE, 0x3F, 0x01, 0xF8, 0x0F,
  0xC3, 0xF0, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF8, 0x0F, 0xC1, 0xF8, 0x3F,
  0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x3F, 0x01, 0xFC, 0x1F,
  0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F,
  0x80, 0xFC, 0x7E, 0x01, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x80, 0xFC, 0x7E,
  0x03, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x00, 0x7E, 0x7E, 0x03, 0xF0, 0x07,
  0xEF, 0xE0, 0x3F, 0x00, 0x7E, 0xFC, 0x03, 0xF0, 0x07, 0xEF, 0xC0, 0x3F,
  0x00, 0x7F, 0xFC, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x7E, 0x00, 0x3F, 0xFC,
  0x07, 0xE0, 0x03, 0xFF, 0xC0, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xE0, 0x03,
  0xFF, 0x80, 0x7E, 0x00, 0x1F, 0xF8, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0xFC,
  0x00, 0x1F, 0xF8, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x07,
  0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF1, 0xFE, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x80,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xFB,
  0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFE,
  0x7F, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x0F, 0xF8,
  0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x07, 0xF1, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x00, 0x7E, 0x7F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x40, 0x00,
  0x7F, 0x80, 0x30, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0x80, 0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xE0,
  0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x3F, 0x80, 0x00,
  0x38, 0x03, 0xF8, 0x00, 0x01, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x08, 0x00, 0x00, 0x7F, 0x80, 0xC0, 0x00, 0x07, 0xF0, 0x3E, 0x00,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0xC0, 0x03, 0xFE, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x00, 0xFF, 0x3F, 0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07,
  0xF0, 0x1F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x1F,
  0x81, 0xF8, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0xC0, 0x7E, 0x07, 0xE0,
  0x7F, 0x80, 0xF8, 0x0F, 0xC0, 0xFF, 0x03, 0xF0, 0x1F, 0x03, 0xFE, 0x07,
  0xE0, 0x7E, 0x07, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xF8, 0x1F, 0x01, 0xF8,
  0x3E, 0xF0, 0x7E, 0x03, 0xF0, 0x7D, 0xE0, 0xFC, 0x07, 0xE1, 0xF3, 0xC1,
  0xF8, 0x0F, 0xC3, 0xE7, 0x83, 0xE0, 0x1F, 0x87, 0xCF, 0x0F, 0xC0, 0x3F,
  0x1F, 0x1E, 0x1F, 0x80, 0x7E, 0x3E, 0x3E, 0x3F, 0x00, 0xF8, 0x78, 0x7C,
  0x7C, 0x03, 0xF1, 0xF0, 0xF8, 0xF8, 0x07, 0xE3, 0xE1, 0xF3, 0xF0, 0x0F,
  0xC7, 0x83, 0xE7, 0xE0, 0x1F, 0x9F, 0x07, 0xCF, 0xC0, 0x3F, 0x3E, 0x0F,
  0x9F, 0x00, 0x7E, 0x78, 0x1F, 0x7E, 0x00, 0xFD, 0xF0, 0x3E, 0xFC, 0x01,
  0xFB, 0xE0, 0x7D, 0xF8, 0x03, 0xF7, 0x80, 0xFB, 0xE0, 0x07, 0xDF, 0x01,
  0xF7, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xDF, 0xC0, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00, 0x07, 0xF1,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x01, 0xF9, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0x9F, 0xC0,
  0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x0F,
  0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xF9, 0xFC, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x8E, 0x00,
  0x00, 0x0E, 0x02, 0x00, 0x00, 0x04, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x0F, 0x8F, 0xE1, 0xF8,
  0x7F, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0x7C, 0x1E, 0x02, 0x00,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0xF0, 0x7E, 0x01, 0xFF, 0xF8, 0x7E,
  0x03, 0xFF, 0xFC, 0xFE, 0x07, 0xFF, 0xFE, 0xFE, 0x0F, 0xFF, 0xFE, 0xFE,
  0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFC,
  0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFC,
  0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xF8,
  0x7F, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xF0,
  0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x37, 0xF0, 0x7F, 0x00, 0x77, 0xE0,
  0x7F, 0xC1, 0xEF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFE,
  0x3F, 0xFF, 0x87, 0xFE, 0x1F, 0xFF, 0x03, 0xFE, 0x0F, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x1F, 0x80, 0x07, 0xF0, 0xFF, 0xE0, 0x07, 0xE1, 0xFF, 0xF8,
  0x0F, 0xE3, 0xFF, 0xF8, 0x0F, 0xE7, 0xFF, 0xFC, 0x0F, 0xE7, 0xFF, 0xFE,
  0x0F, 0xEF, 0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFE, 0x0F, 0xD8, 0x00, 0xFE,
  0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xFC,
  0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0,
  0xFF, 0xE0, 0x3F, 0xF0, 0xFE, 0xFF, 0xFF, 0xE0, 0xFE, 0xFF, 0xFF, 0xC0,
  0xFE, 0x7F, 0xFF, 0x80, 0xFE, 0x3F, 0xFF, 0x00, 0xFC, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x3F, 0xF0, 0x3F, 0xE1, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x01,
  0xF8, 0xFE, 0x00, 0x0F, 0x0F, 0xE0, 0x00, 0x20, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x10, 0x7F, 0x00, 0x00, 0xE3,
  0xF8, 0x00, 0x07, 0x9F, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x03, 0xFF, 0xC3, 0xF8, 0x00, 0xFF, 0xFC, 0x7F, 0x00, 0x7F,
  0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0xFD, 0xFC, 0x03, 0xFF, 0xFF, 0xBF, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x7F, 0x00, 0x77, 0xF0, 0x0F, 0xF8, 0x3E, 0xFE, 0x01,
  0xFF, 0xFF, 0x9F, 0xC0, 0x1F, 0xFF, 0xE3, 0xF0, 0x03, 0xFF, 0xFC, 0x7E,
  0x00, 0x3F, 0xFF, 0x1F, 0xC0, 0x03, 0xFF, 0xC3, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xC0, 0x7F, 0xC3, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x01, 0xFC,
  0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x7F,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0xE7, 0xF0, 0x3F, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x08, 0x3F, 0x80, 0x00, 0x78, 0x7F, 0x00, 0x03, 0xF1,
  0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x10, 0x01, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xC0, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xFF, 0x87, 0xF0, 0x07, 0xFF,
  0xF1, 0xFC, 0x03, 0xFF, 0xFE, 0x7F, 0x01, 0xFF, 0xFF, 0x9F, 0xC0, 0xFF,
  0xFF, 0xF7, 0xE0, 0x3F, 0xF0, 0x1D, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x06, 0xFC, 0x07,
  0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x03, 0xDF, 0xC0, 0x7F, 0xFF, 0xE7, 0xF0,
  0x0F, 0xFF, 0xF9, 0xFC, 0x03, 0xFF, 0xFC, 0x7E, 0x00, 0x7F, 0xFE, 0x3F,
  0x80, 0x0F, 0xFF, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x03, 0x00, 0x03, 0xF8, 0x01, 0xE0, 0x01, 0xFE, 0x00, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x7F, 0xF0, 0x07, 0xF1, 0xFF, 0xF0, 0x0F,
  0xE7, 0xFF, 0xF0, 0x1F, 0x9F, 0xFF, 0xF0, 0x7F, 0x3F, 0xFF, 0xE0, 0xFE,
  0xF0, 0x7F, 0xC1, 0xFD, 0xC0, 0x3F, 0x83, 0xFF, 0x00, 0x7F, 0x07, 0xFC,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFC, 0x3F, 0xC0, 0x01, 0xF8, 0x7F, 0x80,
  0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x3F, 0x87, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01,
  0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFC,
  0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7E, 0x1F,
  0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x02, 0x00,
  0x3F, 0x80, 0x38, 0x01, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0x80, 0x7E,
  0x07, 0xFC, 0x07, 0xF0, 0x7F, 0xC0, 0x3F, 0x87, 0xFC, 0x01, 0xFC, 0x7F,
  0xC0, 0x0F, 0xC7, 0xFC, 0x00, 0x7E, 0x7F, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x01, 0x00, 0x1F, 0xC0, 0x07, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0xFC, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x01,
  0xFF, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x01,
  0xFE, 0x7E, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0xFF, 0xE0, 0x07, 0xF1, 0xFF,
  0xF8, 0x03, 0xF9, 0xFF, 0xFC, 0x01, 0xF8, 0xFF, 0xFF, 0x01, 0xFC, 0xFF,
  0xFF, 0x80, 0xFE, 0xF0, 0x3F, 0xE0, 0x7F, 0x70, 0x0F, 0xF0, 0x3F, 0xE0,
  0x03, 0xF8, 0x1F, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFC, 0x0F, 0xF0,
  0x00, 0x7E, 0x07, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0x3F, 0x87, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x63,
  0xF8, 0x3F, 0x80, 0x79, 0xFC, 0x1F, 0xC0, 0x7C, 0xFE, 0x07, 0xF0, 0x7F,
  0x7F, 0x03, 0xF8, 0x7F, 0x3F, 0x80, 0xFE, 0xFF, 0x1F, 0x80, 0x7F, 0xFF,
  0x1F, 0xC0, 0x1F, 0xFF, 0x0F, 0xE0, 0x0F, 0xFF, 0x07, 0xF0, 0x03, 0xFF,
  0x03, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x01,
  0x00, 0x7E, 0x00, 0xF0, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x0F, 0xF0, 0x7F,
  0x03, 0xFC, 0x0F, 0xE0, 0xFF, 0x01, 0xF8, 0x3F, 0xC0, 0x3F, 0x0F, 0xF0,
  0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF0, 0x0F, 0xC0, 0x7E, 0x3F, 0x81, 0xFE,
  0x07, 0xE7, 0xFC, 0x3F, 0xF0, 0x7E, 0xFF, 0xE7, 0xFF, 0x07, 0xEF, 0xFE,
  0xFF, 0xF0, 0x7F, 0xFF, 0xEF, 0xFF, 0x0F, 0xD8, 0xFF, 0xC3, 0xF0, 0xFF,
  0x07, 0xF8, 0x3F, 0x0F, 0xE0, 0x7F, 0x01, 0xF0, 0xFE, 0x07, 0xF0, 0x1F,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x1F, 0x80, 0x7E,
  0x03, 0xF1, 0xF8, 0x07, 0xC0, 0x3F, 0x1F, 0x80, 0x7C, 0x03, 0xE1, 0xF8,
  0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC0, 0x7E,
  0x3F, 0x00, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0x80, 0x7E, 0x3F, 0x01, 0xF8,
  0x07, 0xC3, 0xF0, 0x1F, 0x80, 0x7C, 0x3F, 0x01, 0xF8, 0x0F, 0xC3, 0xF0,
  0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x00, 0xFC,
  0x7E, 0x03, 0xF0, 0x0F, 0x87, 0xE0, 0x3F, 0x00, 0xF8, 0x7E, 0x03, 0xF0,
  0x1F, 0x87, 0xC0, 0x3F, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3E, 0x01, 0xF8, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x07, 0xF0, 0x1F, 0x80,
  0x0F, 0xE1, 0xFF, 0xC0, 0x1F, 0xC7, 0xFF, 0xC0, 0x3F, 0x1F, 0xFF, 0xC0,
  0xFE, 0x7F, 0xFF, 0xC1, 0xFC, 0xFF, 0xFF, 0x83, 0xFB, 0xC1, 0xFF, 0x07,
  0xF7, 0x00, 0xFE, 0x0F, 0xFC, 0x01, 0xFC, 0x1F, 0xF0, 0x01, 0xFC, 0x3F,
  0xC0, 0x03, 0xF0, 0xFF, 0x00, 0x07, 0xE1, 0xFE, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80,
  0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFE, 0x1F,
  0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x03, 0xF3, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x7F,
  0xC1, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xFF,
  0x80, 0x03, 0xF0, 0xFF, 0xFC, 0x00, 0xFE, 0x3F, 0xFF, 0x80, 0x1F, 0xCF,
  0xFF, 0xF8, 0x03, 0xF9, 0xFF, 0xFF, 0x80, 0x7F, 0x78, 0x1F, 0xF0, 0x0F,
  0xFC, 0x01, 0xFE, 0x01, 0xFB, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03,
  0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x07, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFD, 0xFF, 0xFF, 0xC0, 0x3F,
  0xBF, 0xFF, 0xF0, 0x07, 0xF3, 0xFF, 0xFC, 0x00, 0xFE, 0x3F, 0xFF, 0x00,
  0x1F, 0x83, 0xFF, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0xF8, 0x7F, 0x00, 0xFF,
  0xFC, 0x7F, 0x03, 0xFF, 0xFE, 0x7F, 0x07, 0xFF, 0xFF, 0x7F, 0x07, 0xFF,
  0xFF, 0x7E, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x01, 0xF8, 0xFE, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00,
  0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x00,
  0x77, 0xF0, 0x7F, 0xC1, 0xF7, 0xF0, 0x7F, 0xFF, 0xE7, 0xF0, 0x3F, 0xFF,
  0xE7, 0xE0, 0x3F, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0x8F, 0xE0, 0x0F, 0xFF,
  0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0x80, 0xFE, 0xFF, 0xFE,
  0x0F, 0xFD, 0xFF, 0xFC, 0x3F, 0xFB, 0xFF, 0xF8, 0xFF, 0xF7, 0xFF, 0xF3,
  0xFF, 0xEF, 0xFF, 0xEF, 0xFF, 0xA0, 0x1F, 0x9E, 0x00, 0x00, 0x3F, 0x70,
  0x00, 0x00, 0xFE, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x38, 0x0F, 0xE0, 0x00,
  0x20, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x10,
  0x00, 0x03, 0xF8, 0x38, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0xC7, 0xFE,
  0x01, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0x00, 0x7F, 0x00, 0x38, 0x03, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x07, 0xFE, 0x0F, 0xE0, 0x7F,
  0xC0, 0x7F, 0x0F, 0xFC, 0x03, 0xF8, 0xFF, 0xC0, 0x1F, 0xCF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC,
  0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFE, 0x3F,
  0x80, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xE1, 0xFE,
  0x00, 0xFF, 0xC3, 0xFC, 0x03, 0xBF, 0x83, 0xFE, 0x1F, 0x7F, 0x07, 0xFF,
  0xFC, 0xFC, 0x0F, 0xFF, 0xF3, 0xF8, 0x0F, 0xFF, 0xE7, 0xF0, 0x0F, 0xFF,
  0x8F, 0xE0, 0x0F, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x18, 0xFF, 0xF8, 0x01, 0xF9, 0xFF, 0xF0, 0x07, 0xF3, 0xFF, 0xE0,
  0x0F, 0xE7, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xF0,
  0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03,
  0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F,
  0x80, 0x7F, 0x80, 0x3F, 0x01, 0xFE, 0x00, 0x7E, 0x0F, 0xF8, 0x00, 0xFC,
  0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x7C, 0x03, 0x03, 0xE0, 0x1F, 0x07, 0xE0, 0xF8, 0x0F, 0xC1, 0xF8, 0x7E,
  0x03, 0xF0, 0x3E, 0x1F, 0x80, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x03, 0xF1,
  0xF8, 0x0F, 0x80, 0xFC, 0x7C, 0x03, 0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0x0F,
  0xCF, 0xC0, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x80, 0xFC, 0xFC, 0x07, 0xE0,
  0x3F, 0x3F, 0x01, 0xF0, 0x0F, 0xCF, 0x80, 0x7C, 0x03, 0xF3, 0xE0, 0x1F,
  0x00, 0xFD, 0xF8, 0x0F, 0xC0, 0x3F, 0x7E, 0x03, 0xF0, 0x0F, 0xDF, 0x80,
  0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0x01, 0xF9, 0xF0, 0x0F, 0x80, 0x7E, 0x7C,
  0x03, 0xE0, 0x1F, 0xBF, 0x01, 0xF8, 0x07, 0xCF, 0xC0, 0x7E, 0x03, 0xF3,
  0xF0, 0x1F, 0x80, 0xFC, 0xFC, 0x0F, 0xE0, 0x3E, 0x3F, 0x03, 0xF8, 0x1F,
  0x8F, 0xC1, 0xFE, 0x0F, 0xC3, 0xF8, 0xFF, 0x83, 0xF0, 0xFF, 0xFB, 0xE1,
  0xF8, 0x3F, 0xFE, 0xFF, 0xFC, 0x0F, 0xFF, 0x3F, 0xFE, 0x01, 0xFF, 0x87,
  0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x03, 0xFF, 0x07,
  0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE7, 0xFF, 0xE0, 0xFF, 0xDF, 0x9E, 0x1F, 0x87, 0xFC, 0x3E, 0xF0,
  0x7F, 0x3F, 0xE0, 0xFB, 0x80, 0xFC, 0x7E, 0x03, 0xEE, 0x03, 0xF0, 0xE0,
  0x0F, 0xB0, 0x0F, 0xC1, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0x18,
  0x3F, 0x00, 0xFF, 0x00, 0xF0, 0xFC, 0x07, 0x7C, 0x0F, 0xE3, 0xF0, 0x1D,
  0xF0, 0x7F, 0x8F, 0xC0, 0xE7, 0xC3, 0xFC, 0x3F, 0x87, 0x9F, 0xBF, 0xE0,
  0xFF, 0xFE, 0x7F, 0xFF, 0x01, 0xFF, 0xF1, 0xFF, 0xF8, 0x07, 0xFF, 0x83,
  0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x07, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F,
  0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFE, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xFC, 0x03, 0xF8, 0x07, 0x7F, 0x00, 0xFF, 0x83, 0xDF, 0xC0,
  0x3F, 0xFF, 0xE7, 0xE0, 0x07, 0xFF, 0xF9, 0xF8, 0x01, 0xFF, 0xFC, 0xFE,
  0x00, 0x3F, 0xFE, 0x3F, 0x80, 0x07, 0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x06, 0x00, 0x07, 0xF8, 0x03, 0xC0,
  0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x0F, 0xC0, 0x3F, 0xFF, 0x07, 0xF0, 0x1F, 0xFF, 0xF1, 0xFC, 0x0F, 0xFF,
  0xFE, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE,
  0x07, 0xFF, 0xF8, 0x3F, 0x00, 0x3F, 0xFE, 0x0F, 0xC0, 0x03, 0xFE, 0x03,
  0xE0, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x60, 0x00, 0x7F,
  0x80, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0x00, 0x3F, 0xC0, 0x07, 0xC0, 0x1F,
  0xE0, 0x01, 0xF8, 0x0F, 0xF0, 0x00, 0x3E, 0x07, 0xFF, 0x00, 0x0F, 0x87,
  0xFF, 0xFE, 0x03, 0xE1, 0xFF, 0xFF, 0xF8, 0xFC, 0x7E, 0xFF, 0xFF, 0xFE,
  0x1F, 0x8F, 0xFF, 0xFF, 0x87, 0xE0, 0x7F, 0xFF, 0xE3, 0xF8, 0x07, 0xFF,
  0xF0, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x7F, 0xC0,
  0x01, 0xF0, 0x3F, 0xF8, 0x00, 0xFC, 0x1F, 0xFF, 0x00, 0x3F, 0x0F, 0xFF,
  0xE0, 0x0F, 0x87, 0xFF, 0xF8, 0x07, 0xE1, 0xFC, 0x7F, 0x01, 0xF8, 0xFE,
  0x0F, 0xE0, 0xFC, 0x3F, 0x03, 0xFC, 0x7F, 0x1F, 0x80, 0x7F, 0xFF, 0x87,
  0xE0, 0x0F, 0xFF, 0xC1, 0xF0, 0x03, 0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0xF8,
  0x3F, 0x00, 0x0F, 0xF8, 0x01, 0x80, 0x00, 0xFC, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 16, 45, 38, 11, -44 },
  { 91, 21, 19, 38, 12, -47 },
  { 141, 39, 44, 38, 0, -44 },
  { 356, 36, 58, 38, 1, -51 },
  { 617, 44, 46, 38, -2, -45 },
  { 870, 37, 46, 38, 0, -45 },
  { 1083, 9, 19, 38, 18, -47 },
  { 1105, 25, 57, 38, 12, -48 },
  { 1284, 25, 57, 38, 2, -48 },
  { 1463, 33, 31, 38, 3, -35 },
  { 1591, 31, 32, 38, 4, -35 },
  { 1715, 16, 19, 38, 8, -10 },
  { 1753, 20, 6, 38, 9, -22 },
  { 1768, 11, 10, 38, 11, -9 },
  { 1782, 37, 57, 38, 1, -48 },
  { 2046, 33, 46, 38, 3, -45 },
  { 2236, 31, 44, 38, 3, -44 },
  { 2407, 34, 45, 38, 1, -45 },
  { 2599, 34, 46, 38, 1, -45 },
  { 2795, 34, 44, 38, 1, -44 },
  { 2982, 35, 45, 38, 2, -44 },
  { 3179, 32, 45, 38, 3, -44 },
  { 3359, 32, 44, 38, 6, -44 },
  { 3535, 34, 46, 38, 2, -45 },
  { 3731, 31, 45, 38, 5, -45 },
  { 3906, 15, 34, 38, 11, -33 },
  { 3970, 18, 42, 38, 8, -33 },
  { 4065, 31, 37, 38, 5, -38 },
  { 4209, 33, 19, 38, 3, -29 },
  { 4288, 31, 37, 38, 3, -38 },
  { 4432, 28, 46, 38, 7, -45 },
  { 4593, 33, 52, 38, 3, -45 },
  { 4808, 35, 44, 38, -1, -44 },
  { 5001, 33, 44, 38, 3, -44 },
  { 5183, 33, 46, 38, 4, -45 },
  { 5373, 33, 44, 38, 3, -44 },
  { 5555, 34, 44, 38, 3, -44 },
  { 5742, 35, 44, 38, 3, -44 },
  { 5935, 32, 46, 38, 4, -45 },
  { 6119, 36, 44, 38, 2, -44 },
  { 6317, 35, 44, 38, 2, -44 },
  { 6510, 33, 45, 38, 3, -44 },
  { 6696, 39, 44, 38, 2, -44 },
  { 6911, 28, 44, 38, 4, -44 },
  { 7065, 38, 44, 38, 1, -44 },
  { 7274, 36, 44, 38, 2, -44 },
  { 7472, 33, 46, 38, 3, -45 },
  { 7662, 34, 44, 38, 3, -44 },
  { 7849, 33, 57, 38, 3, -45 },
  { 8085, 34, 44, 38, 3, -44 },
  { 8272, 36, 46, 38, 1, -45 },
  { 8479, 36, 44, 38, 5, -44 },
  { 8677, 34, 45, 38, 4, -44 },
  { 8869, 35, 44, 38, 6, -44 },
  { 9062, 39, 44, 38, 2, -44 },
  { 9277, 42, 44, 38, -1, -44 },
  { 9508, 37, 44, 38, 5, -44 },
  { 9712, 38, 44, 38, 0, -44 },
  { 9921, 28, 57, 38, 9, -48 },
  { 10121, 17, 57, 38, 11, -48 },
  { 10243, 28, 57, 38, 1, -48 },
  { 10443, 33, 27, 38, 3, -44 },
  { 10555, 31, 6, 38, 0, 5 },
  { 10579, 10, 13, 38, 13, -49 },
  { 10596, 32, 34, 38, 3, -33 },
  { 10732, 32, 48, 38, 3, -47 },
  { 10924, 29, 34, 38, 4, -33 },
  { 11048, 35, 48, 38, 3, -47 },
  { 11258, 30, 34, 38, 4, -33 },
  { 11386, 42, 60, 38, -1, -47 },
  { 11701, 34, 46, 38, 1, -33 },
  { 11897, 31, 47, 38, 3, -47 },
  { 12080, 29, 49, 38, 5, -48 },
  { 12258, 31, 61, 38, 2, -48 },
  { 12495, 33, 48, 38, 3, -47 },
  { 12693, 27, 48, 38, 6, -47 },
  { 12855, 36, 33, 38, 0, -33 },
  { 13004, 31, 33, 38, 3, -33 },
  { 13132, 31, 34, 38, 3, -33 },
  { 13264, 35, 46, 38, 0, -33 },
  { 13466, 32, 46, 38, 3, -33 },
  { 13650, 31, 33, 38, 6, -33 },
  { 13778, 31, 34, 38, 3, -33 },
  { 13910, 29, 45, 38, 5, -44 },
  { 14074, 31, 34, 38, 4, -33 },
  { 14206, 31, 34, 38, 3, -33 },
  { 14338, 34, 34, 38, 2, -33 },
  { 14483, 38, 34, 38, 0, -33 },
  { 14645, 34, 46, 38, 1, -33 },
  { 14841, 34, 34, 38, 2, -33 },
  { 14986, 30, 57, 38, 7, -48 },
  { 15200, 15, 57, 38, 12, -48 },
  { 15307, 30, 57, 38, 2, -48 },
  { 15521, 34, 15, 38, 2, -27 },
};

const GFXfont IBMPlexMono_MediumItalic63pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic63pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic63pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _IBMPLEXMONO_MEDIUMITALIC63PT7B_H_
