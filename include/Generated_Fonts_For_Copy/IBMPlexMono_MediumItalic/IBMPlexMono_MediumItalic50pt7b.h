#ifndef _IBMPLEXMONO_MEDIUMITALIC50PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x3F, 0x81, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFC, 0x00,
  0x1F, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0,
  0x78, 0xF8, 0x7C, 0x78, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF,
  0x83, 0xC7, 0xC3, 0xE3, 0xC1, 0xF3, 0xE0, 0xF8, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x7C, 0x1E, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF,
  0xC1, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0x80, 0x1E, 0x0F, 0x80, 0x00, 0x7C,
  0x1E, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC1,
  0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F,
  0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x07,
  0xF9, 0xEF, 0xF0, 0x7E, 0x1E, 0x3F, 0x0F, 0xC1, 0xC0, 0xC0, 0xFC, 0x1C,
  0x08, 0x0F, 0x81, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0xFC, 0x3C, 0x00, 0x0F, 0xE3, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x3F, 0xC0, 0x00,
  0xF0, 0xFC, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x0E, 0x07,
  0xC1, 0x00, 0xE0, 0x7C, 0x18, 0x1E, 0x0F, 0xC7, 0xC1, 0xE0, 0xFC, 0xFE,
  0x1E, 0x1F, 0x8F, 0xF9, 0xE7, 0xF8, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x7C, 0x03, 0xFF, 0x80, 0x0F, 0x00, 0xFF, 0xF8, 0x03, 0xE0, 0x3E,
  0x1F, 0x00, 0xF8, 0x07, 0x81, 0xE0, 0x1E, 0x00, 0xF0, 0x3C, 0x07, 0xC0,
  0x3E, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x3C, 0x00, 0xF0, 0x1E, 0x0F,
  0x80, 0x1E, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0xF8, 0x78, 0x00, 0x78, 0x1E,
  0x1F, 0x00, 0x0F, 0x87, 0xC3, 0xC0, 0x00, 0xFF, 0xF0, 0xF0, 0x00, 0x1F,
  0xFC, 0x3E, 0x00, 0x01, 0xFF, 0x07, 0x80, 0x00, 0x0F, 0x81, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE1, 0xFF,
  0x80, 0x00, 0x78, 0x7F, 0xF8, 0x00, 0x1F, 0x1F, 0xFF, 0x00, 0x03, 0xC3,
  0xE1, 0xE0, 0x00, 0xF0, 0xF8, 0x1E, 0x00, 0x3E, 0x1E, 0x03, 0xC0, 0x07,
  0x83, 0xC0, 0x78, 0x01, 0xE0, 0xF8, 0x1F, 0x00, 0x7C, 0x1E, 0x03, 0xE0,
  0x0F, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF8, 0x0F, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0xF8, 0x07, 0xC0, 0x1F, 0xFF, 0x01, 0xF0, 0x03,
  0xFF, 0xC0, 0x3C, 0x00, 0x3F, 0xF0, 0x08, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0,
  0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x3E, 0x3E, 0x00, 0x0F, 0xFB, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x80,
  0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0x00, 0xFC, 0x0C, 0xFC, 0x03, 0xF0, 0x7F,
  0xF0, 0x0F, 0xC1, 0xEF, 0xC0, 0x2F, 0x8F, 0x1F, 0x01, 0xBE, 0x3C, 0x7E,
  0x0E, 0x7D, 0xE0, 0xFF, 0xF1, 0xFF, 0x83, 0xFF, 0x83, 0xFC, 0x07, 0xFC,
  0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xDF,
  0x3E, 0x7C, 0xF9, 0xF3, 0xEF, 0x9F, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0xC0, 0x3C, 0x03, 0x3E, 0x0F, 0x07, 0xDF,
  0xF7, 0xCF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F,
  0x81, 0xF0, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x38, 0x03, 0xC0,
  0x04, 0x00, 0x40, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0x83, 0xFC,
  0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0x3E, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7C, 0xF8,
  0x00, 0x1F, 0x7E, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x1E, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0,
  0xFF, 0xF0, 0xFC, 0x3E, 0xF8, 0x7F, 0x1F, 0xBE, 0x0F, 0x87, 0xEF, 0x80,
  0x01, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xCF,
  0x80, 0x03, 0xF3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x1F, 0xC1, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xEF, 0x80, 0x0F, 0xE7, 0xC0, 0x0F, 0xE3,
  0xE0, 0x0F, 0xE3, 0xF0, 0x1F, 0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xE0,
  0x7C, 0x00, 0xE0, 0x3E, 0x00, 0x20, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0x70, 0x00, 0xFC,
  0x02, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC1, 0xF8, 0x03, 0xF8, 0x1E, 0x00, 0x3F, 0x01, 0x80, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x08,
  0x00, 0x0F, 0xC1, 0x80, 0x03, 0xF8, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x1F,
  0xC3, 0xF8, 0x0F, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0x7C,
  0x00, 0x0F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0xC0,
  0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x78, 0x00, 0xF8, 0x1F,
  0x00, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x0F, 0xC0, 0x03, 0xC7, 0xFE, 0x00, 0x7B,
  0xFF, 0xE0, 0x1F, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0x03, 0xFC,
  0x0F, 0xC0, 0x1F, 0xC2, 0x60, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x40, 0x00, 0x7E, 0x0C, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xF1, 0xFC, 0x01,
  0xFC, 0x3F, 0xC0, 0x7F, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x8F,
  0xE0, 0x1F, 0x3F, 0xF8, 0x3F, 0x7F, 0xFC, 0x3E, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0xFC, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x03, 0xF8,
  0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00,
  0x1F, 0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x01,
  0xF0, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x01, 0xFC, 0x07, 0xE0, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F,
  0x9F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xCF, 0xC0,
  0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xC7, 0xF8, 0x0F, 0xF0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFE, 0x07, 0xF8,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0x7F, 0x80,
  0xFF, 0x9F, 0xFF, 0xEF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xF7, 0xE0, 0xFF,
  0xE7, 0xE0, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFE, 0x1F, 0xE0, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x7F, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x0F,
  0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0x80, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x00,
  0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF0, 0x04, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xFE, 0x0F,
  0xE7, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x60, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x81, 0xF8, 0x07, 0xC0, 0x0F, 0x81, 0xF0,
  0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0x7C,
  0x7C, 0x07, 0x8F, 0x8F, 0x03, 0xFD, 0xF1, 0xE0, 0xFF, 0xBC, 0x7C, 0x3F,
  0xF7, 0x8F, 0x87, 0xC3, 0xF1, 0xE1, 0xF0, 0x3E, 0x3C, 0x3E, 0x07, 0xCF,
  0x8F, 0x80, 0xF9, 0xF1, 0xF0, 0x1E, 0x3E, 0x3E, 0x03, 0xC7, 0xC7, 0xC0,
  0x78, 0xF0, 0xF0, 0x0F, 0x1E, 0x1E, 0x03, 0xE3, 0xC3, 0xC0, 0x7C, 0x78,
  0x78, 0x0F, 0x1F, 0x0F, 0x03, 0xE3, 0xE1, 0xF0, 0xFC, 0x7C, 0x3F, 0x77,
  0x8F, 0x87, 0xFF, 0xF1, 0xF0, 0x7F, 0xBE, 0x3E, 0x07, 0xE7, 0xC3, 0xC0,
  0x20, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE0,
  0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0xC0,
  0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x07, 0xE1, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xF0, 0x07, 0xF0, 0x7C,
  0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0,
  0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07,
  0xE1, 0xF8, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x0F,
  0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F,
  0x8F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x7C, 0x00,
  0x7F, 0x1F, 0x00, 0x3F, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x10, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x02,
  0x03, 0xF0, 0x00, 0x70, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF0,
  0x07, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x00,
  0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0x3E,
  0x00, 0x1F, 0x87, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x87, 0xE0, 0x0F, 0xE0, 0xF8, 0x07, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01,
  0xFE, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F,
  0xC7, 0xE0, 0x01, 0xE3, 0xF0, 0x00, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0xF3, 0xF0, 0x3F, 0xFC,
  0xFC, 0x0F, 0xFF, 0x3F, 0x03, 0xFF, 0xCF, 0xC0, 0xFF, 0xF3, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xF0,
  0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x0F, 0xC1,
  0xF8, 0x07, 0xF0, 0x7F, 0x03, 0x7C, 0x0F, 0xFF, 0xDF, 0x01, 0xFF, 0xE7,
  0xC0, 0x3F, 0xF1, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E,
  0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC1, 0xF8,
  0x00, 0x7C, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F,
  0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xE0, 0x01,
  0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x07,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0,
  0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x03, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF8,
  0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F,
  0x00, 0x3F, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xF8, 0x03, 0xF8, 0x03, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x3E, 0x0F, 0xE0, 0x00, 0x7C, 0x3F, 0x80, 0x00, 0xF8, 0xFE,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x1F, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xBE, 0x00, 0x03, 0xFE, 0x7E, 0x00, 0x07, 0xF8, 0xFC, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7F, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x01, 0xFE, 0x07,
  0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xBC, 0x1E, 0xF0, 0x3E, 0xF0, 0xF3, 0xC0, 0xFB, 0xC3,
  0xDF, 0x03, 0xCF, 0x1E, 0x7C, 0x1F, 0x3E, 0xF9, 0xF0, 0x7C, 0x7B, 0xC7,
  0xC1, 0xF1, 0xFF, 0x1E, 0x07, 0xC7, 0xF8, 0xF8, 0x1F, 0x1F, 0xE3, 0xE0,
  0x78, 0x3F, 0x0F, 0x83, 0xE0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x03, 0xC0, 0xF8, 0x3C, 0x1F, 0x03, 0xE0, 0x60, 0x7C, 0x0F, 0x01,
  0x81, 0xF0, 0x7C, 0x04, 0x07, 0xC1, 0xF0, 0x10, 0x1F, 0x07, 0xC0, 0x00,
  0x78, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x01, 0xF0,
  0x7F, 0x80, 0x1F, 0x07, 0xF8, 0x01, 0xF0, 0x7F, 0x80, 0x1E, 0x07, 0xF8,
  0x03, 0xE0, 0xFF, 0xC0, 0x3E, 0x0F, 0xFC, 0x03, 0xE0, 0xFF, 0xC0, 0x3E,
  0x0F, 0xBC, 0x03, 0xE0, 0xFB, 0xC0, 0x3C, 0x0F, 0xBE, 0x07, 0xC1, 0xF3,
  0xE0, 0x7C, 0x1F, 0x3E, 0x07, 0xC1, 0xF1, 0xE0, 0x7C, 0x1F, 0x1F, 0x07,
  0xC1, 0xF1, 0xF0, 0x78, 0x1F, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x3E,
  0x0F, 0x0F, 0x83, 0xE0, 0xF8, 0xF8, 0x3E, 0x0F, 0x8F, 0x83, 0xE0, 0xF8,
  0xF0, 0x3E, 0x0F, 0x9F, 0x07, 0xC0, 0x79, 0xF0, 0x7C, 0x07, 0xDF, 0x07,
  0xC0, 0x7D, 0xF0, 0x7C, 0x07, 0xDF, 0x07, 0xC0, 0x7F, 0xE0, 0x7C, 0x03,
  0xFE, 0x0F, 0x80, 0x3F, 0xE0, 0xF8, 0x03, 0xFE, 0x0F, 0x80, 0x3F, 0xE0,
  0xF8, 0x03, 0xFE, 0x0F, 0x80, 0x1F, 0xC0, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x7F, 0x00,
  0x3E, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xF8,
  0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xEF, 0x80,
  0x01, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xCF,
  0x80, 0x03, 0xF3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xC0, 0x1F, 0xC1, 0xF0, 0x01, 0xF8,
  0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x3F, 0x00,
  0x0F, 0x87, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC3,
  0xE0, 0x03, 0xF0, 0xFC, 0x01, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0x3E, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xF8,
  0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xEF, 0x80,
  0x01, 0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xCF,
  0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x7F,
  0x07, 0xF0, 0x7F, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x81, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xC0,
  0x1F, 0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1,
  0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0xF8, 0x00,
  0x7E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xFC, 0x01, 0xFE, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xF8,
  0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x07, 0xC0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x00,
  0x3F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0x80,
  0xFF, 0x07, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x1C, 0x0F, 0xC0, 0x00, 0x80,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC1, 0x00, 0x00, 0xFC, 0x18, 0x00, 0x0F, 0x87, 0xC0, 0x01,
  0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xF8, 0x0F, 0xF0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xFC,
  0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x3F, 0x00,
  0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC3,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F,
  0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x87, 0xE0,
  0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF8,
  0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00,
  0x3F, 0x0F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x07,
  0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0x80, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x0F, 0x80, 0x1F,
  0x03, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xC3, 0xE0,
  0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C,
  0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x7C, 0x00,
  0x01, 0xF1, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x78, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E,
  0x3E, 0x0F, 0xC0, 0xF0, 0xF8, 0x3F, 0x07, 0xC3, 0xE0, 0xFC, 0x1F, 0x0F,
  0x07, 0xF0, 0x7C, 0x3C, 0x1F, 0xC1, 0xE0, 0xF0, 0x7F, 0x07, 0x87, 0xC3,
  0xFC, 0x3E, 0x1F, 0x0F, 0xF0, 0xF8, 0x7C, 0x3B, 0xC3, 0xC1, 0xF1, 0xEF,
  0x0F, 0x07, 0xC7, 0xBC, 0x7C, 0x1F, 0x3C, 0xF1, 0xF0, 0x7C, 0xF3, 0xC7,
  0x81, 0xE3, 0xCF, 0x1E, 0x07, 0x9E, 0x3C, 0x78, 0x1E, 0x78, 0xF3, 0xE0,
  0x79, 0xE1, 0xCF, 0x83, 0xEF, 0x07, 0x3C, 0x0F, 0xBC, 0x1C, 0xF0, 0x3E,
  0xF0, 0x77, 0xC0, 0xFF, 0x81, 0xDF, 0x03, 0xFE, 0x07, 0x78, 0x0F, 0xF8,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x7C, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0x9F,
  0x80, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xF0, 0x07,
  0x80, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x7E, 0x00,
  0x0F, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x1F,
  0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x07, 0xE0,
  0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x9F,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x1F, 0x30, 0x00, 0x06,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x08, 0x1C, 0xFC, 0x7C, 0x7E, 0x3E, 0x1E, 0x1F,
  0x0F, 0x0F, 0x04, 0x00, 0x7E, 0x0F, 0xC0, 0x7F, 0xE3, 0xE0, 0x3F, 0xFC,
  0xF8, 0x1F, 0xFF, 0xBE, 0x0F, 0xE0, 0xEF, 0x87, 0xE0, 0x0F, 0xE1, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC7,
  0xE0, 0x01, 0xF1, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x1F, 0x00, 0x0F,
  0x8F, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x0F, 0xE1, 0xF0, 0x03, 0xF0, 0x7C, 0x01, 0xFC, 0x1F,
  0x80, 0xDF, 0x07, 0xF0, 0xF7, 0xF8, 0xFF, 0xF9, 0xFE, 0x3F, 0xFC, 0x7F,
  0x87, 0xFE, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0x87,
  0xFE, 0x03, 0xE3, 0xFF, 0xC0, 0xF9, 0xFF, 0xF0, 0x3E, 0xE0, 0xFE, 0x1F,
  0xF0, 0x1F, 0x87, 0xF8, 0x03, 0xE1, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF8, 0xF8,
  0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xC7, 0xE0, 0x03, 0xF1,
  0xF8, 0x01, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x60, 0x7F, 0x0F, 0xDF, 0xFF,
  0x83, 0xF3, 0xFF, 0xC0, 0xF8, 0x7F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F,
  0xE0, 0xFE, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3D, 0x3F, 0x00, 0x10, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x10, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x7E, 0x7C,
  0x00, 0x7C, 0x7E, 0x01, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x07,
  0xF0, 0x7C, 0x01, 0xFF, 0x8F, 0xC0, 0x3F, 0xFC, 0xFC, 0x07, 0xFF, 0xEF,
  0x80, 0xFE, 0x06, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x01,
  0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0xFE, 0x07, 0xC0, 0x1F, 0xE0,
  0x7E, 0x03, 0xFC, 0x07, 0xF0, 0x77, 0xC0, 0x3F, 0xFF, 0x7C, 0x03, 0xFF,
  0xE7, 0xC0, 0x1F, 0xF8, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F,
  0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7C, 0x00, 0xFE, 0x7C, 0x0F, 0xFC, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x18, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x7E,
  0x7E, 0x00, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x83, 0xE0, 0x1F, 0xFC, 0xFC, 0x07, 0xFF, 0xDF, 0x81, 0xFF,
  0xFB, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF0, 0xFC, 0x00,
  0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xE3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x07, 0xC0, 0x07,
  0xE0, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x0F, 0xF0, 0x7F,
  0x07, 0x7C, 0x07, 0xFF, 0xCF, 0x80, 0x7F, 0xF9, 0xF0, 0x0F, 0xFC, 0x3E,
  0x00, 0x7F, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x04, 0x00, 0x3E, 0x01, 0xC0, 0x0F, 0xC0,
  0x7E, 0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x7F, 0xC0, 0x7E, 0x7F,
  0xF0, 0x3E, 0x7F, 0xFC, 0x1F, 0x70, 0xFE, 0x0F, 0xB0, 0x3F, 0x0F, 0xF0,
  0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3,
  0xF0, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0x7E,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0xC0, 0x3F, 0x03,
  0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xE3, 0xF0,
  0x0F, 0xCF, 0xC0, 0x1F, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x30, 0x0F, 0xC0,
  0x78, 0x0F, 0x80, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x3F, 0x0F, 0x80,
  0x1F, 0x1F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xDF, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0xFC, 0x7F, 0xE0, 0x1F, 0x9F, 0xFE, 0x03, 0xE7, 0xFF, 0xC0,
  0x7D, 0xC1, 0xF8, 0x0F, 0xB0, 0x1F, 0x83, 0xFC, 0x03, 0xF0, 0x7F, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x07,
  0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x07, 0xE1, 0xFC,
  0x00, 0xF9, 0xFC, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0xFC,
  0x3E, 0x03, 0x1F, 0x87, 0xC0, 0xF3, 0xF0, 0xFC, 0x3F, 0x7C, 0x0F, 0x8F,
  0x8F, 0x81, 0xFB, 0xE1, 0xF0, 0x1F, 0xFC, 0x7E, 0x03, 0xFE, 0x0F, 0xC0,
  0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x18, 0x1F, 0x01, 0xE0, 0xF8, 0x1F, 0x87, 0xC1,
  0xF8, 0x7E, 0x1F, 0x83, 0xF1, 0xF8, 0x1F, 0x9F, 0x80, 0xF9, 0xF8, 0x07,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x8F,
  0x03, 0xE0, 0x7C, 0xFC, 0x3F, 0x83, 0xEF, 0xF3, 0xFE, 0x1E, 0xFF, 0xBF,
  0xF0, 0xF4, 0x7F, 0x8F, 0x8F, 0xC1, 0xF8, 0x7C, 0x7E, 0x0F, 0x83, 0xE3,
  0xE0, 0x7C, 0x1F, 0x1F, 0x07, 0xC0, 0xF8, 0xF0, 0x3E, 0x07, 0x87, 0x81,
  0xF0, 0x3C, 0x7C, 0x0F, 0x81, 0xE3, 0xE0, 0x78, 0x1F, 0x1F, 0x03, 0xC0,
  0xF8, 0xF8, 0x3E, 0x07, 0xC7, 0x81, 0xF0, 0x3C, 0x3C, 0x0F, 0x81, 0xE3,
  0xE0, 0x7C, 0x0F, 0x1F, 0x03, 0xC0, 0xF8, 0xF8, 0x1E, 0x07, 0xC7, 0xC1,
  0xF0, 0x3E, 0x3C, 0x0F, 0x81, 0xE1, 0xE0, 0x7C, 0x0F, 0x1F, 0x03, 0xE0,
  0xF8, 0xF8, 0x1E, 0x07, 0xC7, 0xC0, 0xF0, 0x3E, 0x00, 0x0F, 0xC1, 0xF8,
  0x07, 0xE3, 0xFE, 0x03, 0xF3, 0xFF, 0x81, 0xF3, 0xFF, 0xE0, 0xFB, 0x87,
  0xF0, 0x7D, 0x81, 0xF8, 0x7F, 0x80, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0,
  0x01, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0x80,
  0x7E, 0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0x7C, 0x01,
  0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x1F, 0xF8, 0x03,
  0xE3, 0xFF, 0xC0, 0x3E, 0x7F, 0xFC, 0x03, 0xEE, 0x0F, 0xE0, 0x7F, 0xC0,
  0x7E, 0x07, 0xF8, 0x03, 0xE0, 0x7F, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7E,
  0x0F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xC1, 0xF8,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0x60, 0x7F,
  0x03, 0xF7, 0xFF, 0xE0, 0x3F, 0x3F, 0xFC, 0x03, 0xE1, 0xFF, 0x80, 0x3E,
  0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x07, 0xC0, 0x7F, 0xE3, 0xF0, 0x3F, 0xFC, 0xFC, 0x1F, 0xFF, 0xBE, 0x0F,
  0xE0, 0x6F, 0x87, 0xF0, 0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7E,
  0x3E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0,
  0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE1,
  0xF0, 0x03, 0xF8, 0x7C, 0x01, 0xFE, 0x1F, 0x80, 0xFF, 0x07, 0xF0, 0x77,
  0xC0, 0xFF, 0xF9, 0xF0, 0x3F, 0xFC, 0x7C, 0x07, 0xFE, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0xF8, 0x3F, 0xBF, 0xFC,
  0x7F, 0xBF, 0xFC, 0x7F, 0xDF, 0xFE, 0x7F, 0xE0, 0x1F, 0x7F, 0xF0, 0x0F,
  0xB8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x00, 0x70,
  0x3E, 0x00, 0x10, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x82, 0x00, 0x07, 0xC3, 0x80, 0x03, 0xE3, 0xE0,
  0x03, 0xF3, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x30, 0x1F, 0x00, 0xF0,
  0x7E, 0x07, 0xF0, 0xFC, 0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xE3, 0xF8, 0x07,
  0xCF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0xFC,
  0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x8F, 0xC0, 0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x3F, 0x00,
  0x3F, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x3F, 0x83, 0xF0, 0x37, 0xC1, 0xFC,
  0x3B, 0xE0, 0xFF, 0xF9, 0xF0, 0x3F, 0xF9, 0xF8, 0x0F, 0xF8, 0xFC, 0x01,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x06, 0xFF, 0xC0, 0x3E, 0xFF, 0xC0, 0x7E,
  0xFF, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F,
  0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3E,
  0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x1F, 0x01, 0xF8,
  0x3F, 0x03, 0xF8, 0x3F, 0x07, 0xF0, 0x3E, 0x0F, 0xE0, 0x3E, 0x3F, 0xC0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x03, 0xC0, 0x41, 0xF0, 0x3C, 0x3E, 0x1F, 0x03, 0xC3, 0xE1, 0xF0,
  0x7C, 0x1E, 0x1F, 0x07, 0xC1, 0xE1, 0xE0, 0x7C, 0x1E, 0x1E, 0x07, 0x81,
  0xF1, 0xE0, 0x78, 0x1F, 0x3E, 0x07, 0x81, 0xF3, 0xE0, 0xF8, 0x1F, 0x3E,
  0x0F, 0x81, 0xE3, 0xC0, 0xF8, 0x1E, 0x3C, 0x0F, 0x01, 0xE3, 0xC0, 0xF0,
  0x1E, 0x7C, 0x0F, 0x01, 0xE7, 0xC0, 0xF0, 0x3E, 0x7C, 0x1F, 0x03, 0xC7,
  0x81, 0xF0, 0x3C, 0x78, 0x1F, 0x03, 0xC7, 0x81, 0xE0, 0x78, 0x78, 0x3E,
  0x07, 0x8F, 0x82, 0xE0, 0xF0, 0x7C, 0xEE, 0x0F, 0x07, 0xFC, 0xF1, 0xE0,
  0x7F, 0xCF, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x03, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xF0, 0xFF, 0x81, 0xFF,
  0xC7, 0xFF, 0x0F, 0xEF, 0xBC, 0x7C, 0xFE, 0x3E, 0xE1, 0xF1, 0xF0, 0xFB,
  0x07, 0xC7, 0x01, 0xF8, 0x1F, 0x10, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x81,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0xE0, 0x7F, 0x00, 0x0F, 0x81, 0xFC, 0x04, 0x3E, 0x07,
  0xF0, 0x38, 0xF8, 0x37, 0xC3, 0xF3, 0xE1, 0xDF, 0x1F, 0x8F, 0xCF, 0x3D,
  0xFC, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x07, 0xF0,
  0x01, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xFC,
  0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x80,
  0x0F, 0x83, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x81,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x01,
  0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F,
  0x00, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x01, 0xFC, 0x0F, 0x80, 0x7F,
  0x81, 0xF8, 0x1B, 0xE0, 0x3F, 0x87, 0x7C, 0x07, 0xFF, 0xCF, 0x80, 0x7F,
  0xF1, 0xF0, 0x07, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x08, 0x00,
  0x7E, 0x01, 0xC0, 0x1F, 0xC0, 0x7C, 0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x07, 0xC1, 0xFF, 0xE1, 0xF0, 0xFF, 0xFE, 0x7C, 0x3F, 0xFF, 0xFF, 0x1F,
  0x07, 0xFF, 0xC7, 0x80, 0x3F, 0xE1, 0xE0, 0x03, 0xF0, 0x78, 0x01, 0xF8,
  0x1E, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x18, 0x01, 0xF8, 0x1E, 0x01, 0xFC, 0x07, 0xC0, 0xFE, 0x00, 0xF0,
  0x7F, 0x00, 0x3C, 0x3F, 0x80, 0x0F, 0x1F, 0xFE, 0x03, 0xEF, 0xBF, 0xFC,
  0xFB, 0xE3, 0xFF, 0xFC, 0xF8, 0x1F, 0xFF, 0x3E, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xE0,
  0x01, 0x80, 0xFF, 0x00, 0x7C, 0x7F, 0xF0, 0x0F, 0x0F, 0xFF, 0x01, 0xE3,
  0xE3, 0xE0, 0x7C, 0xF8, 0x3E, 0x1F, 0x1F, 0x07, 0xE7, 0xE3, 0xC0, 0x7F,
  0xF8, 0xF8, 0x07, 0xFE, 0x1E, 0x00, 0x7F, 0x80, 0xC0, 0x07, 0xC0, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 13, 36, 30, 9, -35 },
  { 60, 17, 15, 30, 9, -37 },
  { 92, 31, 35, 30, 0, -35 },
  { 228, 28, 46, 30, 1, -40 },
  { 389, 35, 37, 30, -2, -36 },
  { 551, 30, 37, 30, 0, -36 },
  { 690, 7, 15, 30, 14, -37 },
  { 704, 19, 45, 30, 10, -38 },
  { 811, 19, 45, 30, 2, -38 },
  { 918, 26, 25, 30, 2, -27 },
  { 1000, 25, 24, 30, 3, -27 },
  { 1075, 13, 15, 30, 6, -8 },
  { 1100, 16, 5, 30, 7, -18 },
  { 1110, 9, 8, 30, 9, -7 },
  { 1119, 29, 45, 30, 1, -38 },
  { 1283, 26, 37, 30, 3, -36 },
  { 1404, 25, 35, 30, 2, -35 },
  { 1514, 27, 36, 30, 1, -36 },
  { 1636, 27, 37, 30, 1, -36 },
  { 1761, 27, 35, 30, 1, -35 },
  { 1880, 27, 36, 30, 2, -35 },
  { 2002, 24, 36, 30, 3, -35 },
  { 2110, 25, 35, 30, 5, -35 },
  { 2220, 27, 37, 30, 2, -36 },
  { 2345, 25, 36, 30, 4, -36 },
  { 2458, 12, 27, 30, 9, -26 },
  { 2499, 15, 33, 30, 6, -26 },
  { 2561, 25, 29, 30, 4, -30 },
  { 2652, 26, 15, 30, 2, -23 },
  { 2701, 25, 29, 30, 2, -30 },
  { 2792, 22, 37, 30, 6, -36 },
  { 2894, 27, 42, 30, 2, -36 },
  { 3036, 28, 35, 30, -1, -35 },
  { 3159, 26, 35, 30, 2, -35 },
  { 3273, 27, 37, 30, 3, -36 },
  { 3398, 27, 35, 30, 2, -35 },
  { 3517, 28, 35, 30, 2, -35 },
  { 3640, 28, 35, 30, 2, -35 },
  { 3763, 26, 37, 30, 3, -36 },
  { 3884, 28, 35, 30, 2, -35 },
  { 4007, 28, 35, 30, 2, -35 },
  { 4130, 26, 36, 30, 2, -35 },
  { 4247, 31, 35, 30, 2, -35 },
  { 4383, 23, 35, 30, 3, -35 },
  { 4484, 30, 35, 30, 1, -35 },
  { 4616, 28, 35, 30, 2, -35 },
  { 4739, 26, 37, 30, 3, -36 },
  { 4860, 27, 35, 30, 2, -35 },
  { 4979, 26, 46, 30, 3, -36 },
  { 5129, 27, 35, 30, 2, -35 },
  { 5248, 28, 37, 30, 1, -36 },
  { 5378, 28, 35, 30, 4, -35 },
  { 5501, 27, 36, 30, 3, -35 },
  { 5623, 27, 35, 30, 5, -35 },
  { 5742, 30, 35, 30, 2, -35 },
  { 5874, 33, 35, 30, -1, -35 },
  { 6019, 29, 35, 30, 4, -35 },
  { 6146, 31, 35, 30, 0, -35 },
  { 6282, 22, 45, 30, 7, -38 },
  { 6406, 13, 45, 30, 9, -38 },
  { 6480, 22, 45, 30, 1, -38 },
  { 6604, 26, 21, 30, 3, -35 },
  { 6673, 24, 5, 30, 0, 4 },
  { 6688, 8, 11, 30, 10, -40 },
  { 6699, 26, 27, 30, 2, -26 },
  { 6787, 26, 38, 30, 2, -37 },
  { 6911, 24, 27, 30, 3, -26 },
  { 6992, 28, 38, 30, 2, -37 },
  { 7125, 24, 27, 30, 3, -26 },
  { 7206, 33, 48, 30, -1, -37 },
  { 7404, 27, 37, 30, 1, -26 },
  { 7529, 25, 37, 30, 2, -37 },
  { 7645, 23, 39, 30, 4, -38 },
  { 7758, 24, 49, 30, 2, -38 },
  { 7905, 27, 38, 30, 2, -37 },
  { 8034, 21, 38, 30, 5, -37 },
  { 8134, 29, 26, 30, 0, -26 },
  { 8229, 25, 26, 30, 2, -26 },
  { 8311, 24, 27, 30, 3, -26 },
  { 8392, 28, 36, 30, 0, -26 },
  { 8518, 26, 36, 30, 2, -26 },
  { 8635, 25, 26, 30, 5, -26 },
  { 8717, 25, 27, 30, 2, -26 },
  { 8802, 23, 36, 30, 4, -35 },
  { 8906, 25, 27, 30, 3, -26 },
  { 8991, 24, 27, 30, 3, -26 },
  { 9072, 28, 27, 30, 1, -26 },
  { 9167, 30, 27, 30, 0, -26 },
  { 9269, 27, 37, 30, 1, -26 },
  { 9394, 26, 27, 30, 2, -26 },
  { 9482, 24, 45, 30, 5, -38 },
  { 9617, 13, 45, 30, 9, -38 },
  { 9691, 24, 45, 30, 2, -38 },
  { 9826, 27, 11, 30, 2, -21 },
};

const GFXfont IBMPlexMono_MediumItalic50pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic50pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic50pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _IBMPLEXMONO_MEDIUMITALIC50PT7B_H_
