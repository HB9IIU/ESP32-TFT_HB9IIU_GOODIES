#ifndef _IBMPLEXMONO_MEDIUMITALIC17PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x33, 0x22, 0x20, 0x0E, 0xEE, 0x6D, 0x34, 0xF2, 0xD8, 0x06,
  0xC1, 0x90, 0x36, 0x3C, 0xF7, 0x9C, 0x36, 0x04, 0xC7, 0x9C, 0xF7, 0x84,
  0xC0, 0x90, 0x36, 0x00, 0x02, 0x00, 0x80, 0xF0, 0xFF, 0x36, 0xC9, 0x03,
  0x40, 0xFC, 0x0F, 0x81, 0x64, 0xDB, 0xA6, 0x7F, 0x0F, 0x80, 0x80, 0x60,
  0x1E, 0x33, 0xE2, 0x32, 0x62, 0x2C, 0x3E, 0x81, 0xD0, 0x01, 0xC0, 0xBE,
  0x12, 0x63, 0x66, 0x23, 0xCC, 0x38, 0x0F, 0x07, 0xE1, 0x98, 0x46, 0x19,
  0x8F, 0xC6, 0xC3, 0x30, 0xC6, 0xB1, 0xBF, 0xB9, 0xCE, 0x7F, 0xC0, 0x0E,
  0x30, 0xC1, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x83, 0x02, 0x06, 0x0C, 0x0C,
  0x00, 0x30, 0x60, 0xC3, 0x04, 0x10, 0x41, 0x0C, 0x30, 0x86, 0x31, 0x8C,
  0x00, 0x0C, 0x04, 0x22, 0x5F, 0xF3, 0xE1, 0xE1, 0xB1, 0x8C, 0x0C, 0x08,
  0x08, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x37, 0x64, 0xC0, 0xFF, 0xC0, 0xFF,
  0x80, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x01, 0x80, 0x60, 0x30, 0x08,
  0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x00, 0x1E, 0x1F, 0x98, 0x6C,
  0x3C, 0x1E, 0xCF, 0x67, 0x86, 0xC3, 0x63, 0xBF, 0x8F, 0x80, 0x1E, 0x3E,
  0x74, 0xE4, 0x4C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0xFF, 0xFF, 0x0F, 0x07,
  0xE3, 0x1C, 0x83, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x07, 0xFB,
  0xFE, 0x0F, 0x07, 0xE3, 0x1C, 0x02, 0x01, 0x83, 0xC0, 0xF0, 0x46, 0x41,
  0xB8, 0xE7, 0xF0, 0xF8, 0x03, 0x80, 0xE0, 0x78, 0x36, 0x19, 0x04, 0x42,
  0x31, 0x8C, 0xFF, 0xFF, 0xE0, 0x30, 0x18, 0x3F, 0x9F, 0xD8, 0x0C, 0x07,
  0xE3, 0xF9, 0x8C, 0x06, 0x83, 0x63, 0xBF, 0x8F, 0x80, 0x07, 0x1C, 0x30,
  0x20, 0x7E, 0xFF, 0xE3, 0xC3, 0xC3, 0xC7, 0xFE, 0x7C, 0xFF, 0xFF, 0x83,
  0x86, 0x04, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0xC0, 0x1F, 0x1F, 0xD8,
  0x6C, 0x36, 0x31, 0xF1, 0xF9, 0x86, 0xC3, 0x61, 0xBF, 0x8F, 0x80, 0x1E,
  0x3F, 0x98, 0x78, 0x3C, 0x1F, 0x1D, 0xFC, 0x76, 0x06, 0x06, 0x06, 0x0E,
  0x00, 0x37, 0x70, 0x00, 0xEE, 0xE0, 0x19, 0xCE, 0x00, 0x00, 0xCE, 0x62,
  0x30, 0x00, 0x81, 0x83, 0x87, 0x06, 0x03, 0x03, 0xC0, 0x38, 0x06, 0x01,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x40, 0x70, 0x38, 0x0E,
  0x03, 0x07, 0x1E, 0x78, 0xE0, 0x80, 0x3C, 0x7E, 0xC6, 0x43, 0x06, 0x1C,
  0x30, 0x30, 0x00, 0x70, 0x70, 0x60, 0x1E, 0x1F, 0x98, 0x6D, 0xFD, 0xFE,
  0xCB, 0x45, 0x26, 0x9F, 0x4F, 0xA0, 0x18, 0x07, 0xC1, 0xE0, 0x07, 0x07,
  0x83, 0xC1, 0x61, 0xB0, 0x88, 0xC4, 0x7F, 0x7F, 0xB0, 0xF0, 0x78, 0x30,
  0x3F, 0x3F, 0x98, 0x6C, 0x36, 0x33, 0xF1, 0xF9, 0x86, 0xC3, 0x61, 0xBF,
  0x9F, 0x80, 0x1E, 0x1F, 0x9C, 0x6C, 0x36, 0x06, 0x03, 0x01, 0x80, 0xC3,
  0x73, 0x9F, 0x87, 0x80, 0x3E, 0x3F, 0x98, 0xEC, 0x36, 0x1B, 0x0D, 0x07,
  0x86, 0xC3, 0x63, 0xBF, 0x9F, 0x80, 0x3F, 0xBF, 0xD8, 0x0C, 0x06, 0x03,
  0xF9, 0xFD, 0x80, 0xC0, 0x60, 0x3F, 0x9F, 0xC0, 0x3F, 0xBF, 0xD8, 0x0C,
  0x06, 0x03, 0xF9, 0xFD, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x1E, 0x1F,
  0x9C, 0x6C, 0x3C, 0x06, 0x7B, 0x3D, 0x86, 0xC3, 0x63, 0xBF, 0xCF, 0x40,
  0x61, 0xB0, 0xD8, 0x6C, 0x36, 0x13, 0xFB, 0xFD, 0x86, 0xC3, 0x61, 0xB0,
  0x90, 0xC0, 0x3F, 0xBF, 0xC3, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18,
  0x0C, 0x3F, 0x9F, 0xC0, 0x1F, 0x9F, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x0C, 0xC6, 0x63, 0x3F, 0x0F, 0x00, 0x61, 0xD8, 0xE6, 0x31, 0x98, 0x6C,
  0x1E, 0x07, 0xC3, 0xB0, 0xC6, 0x31, 0x8C, 0x33, 0x0C, 0x30, 0x30, 0x30,
  0x20, 0x60, 0x60, 0x60, 0x60, 0x60, 0x40, 0xFF, 0xFE, 0x38, 0xCE, 0x73,
  0x9C, 0xAF, 0x6A, 0xDB, 0xB6, 0xC9, 0x92, 0x49, 0x90, 0x6C, 0x1B, 0x06,
  0x71, 0xB8, 0xDC, 0x6F, 0x35, 0x92, 0xCB, 0x2D, 0x96, 0xCF, 0x67, 0xA3,
  0x90, 0xC0, 0x1E, 0x1F, 0x9C, 0x6C, 0x3C, 0x1E, 0x0F, 0x07, 0x86, 0xC3,
  0x63, 0xBF, 0x8F, 0x80, 0x3F, 0x3F, 0xD8, 0x6C, 0x36, 0x1B, 0x1D, 0xFD,
  0xFC, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x1E, 0x1F, 0x9C, 0x6C, 0x3C, 0x1E,
  0x0F, 0x07, 0x86, 0xC3, 0x63, 0xBF, 0x8F, 0x81, 0x90, 0x68, 0x3E, 0x0C,
  0x3F, 0x3F, 0xD8, 0x6C, 0x36, 0x1B, 0x1D, 0xFD, 0xFC, 0xCC, 0x63, 0x31,
  0x98, 0xE0, 0x0F, 0x0F, 0xE3, 0x0C, 0xC0, 0x30, 0x0F, 0xC0, 0xF8, 0x06,
  0x41, 0xB8, 0x67, 0xF0, 0xF8, 0x7F, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x02,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x61, 0xB0, 0xD8, 0x6C,
  0x36, 0x12, 0x1B, 0x0D, 0x86, 0xC3, 0x63, 0xBF, 0x8F, 0x80, 0xC1, 0xE1,
  0xB0, 0xD8, 0x4C, 0x66, 0x33, 0x30, 0x98, 0x58, 0x3C, 0x1C, 0x0E, 0x00,
  0x40, 0xD0, 0x3C, 0x0B, 0x32, 0xDD, 0xB5, 0x6D, 0x53, 0xD4, 0xA7, 0x29,
  0xCE, 0x73, 0x18, 0x30, 0x66, 0x18, 0x66, 0x0D, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0xF0, 0x33, 0x06, 0x61, 0x86, 0x60, 0xC0, 0xE0, 0xD8, 0x66, 0x30,
  0xCC, 0x36, 0x0F, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x3F,
  0xCF, 0xF0, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F,
  0xFB, 0xFE, 0x1F, 0x1F, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60,
  0x60, 0x40, 0x40, 0x7C, 0xF8, 0xC6, 0x30, 0x84, 0x31, 0x84, 0x21, 0x0C,
  0x61, 0x08, 0x60, 0x1F, 0x1F, 0x02, 0x02, 0x02, 0x06, 0x06, 0x06, 0x04,
  0x04, 0x04, 0x0C, 0x0C, 0xFC, 0xF8, 0x0E, 0x0F, 0x04, 0x86, 0x66, 0x32,
  0x0B, 0x06, 0xFF, 0xFF, 0xBD, 0x3B, 0x7F, 0xE3, 0xC3, 0xC3, 0xC6, 0xC6,
  0xFF, 0x73, 0x30, 0x20, 0x60, 0x60, 0x6E, 0x7F, 0x63, 0x61, 0xC3, 0xC3,
  0xC7, 0xFE, 0xDC, 0x1E, 0x7F, 0x63, 0xC0, 0xC0, 0xC2, 0xC7, 0x7E, 0x38,
  0x01, 0x80, 0xC0, 0x60, 0x33, 0xD3, 0xFB, 0x8D, 0x86, 0xC3, 0x61, 0xB3,
  0x9F, 0xC7, 0x60, 0x1E, 0x7F, 0x63, 0xC3, 0xFC, 0xC2, 0xC3, 0x7E, 0x3C,
  0x03, 0xE0, 0x7C, 0x18, 0x03, 0x03, 0xFC, 0x7F, 0x81, 0x80, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x0C, 0xC1, 0xF0, 0x1E, 0x01, 0xC0, 0x1C, 0xCF,
  0xA7, 0x19, 0x86, 0x61, 0x98, 0x66, 0x71, 0xFC, 0x3B, 0x11, 0xCF, 0xE0,
  0xF0, 0x30, 0x20, 0x60, 0x60, 0x6E, 0x7F, 0x73, 0x63, 0xC3, 0xC3, 0xC2,
  0xC2, 0xC6, 0x0C, 0x0C, 0x00, 0x00, 0xF8, 0xF8, 0x18, 0x18, 0x12, 0x13,
  0x37, 0x3E, 0x38, 0x03, 0x07, 0x00, 0x00, 0x3E, 0x3E, 0x06, 0x04, 0x04,
  0x0C, 0x0C, 0x8C, 0xCC, 0xE8, 0x78, 0x38, 0x30, 0x10, 0x18, 0x0C, 0x06,
  0xE3, 0xF9, 0xCC, 0xC6, 0xCC, 0x6C, 0xB6, 0x79, 0xEC, 0xE0, 0xF9, 0xE0,
  0xC1, 0x83, 0x06, 0x08, 0x30, 0x64, 0xCD, 0xF3, 0xC7, 0x00, 0x6D, 0xDF,
  0xF6, 0x6D, 0x93, 0x4C, 0x93, 0x2C, 0xCB, 0x26, 0xC9, 0x80, 0x6E, 0x7F,
  0x73, 0x63, 0xC3, 0xC3, 0xC2, 0xC2, 0xC6, 0x1E, 0x7F, 0x63, 0xC3, 0xC3,
  0xC3, 0xC7, 0xFE, 0x7C, 0x37, 0x1F, 0xCC, 0x66, 0x16, 0x1B, 0x0D, 0x8E,
  0xFE, 0x6E, 0x20, 0x30, 0x18, 0x00, 0x3D, 0xBF, 0xB8, 0xD8, 0x6C, 0x36,
  0x1B, 0x39, 0xFC, 0x76, 0x03, 0x01, 0x80, 0xC0, 0xF7, 0xFF, 0x38, 0x30,
  0x20, 0x60, 0x60, 0x60, 0x60, 0x3E, 0x7F, 0x62, 0x78, 0x7E, 0x0F, 0x83,
  0xFE, 0x7C, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x10, 0x30, 0x30, 0x33, 0x37,
  0x3C, 0x38, 0x61, 0x63, 0x63, 0x43, 0xC3, 0xC7, 0xC6, 0xFE, 0x76, 0xF3,
  0xE3, 0x23, 0x63, 0x63, 0x67, 0x6E, 0x7C, 0x78, 0x4D, 0x64, 0xF2, 0x73,
  0x39, 0x9C, 0xCA, 0x65, 0xF4, 0xCC, 0x00, 0x19, 0x8F, 0xF6, 0xE5, 0x31,
  0x0C, 0x33, 0x2D, 0x5F, 0xDC, 0x66, 0x00, 0x30, 0x98, 0xCC, 0x64, 0x36,
  0x1B, 0x1D, 0x8C, 0xFE, 0x3B, 0x23, 0xBF, 0x8F, 0x80, 0x3D, 0xBF, 0x91,
  0xC1, 0xC1, 0x81, 0x9B, 0xC5, 0xFE, 0x9F, 0x00, 0x1F, 0x1F, 0x10, 0x10,
  0x08, 0x08, 0xF8, 0xF0, 0x18, 0x10, 0x20, 0x60, 0x60, 0x7C, 0x78, 0x11,
  0x33, 0x32, 0x26, 0x66, 0x64, 0x4C, 0xC0, 0x3C, 0x3E, 0x04, 0x04, 0x08,
  0x10, 0x1F, 0x1F, 0x30, 0x30, 0x10, 0x18, 0x18, 0xF8, 0xF0, 0x71, 0xFC,
  0xB7, 0xD1, 0xC0,
};

const GFXglyph IBMPlexMono_MediumItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 6, 5, 10, 3, -13 },
  { 11, 11, 12, 10, 0, -12 },
  { 28, 10, 16, 10, 0, -14 },
  { 48, 12, 12, 10, -1, -12 },
  { 66, 10, 12, 10, 0, -12 },
  { 81, 2, 5, 10, 5, -13 },
  { 83, 7, 15, 10, 3, -13 },
  { 97, 6, 15, 10, 1, -13 },
  { 109, 9, 8, 10, 1, -9 },
  { 118, 8, 8, 10, 1, -9 },
  { 126, 4, 5, 10, 2, -3 },
  { 129, 5, 2, 10, 3, -6 },
  { 131, 3, 3, 10, 3, -3 },
  { 133, 10, 15, 10, 0, -13 },
  { 152, 9, 12, 10, 1, -12 },
  { 166, 8, 12, 10, 1, -12 },
  { 178, 10, 12, 10, 0, -12 },
  { 193, 10, 12, 10, 0, -12 },
  { 208, 10, 12, 10, 0, -12 },
  { 223, 9, 12, 10, 1, -12 },
  { 237, 8, 12, 10, 1, -12 },
  { 249, 8, 12, 10, 2, -12 },
  { 261, 9, 12, 10, 1, -12 },
  { 275, 9, 12, 10, 1, -12 },
  { 289, 4, 9, 10, 3, -9 },
  { 294, 5, 11, 10, 2, -9 },
  { 301, 9, 10, 10, 1, -10 },
  { 313, 9, 6, 10, 1, -8 },
  { 320, 8, 10, 10, 1, -10 },
  { 330, 8, 12, 10, 2, -12 },
  { 342, 9, 14, 10, 1, -12 },
  { 358, 9, 12, 10, 0, -12 },
  { 372, 9, 12, 10, 1, -12 },
  { 386, 9, 12, 10, 1, -12 },
  { 400, 9, 12, 10, 1, -12 },
  { 414, 9, 12, 10, 1, -12 },
  { 428, 9, 12, 10, 1, -12 },
  { 442, 9, 12, 10, 1, -12 },
  { 456, 9, 12, 10, 1, -12 },
  { 470, 9, 12, 10, 1, -12 },
  { 484, 9, 12, 10, 1, -12 },
  { 498, 10, 12, 10, 1, -12 },
  { 513, 8, 12, 10, 1, -12 },
  { 525, 10, 12, 10, 0, -12 },
  { 540, 9, 12, 10, 1, -12 },
  { 554, 9, 12, 10, 1, -12 },
  { 568, 9, 12, 10, 1, -12 },
  { 582, 9, 16, 10, 1, -12 },
  { 600, 9, 12, 10, 1, -12 },
  { 614, 10, 12, 10, 0, -12 },
  { 629, 10, 12, 10, 1, -12 },
  { 644, 9, 12, 10, 1, -12 },
  { 658, 9, 12, 10, 2, -12 },
  { 672, 10, 12, 10, 1, -12 },
  { 687, 11, 12, 10, 0, -12 },
  { 704, 10, 12, 10, 1, -12 },
  { 719, 10, 12, 10, 0, -12 },
  { 734, 8, 15, 10, 2, -13 },
  { 749, 5, 15, 10, 3, -13 },
  { 759, 8, 15, 10, 0, -13 },
  { 774, 9, 7, 10, 1, -12 },
  { 782, 8, 2, 10, 0, 1 },
  { 784, 2, 4, 10, 4, -14 },
  { 785, 8, 9, 10, 1, -9 },
  { 794, 8, 13, 10, 1, -13 },
  { 807, 8, 9, 10, 1, -9 },
  { 816, 9, 13, 10, 1, -13 },
  { 831, 8, 9, 10, 1, -9 },
  { 840, 11, 16, 10, 0, -13 },
  { 862, 10, 12, 10, 0, -9 },
  { 877, 8, 13, 10, 1, -13 },
  { 890, 8, 13, 10, 1, -13 },
  { 903, 8, 16, 10, 1, -13 },
  { 919, 9, 13, 10, 1, -13 },
  { 934, 7, 13, 10, 2, -13 },
  { 946, 10, 9, 10, 0, -9 },
  { 958, 8, 9, 10, 1, -9 },
  { 967, 8, 9, 10, 1, -9 },
  { 976, 9, 12, 10, 0, -9 },
  { 990, 9, 12, 10, 1, -9 },
  { 1004, 8, 9, 10, 2, -9 },
  { 1013, 8, 9, 10, 1, -9 },
  { 1022, 8, 12, 10, 1, -12 },
  { 1034, 8, 9, 10, 1, -9 },
  { 1043, 8, 9, 10, 1, -9 },
  { 1052, 9, 9, 10, 1, -9 },
  { 1063, 10, 9, 10, 0, -9 },
  { 1075, 9, 12, 10, 0, -9 },
  { 1089, 9, 9, 10, 1, -9 },
  { 1100, 8, 15, 10, 2, -13 },
  { 1115, 4, 15, 10, 3, -13 },
  { 1123, 8, 15, 10, 1, -13 },
  { 1138, 9, 4, 10, 1, -7 },
};

const GFXfont IBMPlexMono_MediumItalic17pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic17pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _IBMPLEXMONO_MEDIUMITALIC17PT7B_H_
