#ifndef _IBMPLEXMONO_MEDIUMITALIC39PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x07, 0xE3, 0xF8, 0xFE, 0x3F, 0x07, 0x80, 0x3C,
  0x3C, 0xF1, 0xE3, 0xC7, 0x8E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9E,
  0x3C, 0x78, 0xF1, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0x00, 0x1E, 0x1C, 0x00,
  0x1E, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x78, 0x00,
  0x38, 0x70, 0x00, 0x78, 0x70, 0x00, 0x70, 0xF0, 0x1F, 0xF0, 0xFF, 0x1F,
  0xF0, 0xFF, 0x1F, 0xE1, 0xFF, 0x01, 0xE1, 0xC0, 0x01, 0xE1, 0xC0, 0x01,
  0xC3, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0xC3, 0x80, 0x7F, 0x87, 0xFC, 0x7F,
  0x87, 0xF8, 0xFF, 0x8F, 0xF8, 0x07, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F,
  0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1C,
  0x3C, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF,
  0x03, 0xFF, 0xFE, 0x0F, 0x8C, 0xFC, 0x7C, 0x70, 0xE1, 0xE1, 0xC1, 0x07,
  0x87, 0x00, 0x1E, 0x1C, 0x00, 0x7C, 0x70, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x71, 0xF0, 0x01, 0xC3, 0xC0, 0x07, 0x0F, 0x08, 0x1C, 0x3C, 0x70,
  0x70, 0xF3, 0xE1, 0x87, 0xCF, 0xCE, 0x7E, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x7F, 0x80,
  0x78, 0x1F, 0xF8, 0x0E, 0x07, 0x87, 0x03, 0x80, 0xE0, 0xE0, 0xF0, 0x1C,
  0x1C, 0x3C, 0x07, 0x83, 0x87, 0x00, 0xF0, 0x71, 0xC0, 0x1C, 0x0E, 0x78,
  0x03, 0x83, 0xDE, 0x00, 0x78, 0xF3, 0x80, 0x07, 0xFE, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x01, 0xEF, 0x0E, 0x00, 0x39, 0xC1, 0xC0, 0x0E, 0x38, 0x38, 0x03, 0xCF,
  0x07, 0x00, 0x71, 0xE0, 0xE0, 0x1C, 0x38, 0x1C, 0x07, 0x87, 0x87, 0x81,
  0xE0, 0x71, 0xE0, 0x38, 0x0F, 0xFC, 0x0E, 0x00, 0xFF, 0x03, 0xC0, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F,
  0x8F, 0x80, 0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0,
  0x78, 0x03, 0xC0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F,
  0x00, 0x7F, 0x78, 0x03, 0xFF, 0xE0, 0x0F, 0x1E, 0x00, 0x3C, 0x3C, 0x00,
  0x78, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0xF8, 0x07, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0xFE, 0x03, 0xE3, 0xFE, 0x0D, 0xC7, 0x3E, 0x33, 0xDC, 0x7F,
  0xE7, 0xF8, 0x7F, 0x87, 0xE0, 0x3E, 0x07, 0x80, 0x3C, 0xF7, 0x9E, 0x79,
  0xE7, 0x9E, 0xF3, 0xCF, 0x3C, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x04, 0x07, 0x01, 0x78, 0x70, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7B, 0xC0,
  0x0F, 0x3C, 0x01, 0xE1, 0xE0, 0x3C, 0x1F, 0x07, 0xC0, 0xF0, 0x18, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE8, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0xC7, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x78,
  0x1E, 0x0F, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0xFF,
  0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xF8, 0x3F, 0x0F, 0x80, 0x78, 0xF8, 0x03, 0xC7,
  0x80, 0x1E, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0xE1,
  0xFF, 0x8F, 0x8F, 0x7C, 0x7C, 0x7B, 0xE3, 0xE3, 0xDE, 0x1E, 0x3E, 0xF0,
  0x01, 0xF7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x07, 0xCF, 0x00, 0x3C,
  0x7C, 0x03, 0xE1, 0xF0, 0x7E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x03,
  0xFF, 0x80, 0xFD, 0xE0, 0x3F, 0x3C, 0x0F, 0xC7, 0x83, 0xF0, 0xF0, 0x3C,
  0x1E, 0x03, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFC, 0x1F, 0x0F, 0x80,
  0x7C, 0x7C, 0x03, 0xE1, 0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFC, 0x1F, 0x87, 0x80, 0x7C,
  0x18, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x40, 0x03,
  0xC7, 0x00, 0x3E, 0x78, 0x01, 0xF3, 0xF0, 0x3F, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7B, 0xC0,
  0x03, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0xC0, 0x1E,
  0x1E, 0x00, 0xF0, 0x78, 0x03, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0x80, 0xF8, 0x3C, 0x03, 0xC0, 0xE0, 0x0F, 0x07, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE8, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0xFC, 0x00, 0xEF, 0xFC, 0x07, 0xFF, 0xF8, 0x1D, 0xFF, 0xE0, 0x7C, 0x0F,
  0xC1, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x04, 0x00, 0x7C, 0x30, 0x01, 0xE1, 0xE0, 0x0F, 0x8F, 0xE0,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC7,
  0xC0, 0xF3, 0xFE, 0x1E, 0xFF, 0xE7, 0xBF, 0xFE, 0xFE, 0x0F, 0xFF, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0x9F, 0x03, 0xF3, 0xFF, 0xFC, 0x3F, 0xFF,
  0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFE, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0x8F,
  0x00, 0x78, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xC0, 0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1E,
  0x1E, 0x00, 0x78, 0x38, 0x01, 0xE0, 0xF0, 0x0F, 0x01, 0xE0, 0xF8, 0x03,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x3C, 0x01,
  0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x3E, 0x00, 0x3C, 0xF8, 0x01, 0xF3,
  0xE0, 0x0F, 0xC7, 0xE0, 0x7E, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xE3, 0xF0, 0x7E, 0xF8, 0x07, 0xDE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xF8, 0x1F, 0xDF, 0xFF, 0xF3, 0xFF, 0xDE, 0x3F, 0xF7, 0x81, 0xF9, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x0F,
  0xC7, 0xE7, 0xF3, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x7E, 0x7F, 0x3F, 0x9F, 0x87, 0x80, 0x03, 0xC0,
  0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0x83, 0xE0, 0x7C,
  0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x01,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0x10, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFE,
  0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x3E, 0x40,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x7F, 0xC0,
  0x7F, 0x80, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0xE0, 0xF8, 0x1E, 0x0F, 0x00, 0xF1, 0xE0, 0x07, 0x1C, 0x00, 0x73,
  0xC0, 0x07, 0x38, 0x1E, 0x77, 0x87, 0xF7, 0x78, 0xFF, 0x77, 0x8F, 0x1F,
  0x71, 0xE0, 0xF7, 0x1E, 0x0F, 0xF1, 0xC0, 0xEF, 0x1C, 0x0E, 0xF3, 0xC0,
  0xEF, 0x3C, 0x1E, 0xE3, 0xC1, 0xEE, 0x3C, 0x1E, 0xE3, 0xC3, 0xCE, 0x1F,
  0xDC, 0xE1, 0xFD, 0xCE, 0x0F, 0xBC, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x1E, 0x7C, 0x00, 0x78,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xE0, 0xF0,
  0x0F, 0x83, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3E, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0x00, 0x78, 0x78, 0x01,
  0xE3, 0xE0, 0x07, 0x8F, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x1F, 0x1E,
  0x01, 0xF1, 0xE0, 0x1E, 0x3E, 0x03, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03,
  0xFF, 0xF8, 0x3C, 0x07, 0xC3, 0xC0, 0x3C, 0x78, 0x01, 0xE7, 0x80, 0x1E,
  0x78, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x0F,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x83, 0xE3,
  0xF0, 0x1F, 0x3E, 0x00, 0xF7, 0xC0, 0x0F, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0x0F, 0x00,
  0x3C, 0xF0, 0x07, 0xCF, 0x80, 0xF8, 0xFC, 0x1F, 0x07, 0xFF, 0xF0, 0x3F,
  0xFE, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x03, 0xE1, 0xF0, 0x1F, 0x1E, 0x00,
  0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xE0,
  0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x01, 0xF3, 0xC0, 0x1F, 0x7C,
  0x01, 0xF7, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x07, 0xC7,
  0x80, 0xFC, 0xF8, 0x1F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF1, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0xFC, 0x3F, 0x0F, 0x80, 0xF8, 0x78, 0x03, 0xC7,
  0xC0, 0x1F, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x1F, 0xF3, 0xE0, 0xFF, 0x9F, 0x07, 0xFC, 0xF8,
  0x3F, 0xE7, 0xC0, 0x0F, 0x3E, 0x00, 0x79, 0xF0, 0x03, 0x8F, 0x80, 0x3C,
  0x3C, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0xC3, 0x78, 0x3F, 0xFB, 0xC0, 0xFF,
  0xBC, 0x03, 0xF1, 0xE0, 0x07, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF8, 0x03,
  0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0x87,
  0xC0, 0x1E, 0x1F, 0x00, 0x78, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x87, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0x00, 0x3C,
  0x3C, 0x01, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x1F, 0x00, 0x78, 0x7C,
  0x01, 0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF0, 0x78, 0x03,
  0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x3C, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC2, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x87, 0x00, 0xF8,
  0xF0, 0x0F, 0x8F, 0x81, 0xF0, 0xFC, 0x3F, 0x07, 0xFF, 0xE0, 0x3F, 0xFE,
  0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x1F, 0x83, 0xC0, 0x1F,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0x78, 0x1F,
  0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x9F,
  0x80, 0x07, 0x8F, 0x80, 0x03, 0xCF, 0x80, 0x01, 0xEF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x3C, 0x00, 0x3F, 0x1F, 0x00, 0x1F,
  0x8F, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0x78, 0x03,
  0xE0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0xC0, 0x78, 0x03, 0xE0,
  0x3C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x3F,
  0x03, 0xF8, 0xFE, 0x07, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF8,
  0xFF, 0x0F, 0xF1, 0xDE, 0x1C, 0xE7, 0xBC, 0x79, 0xCE, 0x70, 0xF3, 0xBC,
  0xE1, 0xE7, 0xF3, 0xC3, 0xC7, 0xC7, 0x87, 0x8F, 0x8F, 0x0E, 0x1E, 0x1E,
  0x3C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xF0, 0x61, 0xE1, 0xE0, 0x83, 0xC3,
  0xC1, 0x07, 0x87, 0x00, 0x0F, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x78,
  0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x3C, 0x3F, 0x80, 0xF0, 0xFE, 0x03, 0xC3, 0xF8, 0x0F, 0x0F, 0xE0,
  0x3C, 0x3F, 0x80, 0xF0, 0xEF, 0x07, 0x87, 0xBC, 0x1E, 0x1E, 0xF0, 0x78,
  0x79, 0xC1, 0xE1, 0xE7, 0x87, 0x87, 0x9E, 0x1C, 0x1C, 0x78, 0xF0, 0xF1,
  0xE3, 0xC3, 0xC3, 0x8F, 0x0F, 0x0F, 0x3C, 0x3C, 0x3C, 0xF0, 0xF0, 0xF3,
  0x83, 0x83, 0xDE, 0x1E, 0x07, 0x78, 0x78, 0x1F, 0xE1, 0xE0, 0x7F, 0x87,
  0x81, 0xFE, 0x1E, 0x03, 0xF0, 0x70, 0x0F, 0xC3, 0xC0, 0x3F, 0x0F, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC1, 0xF8, 0x3F, 0x0F, 0x80, 0xF8, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x7C,
  0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0x7C, 0x00, 0x7B, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80,
  0x0F, 0x3C, 0x00, 0xF9, 0xE0, 0x07, 0xCF, 0x80, 0x7C, 0x7C, 0x03, 0xE1,
  0xF0, 0x7E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1,
  0xF0, 0x1F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xC0, 0x0F, 0x1E, 0x00,
  0xF8, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xE3, 0xC0, 0x3F, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xF8,
  0x3F, 0x0F, 0x80, 0xF8, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xFB,
  0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0x7C, 0x00,
  0x7B, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0x3C,
  0x00, 0xF9, 0xE0, 0x07, 0xCF, 0x80, 0x7C, 0x7C, 0x03, 0xE1, 0xF0, 0x7E,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x04, 0x00, 0x7C, 0x70, 0x01, 0xE7, 0xC0, 0x0F, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0x80, 0x7F,
  0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xF0, 0x1F, 0x8F, 0x80, 0x7C,
  0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x80,
  0x3E, 0x7C, 0x03, 0xE3, 0xC0, 0x3F, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0xF0, 0x7C,
  0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x83, 0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0xF0,
  0x0F, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x7C, 0x01, 0xE1,
  0xF0, 0x03, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x08,
  0x00, 0x7C, 0x70, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0xE0, 0x7E, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E,
  0x1E, 0x00, 0xF8, 0x78, 0x03, 0xE3, 0xE0, 0x0F, 0x0F, 0x80, 0x3C, 0x3C,
  0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x7C, 0x7C, 0x01,
  0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xE1,
  0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF8, 0x07, 0xC1, 0xE0,
  0x1E, 0x07, 0xC1, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3D,
  0xF0, 0x03, 0xEF, 0x80, 0x1E, 0x7C, 0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x00,
  0xF8, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07,
  0x81, 0xF0, 0x3E, 0x0F, 0x00, 0xF0, 0xF8, 0x07, 0x87, 0x80, 0x3C, 0x3C,
  0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E,
  0xF8, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x0F,
  0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x3C, 0x3E, 0x1C, 0x3C, 0x3E, 0x1C, 0x3C, 0x7E, 0x3C, 0x38, 0x7E, 0x3C,
  0x38, 0x7E, 0x38, 0x38, 0xEE, 0x38, 0x78, 0xEE, 0x78, 0x78, 0xEE, 0x78,
  0x79, 0xCE, 0x78, 0x79, 0xCE, 0x70, 0x7B, 0x8E, 0x70, 0x7B, 0x8E, 0xF0,
  0x7B, 0x8E, 0xF0, 0x77, 0x0E, 0xE0, 0x77, 0x0E, 0xE0, 0x77, 0x0F, 0xE0,
  0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x07, 0x80,
  0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE3, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1E,
  0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC1, 0xE0, 0x03, 0xE0, 0x7C, 0x00,
  0xF0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x1E,
  0x0F, 0x80, 0x07, 0xC0, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0xF9, 0xF0, 0x03,
  0xE1, 0xE0, 0x0F, 0x83, 0xC0, 0x1F, 0x07, 0xC0, 0x7C, 0x07, 0x81, 0xF0,
  0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x1E, 0x3E, 0x00, 0x3C, 0x78, 0x00,
  0x3D, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xC0, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0xE0, 0x38,
  0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xE0,
  0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xEF, 0x80, 0x3E, 0x78,
  0x03, 0xC7, 0x80, 0x78, 0x3C, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x1E, 0x01,
  0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x0F, 0xF8, 0x00, 0xF7, 0x00,
  0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x33,
  0xC7, 0x9E, 0x38, 0xF1, 0xC6, 0x03, 0xF1, 0xE1, 0xFF, 0x3C, 0x7F, 0xF7,
  0x9F, 0x82, 0xF3, 0xE0, 0x3E, 0xF8, 0x07, 0xDE, 0x00, 0xF3, 0xC0, 0x1E,
  0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xEF, 0x00, 0x79,
  0xE0, 0x1F, 0x3C, 0x03, 0xE7, 0xC0, 0xBC, 0xFC, 0x37, 0x8F, 0xFD, 0xFC,
  0xFF, 0x1F, 0x8F, 0x81, 0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE1, 0xF0, 0x1E, 0x7F, 0xC3, 0xEF, 0xFC, 0x3F,
  0xC3, 0xE3, 0xD0, 0x1E, 0x3E, 0x01, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xF7,
  0xC0, 0x1F, 0x7C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3E,
  0x78, 0x03, 0xCF, 0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x41, 0xF8, 0xF7, 0xFF,
  0x0F, 0x3F, 0xE0, 0xF1, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC1, 0xFF,
  0xF8, 0xFC, 0x3E, 0x3C, 0x07, 0xDE, 0x00, 0x87, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x02, 0x3C,
  0x00, 0xCF, 0x00, 0x7B, 0xE0, 0x3C, 0x7C, 0x3E, 0x1F, 0xFF, 0x83, 0xFF,
  0x80, 0x3F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x1F, 0x87, 0x81, 0xFF, 0x7C, 0x3F, 0xFB, 0xC3, 0xF0,
  0x7E, 0x1F, 0x01, 0xF1, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xE7,
  0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03,
  0xE3, 0xC0, 0x1F, 0x1E, 0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xE1, 0xBC, 0x1F,
  0xF9, 0xE0, 0x7F, 0x8F, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7C, 0x1F, 0x3C, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3F,
  0xC0, 0x1F, 0xF0, 0x7F, 0xBF, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x8F, 0x00, 0x3B, 0xE0, 0x1E, 0x7C, 0x1F, 0x1F, 0xFF,
  0x83, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x04, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x20, 0x3C, 0x00, 0x1C, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF1, 0xE0,
  0x00, 0x3E, 0x78, 0x00, 0x07, 0xDE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x78, 0x3F, 0xF7, 0xC3,
  0xFF, 0xBC, 0x1F, 0x07, 0xE1, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x03,
  0xC7, 0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0,
  0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x1F, 0x0F, 0x81, 0xF8,
  0x3E, 0x1B, 0xC1, 0xFF, 0x9E, 0x07, 0xFC, 0xF0, 0x1F, 0x8F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x04, 0x01, 0xE0, 0x78, 0x3F, 0x07,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC3, 0xE0, 0x79, 0xFE, 0x0F, 0x7F,
  0xE3, 0xFC, 0x7C, 0x7E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3C, 0x03,
  0xE7, 0x80, 0x79, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07,
  0x9E, 0x01, 0xF3, 0xC0, 0x3C, 0xF8, 0x07, 0x9F, 0x00, 0xF3, 0xC0, 0x1E,
  0x78, 0x03, 0xCF, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x81, 0x81, 0xE0, 0xF0, 0x78, 0x78, 0x3E, 0x3C, 0x0F,
  0x9E, 0x03, 0xCF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x03, 0x03, 0xC1, 0xF0, 0x78, 0x1F, 0x0F,
  0x01, 0xF1, 0xE0, 0x1E, 0x7C, 0x01, 0xEF, 0x00, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0xF8, 0x07, 0x9F, 0xF0, 0x3D, 0xFF, 0x83, 0xFC,
  0x3E, 0x1F, 0x81, 0xF0, 0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x3C, 0x03, 0xC1,
  0xE0, 0x3C, 0x1F, 0x03, 0xC0, 0xF8, 0xFC, 0x07, 0x9F, 0x00, 0x3C, 0xF8,
  0x01, 0xE3, 0xC0, 0x8F, 0x1E, 0x0E, 0xF8, 0x78, 0xFF, 0xC3, 0xCF, 0x3C,
  0x0F, 0xF1, 0xE0, 0x7F, 0x0F, 0x01, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x06, 0x1E, 0x0F, 0x1E, 0x1E, 0x1E, 0x3C, 0x3E, 0x78, 0x3C, 0xF0,
  0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0x00, 0x1E, 0x78, 0x78, 0x3D, 0xF9, 0xF8,
  0x7F, 0xF7, 0xF0, 0xF9, 0xF8, 0xF1, 0xE1, 0xE1, 0xE7, 0x83, 0xC3, 0x8F,
  0x07, 0x07, 0x1E, 0x1E, 0x0E, 0x3C, 0x3C, 0x3C, 0x70, 0x78, 0x78, 0xE0,
  0xE0, 0xF3, 0xC1, 0xC1, 0xC7, 0x87, 0x83, 0x8F, 0x0F, 0x07, 0x1E, 0x1E,
  0x1E, 0x38, 0x3C, 0x3C, 0x70, 0x70, 0x79, 0xE0, 0xE0, 0xE3, 0xC3, 0xC1,
  0xC7, 0x87, 0x87, 0x80, 0x1E, 0x1F, 0x03, 0xCF, 0xF0, 0x7B, 0xFF, 0x0F,
  0xE3, 0xE3, 0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x1F, 0x3C,
  0x03, 0xCF, 0x80, 0x79, 0xF0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0,
  0x0F, 0x9E, 0x01, 0xE7, 0xC0, 0x3C, 0xF8, 0x07, 0x9E, 0x00, 0xF3, 0xC0,
  0x1E, 0x78, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F,
  0x83, 0xE3, 0xE0, 0x3E, 0x78, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xBE, 0x01, 0xF3, 0xC0, 0x3C, 0x7C, 0x1F, 0x07, 0xFF, 0xC0, 0x7F,
  0xF0, 0x03, 0xF8, 0x00, 0x07, 0x87, 0xC0, 0x1E, 0x7F, 0xC0, 0xFB, 0xFF,
  0x03, 0xFC, 0x3E, 0x0F, 0x40, 0x78, 0x3E, 0x01, 0xE0, 0xF8, 0x07, 0x83,
  0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80,
  0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x7C,
  0x3D, 0x07, 0xE0, 0xF7, 0xFF, 0x03, 0xCF, 0xF8, 0x0F, 0x1F, 0x80, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0xF0,
  0x7F, 0xDF, 0x1F, 0xFD, 0xE3, 0xF0, 0x7E, 0x3E, 0x03, 0xE7, 0xC0, 0x1E,
  0x78, 0x01, 0xE7, 0x80, 0x3E, 0xF8, 0x03, 0xCF, 0x80, 0x3C, 0xF0, 0x03,
  0xCF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x0F, 0x8F, 0x81,
  0xF8, 0xFC, 0x37, 0x87, 0xFE, 0x78, 0x3F, 0xC7, 0x81, 0xF8, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0xFF, 0xC3, 0xFF, 0xF9, 0xFF,
  0xFF, 0x7F, 0x83, 0xCF, 0xF0, 0x7B, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF0,
  0x3F, 0xFF, 0x8F, 0x81, 0xE1, 0xE0, 0x08, 0x78, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x88, 0x01, 0xF3, 0x80, 0x3C, 0xFC, 0x0F, 0x8F,
  0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x0E, 0x0F, 0x07, 0xC7, 0xC3, 0xE1, 0xE3, 0xE0, 0x79,
  0xF0, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xE7, 0x80,
  0x79, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x01,
  0xF3, 0xC0, 0x3C, 0xF8, 0x07, 0x9F, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03,
  0xCF, 0x00, 0xF9, 0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0x81, 0xF8, 0xF8, 0x6F,
  0x1F, 0xF9, 0xE1, 0xFE, 0x7C, 0x1F, 0x8F, 0x00, 0x7F, 0x80, 0xDF, 0xE0,
  0x7B, 0xFC, 0x0F, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC7, 0xC0,
  0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x8F, 0x01,
  0xE1, 0xE0, 0x7C, 0x7C, 0x0F, 0x0F, 0x03, 0xC1, 0xE1, 0xF8, 0x3C, 0xFE,
  0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xC0, 0x00, 0x1C, 0x1C, 0x11, 0xE1,
  0xE3, 0xCF, 0x0F, 0x1E, 0x78, 0x78, 0x73, 0x83, 0x83, 0x9C, 0x1C, 0x1C,
  0xE0, 0xE0, 0xEF, 0x0F, 0x07, 0x78, 0x78, 0x3B, 0xC3, 0xC1, 0xDC, 0x1C,
  0x1E, 0xE0, 0xE0, 0xF7, 0x07, 0x07, 0x78, 0x78, 0x3B, 0xC3, 0xC3, 0xDE,
  0x3E, 0x1C, 0xF1, 0x71, 0xE7, 0xFB, 0x9E, 0x1F, 0x8F, 0xE0, 0x78, 0x7C,
  0x00, 0x01, 0xE0, 0x78, 0x0F, 0xE1, 0xF8, 0x3F, 0xE7, 0xF8, 0xF9, 0xDC,
  0xF3, 0xE3, 0xB1, 0xE7, 0x07, 0x41, 0xC4, 0x0F, 0x83, 0x80, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x1E, 0x0F, 0x82, 0x3C, 0x3F, 0x0E, 0x78, 0x7E, 0x3E, 0xF1,
  0x9D, 0xF9, 0xFF, 0x3F, 0xC1, 0xFC, 0x7F, 0x01, 0xF0, 0x78, 0x00, 0x0F,
  0x00, 0xF8, 0x78, 0x07, 0x87, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0, 0x0F,
  0x0F, 0x00, 0x78, 0x78, 0x07, 0xC3, 0xC0, 0x3C, 0x1E, 0x01, 0xE1, 0xF0,
  0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xE0,
  0xF0, 0x1F, 0x07, 0x81, 0xF8, 0x3E, 0x1B, 0xC0, 0xFF, 0x9E, 0x07, 0xF9,
  0xF0, 0x0F, 0x8F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x04,
  0x01, 0xE0, 0x70, 0x3E, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF0, 0x78, 0x7F, 0xF3, 0xC3, 0xFF, 0xDE, 0x3C, 0x3F, 0xF1,
  0xC0, 0x3F, 0x0E, 0x01, 0xF0, 0x70, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x80, 0x7C, 0x1E, 0x07,
  0xC0, 0x70, 0x7C, 0x03, 0x87, 0xF0, 0x1E, 0x7F, 0xFC, 0x73, 0xDF, 0xFF,
  0x9E, 0x3F, 0xF9, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C,
  0x0F, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFC, 0x01, 0xFF, 0x80,
  0xF8, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xC0, 0x38, 0x3F, 0x80, 0xF1, 0xFF, 0x03, 0x8F, 0x3C,
  0x1E, 0x38, 0x78, 0x71, 0xE0, 0xF3, 0xC7, 0x03, 0xFE, 0x1C, 0x07, 0xF0,
  0xF0, 0x0F, 0x80,
};

const GFXglyph IBMPlexMono_MediumItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 10, 27, 23, 7, -27 },
  { 35, 14, 12, 23, 7, -29 },
  { 56, 24, 27, 23, 0, -27 },
  { 137, 22, 35, 23, 1, -31 },
  { 234, 27, 27, 23, -1, -27 },
  { 326, 23, 27, 23, 0, -27 },
  { 404, 6, 12, 23, 11, -29 },
  { 413, 16, 35, 23, 7, -30 },
  { 483, 16, 35, 23, 1, -30 },
  { 553, 20, 19, 23, 2, -21 },
  { 601, 20, 19, 23, 2, -21 },
  { 649, 10, 12, 23, 5, -6 },
  { 664, 12, 4, 23, 6, -14 },
  { 670, 7, 6, 23, 7, -6 },
  { 676, 22, 35, 23, 1, -30 },
  { 773, 21, 27, 23, 2, -27 },
  { 844, 19, 27, 23, 2, -27 },
  { 909, 21, 27, 23, 1, -27 },
  { 980, 21, 27, 23, 1, -27 },
  { 1051, 22, 27, 23, 0, -27 },
  { 1126, 22, 27, 23, 1, -27 },
  { 1201, 19, 27, 23, 2, -27 },
  { 1266, 20, 27, 23, 4, -27 },
  { 1334, 22, 27, 23, 1, -27 },
  { 1409, 19, 27, 23, 3, -27 },
  { 1474, 9, 21, 23, 7, -21 },
  { 1498, 11, 27, 23, 5, -21 },
  { 1536, 19, 23, 23, 3, -23 },
  { 1591, 20, 12, 23, 2, -18 },
  { 1621, 19, 23, 23, 2, -23 },
  { 1676, 17, 27, 23, 5, -27 },
  { 1734, 20, 31, 23, 2, -27 },
  { 1812, 22, 27, 23, -1, -27 },
  { 1887, 20, 27, 23, 2, -27 },
  { 1955, 20, 27, 23, 3, -27 },
  { 2023, 20, 27, 23, 2, -27 },
  { 2091, 21, 27, 23, 2, -27 },
  { 2162, 22, 27, 23, 2, -27 },
  { 2237, 21, 27, 23, 2, -27 },
  { 2308, 22, 27, 23, 1, -27 },
  { 2383, 22, 27, 23, 1, -27 },
  { 2458, 20, 27, 23, 2, -27 },
  { 2526, 25, 27, 23, 1, -27 },
  { 2611, 17, 27, 23, 3, -27 },
  { 2669, 23, 27, 23, 1, -27 },
  { 2747, 22, 27, 23, 1, -27 },
  { 2822, 21, 27, 23, 2, -27 },
  { 2893, 21, 27, 23, 2, -27 },
  { 2964, 21, 35, 23, 2, -27 },
  { 3056, 21, 27, 23, 2, -27 },
  { 3127, 22, 27, 23, 1, -27 },
  { 3202, 22, 27, 23, 3, -27 },
  { 3277, 22, 27, 23, 2, -27 },
  { 3352, 21, 27, 23, 4, -27 },
  { 3423, 24, 27, 23, 1, -27 },
  { 3504, 26, 27, 23, -1, -27 },
  { 3592, 23, 27, 23, 3, -27 },
  { 3670, 24, 27, 23, 0, -27 },
  { 3751, 17, 35, 23, 6, -30 },
  { 3826, 10, 35, 23, 7, -30 },
  { 3870, 17, 35, 23, 1, -30 },
  { 3945, 20, 16, 23, 2, -27 },
  { 3985, 19, 4, 23, 0, 3 },
  { 3995, 6, 8, 23, 8, -31 },
  { 4001, 19, 20, 23, 2, -20 },
  { 4049, 20, 29, 23, 2, -29 },
  { 4122, 18, 20, 23, 3, -20 },
  { 4167, 21, 29, 23, 2, -29 },
  { 4244, 18, 20, 23, 3, -20 },
  { 4289, 26, 37, 23, -1, -29 },
  { 4410, 21, 28, 23, 1, -20 },
  { 4484, 19, 29, 23, 2, -29 },
  { 4553, 18, 29, 23, 3, -29 },
  { 4619, 19, 37, 23, 1, -29 },
  { 4707, 21, 29, 23, 2, -29 },
  { 4784, 16, 29, 23, 4, -29 },
  { 4842, 23, 20, 23, 0, -20 },
  { 4900, 19, 20, 23, 2, -20 },
  { 4948, 19, 20, 23, 2, -20 },
  { 4996, 22, 28, 23, 0, -20 },
  { 5073, 20, 28, 23, 2, -20 },
  { 5143, 19, 20, 23, 4, -20 },
  { 5191, 19, 20, 23, 2, -20 },
  { 5239, 18, 27, 23, 3, -27 },
  { 5300, 19, 20, 23, 3, -20 },
  { 5348, 19, 20, 23, 2, -20 },
  { 5396, 21, 20, 23, 1, -20 },
  { 5449, 23, 20, 23, 0, -20 },
  { 5507, 21, 28, 23, 1, -20 },
  { 5581, 21, 20, 23, 1, -20 },
  { 5634, 19, 35, 23, 4, -30 },
  { 5718, 10, 35, 23, 7, -30 },
  { 5762, 19, 35, 23, 1, -30 },
  { 5846, 22, 9, 23, 1, -16 },
};

const GFXfont IBMPlexMono_MediumItalic39pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic39pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _IBMPLEXMONO_MEDIUMITALIC39PT7B_H_
