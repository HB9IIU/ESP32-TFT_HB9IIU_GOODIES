#ifndef _IBMPLEXMONO_MEDIUMITALIC71PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x7F,
  0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F,
  0x01, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x08,
  0x07, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xCF, 0x9F, 0xFC, 0x03, 0xFF, 0x07, 0xC3, 0xFF, 0x01, 0xFF, 0x03, 0xE0,
  0x7E, 0x00, 0xFF, 0x01, 0xF0, 0x1E, 0x00, 0xFF, 0x01, 0xF8, 0x06, 0x00,
  0x7F, 0x80, 0xF8, 0x02, 0x00, 0x3F, 0xC0, 0x7C, 0x00, 0x00, 0x1F, 0xE0,
  0x3E, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0x80,
  0x00, 0x03, 0xFC, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0x07, 0xC0, 0x00, 0x00,
  0x7F, 0xE3, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xEF, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0xFF,
  0xC0, 0x00, 0x00, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x7C, 0x0F, 0xF8, 0x00,
  0x00, 0x3E, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x7F, 0x80, 0x40, 0x07, 0xC0, 0x3F,
  0xC0, 0x30, 0x03, 0xE0, 0x3F, 0xC0, 0x78, 0x01, 0xF0, 0x1F, 0xE0, 0x7E,
  0x01, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xF8, 0x1F, 0xF0, 0x7F, 0xF0, 0x7C,
  0x1F, 0xF8, 0x1F, 0xFF, 0x3E, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF8, 0x0F,
  0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x7E, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x20, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x87, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x87, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0x87, 0xF8, 0x7F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x1F, 0x80,
  0x00, 0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xE0, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x01, 0xFF,
  0xE7, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0x9F, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x01, 0x8F, 0xF0, 0x00, 0xFF, 0x00, 0xFB, 0xFC, 0x00,
  0x3F, 0xE0, 0x3F, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0x9F, 0xC0, 0x07, 0xFE,
  0x0F, 0xE7, 0xF8, 0x01, 0x9F, 0xC3, 0xF1, 0xFF, 0x00, 0xE7, 0xF1, 0xFC,
  0x7F, 0xE0, 0xF9, 0xFE, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF,
  0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xCF,
  0xE3, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x73, 0xE0, 0x1F,
  0xC0, 0x3F, 0x7F, 0xC1, 0xFC, 0x1F, 0xF7, 0xFF, 0x9F, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x0F, 0xC3, 0xFE, 0x7F, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x7F, 0xC3,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x03, 0xF9,
  0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x03, 0xFD, 0xFE,
  0x03, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x83, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0x83, 0xFD, 0xFE, 0x07,
  0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0xC0, 0xFF, 0x7F, 0x80, 0xFC, 0x07, 0xFB,
  0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xC0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00,
  0x1F, 0xE7, 0xF0, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x0F, 0xF9, 0xFC,
  0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xC0,
  0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x07, 0xFC, 0x3F,
  0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x03,
  0x80, 0x1F, 0xE0, 0x00, 0x20, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x01,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x01, 0xC0, 0x00, 0x1F,
  0xF0, 0x01, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x80, 0x00, 0x03, 0xFE, 0x01, 0x80, 0x00, 0x07, 0xFC,
  0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x80, 0x00,
  0x1F, 0xC3, 0xFF, 0xE0, 0x00, 0x3F, 0x1F, 0xFF, 0xF0, 0x00, 0x7E, 0x7F,
  0xFF, 0xF0, 0x00, 0xFD, 0xFF, 0xFF, 0xF0, 0x03, 0xFB, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x8E, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x01, 0x80, 0x00, 0x07,
  0xF8, 0x07, 0x80, 0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x00, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07,
  0xF8, 0x7F, 0xFC, 0x01, 0xFE, 0x3F, 0xFF, 0xC0, 0x3F, 0xCF, 0xFF, 0xFC,
  0x0F, 0xF3, 0xFF, 0xFF, 0xC1, 0xFE, 0xFF, 0xFF, 0xFC, 0x7F, 0xBF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x8F,
  0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xF0, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00,
  0x1F, 0xE1, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x00,
  0x7F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFE,
  0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFE,
  0x7F, 0x80, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x01,
  0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0xE7, 0xF0,
  0x07, 0xFF, 0xF8, 0xFF, 0x00, 0x1F, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE,
  0x03, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xF8, 0x0F, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF,
  0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0x00, 0x00, 0xFF,
  0x06, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0xC3, 0xF8, 0x07, 0xFC, 0x7F,
  0x0F, 0xC0, 0x3F, 0xF9, 0xFC, 0x7F, 0x01, 0xFF, 0xF7, 0xE1, 0xFC, 0x0F,
  0xFF, 0xDF, 0x87, 0xE0, 0x7F, 0xFF, 0x7E, 0x1F, 0x81, 0xFE, 0x0F, 0xF8,
  0xFE, 0x0F, 0xF0, 0x1F, 0xE3, 0xF8, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0xFE,
  0x00, 0xFC, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0xFC, 0x1F, 0xC0, 0x0F, 0xC7,
  0xF0, 0x7F, 0x00, 0x3F, 0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x7F, 0x0F, 0xE0,
  0x07, 0xF1, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0xFE, 0x00, 0x7E, 0x1F,
  0x83, 0xF8, 0x01, 0xF8, 0x7E, 0x0F, 0xE0, 0x07, 0xE1, 0xF8, 0x3F, 0x80,
  0x3F, 0x87, 0xE0, 0xFE, 0x00, 0xFE, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0xFE,
  0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x3F, 0x81, 0xBF, 0x0F, 0xE0, 0x7F, 0x0E,
  0xFC, 0x3F, 0x81, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0xDF, 0xC3, 0xF8,
  0x0F, 0xFE, 0x7E, 0x07, 0xE0, 0x3F, 0xF9, 0xF8, 0x1F, 0x80, 0x7F, 0xC7,
  0xE0, 0x7E, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x07, 0xF1, 0xFE, 0x00,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x3F, 0xE7,
  0xF8, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x07,
  0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x00, 0xFF,
  0x87, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x80, 0x00,
  0x08, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x30, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xE1, 0xFE,
  0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0x80,
  0x01, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0xC0, 0x00, 0x0C, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xFF,
  0x3F, 0xE0, 0x0F, 0xFF, 0xF9, 0xFF, 0x00, 0x7F, 0xFF, 0xCF, 0xF8, 0x03,
  0xFF, 0xFC, 0x7F, 0x80, 0x1F, 0xFF, 0xE3, 0xFC, 0x01, 0xFF, 0xFF, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00,
  0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0E, 0xFE, 0x03,
  0xFF, 0x81, 0xF7, 0xF0, 0x0F, 0xFF, 0xFF, 0x3F, 0x80, 0x7F, 0xFF, 0xF3,
  0xF8, 0x01, 0xFF, 0xFF, 0x1F, 0xC0, 0x07, 0xFF, 0xF0, 0xFE, 0x00, 0x0F,
  0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0x80, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xF8,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x00, 0x07,
  0xF0, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x00, 0x03,
  0xFD, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xBF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xDF, 0xE0, 0x00, 0x01, 0xFF, 0xF3, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFD, 0xF8, 0x0F, 0xDF,
  0xC0, 0x3F, 0xBF, 0x01, 0xFB, 0xF8, 0x07, 0xF7, 0xE0, 0x7E, 0x7F, 0x00,
  0xFE, 0x7E, 0x0F, 0xCF, 0xC0, 0x1F, 0x8F, 0xC3, 0xF3, 0xF8, 0x07, 0xF1,
  0xF8, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x1F, 0x8F, 0xE0, 0x1F, 0xC7, 0xE7,
  0xF1, 0xFC, 0x03, 0xF8, 0x7E, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xFF, 0x07,
  0xE0, 0x0F, 0xE1, 0xFF, 0xE1, 0xFC, 0x01, 0xF8, 0x3F, 0xF8, 0x3F, 0x80,
  0x7F, 0x07, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0xC0, 0xFE, 0x01, 0xFC,
  0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F,
  0xC0, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3C, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x60, 0x0F, 0xE0, 0x1F, 0xC0, 0x08, 0x01, 0xFC, 0x03, 0xF8, 0x01,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0xF0, 0x00, 0x3F, 0x80,
  0x3F, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xFF,
  0x00, 0x07, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x01,
  0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xFF,
  0x00, 0x1F, 0xC0, 0x3F, 0x9F, 0x80, 0x0F, 0xE0, 0x1F, 0xCF, 0xC0, 0x0F,
  0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0x03,
  0xF9, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x3F,
  0x00, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x3F,
  0x80, 0x3F, 0x87, 0xF0, 0x1F, 0xC0, 0x1F, 0xC1, 0xF8, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F,
  0x83, 0xF8, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0xFE,
  0x00, 0xFE, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x8F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xF0, 0x07, 0xF3, 0xF8,
  0x03, 0xF8, 0x03, 0xF9, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0xFE, 0x01, 0xFC,
  0x00, 0x7E, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x00, 0x1F,
  0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xFF, 0xE0,
  0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xF0,
  0x00, 0x7F, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xFC, 0x01, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x7F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x3F, 0xF0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x80,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F,
  0xFB, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x0F, 0xF9,
  0xFC, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x03,
  0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03,
  0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x3F, 0xF0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x80,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F,
  0xFB, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x0F, 0xF9,
  0xFC, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0x00, 0x00, 0x7F, 0x80, 0x38, 0x00,
  0x01, 0xFE, 0x03, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03,
  0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x20, 0x00, 0x00, 0x3F, 0xC0, 0x18, 0x00, 0x00,
  0x1F, 0xE0, 0x3C, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00,
  0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x81, 0xFC, 0x07, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0xE0, 0x3F,
  0x01, 0xFC, 0x07, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0xE0, 0x7F, 0x01,
  0xFC, 0x0F, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0xFF, 0xE0, 0x7E, 0x01, 0xFC,
  0x1F, 0x7E, 0x0F, 0xE0, 0x1F, 0x81, 0xF7, 0xE0, 0xFE, 0x01, 0xF8, 0x1F,
  0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xE7, 0xE0, 0xFC, 0x03, 0xF8, 0x3E, 0x7E,
  0x1F, 0xC0, 0x3F, 0x87, 0xE7, 0xE1, 0xFC, 0x03, 0xF8, 0x7C, 0x7E, 0x1F,
  0x80, 0x3F, 0x87, 0xC7, 0xE1, 0xF8, 0x03, 0xF8, 0xFC, 0x7E, 0x1F, 0x80,
  0x3F, 0x8F, 0x87, 0xE3, 0xF8, 0x03, 0xF0, 0xF8, 0x7E, 0x3F, 0x80, 0x3F,
  0x1F, 0x87, 0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0x7E, 0x3F, 0x00, 0x3F, 0x1F,
  0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF0, 0x7E, 0x7F, 0x00, 0x7F, 0x3E, 0x07,
  0xE7, 0xE0, 0x07, 0xF3, 0xE0, 0x7E, 0x7E, 0x00, 0x7F, 0x7E, 0x07, 0xE7,
  0xE0, 0x07, 0xF7, 0xC0, 0x7E, 0xFE, 0x00, 0x7F, 0x7C, 0x07, 0xEF, 0xC0,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x00, 0x7E, 0xF8, 0x07, 0xEF, 0xC0, 0x07,
  0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xBF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x00, 0xFF,
  0x9F, 0xE0, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x7F, 0xC3, 0xFC,
  0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x0F, 0xE3, 0xFE,
  0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x7F,
  0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xF1, 0xC0, 0x00,
  0x00, 0x3C, 0x06, 0x00, 0x00, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x06, 0x03, 0xC1, 0xF8, 0x7F, 0x87, 0xF0, 0xFE, 0x0F, 0xE1,
  0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0x80, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0x00, 0x7F, 0xFF, 0x0F,
  0xF0, 0x0F, 0xFF, 0xF8, 0xFF, 0x01, 0xFF, 0xFF, 0xCF, 0xE0, 0x3F, 0xFF,
  0xFC, 0xFE, 0x07, 0xFF, 0x01, 0xEF, 0xE0, 0x7F, 0xC0, 0x07, 0xFE, 0x0F,
  0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x3F,
  0x87, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFF,
  0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0x80, 0x07, 0xFF, 0x07, 0xF8, 0x00,
  0xEF, 0xE0, 0x7F, 0xC0, 0x1E, 0xFE, 0x03, 0xFF, 0x07, 0xDF, 0xFF, 0x3F,
  0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFF, 0xE0, 0x03,
  0xF8, 0x7F, 0xFF, 0x00, 0x7F, 0x8F, 0xFF, 0xF8, 0x07, 0xF9, 0xFF, 0xFF,
  0xC0, 0x7F, 0x9F, 0xFF, 0xFE, 0x07, 0xFB, 0xE0, 0x7F, 0xE0, 0x7F, 0x78,
  0x03, 0xFE, 0x07, 0xF7, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0x0F,
  0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x03, 0xFC, 0x3F,
  0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x7F,
  0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xF7, 0x80,
  0xFF, 0xE0, 0x7F, 0x3F, 0xFF, 0xFC, 0x0F, 0xF3, 0xFF, 0xFF, 0xC0, 0xFF,
  0x1F, 0xFF, 0xF0, 0x0F, 0xF0, 0xFF, 0xFE, 0x00, 0xFF, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0x0F, 0xF0,
  0x00, 0x0E, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x30,
  0x7F, 0x80, 0x00, 0x3E, 0x3F, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x3F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xFE, 0x0F, 0xF0, 0x01, 0xFF,
  0xFE, 0x1F, 0xC0, 0x07, 0xFF, 0xFE, 0x3F, 0x80, 0x1F, 0xFF, 0xFE, 0x7F,
  0x00, 0x7F, 0xFF, 0xFD, 0xFE, 0x01, 0xFF, 0xC0, 0x7B, 0xFC, 0x03, 0xFE,
  0x00, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x03,
  0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x00,
  0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xBF, 0xC0, 0x1F, 0xF8, 0x1F, 0x7F, 0x80,
  0x3F, 0xFF, 0xFC, 0xFE, 0x00, 0x3F, 0xFF, 0xF1, 0xFC, 0x00, 0x7F, 0xFF,
  0xC7, 0xF8, 0x00, 0x7F, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xFC, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x1F,
  0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xCF,
  0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x1F, 0xFC,
  0xFF, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x20, 0x7F, 0x00, 0x00, 0x1C, 0x3F, 0xC0, 0x00, 0x0F, 0x1F, 0xE0, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xF1, 0xFF, 0x00,
  0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x3F, 0xFE, 0x0F, 0xF0, 0x03, 0xFF, 0xFC, 0x3F, 0x80, 0x1F, 0xFF,
  0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xF7, 0xF8, 0x07, 0xFF, 0xFF, 0xDF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xBF,
  0x80, 0xFF, 0x80, 0x1D, 0xFE, 0x01, 0xFF, 0x81, 0xF7, 0xF8, 0x07, 0xFF,
  0xFF, 0x9F, 0xE0, 0x0F, 0xFF, 0xFC, 0x7F, 0x00, 0x3F, 0xFF, 0xE1, 0xFC,
  0x00, 0x7F, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x80, 0x00, 0x3F, 0xC0, 0x07, 0x00, 0x01, 0xFE, 0x00,
  0x3E, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF,
  0xFC, 0x01, 0xFC, 0x3F, 0xFF, 0xC0, 0x3F, 0x8F, 0xFF, 0xF8, 0x0F, 0xF3,
  0xFF, 0xFF, 0x81, 0xFE, 0x78, 0x3F, 0xF0, 0x3F, 0xDC, 0x01, 0xFE, 0x07,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x7F,
  0x87, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x02, 0x00,
  0x03, 0xF8, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x07,
  0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x20, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0x7F, 0x80, 0x0F, 0x80, 0x1F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F,
  0xC3, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00,
  0x7F, 0xCF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0xF8, 0x00, 0x3F, 0xC3, 0xFF, 0xF0,
  0x00, 0xFE, 0x1F, 0xFF, 0xE0, 0x03, 0xF8, 0xFF, 0xFF, 0xC0, 0x1F, 0xE7,
  0xFF, 0xFF, 0x00, 0x7F, 0xBE, 0x07, 0xFE, 0x01, 0xFE, 0xE0, 0x0F, 0xF8,
  0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x01, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFF,
  0xC0, 0x00, 0x7F, 0x1F, 0xF8, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF0,
  0x01, 0x83, 0xFC, 0x1F, 0xE0, 0x0F, 0x0F, 0xE0, 0x7F, 0x80, 0x7E, 0x3F,
  0x80, 0xFF, 0x03, 0xFD, 0xFE, 0x03, 0xFC, 0x1F, 0xE7, 0xF8, 0x07, 0xF8,
  0xFF, 0x1F, 0xE0, 0x1F, 0xE7, 0xF8, 0x7F, 0x80, 0x3F, 0xFF, 0xC1, 0xFC,
  0x00, 0xFF, 0xFE, 0x07, 0xF0, 0x01, 0xFF, 0xF0, 0x3F, 0xC0, 0x07, 0xFF,
  0x80, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x40, 0x0F, 0xF0, 0x01, 0x80, 0x3F, 0xC0,
  0x0F, 0x00, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x3F,
  0xE0, 0x7F, 0x81, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF0, 0x7F, 0xC0,
  0x1F, 0xC3, 0xFE, 0x00, 0x7F, 0x1F, 0xF0, 0x01, 0xFC, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x7F, 0x81, 0xFF, 0x00, 0xFC, 0x7F, 0xE1,
  0xFF, 0xC0, 0x7E, 0x7F, 0xF1, 0xFF, 0xF0, 0x7F, 0x7F, 0xFD, 0xFF, 0xF8,
  0x3F, 0xBF, 0xFE, 0xFF, 0xFC, 0x1F, 0xF8, 0xFF, 0xF1, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC3, 0xFC, 0x07, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x80,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE0, 0x1F, 0xC3,
  0xF8, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0x7F, 0x83, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0xFC, 0x01, 0xFC, 0x3F,
  0xFF, 0xC0, 0x3F, 0x8F, 0xFF, 0xF8, 0x0F, 0xF3, 0xFF, 0xFF, 0x81, 0xFE,
  0x78, 0x3F, 0xF0, 0x3F, 0xDC, 0x01, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xE0,
  0xFE, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x87, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x07,
  0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x01, 0xFC, 0xFF,
  0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFE,
  0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07,
  0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFE, 0x07, 0xFF, 0x80, 0x01,
  0xFC, 0x3F, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0xFF, 0x80, 0x0F, 0xF3, 0xFF,
  0xFF, 0x80, 0x1F, 0xE7, 0xFF, 0xFF, 0x80, 0x3F, 0xDF, 0x03, 0xFF, 0x00,
  0x7F, 0x78, 0x03, 0xFE, 0x00, 0xFE, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0x80,
  0x03, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x80,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xF7, 0x80, 0xFF,
  0xE0, 0x0F, 0xE7, 0xFF, 0xFF, 0x80, 0x3F, 0xCF, 0xFF, 0xFF, 0x00, 0x7F,
  0x8F, 0xFF, 0xF8, 0x00, 0xFF, 0x0F, 0xFF, 0xE0, 0x01, 0xFE, 0x0F, 0xFF,
  0x80, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xF8, 0x3F, 0xC0, 0x1F, 0xFF, 0xE1, 0xFC,
  0x01, 0xFF, 0xFF, 0x8F, 0xE0, 0x1F, 0xFF, 0xFE, 0xFF, 0x01, 0xFF, 0xFF,
  0xF7, 0xF8, 0x1F, 0xFC, 0x07, 0xBF, 0xC0, 0xFF, 0x80, 0x0F, 0xFE, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xF8, 0x7F,
  0x80, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xF0,
  0x3F, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0x3B, 0xFC, 0x07, 0xFE, 0x07,
  0xDF, 0xE0, 0x3F, 0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0xC7, 0xF0, 0x07,
  0xFF, 0xFC, 0x7F, 0x80, 0x1F, 0xFF, 0xC3, 0xFC, 0x00, 0x7F, 0xFC, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xEF, 0xFF,
  0xF8, 0x1F, 0xFD, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0xFF, 0xE3, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFD, 0xFF, 0xFF, 0x1F, 0xFF, 0x80, 0x0F, 0xE7, 0xFF,
  0xF0, 0x03, 0xFD, 0xF0, 0x00, 0x00, 0x7F, 0xB8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0xFC, 0x07,
  0xF8, 0x00, 0x07, 0x00, 0xFF, 0x00, 0x00, 0x40, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x04, 0x00,
  0x00, 0x3F, 0xC0, 0xC0, 0x00, 0x07, 0xF0, 0x7C, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x7F, 0xC7, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x30, 0x01, 0xFE, 0x00, 0x1E,
  0x00, 0x7F, 0x80, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07,
  0xFE, 0x01, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0x03, 0xFF, 0x00, 0x3F, 0xC1,
  0xFF, 0x00, 0x0F, 0xF1, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x3F, 0xF0, 0xFF,
  0x00, 0x0F, 0xFC, 0x3F, 0xC0, 0x06, 0xFF, 0x0F, 0xF8, 0x07, 0xBF, 0x81,
  0xFF, 0x03, 0xCF, 0xE0, 0x7F, 0xFF, 0xE7, 0xF8, 0x1F, 0xFF, 0xF9, 0xFE,
  0x03, 0xFF, 0xFC, 0x7F, 0x80, 0x7F, 0xFE, 0x1F, 0xE0, 0x0F, 0xFF, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0x0F, 0xFF,
  0xC0, 0x03, 0xF3, 0xFF, 0xF8, 0x01, 0xFE, 0x7F, 0xFF, 0x00, 0x3F, 0xEF,
  0xFF, 0xE0, 0x03, 0xFD, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F,
  0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF8,
  0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x3F, 0x80, 0x1F, 0xF0, 0x07, 0xF0, 0x07, 0xFE, 0x00, 0xFE, 0x01, 0xFF,
  0x80, 0x1F, 0xC0, 0x7F, 0xE0, 0x07, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x18, 0x1F, 0xC0,
  0x3F, 0x01, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x0F,
  0xE0, 0xFC, 0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x00,
  0xFE, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0xFC,
  0x03, 0xF8, 0x07, 0xF1, 0xF8, 0x07, 0xF0, 0x0F, 0xE3, 0xF0, 0x0F, 0xC0,
  0x1F, 0xCF, 0xE0, 0x1F, 0x80, 0x3F, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8,
  0x03, 0xF1, 0xF8, 0x07, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xC0, 0x1F, 0xCF,
  0xE0, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFE,
  0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0x07, 0xE3,
  0xF8, 0x07, 0xE0, 0x0F, 0xC7, 0xF0, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F,
  0x80, 0x7E, 0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x3F, 0x83, 0xFE, 0x03, 0xF0,
  0x7F, 0x8F, 0x7E, 0x0F, 0xC0, 0xFF, 0xFE, 0xFC, 0x3F, 0x80, 0xFF, 0xF9,
  0xFF, 0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xE0,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xF7, 0xF3, 0xE1, 0xFC,
  0x3F, 0xF1, 0xFC, 0xF0, 0x7F, 0x1F, 0xF0, 0x3F, 0x78, 0x0F, 0xC3, 0xF8,
  0x0F, 0xDC, 0x03, 0xF0, 0xF8, 0x03, 0xF7, 0x00, 0xFC, 0x1C, 0x00, 0xFF,
  0x80, 0x3F, 0x04, 0x00, 0x3F, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x03,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80,
  0x3F, 0xE0, 0x02, 0x0F, 0xE0, 0x1D, 0xF8, 0x03, 0xC3, 0xF8, 0x07, 0x7E,
  0x01, 0xF8, 0xFE, 0x03, 0xDF, 0x81, 0xFE, 0x3F, 0x80, 0xE7, 0xE0, 0xFF,
  0xCF, 0xE0, 0x79, 0xF8, 0x7F, 0xC3, 0xFC, 0x3E, 0x7F, 0x7F, 0xE0, 0x7F,
  0xFF, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xBF,
  0xC0, 0x3F, 0xE0, 0x0E, 0xFF, 0x00, 0x7F, 0xE0, 0xF3, 0xF8, 0x01, 0xFF,
  0xFF, 0xCF, 0xE0, 0x03, 0xFF, 0xFE, 0x3F, 0x80, 0x0F, 0xFF, 0xF1, 0xFE,
  0x00, 0x1F, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xFC, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x80, 0x00, 0x3F, 0xE0, 0x03, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xC0,
  0x7F, 0xFF, 0xE0, 0xFE, 0x07, 0xFF, 0xFF, 0xC7, 0xF0, 0x7F, 0xFF, 0xFF,
  0x3F, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC,
  0x00, 0xFF, 0xFE, 0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x7E, 0x00, 0x03, 0xFE,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0x00, 0x03, 0xFE, 0x01, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x80, 0x00, 0xFF, 0x80, 0x3C,
  0x00, 0x0F, 0xF8, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xF0,
  0x00, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0x81,
  0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xFF, 0xC0, 0x03, 0xF1, 0xFF, 0xFF, 0xE0,
  0x1F, 0x9F, 0xFF, 0xFF, 0xF8, 0xFC, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xF0,
  0x7F, 0xFF, 0xFE, 0x3F, 0x80, 0x7F, 0xFF, 0xF1, 0xFC, 0x00, 0xFF, 0xFF,
  0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x70, 0x01,
  0xFF, 0x80, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x1F, 0xFF, 0x80,
  0x07, 0xE0, 0x7F, 0xFF, 0x80, 0x0F, 0xC1, 0xFF, 0xFF, 0x80, 0x3F, 0x83,
  0xF8, 0xFF, 0x00, 0x7E, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0xFF,
  0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x1F, 0xE0, 0xFC, 0x00, 0xFF, 0xFF, 0x83,
  0xF8, 0x01, 0xFF, 0xFE, 0x07, 0xE0, 0x01, 0xFF, 0xF8, 0x0F, 0xC0, 0x01,
  0xFF, 0xE0, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x06, 0x00, 0x00, 0xFC, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 18, 51, 43, 13, -50 },
  { 116, 24, 21, 43, 13, -53 },
  { 179, 44, 50, 43, 0, -50 },
  { 454, 41, 65, 43, 1, -57 },
  { 788, 49, 51, 43, -2, -50 },
  { 1101, 42, 51, 43, 0, -50 },
  { 1369, 10, 21, 43, 20, -53 },
  { 1396, 28, 64, 43, 14, -54 },
  { 1620, 28, 64, 43, 2, -54 },
  { 1844, 36, 35, 43, 4, -39 },
  { 2002, 34, 34, 43, 5, -39 },
  { 2147, 18, 21, 43, 9, -11 },
  { 2195, 22, 7, 43, 11, -25 },
  { 2215, 12, 12, 43, 13, -11 },
  { 2233, 41, 64, 43, 1, -54 },
  { 2561, 37, 51, 43, 4, -50 },
  { 2797, 35, 50, 43, 3, -50 },
  { 3016, 38, 50, 43, 2, -50 },
  { 3254, 39, 51, 43, 1, -50 },
  { 3503, 39, 50, 43, 1, -50 },
  { 3747, 39, 51, 43, 2, -50 },
  { 3996, 35, 51, 43, 4, -50 },
  { 4220, 37, 50, 43, 6, -50 },
  { 4452, 39, 51, 43, 2, -50 },
  { 4701, 36, 50, 43, 5, -50 },
  { 4926, 17, 39, 43, 13, -38 },
  { 5009, 21, 48, 43, 9, -38 },
  { 5135, 34, 41, 43, 6, -42 },
  { 5310, 37, 21, 43, 3, -32 },
  { 5408, 35, 41, 43, 3, -42 },
  { 5588, 32, 51, 43, 8, -50 },
  { 5792, 38, 58, 43, 3, -50 },
  { 6068, 39, 50, 43, -1, -50 },
  { 6312, 37, 50, 43, 3, -50 },
  { 6544, 37, 51, 43, 5, -50 },
  { 6780, 38, 50, 43, 3, -50 },
  { 7018, 39, 50, 43, 3, -50 },
  { 7262, 40, 50, 43, 3, -50 },
  { 7512, 37, 51, 43, 4, -50 },
  { 7748, 41, 50, 43, 2, -50 },
  { 8005, 39, 50, 43, 3, -50 },
  { 8249, 37, 51, 43, 3, -50 },
  { 8485, 43, 50, 43, 3, -50 },
  { 8754, 31, 50, 43, 5, -50 },
  { 8948, 43, 50, 43, 1, -50 },
  { 9217, 41, 50, 43, 2, -50 },
  { 9474, 37, 51, 43, 4, -50 },
  { 9710, 39, 50, 43, 3, -50 },
  { 9954, 37, 64, 43, 4, -50 },
  { 10250, 39, 50, 43, 3, -50 },
  { 10494, 41, 51, 43, 1, -50 },
  { 10756, 40, 50, 43, 6, -50 },
  { 11006, 39, 51, 43, 4, -50 },
  { 11255, 39, 50, 43, 7, -50 },
  { 11499, 44, 50, 43, 2, -50 },
  { 11774, 48, 50, 43, -2, -50 },
  { 12074, 41, 50, 43, 6, -50 },
  { 12331, 43, 50, 43, 0, -50 },
  { 12600, 32, 64, 43, 10, -54 },
  { 12856, 20, 64, 43, 12, -54 },
  { 13016, 32, 64, 43, 1, -54 },
  { 13272, 37, 30, 43, 4, -50 },
  { 13411, 35, 7, 43, 0, 6 },
  { 13442, 11, 15, 43, 15, -56 },
  { 13463, 36, 38, 43, 3, -37 },
  { 13634, 36, 54, 43, 3, -53 },
  { 13877, 33, 38, 43, 5, -37 },
  { 14034, 39, 54, 43, 3, -53 },
  { 14298, 33, 38, 43, 5, -37 },
  { 14455, 48, 68, 43, -2, -53 },
  { 14863, 38, 52, 43, 2, -37 },
  { 15110, 35, 53, 43, 3, -53 },
  { 15342, 34, 55, 43, 5, -54 },
  { 15576, 34, 69, 43, 3, -54 },
  { 15870, 38, 54, 43, 3, -53 },
  { 16127, 30, 54, 43, 7, -53 },
  { 16330, 41, 37, 43, 0, -37 },
  { 16520, 35, 37, 43, 3, -37 },
  { 16682, 35, 38, 43, 4, -37 },
  { 16849, 39, 51, 43, 0, -37 },
  { 17098, 37, 51, 43, 3, -37 },
  { 17334, 35, 37, 43, 7, -37 },
  { 17496, 35, 38, 43, 3, -37 },
  { 17663, 34, 51, 43, 5, -50 },
  { 17880, 34, 38, 43, 5, -37 },
  { 18042, 35, 38, 43, 4, -37 },
  { 18209, 39, 38, 43, 2, -37 },
  { 18395, 42, 38, 43, 0, -37 },
  { 18595, 38, 52, 43, 1, -37 },
  { 18842, 37, 38, 43, 3, -37 },
  { 19018, 33, 64, 43, 8, -54 },
  { 19282, 18, 64, 43, 13, -54 },
  { 19426, 34, 64, 43, 2, -54 },
  { 19698, 39, 16, 43, 2, -30 },
};

const GFXfont IBMPlexMono_MediumItalic71pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic71pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic71pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _IBMPLEXMONO_MEDIUMITALIC71PT7B_H_
