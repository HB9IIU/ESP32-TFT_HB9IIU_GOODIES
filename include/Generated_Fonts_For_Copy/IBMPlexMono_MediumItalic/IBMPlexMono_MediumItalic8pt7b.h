#ifndef _IBMPLEXMONO_MEDIUMITALIC8PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x30, 0x74, 0x29, 0x96, 0xAE, 0x50, 0x33, 0xD8, 0x63, 0x79,
  0x00, 0x6D, 0x6C, 0xAE, 0xD8, 0x32, 0x95, 0x4B, 0x6C, 0xC0, 0x72, 0x49,
  0x30, 0x64, 0x92, 0x70, 0x27, 0xD9, 0x60, 0x5D, 0x20, 0x60, 0xE0, 0xC0,
  0x18, 0x88, 0x44, 0x22, 0x00, 0x32, 0x53, 0x59, 0x38, 0x35, 0x22, 0x2F,
  0x32, 0x86, 0x64, 0x78, 0x32, 0x86, 0x61, 0x78, 0x11, 0x94, 0xAF, 0x90,
  0x7A, 0x18, 0xA1, 0x78, 0x12, 0x65, 0x97, 0xF9, 0x24, 0x48, 0x32, 0x54,
  0xE9, 0x38, 0x69, 0x9E, 0x2C, 0x43, 0x41, 0x80, 0x16, 0x84, 0x20, 0x78,
  0x3C, 0x42, 0x12, 0xC0, 0x74, 0xA1, 0x80, 0x32, 0x6F, 0x6D, 0x51, 0x80,
  0x33, 0x55, 0x79, 0x72, 0x54, 0xE9, 0x78, 0x69, 0x88, 0xAE, 0x62, 0x92,
  0x99, 0x78, 0x7A, 0x10, 0xE8, 0x78, 0x7A, 0x10, 0xE8, 0x40, 0x32, 0x51,
  0x69, 0x38, 0x4A, 0x54, 0xE9, 0x48, 0x79, 0x08, 0x42, 0x78, 0x38, 0x84,
  0x21, 0x70, 0x4A, 0x98, 0xC9, 0x48, 0x92, 0x49, 0xC0, 0x4A, 0xEB, 0x6D,
  0x48, 0x4B, 0x5D, 0x6B, 0x48, 0x32, 0x53, 0x19, 0x38, 0x72, 0x52, 0xE8,
  0x40, 0x32, 0x53, 0x19, 0x38, 0xC5, 0x72, 0x52, 0xEA, 0x48, 0x32, 0xD0,
  0x61, 0x78, 0xF4, 0x44, 0x44, 0x4A, 0x54, 0xA9, 0x38, 0x99, 0xAA, 0xCC,
  0x4C, 0x6B, 0xED, 0x68, 0x4A, 0x8C, 0x45, 0x48, 0x99, 0xA4, 0x44, 0x78,
  0x84, 0x44, 0x78, 0x74, 0x48, 0x88, 0xE0, 0x91, 0x24, 0x98, 0x72, 0x22,
  0x22, 0xE0, 0x21, 0x95, 0x10, 0xF0, 0x80, 0x79, 0x97, 0x44, 0x75, 0x9F,
  0xF2, 0xF0, 0x08, 0x5D, 0x29, 0x38, 0xF7, 0x70, 0x19, 0x1E, 0x42, 0x12,
  0x88, 0x79, 0x97, 0x1E, 0x44, 0x75, 0x99, 0x43, 0x2B, 0x80, 0x10, 0x71,
  0x22, 0xE6, 0x42, 0x1C, 0xAA, 0x5C, 0xC9, 0x4B, 0x80, 0x7D, 0x6D, 0x60,
  0x75, 0x99, 0x79, 0x97, 0x75, 0x9F, 0x88, 0x79, 0x97, 0x11, 0xF4, 0x88,
  0x74, 0x3F, 0x4B, 0xCB, 0x80, 0xB6, 0xF0, 0xD5, 0x56, 0xAD, 0x6D, 0xE0,
  0x7D, 0x09, 0xE0, 0x55, 0x97, 0x1E, 0x79, 0x15, 0xE0, 0x74, 0x48, 0x48,
  0xE0, 0xFE, 0x72, 0x21, 0x62, 0xE0, 0xF9, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 6, 5, 1, -6 },
  { 3, 3, 2, 5, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 5, 7, 5, 0, -6 },
  { 13, 5, 6, 5, 0, -6 },
  { 17, 5, 6, 5, 0, -6 },
  { 21, 1, 2, 5, 2, -6 },
  { 22, 3, 7, 5, 2, -6 },
  { 25, 3, 7, 5, 0, -6 },
  { 28, 5, 4, 5, 0, -4 },
  { 31, 3, 4, 5, 1, -4 },
  { 33, 2, 2, 5, 1, -1 },
  { 34, 3, 1, 5, 1, -3 },
  { 35, 2, 1, 5, 1, -1 },
  { 36, 5, 7, 5, 0, -6 },
  { 41, 5, 6, 5, 0, -6 },
  { 45, 4, 6, 5, 0, -6 },
  { 48, 5, 6, 5, 0, -6 },
  { 52, 5, 6, 5, 0, -6 },
  { 56, 5, 6, 5, 0, -6 },
  { 60, 5, 6, 5, 0, -6 },
  { 64, 4, 6, 5, 0, -6 },
  { 67, 4, 6, 5, 1, -6 },
  { 70, 5, 6, 5, 0, -6 },
  { 74, 4, 6, 5, 1, -6 },
  { 77, 2, 4, 5, 1, -4 },
  { 78, 2, 5, 5, 1, -4 },
  { 80, 4, 5, 5, 1, -5 },
  { 83, 5, 3, 5, 0, -4 },
  { 85, 4, 5, 5, 0, -5 },
  { 88, 3, 6, 5, 1, -6 },
  { 91, 5, 7, 5, 0, -6 },
  { 96, 4, 6, 5, 0, -6 },
  { 99, 5, 6, 5, 0, -6 },
  { 103, 4, 6, 5, 1, -6 },
  { 106, 5, 6, 5, 0, -6 },
  { 110, 5, 6, 5, 0, -6 },
  { 114, 5, 6, 5, 0, -6 },
  { 118, 5, 6, 5, 0, -6 },
  { 122, 5, 6, 5, 0, -6 },
  { 126, 5, 6, 5, 0, -6 },
  { 130, 5, 6, 5, 0, -6 },
  { 134, 5, 6, 5, 0, -6 },
  { 138, 3, 6, 5, 1, -6 },
  { 141, 5, 6, 5, 0, -6 },
  { 145, 5, 6, 5, 0, -6 },
  { 149, 5, 6, 5, 0, -6 },
  { 153, 5, 6, 5, 0, -6 },
  { 157, 5, 8, 5, 0, -6 },
  { 162, 5, 6, 5, 0, -6 },
  { 166, 5, 6, 5, 0, -6 },
  { 170, 4, 6, 5, 1, -6 },
  { 173, 5, 6, 5, 0, -6 },
  { 177, 4, 6, 5, 1, -6 },
  { 180, 5, 6, 5, 0, -6 },
  { 184, 5, 6, 5, 0, -6 },
  { 188, 4, 6, 5, 1, -6 },
  { 191, 5, 6, 5, 0, -6 },
  { 195, 4, 7, 5, 1, -6 },
  { 199, 3, 7, 5, 1, -6 },
  { 202, 4, 7, 5, 0, -6 },
  { 206, 5, 4, 5, 0, -6 },
  { 209, 4, 1, 5, 0, 1 },
  { 210, 1, 1, 5, 2, -6 },
  { 211, 4, 4, 5, 0, -4 },
  { 213, 4, 6, 5, 0, -6 },
  { 216, 3, 4, 5, 1, -4 },
  { 218, 5, 6, 5, 0, -6 },
  { 222, 3, 4, 5, 1, -4 },
  { 224, 5, 8, 5, 0, -6 },
  { 229, 4, 6, 5, 0, -4 },
  { 232, 4, 6, 5, 0, -6 },
  { 235, 3, 6, 5, 1, -6 },
  { 238, 4, 8, 5, 0, -6 },
  { 242, 5, 6, 5, 0, -6 },
  { 246, 3, 6, 5, 1, -6 },
  { 249, 5, 4, 5, 0, -4 },
  { 252, 4, 4, 5, 0, -4 },
  { 254, 4, 4, 5, 0, -4 },
  { 256, 4, 6, 5, 0, -4 },
  { 259, 4, 6, 5, 0, -4 },
  { 262, 4, 4, 5, 1, -4 },
  { 264, 4, 4, 5, 0, -4 },
  { 266, 3, 6, 5, 1, -6 },
  { 269, 3, 4, 5, 1, -4 },
  { 271, 4, 4, 5, 0, -4 },
  { 273, 5, 4, 5, 0, -4 },
  { 276, 5, 4, 5, 0, -4 },
  { 279, 4, 6, 5, 0, -4 },
  { 282, 5, 4, 5, 0, -4 },
  { 285, 4, 7, 5, 1, -6 },
  { 289, 1, 7, 5, 2, -6 },
  { 290, 4, 7, 5, 0, -6 },
  { 294, 5, 2, 5, 0, -3 },
};

const GFXfont IBMPlexMono_MediumItalic8pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic8pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic8pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _IBMPLEXMONO_MEDIUMITALIC8PT7B_H_
