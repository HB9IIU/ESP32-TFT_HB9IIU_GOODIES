#ifndef _IBMPLEXMONO_MEDIUMITALIC69PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x7E, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFC, 0x07, 0xF3, 0xF8, 0x0F,
  0xE7, 0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC,
  0x7E, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F,
  0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFC,
  0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x02, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xE7, 0xCF, 0xFE, 0x00, 0xFF, 0x87, 0xC3, 0xFF, 0x01, 0xFE, 0x07, 0xC0,
  0xFC, 0x01, 0xFE, 0x07, 0xC0, 0x78, 0x03, 0xFC, 0x07, 0xC0, 0x30, 0x03,
  0xFC, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x0F,
  0x80, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x00,
  0x03, 0xFC, 0x0F, 0x80, 0x00, 0x03, 0xFC, 0x0F, 0x80, 0x00, 0x03, 0xFE,
  0x0F, 0x80, 0x00, 0x01, 0xFF, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x3F, 0xF0, 0x00, 0x00,
  0x7C, 0x1F, 0xF0, 0x00, 0x00, 0x7C, 0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x07,
  0xF8, 0x00, 0x00, 0x7C, 0x07, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xF8, 0x00,
  0x00, 0x7C, 0x07, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xF8, 0x00, 0x00, 0xF8,
  0x07, 0xF0, 0x04, 0x00, 0xF8, 0x0F, 0xF0, 0x1E, 0x00, 0xF8, 0x0F, 0xF0,
  0x3F, 0x00, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xF8, 0x3F, 0xE0, 0xFF, 0xE0,
  0xF8, 0x7F, 0xC0, 0x7F, 0xF9, 0xF1, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xE0, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x1F,
  0x80, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC1, 0xF8,
  0x00, 0x03, 0xF0, 0x1F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x87, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x0F, 0xC0,
  0x00, 0x00, 0xFF, 0xFC, 0x10, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE1, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x1F,
  0x80, 0x00, 0x1F, 0x83, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x87, 0xE0, 0x0F,
  0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0x7F, 0xE3, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x87, 0xF8,
  0x00, 0x7F, 0x00, 0xF3, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xFE, 0x00, 0x3F,
  0xE0, 0x7E, 0x7F, 0x00, 0x1B, 0xF8, 0x7F, 0x3F, 0xC0, 0x1D, 0xFC, 0x3F,
  0x1F, 0xE0, 0x1E, 0xFE, 0x3F, 0x8F, 0xFC, 0x1E, 0x3F, 0xBF, 0x83, 0xFF,
  0xFF, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x83,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE1, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7E, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x02, 0x00,
  0x0F, 0xE0, 0x02, 0x1C, 0x00, 0xFC, 0x00, 0xE3, 0xF8, 0x0F, 0xC0, 0x7F,
  0x3F, 0xF0, 0xFC, 0x3F, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x1F,
  0xE1, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x0F, 0xC1, 0xFF,
  0x8F, 0xFC, 0xFF, 0xF7, 0xFF, 0xBF, 0xFB, 0xFF, 0xDF, 0xFE, 0x7F, 0xE3,
  0xFF, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x80,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7,
  0xF8, 0x1F, 0x80, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0,
  0xFF, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFE, 0xFF, 0x07,
  0xFC, 0x1F, 0xEF, 0xF0, 0x3F, 0x81, 0xFE, 0xFE, 0x03, 0xF0, 0x1F, 0xEF,
  0xE0, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03,
  0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x03, 0xFC, 0xFE, 0x00,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0,
  0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x1F, 0xF0, 0x3F,
  0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFC, 0x01,
  0xFE, 0x00, 0x1E, 0x00, 0x7F, 0x80, 0x03, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01,
  0xFE, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x00, 0x7F, 0x80, 0x10,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0xFE, 0x00, 0x07, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x03, 0x80, 0x00,
  0x3F, 0xC0, 0x04, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x00,
  0x03, 0xFC, 0x07, 0x80, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xFE,
  0x00, 0x00, 0xFC, 0x3F, 0xFE, 0x00, 0x03, 0xF1, 0xFF, 0xFE, 0x00, 0x1F,
  0xCF, 0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0xFF, 0xF8, 0x01, 0xFB, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x38, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x18, 0x00, 0x00, 0xFF, 0x00, 0xF0, 0x00, 0x07, 0xFC,
  0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFF, 0x80,
  0x0F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x87, 0xFF,
  0xC0, 0x1F, 0xE7, 0xFF, 0xF8, 0x0F, 0xF3, 0xFF, 0xFF, 0x83, 0xFD, 0xFF,
  0xFF, 0xE1, 0xFE, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x07, 0xFF, 0x9F, 0xFC,
  0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00,
  0x7F, 0xBF, 0x80, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x07, 0xFC, 0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0x00, 0x1F,
  0xE3, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00,
  0x07, 0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x87, 0xF0, 0x00, 0x0F, 0xF0, 0x7E,
  0x00, 0x01, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F,
  0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xC0,
  0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0x87, 0xFC, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x01, 0xFC,
  0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x07, 0xFC, 0xFF,
  0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x1F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xFF, 0x87, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F, 0xFF, 0xFB,
  0xFC, 0x07, 0xFF, 0xFE, 0x7F, 0x80, 0x7F, 0xFF, 0x9F, 0xE0, 0x07, 0xFF,
  0xC3, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x07,
  0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x40, 0x0F, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xE0, 0x03, 0xFE, 0x7F, 0x80,
  0x03, 0xFC, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x07, 0xF9, 0xF0, 0x00,
  0x0F, 0xF0, 0x60, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F,
  0xE0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x80,
  0x3F, 0x0F, 0xE1, 0xF8, 0x07, 0xFE, 0x7E, 0x1F, 0xC0, 0x7F, 0xF3, 0xF0,
  0xFE, 0x07, 0xFF, 0xDF, 0x87, 0xE0, 0x7F, 0xFE, 0xFC, 0x3F, 0x03, 0xFC,
  0x3F, 0xE3, 0xF8, 0x3F, 0x80, 0xFF, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0xFC,
  0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0xFE, 0x00, 0xFC, 0x3F, 0x07, 0xE0, 0x07,
  0xE3, 0xF8, 0x3F, 0x00, 0x3F, 0x1F, 0xC3, 0xF8, 0x01, 0xF8, 0xFE, 0x1F,
  0xC0, 0x1F, 0xC7, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x07, 0xE0, 0x07, 0xE1,
  0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7E, 0x0F, 0xC0,
  0x1F, 0xC7, 0xF0, 0x7E, 0x00, 0xFE, 0x3F, 0x83, 0xF0, 0x0F, 0xE1, 0xF8,
  0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0xFE, 0x07, 0xF8, 0x7E, 0x07, 0xF8, 0xEF,
  0xC3, 0xF0, 0x3F, 0xFF, 0x7E, 0x1F, 0x80, 0xFF, 0xF7, 0xF0, 0xFC, 0x07,
  0xFF, 0xBF, 0x07, 0xE0, 0x1F, 0xF9, 0xF8, 0x1F, 0x80, 0x7F, 0x8F, 0xC0,
  0xFC, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x1F,
  0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x03, 0xFC, 0x3F,
  0x80, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF0, 0x00,
  0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0xFF,
  0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x0F, 0xC1, 0xFE, 0x00, 0x00, 0x40, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x02, 0x00, 0xFE,
  0x00, 0x00, 0x7C, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0x80, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xFC, 0x03,
  0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07,
  0xC1, 0xFE, 0x00, 0x00, 0x40, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0xFC, 0xFF,
  0x00, 0x7F, 0xFF, 0x8F, 0xF0, 0x07, 0xFF, 0xF8, 0xFF, 0x00, 0x7F, 0xFF,
  0x8F, 0xF0, 0x07, 0xFF, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0x03, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x03, 0xF0, 0xFF,
  0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x0E, 0xFE, 0x03, 0xFF, 0x03, 0xEF, 0xE0, 0x3F, 0xFF, 0xFC, 0xFE,
  0x01, 0xFF, 0xFF, 0x8F, 0xC0, 0x0F, 0xFF, 0xF9, 0xFC, 0x00, 0x7F, 0xFF,
  0x1F, 0xC0, 0x03, 0xFF, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0E,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x3F,
  0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xC0, 0x00,
  0x03, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE1, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x9F,
  0xF0, 0x00, 0x00, 0x0F, 0xF7, 0xFE, 0x00, 0x00, 0x01, 0xFD, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xDF, 0xF0, 0x00, 0x00, 0xFF, 0xF1, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x3F, 0xC0, 0x00, 0x07, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03,
  0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0xFD, 0xFC, 0x03, 0xF3, 0xF0, 0x7F, 0x7F,
  0x00, 0xFC, 0xFC, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x0F, 0xE7, 0xE0, 0x1F,
  0xCF, 0xC3, 0xF3, 0xF8, 0x07, 0xF1, 0xF9, 0xF8, 0xFE, 0x01, 0xFC, 0x7E,
  0x7E, 0x3F, 0x80, 0x7F, 0x1F, 0xBF, 0x0F, 0xE0, 0x1F, 0x87, 0xFF, 0xC3,
  0xF0, 0x07, 0xE0, 0xFF, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0xF8, 0x7F, 0x00,
  0xFE, 0x0F, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0xFF, 0x81, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xF0,
  0x3F, 0x80, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0x80, 0x3F, 0x80, 0x7E,
  0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x30, 0x07, 0xF0, 0x0F, 0xE0, 0x04,
  0x01, 0xFC, 0x03, 0xF8, 0x02, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7E, 0x01, 0xFF, 0x80,
  0x01, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xF0,
  0x1F, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0xF8,
  0x00, 0x3F, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFC,
  0x03, 0xFF, 0xE0, 0x03, 0xF8, 0x0F, 0xEF, 0xC0, 0x07, 0xF0, 0x1F, 0xDF,
  0x80, 0x0F, 0xE0, 0x3F, 0xBF, 0x80, 0x1F, 0x80, 0x7F, 0x7F, 0x00, 0x7F,
  0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x07, 0xF1,
  0xF8, 0x03, 0xF8, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F,
  0xC0, 0x3F, 0x87, 0xE0, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x7F, 0x00, 0xFC,
  0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0x3F,
  0x81, 0xFC, 0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0x07, 0xE1, 0xFC, 0x07, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F,
  0xE0, 0x1F, 0xCF, 0xE0, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x3F, 0x00, 0x7F,
  0x3F, 0x80, 0xFE, 0x00, 0x7E, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0xFC, 0x03,
  0xF8, 0x01, 0xFD, 0xF8, 0x07, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0x07,
  0xFF, 0xE0, 0x1F, 0x80, 0x07, 0xFF, 0xC0, 0x7F, 0x00, 0x0F, 0xFF, 0x80,
  0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xF8, 0x00,
  0x3F, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0xE0,
  0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03,
  0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x03, 0xFC, 0xFE, 0x00,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x8F,
  0xE0, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00,
  0xFF, 0x81, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFE, 0xFE, 0x00,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xCF,
  0xE0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0x00, 0x00, 0x7F, 0x00,
  0x78, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x00, 0xFF, 0x81, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x78,
  0x01, 0xFE, 0x00, 0x00, 0x30, 0x03, 0xFC, 0x00, 0x00, 0x40, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x04, 0x00, 0x00, 0x0F,
  0xF0, 0x0E, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x80,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x81,
  0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFF, 0x80, 0xFC, 0x07, 0xF0,
  0x1F, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0xFF,
  0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xFF, 0x03,
  0xF0, 0x0F, 0xC0, 0xFF, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x7C, 0x1F, 0xC0,
  0x3F, 0x03, 0xEF, 0x83, 0xF8, 0x07, 0xE0, 0xF9, 0xF0, 0x7E, 0x01, 0xFC,
  0x1F, 0x3E, 0x0F, 0xC0, 0x3F, 0x87, 0xE7, 0xC1, 0xF8, 0x07, 0xF0, 0xF8,
  0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x1F, 0x0F, 0xC0, 0x1F, 0x87, 0xE3, 0xE1,
  0xF8, 0x03, 0xF0, 0xF8, 0x7C, 0x3F, 0x00, 0x7E, 0x1F, 0x0F, 0x8F, 0xE0,
  0x0F, 0xC7, 0xE1, 0xF1, 0xF8, 0x01, 0xF8, 0xF8, 0x3E, 0x3F, 0x00, 0x3F,
  0x1F, 0x07, 0xC7, 0xE0, 0x0F, 0xE7, 0xE0, 0xF9, 0xFC, 0x01, 0xFC, 0xF8,
  0x1F, 0x3F, 0x00, 0x3F, 0x9F, 0x03, 0xE7, 0xE0, 0x07, 0xF7, 0xE0, 0x7C,
  0xFC, 0x00, 0xFC, 0xF8, 0x0F, 0x9F, 0x80, 0x1F, 0x9F, 0x01, 0xF7, 0xE0,
  0x03, 0xF7, 0xC0, 0x3E, 0xFC, 0x00, 0x7E, 0xF8, 0x07, 0xDF, 0x80, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x7F,
  0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x07, 0xF3, 0xC0, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x02, 0x01, 0xC0, 0xFC, 0x7F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0,
  0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0x80, 0xC0, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xFF, 0x83, 0xFC, 0x01, 0xFF, 0xFC, 0x7F,
  0x80, 0xFF, 0xFF, 0xCF, 0xE0, 0x3F, 0xFF, 0xF9, 0xFC, 0x07, 0xFF, 0xFF,
  0xBF, 0x81, 0xFF, 0xC0, 0xF7, 0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x0F, 0xF0,
  0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x80,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0x80, 0x03,
  0xFF, 0x07, 0xF8, 0x00, 0xDF, 0xC0, 0xFF, 0x80, 0x7B, 0xF8, 0x1F, 0xF8,
  0x1E, 0x7F, 0xF1, 0xFF, 0xFF, 0xCF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3F, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0x0F, 0xFF, 0xC0,
  0x1F, 0xE3, 0xFF, 0xFC, 0x03, 0xF8, 0xFF, 0xFF, 0xC0, 0x7F, 0x3F, 0xFF,
  0xFC, 0x0F, 0xEF, 0x81, 0xFF, 0x83, 0xFD, 0xC0, 0x0F, 0xF0, 0x7F, 0xF0,
  0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x03, 0xFC, 0x3F,
  0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0xFE,
  0x3F, 0xC0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00,
  0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x7F,
  0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x01, 0xFC,
  0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03,
  0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xE0, 0xFE, 0xF0,
  0x1F, 0xF8, 0x3F, 0xDF, 0xFF, 0xFF, 0x07, 0xF9, 0xFF, 0xFF, 0xC0, 0xFF,
  0x3F, 0xFF, 0xF0, 0x1F, 0xC3, 0xFF, 0xF8, 0x03, 0xF8, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7C, 0x3F, 0xC0, 0x00,
  0x60, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x60, 0xFE, 0x00, 0x00, 0x78, 0xFE, 0x00, 0x00,
  0xFC, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x07,
  0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x1F, 0xFE, 0x0F, 0xE0, 0x01, 0xFF, 0xFC, 0x3F, 0x80, 0x0F,
  0xFF, 0xF8, 0xFE, 0x00, 0x7F, 0xFF, 0xF3, 0xF8, 0x03, 0xFF, 0xFF, 0xDF,
  0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0x80,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xE0, 0x03,
  0xBF, 0x80, 0x7F, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0x81, 0xF7, 0xF8, 0x03,
  0xFF, 0xFF, 0x9F, 0xC0, 0x0F, 0xFF, 0xFE, 0x7F, 0x00, 0x1F, 0xFF, 0xF1,
  0xFC, 0x00, 0x3F, 0xFF, 0x87, 0xF0, 0x00, 0x7F, 0xF8, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF,
  0x1F, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0x03, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x20, 0xFE, 0x00, 0x00, 0x70,
  0xFE, 0x00, 0x00, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x08, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x38, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0xF8, 0x3F, 0x80, 0x0F, 0xFF,
  0xE1, 0xFC, 0x01, 0xFF, 0xFF, 0x8F, 0xE0, 0x1F, 0xFF, 0xFE, 0x7F, 0x00,
  0xFF, 0xFF, 0xF7, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x81, 0xFC, 0x00, 0x0F, 0xF8,
  0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x0E, 0xFE, 0x03, 0xFE, 0x00,
  0xF7, 0xF0, 0x0F, 0xF8, 0x1F, 0x7F, 0x80, 0x7F, 0xFF, 0xF3, 0xFC, 0x01,
  0xFF, 0xFF, 0x9F, 0xC0, 0x0F, 0xFF, 0xF8, 0xFE, 0x00, 0x3F, 0xFF, 0x87,
  0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x80, 0x00,
  0x3F, 0xC0, 0x06, 0x00, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xFC, 0x00, 0xFE, 0x1F, 0xFF,
  0x80, 0x7F, 0x8F, 0xFF, 0xF0, 0x1F, 0xE7, 0xFF, 0xFC, 0x07, 0xF9, 0xFF,
  0xFF, 0x81, 0xFE, 0xF0, 0x3F, 0xE0, 0x7F, 0x78, 0x07, 0xF8, 0x1F, 0xD8,
  0x00, 0xFF, 0x0F, 0xF4, 0x00, 0x3F, 0xC3, 0xFF, 0x00, 0x0F, 0xF0, 0xFF,
  0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFE,
  0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xFE,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC,
  0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x08, 0x00, 0x7F, 0x80, 0x3C, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFE, 0x1F, 0xF0, 0x00, 0xFE, 0x3F,
  0xE0, 0x00, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x08, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0xC0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x03, 0xFE, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xFC, 0x00, 0x1F, 0xC3, 0xFF,
  0xF0, 0x01, 0xFE, 0x3F, 0xFF, 0xC0, 0x0F, 0xF3, 0xFF, 0xFF, 0x00, 0x7F,
  0xBF, 0xFF, 0xF8, 0x03, 0xF9, 0xE0, 0x7F, 0xE0, 0x1F, 0xDC, 0x01, 0xFF,
  0x00, 0xFE, 0xC0, 0x07, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xE0,
  0x01, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x03,
  0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0x07, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0x8F, 0xFE, 0x00,
  0x01, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x18, 0x3F, 0x83, 0xFC, 0x01, 0xE1,
  0xFC, 0x0F, 0xE0, 0x1F, 0x8F, 0xE0, 0x7F, 0x81, 0xFE, 0xFF, 0x01, 0xFC,
  0x1F, 0xE7, 0xF8, 0x0F, 0xF1, 0xFE, 0x3F, 0x80, 0x3F, 0x9F, 0xE1, 0xFC,
  0x01, 0xFF, 0xFE, 0x0F, 0xE0, 0x0F, 0xFF, 0xE0, 0x7F, 0x00, 0x3F, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x01, 0x80, 0x3F, 0x80, 0x1E, 0x01, 0xFC, 0x01, 0xF8, 0x1F, 0xE0, 0x1F,
  0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x81, 0xFE, 0x01,
  0xFC, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x07, 0xF3,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x03, 0xF1, 0xFE, 0x07, 0xFC, 0x03, 0xF3,
  0xFF, 0x0F, 0xFE, 0x07, 0xF3, 0xFF, 0x9F, 0xFE, 0x07, 0xF7, 0xFF, 0xBF,
  0xFF, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0x07, 0xEC, 0x3F, 0xF8, 0xFF, 0x07,
  0xF8, 0x1F, 0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x1F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x1F, 0x80, 0x7F,
  0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x3F, 0x00,
  0xFE, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x1F,
  0x80, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7E,
  0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x01, 0xFC,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x03,
  0xF8, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x7E,
  0x01, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x07, 0xE0,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0x87, 0xFF,
  0xE0, 0x1F, 0xE3, 0xFF, 0xFC, 0x07, 0xF9, 0xFF, 0xFF, 0x01, 0xFE, 0x7F,
  0xFF, 0xE0, 0x7F, 0x3C, 0x0F, 0xF8, 0x1F, 0xDE, 0x01, 0xFE, 0x07, 0xF6,
  0x00, 0x3F, 0xC3, 0xFD, 0x00, 0x0F, 0xF0, 0xFF, 0xC0, 0x03, 0xFC, 0x3F,
  0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0,
  0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x3F,
  0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01,
  0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xE0,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x7F,
  0x80, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F,
  0x0F, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0xFE,
  0x7F, 0x80, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x00, 0x7F, 0xBF, 0x80, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC,
  0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0xFF,
  0xFC, 0x00, 0x3F, 0xC7, 0xFF, 0xF8, 0x00, 0xFE, 0x3F, 0xFF, 0xF0, 0x03,
  0xF9, 0xFF, 0xFF, 0xE0, 0x0F, 0xEF, 0x81, 0xFF, 0x80, 0x7F, 0xB8, 0x01,
  0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0xFE, 0xF0,
  0x1F, 0xF8, 0x03, 0xFB, 0xFF, 0xFF, 0xE0, 0x1F, 0xE7, 0xFF, 0xFF, 0x00,
  0x7F, 0x9F, 0xFF, 0xF8, 0x01, 0xFC, 0x3F, 0xFF, 0x80, 0x07, 0xF0, 0x7F,
  0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x01, 0xFF, 0xE0, 0xFE, 0x00, 0x7F, 0xFF, 0x0F, 0xE0, 0x0F,
  0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xFF, 0xCF, 0xE0, 0x3F, 0xFF, 0xFD, 0xFE,
  0x07, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00,
  0x3F, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01,
  0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF0,
  0x00, 0x7F, 0xE0, 0x7F, 0x80, 0x0E, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0xE0,
  0x7F, 0xE0, 0x7D, 0xFE, 0x03, 0xFF, 0xFF, 0x9F, 0xC0, 0x3F, 0xFF, 0xF1,
  0xFC, 0x01, 0xFF, 0xFF, 0x1F, 0xC0, 0x0F, 0xFF, 0xE1, 0xFC, 0x00, 0x7F,
  0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xDF, 0xFF,
  0xE0, 0x7F, 0xF7, 0xFF, 0xF8, 0x3F, 0xF9, 0xFF, 0xFE, 0x1F, 0xFE, 0xFF,
  0xFF, 0x8F, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xE0, 0x07, 0xFB, 0xFF, 0xF8,
  0x01, 0xFC, 0xF8, 0x00, 0x00, 0x7F, 0x70, 0x00, 0x00, 0x1F, 0xD8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x7C, 0x07, 0xF8, 0x00, 0x0E, 0x01, 0xFC, 0x00, 0x01, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x80, 0x00, 0x0F, 0xF0, 0x30, 0x00,
  0x03, 0xF8, 0x3E, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x8F, 0xFF,
  0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x08, 0x00, 0x7F, 0x80, 0x0E, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8,
  0x3F, 0xF0, 0x03, 0xFC, 0x3F, 0xF0, 0x01, 0xFC, 0x3F, 0xE0, 0x00, 0xFF,
  0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00,
  0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xE0, 0x00,
  0x3F, 0xC7, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x07, 0xF1, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x00,
  0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3, 0xF8,
  0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x07, 0xFC, 0x3F, 0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x03, 0xFF, 0x0F,
  0xF0, 0x03, 0x7F, 0x87, 0xFC, 0x03, 0xBF, 0xC3, 0xFF, 0x07, 0x9F, 0xC0,
  0xFF, 0xFF, 0xCF, 0xE0, 0x7F, 0xFF, 0xC7, 0xF0, 0x1F, 0xFF, 0xC7, 0xF8,
  0x07, 0xFF, 0xC3, 0xFC, 0x01, 0xFF, 0xC1, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x06, 0x3F, 0xFF, 0x80, 0x0F, 0xCF, 0xFF, 0xC0,
  0x0F, 0xF3, 0xFF, 0xF0, 0x01, 0xFE, 0xFF, 0xFC, 0x00, 0x7F, 0xBF, 0xFF,
  0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xC0,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x03,
  0xF8, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0,
  0x1F, 0xE0, 0x7F, 0xE0, 0x07, 0xF0, 0x3F, 0xF0, 0x01, 0xFC, 0x7F, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x30, 0x7F, 0x01, 0xF8, 0x1F,
  0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0xFC, 0x03,
  0xF0, 0x1F, 0x87, 0xE0, 0x1F, 0x80, 0xFC, 0x7F, 0x00, 0xFC, 0x07, 0xE3,
  0xF8, 0x0F, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF0,
  0x0F, 0xC7, 0xE0, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x03, 0xF1, 0xF8,
  0x07, 0xE0, 0x1F, 0x9F, 0xC0, 0x7F, 0x00, 0xFC, 0xFC, 0x03, 0xF0, 0x07,
  0xE7, 0xE0, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0xFC, 0x01, 0xF9, 0xF8, 0x07,
  0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x00, 0x7E, 0xFE, 0x01, 0xF8, 0x07, 0xF7,
  0xE0, 0x1F, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xE0,
  0x0F, 0xCF, 0xC0, 0x3F, 0x00, 0xFE, 0x7E, 0x01, 0xF8, 0x07, 0xE7, 0xF0,
  0x1F, 0xC0, 0x3F, 0x3F, 0x00, 0xFE, 0x03, 0xF9, 0xF8, 0x07, 0xF0, 0x1F,
  0x8F, 0xC0, 0x7F, 0x81, 0xFC, 0x7F, 0x07, 0x7C, 0x0F, 0xC3, 0xF8, 0x7B,
  0xE0, 0xFC, 0x1F, 0xFF, 0x9F, 0x8F, 0xE0, 0xFF, 0xFC, 0xFF, 0xFE, 0x03,
  0xFF, 0xC7, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0xFF,
  0xC0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFC, 0x1F, 0xF9, 0xF9, 0xF0, 0xFE, 0x1F, 0xF0, 0xFC, 0xF0, 0x7F,
  0x1F, 0xF0, 0x7E, 0x70, 0x1F, 0x8F, 0xE0, 0x3F, 0x70, 0x0F, 0xC3, 0xE0,
  0x1F, 0xB8, 0x07, 0xE0, 0xC0, 0x0F, 0xF8, 0x03, 0xF0, 0x40, 0x07, 0xFC,
  0x01, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x01,
  0xFF, 0x00, 0x10, 0x7F, 0x00, 0xFF, 0x80, 0x1C, 0x3F, 0x80, 0x7F, 0xC0,
  0x3E, 0x1F, 0xC0, 0x77, 0xE0, 0x3F, 0x8F, 0xE0, 0x7B, 0xF0, 0x7F, 0xE7,
  0xF0, 0x3C, 0xFC, 0x7F, 0xC3, 0xFC, 0x7C, 0x7E, 0xFF, 0xC0, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x6F, 0xE0, 0x1F, 0xE0,
  0x07, 0xFF, 0x00, 0xFF, 0x80, 0x77, 0xF8, 0x07, 0xFE, 0x0F, 0xBF, 0xC0,
  0x1F, 0xFF, 0xF9, 0xFC, 0x00, 0xFF, 0xFF, 0x8F, 0xE0, 0x03, 0xFF, 0xF8,
  0x7F, 0x00, 0x0F, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xC0, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x40, 0x00, 0x1F, 0xE0, 0x03, 0x00, 0x01, 0xFE, 0x00,
  0x3C, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0x3F,
  0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0xFF, 0xC7, 0xF0, 0x3F, 0xFF, 0xFF, 0xBF,
  0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFC, 0x00,
  0x7F, 0xFE, 0x07, 0xE0, 0x00, 0xFF, 0xE0, 0x7E, 0x00, 0x03, 0xFE, 0x03,
  0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x7E, 0x00,
  0x0F, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x00,
  0x7E, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0x81, 0xFF,
  0xF8, 0x00, 0x7E, 0x1F, 0xFF, 0xFC, 0x03, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F,
  0x8F, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0x0F, 0xFF, 0xFF, 0xC3, 0xF8, 0x0F,
  0xFF, 0xFE, 0x1F, 0xC0, 0x1F, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0xFE, 0x08,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xF0, 0x1F,
  0xFE, 0x00, 0x1F, 0x80, 0xFF, 0xFC, 0x00, 0x7E, 0x07, 0xFF, 0xF0, 0x01,
  0xF8, 0x3F, 0xFF, 0xE0, 0x0F, 0xC0, 0xFE, 0x3F, 0xC0, 0x3F, 0x07, 0xF0,
  0x7F, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0xFC, 0x03, 0xFC, 0x7F,
  0x83, 0xF0, 0x07, 0xFF, 0xFC, 0x1F, 0x80, 0x0F, 0xFF, 0xE0, 0x7E, 0x00,
  0x3F, 0xFF, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xC0, 0x00, 0xFF, 0xC0,
  0x03, 0x00, 0x00, 0xFC, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 17, 49, 41, 13, -48 },
  { 106, 23, 21, 41, 13, -51 },
  { 167, 43, 48, 41, 0, -48 },
  { 425, 40, 64, 41, 1, -56 },
  { 745, 48, 50, 41, -2, -49 },
  { 1045, 41, 50, 41, 0, -49 },
  { 1302, 11, 21, 41, 19, -51 },
  { 1331, 27, 62, 41, 13, -52 },
  { 1541, 28, 62, 41, 2, -52 },
  { 1758, 36, 34, 41, 3, -38 },
  { 1911, 34, 34, 41, 4, -38 },
  { 2056, 18, 20, 41, 8, -10 },
  { 2101, 22, 7, 41, 10, -25 },
  { 2121, 13, 11, 41, 12, -10 },
  { 2139, 40, 62, 41, 1, -52 },
  { 2449, 36, 50, 41, 4, -49 },
  { 2674, 34, 48, 41, 3, -48 },
  { 2878, 37, 49, 41, 2, -49 },
  { 3105, 38, 50, 41, 1, -49 },
  { 3343, 38, 48, 41, 1, -48 },
  { 3571, 38, 49, 41, 2, -48 },
  { 3804, 34, 49, 41, 4, -48 },
  { 4013, 36, 48, 41, 6, -48 },
  { 4229, 38, 50, 41, 2, -49 },
  { 4467, 35, 49, 41, 5, -49 },
  { 4682, 17, 37, 41, 12, -36 },
  { 4761, 21, 46, 41, 8, -36 },
  { 4882, 33, 40, 41, 6, -41 },
  { 5047, 36, 20, 41, 3, -31 },
  { 5137, 34, 40, 41, 3, -41 },
  { 5307, 31, 50, 41, 8, -49 },
  { 5501, 37, 57, 41, 3, -49 },
  { 5765, 38, 48, 41, -1, -48 },
  { 5993, 36, 48, 41, 3, -48 },
  { 6209, 36, 50, 41, 5, -49 },
  { 6434, 37, 48, 41, 3, -48 },
  { 6656, 38, 48, 41, 3, -48 },
  { 6884, 39, 48, 41, 3, -48 },
  { 7118, 36, 50, 41, 4, -49 },
  { 7343, 39, 48, 41, 2, -48 },
  { 7577, 38, 48, 41, 3, -48 },
  { 7805, 36, 49, 41, 3, -48 },
  { 8026, 43, 48, 41, 2, -48 },
  { 8284, 30, 48, 41, 5, -48 },
  { 8464, 42, 48, 41, 1, -48 },
  { 8716, 39, 48, 41, 2, -48 },
  { 8950, 36, 50, 41, 4, -49 },
  { 9175, 38, 48, 41, 3, -48 },
  { 9403, 36, 62, 41, 4, -49 },
  { 9682, 38, 48, 41, 3, -48 },
  { 9910, 40, 50, 41, 1, -49 },
  { 10160, 39, 48, 41, 6, -48 },
  { 10394, 38, 49, 41, 4, -48 },
  { 10627, 38, 48, 41, 7, -48 },
  { 10855, 43, 48, 41, 2, -48 },
  { 11113, 47, 48, 41, -2, -48 },
  { 11395, 40, 48, 41, 6, -48 },
  { 11635, 42, 48, 41, 0, -48 },
  { 11887, 31, 62, 41, 10, -52 },
  { 12128, 19, 62, 41, 12, -52 },
  { 12276, 31, 62, 41, 1, -52 },
  { 12517, 36, 29, 41, 4, -48 },
  { 12648, 34, 6, 41, 0, 6 },
  { 12674, 11, 15, 41, 14, -55 },
  { 12695, 35, 37, 41, 3, -36 },
  { 12857, 35, 52, 41, 3, -51 },
  { 13085, 32, 37, 41, 5, -36 },
  { 13233, 38, 52, 41, 3, -51 },
  { 13480, 32, 37, 41, 5, -36 },
  { 13628, 47, 66, 41, -2, -51 },
  { 14016, 37, 51, 41, 2, -36 },
  { 14252, 34, 51, 41, 3, -51 },
  { 14469, 32, 53, 41, 5, -52 },
  { 14681, 34, 67, 41, 2, -52 },
  { 14966, 37, 52, 41, 3, -51 },
  { 15207, 29, 52, 41, 7, -51 },
  { 15396, 40, 36, 41, 0, -36 },
  { 15576, 34, 36, 41, 3, -36 },
  { 15729, 34, 37, 41, 4, -36 },
  { 15887, 38, 50, 41, 0, -36 },
  { 16125, 36, 50, 41, 3, -36 },
  { 16350, 34, 36, 41, 7, -36 },
  { 16503, 34, 37, 41, 3, -36 },
  { 16661, 33, 49, 41, 5, -48 },
  { 16864, 33, 37, 41, 5, -36 },
  { 17017, 34, 37, 41, 4, -36 },
  { 17175, 37, 37, 41, 2, -36 },
  { 17347, 41, 37, 41, 0, -36 },
  { 17537, 37, 51, 41, 1, -36 },
  { 17773, 37, 37, 41, 2, -36 },
  { 17945, 33, 62, 41, 7, -52 },
  { 18201, 17, 62, 41, 13, -52 },
  { 18333, 33, 62, 41, 2, -52 },
  { 18589, 38, 16, 41, 2, -29 },
};

const GFXfont IBMPlexMono_MediumItalic69pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic69pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic69pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _IBMPLEXMONO_MEDIUMITALIC69PT7B_H_
