#ifndef _IBMPLEXMONO_MEDIUMITALIC29PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x18,
  0x10, 0x00, 0x00, 0x00, 0x78, 0x78, 0xF8, 0xF8, 0x70, 0x39, 0xCC, 0x77,
  0x1D, 0xC7, 0x71, 0xDC, 0x67, 0x39, 0x8E, 0xE3, 0x80, 0x00, 0xE3, 0x80,
  0x39, 0xC0, 0x0C, 0x70, 0x07, 0x18, 0x01, 0xCE, 0x0F, 0xE3, 0xF3, 0xF8,
  0xFC, 0xFE, 0x7F, 0x03, 0x1C, 0x01, 0xC6, 0x00, 0x73, 0x80, 0x18, 0xE0,
  0x7E, 0x3F, 0x3F, 0x9F, 0xCF, 0xC7, 0xF0, 0x71, 0xC0, 0x1C, 0xE0, 0x06,
  0x38, 0x03, 0x8C, 0x00, 0xC7, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x3C, 0xCF, 0x38, 0xC6, 0x38, 0xC0,
  0x38, 0xC0, 0x3C, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFC,
  0x01, 0x9E, 0x01, 0x8E, 0x43, 0x0E, 0xE3, 0x1E, 0xF3, 0x3C, 0xFF, 0xF8,
  0x3F, 0xF0, 0x0F, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0xC0,
  0x70, 0xFE, 0x06, 0x0F, 0xF0, 0xE1, 0xC7, 0x1C, 0x18, 0x71, 0x81, 0x87,
  0x38, 0x18, 0xE7, 0x01, 0xFE, 0x60, 0x1F, 0xCE, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x3B, 0xF8, 0x07, 0x3F, 0x80, 0xE7, 0x1C, 0x0C, 0x61, 0xC1,
  0xC6, 0x1C, 0x38, 0x63, 0x83, 0x07, 0xF8, 0x70, 0x7F, 0x0E, 0x03, 0xE0,
  0x00, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38,
  0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x03, 0xBC, 0x0F, 0xFC, 0x1F, 0xF8, 0x0E,
  0x38, 0x0F, 0x1C, 0x07, 0x07, 0x03, 0x83, 0x85, 0xC1, 0xE7, 0xF1, 0xF7,
  0xBF, 0x9F, 0x9F, 0xCF, 0x87, 0xC3, 0x80, 0x77, 0x77, 0x77, 0x6E, 0xE0,
  0x01, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x70,
  0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0xC0,
  0x0F, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0,
  0x38, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x00,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x61, 0xC6, 0x7D, 0xFE,
  0xFF, 0xFF, 0x1F, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x1E, 0xE0, 0x1C, 0xF0,
  0x38, 0x70, 0x70, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x3E, 0x78, 0xE3, 0xC7, 0x1E,
  0x38, 0x60, 0x7F, 0xDF, 0xEF, 0xF8, 0x7B, 0xFF, 0xF7, 0x00, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE,
  0x1E, 0x1E, 0x3C, 0x0F, 0x38, 0x07, 0x38, 0x07, 0x78, 0x07, 0x71, 0xCF,
  0x73, 0xCF, 0x73, 0xCF, 0x71, 0x8E, 0xF0, 0x0E, 0xF0, 0x1E, 0x70, 0x1C,
  0x70, 0x3C, 0x78, 0x78, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0x01, 0xF0,
  0x0F, 0xC0, 0x7F, 0x07, 0xDC, 0x3E, 0x71, 0xF3, 0xC3, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x0F,
  0xF8, 0x3F, 0xF8, 0xF0, 0xF3, 0xC0, 0xE3, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x03,
  0xF0, 0x0F, 0xF8, 0x7F, 0xF9, 0xF0, 0xF1, 0x80, 0xE2, 0x01, 0xC0, 0x07,
  0x80, 0x1E, 0x07, 0xF8, 0x0F, 0xC0, 0x1F, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0x90, 0x07, 0x70, 0x1E, 0xF0, 0x79, 0xFF, 0xF1, 0xFF, 0xC0, 0xFE,
  0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xEE, 0x01,
  0xCE, 0x03, 0x8E, 0x07, 0x1C, 0x07, 0x1C, 0x0E, 0x1C, 0x1C, 0x1C, 0x38,
  0x1C, 0x70, 0x3C, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x39, 0xF0, 0x3B, 0xF8, 0x3F,
  0xFC, 0x3C, 0x3C, 0x10, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x20, 0x1C, 0x60,
  0x3C, 0xF0, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0xF8,
  0x3B, 0xFC, 0xEF, 0xF9, 0xF0, 0xFB, 0xC0, 0xF7, 0x00, 0xFE, 0x03, 0xDC,
  0x07, 0xB8, 0x0E, 0x78, 0x7C, 0xFF, 0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xF7, 0x00, 0xEE, 0x03, 0x9C, 0x0F, 0x38, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80,
  0x00, 0x03, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x1E, 0x0F, 0x3C, 0x07, 0x38,
  0x0F, 0x38, 0x0E, 0x1C, 0x1E, 0x0F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x78,
  0x3C, 0x70, 0x1E, 0xF0, 0x1E, 0xE0, 0x1E, 0xE0, 0x1C, 0xF0, 0x7C, 0x7F,
  0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1,
  0xE7, 0x01, 0xCE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1D, 0xF0, 0xF9,
  0xFF, 0x71, 0xFD, 0xC1, 0xF7, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1E, 0x7C, 0xF9, 0xF3, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC7, 0x9F, 0x3E, 0x38, 0x0F, 0x1F, 0x1F,
  0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3C, 0x38,
  0x78, 0x70, 0xF0, 0xE0, 0xC0, 0x00, 0x06, 0x00, 0x18, 0x00, 0xF0, 0x07,
  0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0xF0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x10, 0x3F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0x10, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x1C, 0x01,
  0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x07, 0x80, 0x18, 0x00, 0x80,
  0x00, 0x07, 0xC0, 0xFF, 0x8F, 0xFE, 0xF0, 0xF7, 0x03, 0xD0, 0x1C, 0x00,
  0xE0, 0x0E, 0x01, 0xF0, 0x7E, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x0E, 0x1C, 0x07, 0x38, 0x07, 0x38, 0xF7,
  0x71, 0xF6, 0x73, 0xFE, 0x73, 0x8E, 0x77, 0x0E, 0x67, 0x0E, 0x67, 0x0E,
  0xE7, 0x1C, 0xE7, 0xFC, 0xE7, 0xFC, 0xE3, 0xDC, 0x60, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1D, 0x80, 0x0E, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x07,
  0x1C, 0x03, 0x8E, 0x03, 0x87, 0x01, 0xC3, 0x81, 0xE1, 0xE0, 0xFF, 0xF0,
  0xFF, 0xF8, 0x7F, 0xFC, 0x78, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x9C, 0x01,
  0xDE, 0x00, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0xE0, 0x71, 0xC0,
  0xE3, 0x81, 0xCF, 0x03, 0x9C, 0x0E, 0x3F, 0xF8, 0x7F, 0xC0, 0xFF, 0xE1,
  0xC0, 0xE7, 0x81, 0xCE, 0x03, 0xDC, 0x07, 0x38, 0x0E, 0x70, 0x3C, 0xFF,
  0xF3, 0xFF, 0xC7, 0xFF, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF0,
  0xF3, 0xC0, 0xEF, 0x01, 0xDC, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x02, 0x38, 0x0F, 0x78, 0x1C, 0xF8,
  0x78, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1C, 0x1E, 0x1C, 0x0E, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38,
  0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x1E, 0x70,
  0x1C, 0x70, 0x3C, 0x70, 0x78, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x0F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0xF8, 0xFF,
  0xF8, 0xFF, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x1F, 0xF0, 0x7F, 0xF1, 0xE1, 0xE3, 0x81, 0xEF, 0x01, 0xDC, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC3, 0xFB, 0x87, 0xF7, 0x0F, 0xEE, 0x01, 0x9C, 0x07,
  0x38, 0x0E, 0x70, 0x3C, 0xF0, 0xF8, 0xFF, 0x71, 0xFC, 0xC0, 0xF3, 0x80,
  0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x3C, 0x0F, 0x38, 0x0E,
  0x38, 0x0E, 0x38, 0x0E, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x70, 0x1C,
  0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x3C, 0xF0, 0x38,
  0xE0, 0x38, 0xE0, 0x38, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x18, 0x0E,
  0x78, 0x3C, 0x70, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0x1E, 0x03,
  0xC7, 0x01, 0xE1, 0xC0, 0xF0, 0x70, 0x78, 0x1C, 0x3C, 0x0F, 0x1E, 0x03,
  0xCF, 0x00, 0xE7, 0x80, 0x3B, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFB,
  0x80, 0x7C, 0xE0, 0x1E, 0x3C, 0x07, 0x07, 0x01, 0xC1, 0xE0, 0x70, 0x38,
  0x3C, 0x0F, 0x0F, 0x01, 0xC3, 0x80, 0x78, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x03, 0xC7, 0xC1, 0xF1, 0xF0, 0x78, 0x7C,
  0x3E, 0x1F, 0x8F, 0x87, 0xE7, 0xE1, 0xBB, 0xB8, 0xE6, 0xEE, 0x39, 0xF3,
  0x0E, 0x79, 0xC3, 0x9E, 0x70, 0xE3, 0x1C, 0x38, 0xC7, 0x1C, 0x21, 0xC7,
  0x08, 0x61, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE3, 0x80,
  0x38, 0x1F, 0x07, 0x1F, 0x07, 0x1F, 0x07, 0x1F, 0x07, 0x3B, 0x07, 0x3B,
  0x86, 0x3B, 0x8E, 0x3B, 0x8E, 0x3B, 0x8E, 0x39, 0x8E, 0x71, 0xCE, 0x71,
  0xCC, 0x71, 0xDC, 0x71, 0xDC, 0x70, 0xDC, 0x70, 0xFC, 0xE0, 0xFC, 0xE0,
  0xF8, 0xE0, 0x78, 0xE0, 0x78, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1E,
  0x1E, 0x3C, 0x0F, 0x38, 0x07, 0x38, 0x07, 0x78, 0x07, 0x70, 0x0F, 0x70,
  0x0F, 0x70, 0x0F, 0x70, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0x70, 0x1C, 0x70,
  0x3C, 0x78, 0x78, 0x7F, 0xF8, 0x3F, 0xE0, 0x0F, 0xC0, 0x0F, 0xFC, 0x1F,
  0xFE, 0x1F, 0xFF, 0x1C, 0x0F, 0x1C, 0x07, 0x1C, 0x07, 0x3C, 0x07, 0x3C,
  0x0F, 0x38, 0x1E, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x1E, 0x3C, 0x0F, 0x38,
  0x07, 0x38, 0x07, 0x78, 0x07, 0x70, 0x0F, 0x70, 0x0F, 0x70, 0x0E, 0x70,
  0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0x70, 0x1C, 0x70, 0x3C, 0x78, 0x78, 0x7F,
  0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x03, 0x80, 0x03, 0xC6, 0x01, 0xDE, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x70, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1C,
  0x0F, 0x1C, 0x07, 0x1C, 0x07, 0x3C, 0x07, 0x3C, 0x0F, 0x38, 0x1E, 0x3F,
  0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0x78, 0xE0, 0x78, 0xE0, 0x70, 0xF0, 0x70,
  0x70, 0x70, 0x70, 0x70, 0x78, 0xF0, 0x38, 0xF0, 0x3C, 0x03, 0xF8, 0x0F,
  0xFC, 0x1F, 0xFE, 0x3E, 0x0F, 0x3C, 0x06, 0x38, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x1E, 0x00,
  0x1E, 0x40, 0x1E, 0xE0, 0x1C, 0xF0, 0x3C, 0xFF, 0xF8, 0x3F, 0xF0, 0x1F,
  0xC0, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x70, 0x1C,
  0xE0, 0x39, 0xC0, 0x77, 0x81, 0xEE, 0x03, 0xDC, 0x07, 0x38, 0x0E, 0x70,
  0x1D, 0xE0, 0x3B, 0xC0, 0xF7, 0x01, 0xEE, 0x03, 0x9C, 0x07, 0x38, 0x0E,
  0x70, 0x3C, 0xF0, 0xF1, 0xFF, 0xE1, 0xFF, 0x80, 0xFC, 0x00, 0xE0, 0x0F,
  0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1C, 0xF0, 0x3C, 0x70, 0x38, 0x70, 0x38,
  0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0x70, 0xE0, 0x71, 0xE0, 0x71, 0xC0,
  0x73, 0xC0, 0x3B, 0x80, 0x3B, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x38, 0x01, 0xCC, 0x00, 0x63, 0x00, 0x39, 0xC0, 0x0E, 0x70,
  0x03, 0x9C, 0x78, 0xC7, 0x1E, 0x31, 0xCF, 0x9C, 0x73, 0xE7, 0x1C, 0xD9,
  0x87, 0x76, 0x61, 0x99, 0xB8, 0x66, 0x6E, 0x1B, 0x9B, 0x8E, 0xC6, 0xC3,
  0xB1, 0xF0, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0x0F,
  0x00, 0xF0, 0x70, 0x1E, 0x07, 0x83, 0xC0, 0x38, 0x78, 0x03, 0x87, 0x00,
  0x3C, 0xF0, 0x01, 0xDE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0x1C,
  0x00, 0xE1, 0xE0, 0x1E, 0x0E, 0x03, 0xC0, 0xF0, 0x78, 0x07, 0x0F, 0x00,
  0x78, 0xF0, 0x07, 0xB8, 0x07, 0x9E, 0x03, 0x87, 0x03, 0xC3, 0x83, 0xC0,
  0xE1, 0xC0, 0x71, 0xE0, 0x39, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0xFF,
  0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x00,
  0xE0, 0xE0, 0x60, 0x60, 0x60, 0x70, 0x70, 0x30, 0x30, 0x38, 0x38, 0x38,
  0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x06, 0x06,
  0x07, 0x07, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x8F, 0xF8, 0xFF, 0x0F, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3B,
  0x80, 0xE7, 0x03, 0x87, 0x07, 0x0E, 0x1C, 0x1C, 0x70, 0x1C, 0xE0, 0x3B,
  0x80, 0x76, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x67, 0x1C,
  0xE3, 0x1C, 0x07, 0x8E, 0x3F, 0x9C, 0xFF, 0xB9, 0xE1, 0xE7, 0x81, 0xCE,
  0x03, 0x9C, 0x07, 0x78, 0x0E, 0xF0, 0x3D, 0xE0, 0x73, 0xC1, 0xE3, 0x87,
  0xC7, 0xFB, 0xEF, 0xE7, 0xC7, 0x87, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x3E, 0x1E, 0xFE, 0x3B, 0xFC,
  0x74, 0x3C, 0xF0, 0x39, 0xC0, 0x73, 0x80, 0xEF, 0x01, 0xDC, 0x07, 0xB8,
  0x0E, 0x70, 0x3C, 0xF0, 0xF9, 0xFF, 0xE7, 0xFF, 0x8E, 0x3E, 0x00, 0x07,
  0xC0, 0xFF, 0x8F, 0xFE, 0xF8, 0x77, 0x03, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x01, 0xF8, 0x1F, 0xE1, 0xE7, 0xFE, 0x1F, 0xE0, 0x7E, 0x00,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x07, 0xCE, 0x1F, 0xEE, 0x3F, 0xEE, 0x3C, 0x3E, 0x78, 0x1E, 0x70, 0x1C,
  0x70, 0x1C, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x7C, 0x70, 0xF8,
  0x7F, 0xB8, 0x7F, 0x38, 0x1E, 0x38, 0x07, 0xE0, 0x7F, 0xE3, 0xFF, 0x9F,
  0x0F, 0x70, 0x1F, 0xC0, 0xEE, 0x0F, 0xBF, 0xF8, 0xFF, 0x03, 0x80, 0x0E,
  0x03, 0x3C, 0x1E, 0x7F, 0xF1, 0xFF, 0x81, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x21,
  0xE0, 0x07, 0x1C, 0x00, 0xF9, 0xC0, 0x03, 0xDC, 0x00, 0x1F, 0xC0, 0x00,
  0xF8, 0x00, 0x07, 0x00, 0x00, 0x07, 0xCE, 0x3F, 0xDC, 0xFF, 0xB9, 0xE1,
  0xF7, 0x81, 0xEE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0xF0, 0x1D, 0xE0, 0x79,
  0xC1, 0xE3, 0xC7, 0xC7, 0xFB, 0x87, 0xE7, 0x07, 0x8E, 0x00, 0x3C, 0x40,
  0x70, 0xC1, 0xE3, 0xFF, 0x83, 0xFE, 0x03, 0xF0, 0x00, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xCF, 0x87, 0x7F, 0x3D,
  0xFC, 0xF8, 0x73, 0xC1, 0xCF, 0x07, 0x38, 0x1C, 0xE0, 0x77, 0x81, 0xDC,
  0x07, 0x70, 0x3D, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0xF0, 0x38, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0xFF, 0x83, 0xFC, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x86, 0x0E, 0x3C, 0x39, 0xE1, 0xCF, 0x07, 0xF8, 0x0F, 0xC0, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x41, 0xE1, 0x87, 0x0F, 0x1C, 0x1E, 0x70, 0x3D, 0xC0, 0xFF, 0x01, 0xF8,
  0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0xF8, 0x1D, 0xFC, 0x3F, 0xFC, 0x3A, 0x1C, 0x3C, 0x1C,
  0x3C, 0x1C, 0x38, 0x38, 0x38, 0xF0, 0x7F, 0x80, 0x73, 0x84, 0x73, 0xC6,
  0x71, 0xDF, 0x71, 0xFE, 0x70, 0xF8, 0xF0, 0x70, 0xFF, 0x0F, 0xF0, 0xFF,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x63, 0x8F, 0x39, 0xE3, 0xBC, 0x3F,
  0x83, 0xF0, 0x1E, 0x00, 0x39, 0xCF, 0x1D, 0xEF, 0xCF, 0xFF, 0xE7, 0x9E,
  0x73, 0x8E, 0x39, 0x87, 0x1D, 0xC3, 0x0C, 0xE3, 0x86, 0x71, 0xC7, 0x38,
  0xE3, 0x9C, 0x71, 0xCC, 0x30, 0xCE, 0x18, 0x67, 0x1C, 0x73, 0x8E, 0x38,
  0x1C, 0xF8, 0x77, 0xF3, 0xDF, 0xCE, 0x87, 0x3C, 0x1C, 0xF0, 0x73, 0x81,
  0xCE, 0x07, 0x78, 0x1D, 0xC0, 0x77, 0x03, 0xDC, 0x0E, 0x70, 0x39, 0xC0,
  0xEF, 0x03, 0x80, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x0E, 0xF0, 0x3F,
  0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xEE, 0x07, 0xBC, 0x3C,
  0x7F, 0xF1, 0xFF, 0x81, 0xF8, 0x00, 0x0E, 0x7C, 0x1E, 0xFE, 0x1D, 0xFE,
  0x1D, 0x0F, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x0F,
  0x38, 0x0E, 0x38, 0x1E, 0x3C, 0x3E, 0x3F, 0xFC, 0x7F, 0xF8, 0x71, 0xF0,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x07, 0xCE, 0x3F, 0xDC, 0xFF, 0xB9, 0xE1, 0xF7, 0x81, 0xEE, 0x03, 0x9C,
  0x07, 0x78, 0x0E, 0xF0, 0x1D, 0xE0, 0x7B, 0xC1, 0xF3, 0x87, 0xC7, 0xFB,
  0x8F, 0xE7, 0x07, 0x8E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF, 0xC3, 0xE0, 0x0F,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x7F,
  0xF9, 0xE0, 0x43, 0x80, 0x07, 0xC0, 0x07, 0xF8, 0x0F, 0xFC, 0x07, 0xF8,
  0x00, 0x78, 0x00, 0x73, 0x81, 0xCF, 0xFF, 0x8F, 0xFE, 0x07, 0xF0, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x41, 0xC3, 0x87, 0x3E, 0x1D, 0xF0, 0x7F, 0x81, 0xF8, 0x03, 0xC0, 0x38,
  0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x0F, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0xB8,
  0x0E, 0xE0, 0x7B, 0x81, 0xEE, 0x0F, 0x3C, 0x5C, 0xFF, 0x71, 0xF9, 0xC3,
  0xC7, 0x00, 0xFC, 0x1B, 0xF0, 0xEF, 0xC3, 0xCE, 0x07, 0x38, 0x1C, 0xE0,
  0x73, 0x83, 0xCE, 0x0E, 0x38, 0x39, 0xC1, 0xE7, 0x0F, 0x1C, 0xF8, 0x7F,
  0xC1, 0xFE, 0x03, 0xE0, 0x00, 0x30, 0xC6, 0x71, 0xCE, 0x71, 0xC6, 0x71,
  0xC7, 0x71, 0xC7, 0x61, 0x87, 0x61, 0x86, 0xE3, 0x86, 0xE3, 0x8E, 0xE3,
  0x8E, 0xE3, 0x8C, 0xE7, 0x1C, 0xFF, 0x98, 0xF9, 0xF8, 0x71, 0xE0, 0x07,
  0x8F, 0x07, 0xCF, 0xC7, 0xF7, 0xE7, 0xBE, 0x77, 0x1E, 0x19, 0x0F, 0x0C,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x70, 0xE1, 0x38, 0xB1, 0xDC, 0xD9,
  0xCF, 0xEF, 0xC3, 0xE7, 0xC1, 0xE1, 0xC0, 0x0E, 0x07, 0x1E, 0x07, 0x1C,
  0x07, 0x1C, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x0E, 0x38,
  0x1E, 0x38, 0x1E, 0x38, 0x3C, 0x3C, 0x5C, 0x3F, 0xDC, 0x1F, 0x9C, 0x0F,
  0x3C, 0x00, 0x38, 0x20, 0x38, 0x70, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x1F,
  0x80, 0x0F, 0x87, 0x1F, 0xEE, 0x3F, 0xFE, 0x38, 0x7E, 0x30, 0x3C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x08, 0x1E, 0x1C, 0x38, 0x0C, 0xFF,
  0x8C, 0xFF, 0xFC, 0xE7, 0xFC, 0xE0, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x7F,
  0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x3F, 0xC0, 0xFC, 0x03, 0xFC, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0x06, 0x0C, 0x38, 0x70, 0xE1, 0xC3, 0x06,
  0x1C, 0x38, 0x70, 0xE1, 0x83, 0x0E, 0x1C, 0x38, 0x70, 0xC1, 0x87, 0x0E,
  0x1C, 0x38, 0x61, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0xFF, 0x00, 0xFC, 0x0F, 0xF0, 0x70, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x3F, 0xC0, 0xFF, 0x03,
  0xF8, 0x00, 0x1E, 0x06, 0x3F, 0x07, 0x3F, 0x8E, 0x73, 0xCE, 0x61, 0xFC,
  0xE1, 0xF8, 0xC0, 0x70,
};

const GFXglyph IBMPlexMono_MediumItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 8, 20, 17, 5, -20 },
  { 21, 10, 9, 17, 5, -21 },
  { 33, 18, 20, 17, 0, -20 },
  { 78, 16, 26, 17, 1, -23 },
  { 130, 20, 20, 17, -1, -20 },
  { 180, 17, 20, 17, 0, -20 },
  { 223, 4, 9, 17, 8, -21 },
  { 228, 11, 26, 17, 6, -22 },
  { 264, 11, 26, 17, 1, -22 },
  { 300, 16, 14, 17, 1, -16 },
  { 328, 14, 15, 17, 2, -16 },
  { 355, 7, 8, 17, 4, -4 },
  { 362, 10, 3, 17, 4, -10 },
  { 366, 5, 5, 17, 5, -5 },
  { 370, 17, 26, 17, 0, -22 },
  { 426, 16, 20, 17, 1, -20 },
  { 466, 14, 20, 17, 1, -20 },
  { 501, 15, 20, 17, 1, -20 },
  { 539, 15, 20, 17, 1, -20 },
  { 577, 16, 20, 17, 0, -20 },
  { 617, 16, 20, 17, 1, -20 },
  { 657, 15, 20, 17, 1, -20 },
  { 695, 15, 20, 17, 3, -20 },
  { 733, 16, 20, 17, 1, -20 },
  { 773, 15, 20, 17, 2, -20 },
  { 811, 7, 16, 17, 5, -16 },
  { 825, 8, 20, 17, 4, -16 },
  { 845, 15, 17, 17, 2, -17 },
  { 877, 16, 9, 17, 1, -13 },
  { 895, 14, 17, 17, 1, -17 },
  { 925, 13, 20, 17, 3, -20 },
  { 958, 16, 23, 17, 1, -20 },
  { 1004, 17, 20, 17, -1, -20 },
  { 1047, 15, 20, 17, 1, -20 },
  { 1085, 15, 20, 17, 2, -20 },
  { 1123, 16, 20, 17, 1, -20 },
  { 1163, 16, 20, 17, 1, -20 },
  { 1203, 17, 20, 17, 1, -20 },
  { 1246, 15, 20, 17, 2, -20 },
  { 1284, 16, 20, 17, 1, -20 },
  { 1324, 16, 20, 17, 1, -20 },
  { 1364, 15, 20, 17, 1, -20 },
  { 1402, 18, 20, 17, 1, -20 },
  { 1447, 13, 20, 17, 2, -20 },
  { 1480, 18, 20, 17, 0, -20 },
  { 1525, 16, 20, 17, 1, -20 },
  { 1565, 16, 20, 17, 1, -20 },
  { 1605, 16, 20, 17, 1, -20 },
  { 1645, 16, 26, 17, 1, -20 },
  { 1697, 16, 20, 17, 1, -20 },
  { 1737, 16, 20, 17, 1, -20 },
  { 1777, 17, 20, 17, 2, -20 },
  { 1820, 15, 20, 17, 2, -20 },
  { 1858, 16, 20, 17, 3, -20 },
  { 1898, 18, 20, 17, 1, -20 },
  { 1943, 20, 20, 17, -1, -20 },
  { 1993, 17, 20, 17, 2, -20 },
  { 2036, 18, 20, 17, 0, -20 },
  { 2081, 13, 26, 17, 4, -22 },
  { 2124, 8, 26, 17, 5, -22 },
  { 2150, 12, 26, 17, 1, -22 },
  { 2189, 15, 12, 17, 2, -20 },
  { 2212, 14, 3, 17, 0, 2 },
  { 2218, 5, 6, 17, 6, -23 },
  { 2222, 15, 15, 17, 1, -15 },
  { 2251, 15, 21, 17, 1, -21 },
  { 2291, 13, 15, 17, 2, -15 },
  { 2316, 16, 21, 17, 1, -21 },
  { 2358, 14, 15, 17, 2, -15 },
  { 2385, 20, 27, 17, -1, -21 },
  { 2453, 15, 21, 17, 1, -15 },
  { 2493, 14, 21, 17, 1, -21 },
  { 2530, 14, 22, 17, 2, -22 },
  { 2569, 14, 28, 17, 1, -22 },
  { 2618, 16, 21, 17, 1, -21 },
  { 2660, 12, 21, 17, 3, -21 },
  { 2692, 17, 15, 17, 0, -15 },
  { 2724, 14, 15, 17, 1, -15 },
  { 2751, 14, 15, 17, 2, -15 },
  { 2778, 16, 21, 17, 0, -15 },
  { 2820, 15, 21, 17, 1, -15 },
  { 2860, 14, 15, 17, 3, -15 },
  { 2887, 15, 15, 17, 1, -15 },
  { 2916, 14, 20, 17, 2, -20 },
  { 2951, 14, 15, 17, 2, -15 },
  { 2978, 14, 15, 17, 2, -15 },
  { 3005, 16, 15, 17, 1, -15 },
  { 3035, 17, 15, 17, 0, -15 },
  { 3067, 16, 21, 17, 0, -15 },
  { 3109, 16, 15, 17, 1, -15 },
  { 3139, 14, 26, 17, 3, -22 },
  { 3185, 7, 26, 17, 5, -22 },
  { 3208, 14, 26, 17, 1, -22 },
  { 3254, 16, 7, 17, 1, -12 },
};

const GFXfont IBMPlexMono_MediumItalic29pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic29pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _IBMPLEXMONO_MEDIUMITALIC29PT7B_H_
