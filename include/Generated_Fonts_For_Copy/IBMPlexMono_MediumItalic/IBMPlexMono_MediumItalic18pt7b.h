#ifndef _IBMPLEXMONO_MEDIUMITALIC18PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0x8C, 0x63, 0x10, 0x84, 0x00, 0x19, 0xCE, 0x00, 0x65, 0xB6,
  0xD3, 0xCC, 0x06, 0x40, 0x98, 0x13, 0x06, 0x43, 0x9E, 0xF3, 0xC6, 0x47,
  0x9E, 0xF3, 0xC6, 0x40, 0x98, 0x13, 0x06, 0xC0, 0x03, 0x00, 0x60, 0x3E,
  0x0F, 0xE3, 0x2E, 0x64, 0x0D, 0x81, 0xF0, 0x1F, 0x80, 0xF8, 0x13, 0x22,
  0x6E, 0xD8, 0xFF, 0x0F, 0x80, 0x40, 0x08, 0x00, 0x0E, 0x18, 0xF1, 0x8C,
  0xD8, 0x66, 0x83, 0x2C, 0x1F, 0x00, 0x77, 0x00, 0x7C, 0x0F, 0x20, 0xD1,
  0x0C, 0x98, 0x47, 0xCC, 0x1C, 0x00, 0x0F, 0x03, 0xF0, 0x66, 0x0C, 0x41,
  0x98, 0x33, 0x1F, 0xC3, 0x60, 0xC6, 0x18, 0xCB, 0x1F, 0xFD, 0xE7, 0x18,
  0x69, 0x6C, 0x07, 0x0C, 0x18, 0x30, 0x20, 0x60, 0x60, 0x40, 0xC0, 0xC0,
  0xC0, 0x40, 0x60, 0x60, 0x30, 0x18, 0x38, 0x10, 0x30, 0x20, 0x60, 0xC1,
  0x83, 0x06, 0x08, 0x30, 0x41, 0x86, 0x18, 0x60, 0x0C, 0x06, 0x23, 0x3F,
  0xF7, 0xF0, 0xE0, 0xD0, 0xCC, 0xC2, 0x00, 0x0C, 0x06, 0x03, 0x01, 0x8F,
  0xFF, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x39, 0x9C, 0xC6, 0x60, 0xFF,
  0xC0, 0x7F, 0x80, 0x00, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x06,
  0x00, 0x1F, 0x1F, 0xDC, 0x6C, 0x3E, 0x0E, 0x0F, 0x37, 0xBB, 0xC1, 0xE1,
  0xB0, 0xCF, 0xC3, 0xC0, 0x0E, 0x0F, 0x0F, 0x8E, 0xC6, 0x62, 0x20, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x1F, 0xFF, 0xF0, 0x0F, 0x07, 0xF3, 0x8C, 0xC3,
  0x00, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x01, 0xFE, 0xFF, 0x80,
  0x0F, 0x87, 0xF3, 0x0C, 0x83, 0x01, 0xC3, 0xC0, 0xF0, 0x06, 0x01, 0x90,
  0x6E, 0x39, 0xFC, 0x3E, 0x00, 0x01, 0xC0, 0xF0, 0x78, 0x36, 0x09, 0x84,
  0x63, 0x19, 0x84, 0xFF, 0xFF, 0xF0, 0x30, 0x0C, 0x03, 0x00, 0x3F, 0x9F,
  0xC8, 0x0C, 0x06, 0xE2, 0xF9, 0x8E, 0x03, 0x01, 0xC1, 0xF0, 0xDF, 0xC3,
  0xC0, 0x07, 0x86, 0x06, 0x06, 0x06, 0xE3, 0xFB, 0x8F, 0x83, 0xC1, 0xE1,
  0xF0, 0xCF, 0xC3, 0xC0, 0xFF, 0xFF, 0xF0, 0xD0, 0x60, 0x60, 0x30, 0x30,
  0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0E, 0x00, 0x1F, 0x1F, 0xDC, 0x6C, 0x36,
  0x19, 0xF9, 0xFD, 0xC7, 0xC1, 0xE0, 0xF0, 0xDF, 0xE7, 0xC0, 0x1F, 0x1F,
  0xDC, 0x6C, 0x3C, 0x1E, 0x0D, 0x8E, 0xFB, 0x3B, 0x03, 0x03, 0x83, 0x87,
  0x00, 0x33, 0xDC, 0x00, 0x00, 0x0C, 0xE7, 0x00, 0x18, 0xF3, 0x80, 0x00,
  0x00, 0x0E, 0x31, 0xC6, 0x18, 0xC0, 0x01, 0x07, 0x0E, 0x38, 0xE0, 0xC0,
  0xE0, 0x70, 0x1C, 0x0E, 0x02, 0x7F, 0xBF, 0xE0, 0x1F, 0xFF, 0xF0, 0x40,
  0x38, 0x0E, 0x01, 0xC0, 0x78, 0x08, 0x1C, 0x38, 0x70, 0x70, 0x20, 0x00,
  0x3E, 0x7F, 0xE3, 0x43, 0x03, 0x0E, 0x30, 0x30, 0x00, 0x00, 0x70, 0x70,
  0x70, 0x1F, 0x1F, 0xDC, 0x6C, 0x14, 0xEE, 0x7F, 0x67, 0xB3, 0xD1, 0xCF,
  0xA7, 0x58, 0x0C, 0x03, 0xF0, 0xF0, 0x07, 0x01, 0xC0, 0xD0, 0x36, 0x19,
  0x86, 0x61, 0x98, 0xC6, 0x3F, 0x9F, 0xE6, 0x1B, 0x07, 0xC0, 0xC0, 0x3F,
  0x1F, 0xD8, 0x6C, 0x36, 0x1B, 0xF9, 0xFC, 0xC6, 0xC1, 0xE1, 0xF0, 0xDF,
  0xEF, 0xE0, 0x0F, 0x0F, 0xE3, 0x19, 0x83, 0x60, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x6E, 0x31, 0xF8, 0x3C, 0x00, 0x3E, 0x1F, 0xD8, 0x6C, 0x36,
  0x1B, 0x0D, 0x86, 0xC3, 0xC1, 0xE1, 0xF1, 0xDF, 0xCF, 0xC0, 0x3F, 0xCF,
  0xE6, 0x01, 0x80, 0x60, 0x1F, 0xE7, 0xF1, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF6, 0x01, 0x80, 0x60, 0x1F, 0xC7, 0xF1,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x0F, 0x1F, 0xDC, 0x6C,
  0x36, 0x06, 0x03, 0x1F, 0x9F, 0xC1, 0x61, 0xB8, 0xCF, 0xE3, 0xB0, 0x30,
  0xD8, 0x36, 0x19, 0x86, 0x61, 0x9F, 0xE7, 0xFB, 0x06, 0xC3, 0x30, 0xCC,
  0x33, 0x0C, 0xC3, 0x00, 0x3F, 0xCF, 0xE0, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x18, 0x06, 0x01, 0x83, 0xFC, 0xFF, 0x00, 0x1F, 0x8F, 0xC0,
  0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x61, 0xB1, 0x9F, 0xC7, 0xC0,
  0x30, 0xEC, 0x31, 0x8E, 0x33, 0x86, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xE6,
  0x18, 0xC3, 0x0C, 0x61, 0x8C, 0x38, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60,
  0x60, 0x60, 0x60, 0x60, 0x60, 0xFF, 0xFF, 0x38, 0xE7, 0x1C, 0xE3, 0x94,
  0xB2, 0xD4, 0xDD, 0x9B, 0xB3, 0x26, 0x64, 0xCD, 0x19, 0x02, 0x60, 0xCC,
  0x18, 0x30, 0xDE, 0x37, 0x89, 0xE6, 0x79, 0x9A, 0x64, 0xDB, 0x36, 0xCD,
  0x33, 0x4C, 0x73, 0x1C, 0x87, 0x00, 0x1F, 0x1F, 0xDC, 0x6C, 0x3E, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF1, 0xCF, 0xC3, 0xC0, 0x3F, 0x0F, 0xE6,
  0x1D, 0x83, 0x61, 0xD8, 0x67, 0xF9, 0xFC, 0x60, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x00, 0x1F, 0x1F, 0xDC, 0x6C, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE1, 0xF1, 0xCF, 0xC3, 0xC0, 0xC8, 0x36, 0x1E, 0x06, 0x00, 0x3F, 0x0F,
  0xE6, 0x1D, 0x83, 0x61, 0xD8, 0x67, 0xF9, 0xF8, 0x4C, 0x31, 0x8C, 0x63,
  0x0C, 0xC3, 0x00, 0x0F, 0x83, 0xF8, 0xC3, 0x98, 0x03, 0x00, 0x7C, 0x07,
  0xE0, 0x1C, 0x00, 0xC8, 0x1B, 0x86, 0x3F, 0xC3, 0xE0, 0x7F, 0xEF, 0xFA,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x70, 0xD8, 0x36, 0x19, 0x86, 0x61, 0x98, 0x64, 0x1B,
  0x06, 0xC3, 0x30, 0xCC, 0x31, 0xF8, 0x7C, 0x00, 0xC1, 0xF0, 0x6C, 0x3B,
  0x0C, 0xC3, 0x31, 0x84, 0x61, 0xB0, 0x6C, 0x1B, 0x07, 0x81, 0xE0, 0x70,
  0x00, 0x40, 0x68, 0x09, 0x03, 0x66, 0x6C, 0xCD, 0xB9, 0x35, 0x26, 0xAC,
  0xF5, 0x9C, 0xA2, 0x94, 0x73, 0x8C, 0x70, 0x30, 0x71, 0x8E, 0x18, 0xC1,
  0x98, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1B, 0x03, 0x30, 0x71, 0x86,
  0x18, 0xC1, 0xC0, 0xC1, 0xF0, 0x6C, 0x31, 0x98, 0x66, 0x1B, 0x03, 0x80,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x3F, 0xE7, 0xFC, 0x03,
  0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x7F,
  0xCF, 0xF8, 0x3F, 0x3E, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0x40, 0x40,
  0xC0, 0xC0, 0xC0, 0x80, 0xF8, 0xF8, 0xC6, 0x10, 0x86, 0x31, 0x84, 0x21,
  0x8C, 0x21, 0x0C, 0x63, 0x1F, 0x1F, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06,
  0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x7C, 0xFC, 0x0E, 0x07, 0x06, 0xC6,
  0x63, 0x13, 0x0F, 0x07, 0x02, 0xFF, 0xFF, 0xC0, 0x59, 0x30, 0x3D, 0xBE,
  0xD8, 0xD8, 0x6C, 0x36, 0x1B, 0x1D, 0xF7, 0x73, 0x80, 0x30, 0x18, 0x08,
  0x0C, 0x06, 0xF3, 0x7D, 0xC6, 0xC3, 0xC1, 0xE0, 0xF0, 0xDF, 0xED, 0xE0,
  0x1E, 0x1F, 0x98, 0xDC, 0x1C, 0x06, 0x0B, 0x8C, 0xFC, 0x3C, 0x00, 0x00,
  0xC0, 0x20, 0x18, 0x06, 0x3D, 0x9F, 0xE6, 0x3B, 0x04, 0xC3, 0x30, 0xCC,
  0x73, 0xEC, 0x73, 0x00, 0x1F, 0x1F, 0xD8, 0x7F, 0xEF, 0xC6, 0x13, 0x8C,
  0xFE, 0x3C, 0x00, 0x01, 0xF0, 0x3E, 0x03, 0x00, 0x20, 0x3F, 0xE3, 0xFE,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x8C, 0x0C, 0xC0,
  0xEC, 0x07, 0x80, 0x38, 0x00, 0x1E, 0xCF, 0xF3, 0x1D, 0x82, 0x61, 0x98,
  0x66, 0x39, 0xF6, 0x39, 0x80, 0xC4, 0x33, 0xFC, 0x3C, 0x00, 0x30, 0x18,
  0x0C, 0x0C, 0x06, 0x73, 0x79, 0xCE, 0xC3, 0x63, 0x61, 0xB0, 0xD8, 0x6C,
  0x30, 0x0E, 0x06, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x60, 0x30, 0x19, 0x0D,
  0x85, 0xE7, 0xC1, 0xC0, 0x03, 0x03, 0x00, 0x00, 0x3F, 0x3E, 0x06, 0x06,
  0x06, 0x06, 0x04, 0x0C, 0x8C, 0xCC, 0xEC, 0x7C, 0x38, 0x30, 0x18, 0x0C,
  0x0C, 0x06, 0x73, 0x7D, 0xC6, 0xC6, 0x66, 0x6C, 0xB3, 0x79, 0xFC, 0x60,
  0xF9, 0xF0, 0x60, 0x83, 0x06, 0x0C, 0x10, 0x64, 0xCD, 0xBB, 0xE7, 0x00,
  0x6C, 0xDF, 0xF6, 0x65, 0x99, 0x64, 0xD3, 0x3C, 0xCF, 0x32, 0xCC, 0x80,
  0x67, 0x37, 0x9C, 0xEC, 0x36, 0x36, 0x1B, 0x0D, 0x86, 0xC3, 0x00, 0x1E,
  0x3F, 0x98, 0x78, 0x3C, 0x1E, 0x1F, 0x0C, 0xFC, 0x3C, 0x00, 0x37, 0x8D,
  0xF3, 0x8C, 0xC3, 0x20, 0xD8, 0x36, 0x19, 0xFE, 0x6F, 0x18, 0x04, 0x03,
  0x00, 0xC0, 0x00, 0x3D, 0xBF, 0xD8, 0xF8, 0x2C, 0x36, 0x1B, 0x1D, 0xF6,
  0x73, 0x01, 0x81, 0x80, 0xC0, 0x60, 0xF3, 0xFB, 0x8E, 0x06, 0x03, 0x01,
  0x81, 0x80, 0xC0, 0x60, 0x00, 0x1E, 0x3F, 0xD8, 0x4F, 0x03, 0xF0, 0x7A,
  0x0D, 0xFE, 0x7C, 0x00, 0x0C, 0x04, 0x06, 0x03, 0x0F, 0xFF, 0xFC, 0x60,
  0x20, 0x30, 0x19, 0x8D, 0xE7, 0xC3, 0x80, 0x61, 0xB0, 0xD8, 0x6C, 0x6C,
  0x36, 0x1B, 0x1D, 0xF6, 0x73, 0x00, 0xF3, 0x78, 0xC8, 0x64, 0x36, 0x3B,
  0x19, 0xBC, 0xFC, 0x78, 0x00, 0x4D, 0xE6, 0x73, 0x39, 0x18, 0x8C, 0xCE,
  0x67, 0xD6, 0xEE, 0x00, 0x1D, 0xC7, 0xBD, 0xB9, 0xA3, 0x30, 0xC1, 0x98,
  0xB3, 0x77, 0xBC, 0x67, 0x00, 0x30, 0xCC, 0x33, 0x0C, 0xC6, 0x21, 0x98,
  0x66, 0x39, 0xF6, 0x39, 0x80, 0xC4, 0x73, 0xF8, 0x3C, 0x00, 0x3D, 0xBF,
  0xD0, 0xE0, 0xC1, 0xC1, 0x8B, 0xC5, 0xFF, 0xCF, 0x00, 0x0F, 0x8F, 0x86,
  0x03, 0x00, 0x80, 0x60, 0x31, 0xF0, 0xF8, 0x0C, 0x06, 0x06, 0x02, 0x03,
  0x01, 0xF0, 0xF8, 0x18, 0x84, 0x23, 0x18, 0xC4, 0x21, 0x18, 0xC6, 0x21,
  0x18, 0x3E, 0x3E, 0x06, 0x04, 0x0C, 0x18, 0x18, 0x0F, 0x1F, 0x30, 0x10,
  0x18, 0x18, 0x18, 0xF8, 0xF0, 0x30, 0xBC, 0xF7, 0x79, 0xE8, 0x60,
};

const GFXglyph IBMPlexMono_MediumItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 13, 11, 3, -13 },
  { 10, 6, 5, 11, 3, -13 },
  { 14, 11, 13, 11, 0, -13 },
  { 32, 11, 17, 11, 0, -15 },
  { 56, 13, 13, 11, -1, -13 },
  { 78, 11, 13, 11, 0, -13 },
  { 96, 3, 5, 11, 5, -13 },
  { 98, 8, 16, 11, 3, -14 },
  { 114, 7, 16, 11, 1, -14 },
  { 128, 9, 9, 11, 1, -10 },
  { 139, 9, 10, 11, 1, -11 },
  { 151, 5, 6, 11, 2, -3 },
  { 155, 5, 2, 11, 3, -6 },
  { 157, 3, 3, 11, 3, -3 },
  { 159, 11, 16, 11, 0, -14 },
  { 181, 9, 13, 11, 1, -13 },
  { 196, 9, 13, 11, 1, -13 },
  { 211, 10, 13, 11, 0, -13 },
  { 228, 10, 13, 11, 0, -13 },
  { 245, 10, 13, 11, 0, -13 },
  { 262, 9, 13, 11, 1, -13 },
  { 277, 9, 13, 11, 1, -13 },
  { 292, 9, 13, 11, 2, -13 },
  { 307, 9, 13, 11, 1, -13 },
  { 322, 9, 13, 11, 1, -13 },
  { 337, 5, 10, 11, 3, -10 },
  { 344, 6, 13, 11, 2, -10 },
  { 354, 8, 11, 11, 2, -11 },
  { 365, 9, 5, 11, 1, -8 },
  { 371, 9, 11, 11, 1, -11 },
  { 384, 8, 13, 11, 2, -13 },
  { 397, 9, 15, 11, 1, -13 },
  { 414, 10, 13, 11, 0, -13 },
  { 431, 9, 13, 11, 1, -13 },
  { 446, 10, 13, 11, 1, -13 },
  { 463, 9, 13, 11, 1, -13 },
  { 478, 10, 13, 11, 1, -13 },
  { 495, 10, 13, 11, 1, -13 },
  { 512, 9, 13, 11, 1, -13 },
  { 527, 10, 13, 11, 1, -13 },
  { 544, 10, 13, 11, 1, -13 },
  { 561, 9, 13, 11, 1, -13 },
  { 576, 11, 13, 11, 1, -13 },
  { 594, 8, 13, 11, 1, -13 },
  { 607, 11, 13, 11, 0, -13 },
  { 625, 10, 13, 11, 1, -13 },
  { 642, 9, 13, 11, 1, -13 },
  { 657, 10, 13, 11, 1, -13 },
  { 674, 9, 17, 11, 1, -13 },
  { 694, 10, 13, 11, 1, -13 },
  { 711, 11, 13, 11, 0, -13 },
  { 729, 11, 13, 11, 1, -13 },
  { 747, 10, 13, 11, 1, -13 },
  { 764, 10, 13, 11, 2, -13 },
  { 781, 11, 13, 11, 1, -13 },
  { 799, 12, 13, 11, 0, -13 },
  { 819, 10, 13, 11, 2, -13 },
  { 836, 11, 13, 11, 0, -13 },
  { 854, 8, 16, 11, 3, -14 },
  { 870, 5, 16, 11, 3, -14 },
  { 880, 8, 16, 11, 0, -14 },
  { 896, 9, 8, 11, 1, -13 },
  { 905, 9, 2, 11, 0, 1 },
  { 908, 3, 4, 11, 4, -14 },
  { 910, 9, 9, 11, 1, -9 },
  { 921, 9, 13, 11, 1, -13 },
  { 936, 9, 9, 11, 1, -9 },
  { 947, 10, 13, 11, 1, -13 },
  { 964, 9, 9, 11, 1, -9 },
  { 975, 12, 17, 11, 0, -13 },
  { 1001, 10, 13, 11, 0, -9 },
  { 1018, 9, 13, 11, 1, -13 },
  { 1033, 9, 13, 11, 1, -13 },
  { 1048, 8, 17, 11, 1, -13 },
  { 1065, 9, 13, 11, 1, -13 },
  { 1080, 7, 13, 11, 2, -13 },
  { 1092, 10, 9, 11, 0, -9 },
  { 1104, 9, 9, 11, 1, -9 },
  { 1115, 9, 9, 11, 1, -9 },
  { 1126, 10, 13, 11, 0, -9 },
  { 1143, 9, 13, 11, 1, -9 },
  { 1158, 9, 9, 11, 2, -9 },
  { 1169, 9, 9, 11, 1, -9 },
  { 1180, 9, 13, 11, 1, -13 },
  { 1195, 9, 9, 11, 1, -9 },
  { 1206, 9, 9, 11, 1, -9 },
  { 1217, 9, 9, 11, 1, -9 },
  { 1228, 11, 9, 11, 0, -9 },
  { 1241, 10, 13, 11, 0, -9 },
  { 1258, 9, 9, 11, 1, -9 },
  { 1269, 9, 16, 11, 2, -14 },
  { 1287, 5, 16, 11, 3, -14 },
  { 1297, 8, 16, 11, 1, -14 },
  { 1313, 9, 5, 11, 1, -8 },
};

const GFXfont IBMPlexMono_MediumItalic18pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic18pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic18pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _IBMPLEXMONO_MEDIUMITALIC18PT7B_H_
