#ifndef _IBMPLEXMONO_MEDIUMITALIC64PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0x00, 0x1F, 0x81, 0xFC,
  0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x81, 0xF8, 0xFC,
  0x07, 0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF1, 0xFC, 0x0F,
  0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x1F, 0xC7,
  0xE0, 0x7E, 0x3F, 0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0x80, 0xFC, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xC7, 0x9F, 0xF8, 0x07, 0xF8, 0x3C, 0x3F, 0xE0, 0x7F, 0x83, 0xE0,
  0x7C, 0x03, 0xF8, 0x1F, 0x01, 0xC0, 0x1F, 0xC0, 0xF8, 0x08, 0x01, 0xFC,
  0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x00, 0x7F, 0x01, 0xE0, 0x00,
  0x03, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0xE0, 0xF8, 0x00, 0x00, 0xFF, 0x07,
  0xC0, 0x00, 0x03, 0xFE, 0x3E, 0x00, 0x00, 0x1F, 0xFD, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xDF, 0xFC,
  0x00, 0x00, 0x3E, 0x3F, 0xE0, 0x00, 0x01, 0xF0, 0x7F, 0x80, 0x00, 0x0F,
  0x83, 0xFC, 0x00, 0x00, 0x78, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x7F, 0x00,
  0x00, 0x3E, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0x40, 0x0F, 0x80,
  0xFE, 0x03, 0x00, 0x7C, 0x0F, 0xE0, 0x7C, 0x03, 0xC0, 0x7F, 0x07, 0xF0,
  0x1E, 0x07, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0x81, 0xFF, 0xCF, 0x9F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x3E,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFC, 0x00,
  0xFE, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x0F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F,
  0xC0, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0xC0,
  0xFC, 0x00, 0x3E, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x0F, 0x81, 0xF0,
  0x00, 0x3E, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0x87, 0xE0, 0x00,
  0x3E, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x0F, 0xC0, 0x00, 0x3E,
  0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x1F, 0x00, 0x00, 0x1F, 0xFF,
  0xC3, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xE3, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x0F, 0xC0, 0x00,
  0x0F, 0x87, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0xFC, 0x07, 0xE0, 0x00, 0x3F,
  0x0F, 0x80, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x1F,
  0x80, 0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x00,
  0x7E, 0x00, 0x1F, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x7C,
  0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x03, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xE3, 0xFE, 0x00,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0x8F, 0xE0, 0x03, 0xF8, 0x0F,
  0xBF, 0x80, 0x0F, 0xF0, 0x3F, 0xFE, 0x00, 0x3F, 0xC1, 0xF9, 0xFC, 0x01,
  0xBF, 0x87, 0xE7, 0xF0, 0x0E, 0x7E, 0x3F, 0x1F, 0xF0, 0x79, 0xFD, 0xFC,
  0x7F, 0xFF, 0xE7, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xFC,
  0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x00,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF9, 0xFC,
  0xFC, 0x7E, 0x3F, 0x1F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0xFE,
  0x7F, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x1C, 0x00, 0xFC, 0x01, 0xCF, 0xC0, 0xFE, 0x07, 0xEF,
  0xF8, 0x7E, 0x1F, 0xF7, 0xFF, 0xBF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE,
  0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x1F,
  0x8F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0xFF, 0xDF,
  0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x1F,
  0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC,
  0xFF, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x81, 0xF0,
  0x1F, 0xDF, 0xC0, 0xFE, 0x0F, 0xF7, 0xF0, 0x7F, 0x83, 0xFD, 0xFC, 0x1F,
  0xE0, 0xFF, 0x7F, 0x07, 0xF8, 0x3F, 0xBF, 0xC1, 0xFE, 0x0F, 0xEF, 0xF0,
  0x3E, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xF7, 0xF0, 0x00, 0x7F, 0xCF, 0xE0, 0x01, 0xFF, 0x3F, 0x80, 0x07,
  0xF8, 0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x01, 0xFE,
  0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x03, 0xE0, 0x1F, 0xC0, 0x03, 0x80,
  0x3F, 0x80, 0x02, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x07, 0xF0,
  0x03, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0xFC, 0x00, 0x1F, 0xE0, 0x0E, 0x00, 0x03, 0xFC, 0x00, 0xC0, 0x00, 0x7F,
  0x80, 0x10, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x10, 0x00, 0x03, 0xFC, 0x0E, 0x00, 0x00,
  0x7F, 0x83, 0xE0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xE0,
  0x01, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xBF, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x7F, 0x80, 0x00, 0xFC, 0x3F, 0xFC, 0x00, 0x1F, 0x9F,
  0xFF, 0xE0, 0x03, 0xF7, 0xFF, 0xFE, 0x00, 0x7C, 0xFF, 0xFF, 0xC0, 0x0F,
  0xBF, 0xFF, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0xF8,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x10, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x10, 0x00, 0x03, 0xFC,
  0x07, 0x00, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFF,
  0xE0, 0x0F, 0xE7, 0xFF, 0xF0, 0x1F, 0xCF, 0xFF, 0xF8, 0x1F, 0xDF, 0xFF,
  0xFC, 0x3F, 0xBF, 0xFF, 0xFE, 0x3F, 0xFC, 0x07, 0xFE, 0x7F, 0xF0, 0x01,
  0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0xFF, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0xC0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xF8, 0x00, 0x03, 0xFC, 0xFC, 0x00,
  0x01, 0xFC, 0x7E, 0x00, 0x01, 0xFE, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFF, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xC0,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00,
  0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x07,
  0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x0F,
  0xFE, 0x7F, 0xE0, 0x3F, 0xFC, 0x7F, 0xFF, 0xFD, 0xFC, 0x3F, 0xFF, 0xFD,
  0xFC, 0x1F, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xE3, 0xF8, 0x07, 0xFF, 0xC7,
  0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x0F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0x81, 0xFF, 0x87,
  0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x3F, 0xE0, 0x7F, 0xE7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xF1, 0xC0, 0x00, 0xFF, 0x08,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0,
  0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xE0, 0x07, 0xC3, 0xF1, 0xF8, 0x07,
  0xF8, 0xFC, 0x7E, 0x07, 0xFF, 0x3E, 0x1F, 0x01, 0xFF, 0xEF, 0x8F, 0xC0,
  0xFE, 0x1B, 0xE3, 0xF0, 0x7E, 0x03, 0xF8, 0xFC, 0x1F, 0x80, 0x7E, 0x3F,
  0x0F, 0xC0, 0x1F, 0x9F, 0x83, 0xF0, 0x07, 0xC7, 0xE0, 0xFC, 0x01, 0xF1,
  0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0x87, 0xE0, 0x0F,
  0xC7, 0xE1, 0xF8, 0x03, 0xF1, 0xF0, 0x7E, 0x00, 0xF8, 0xFC, 0x1F, 0x80,
  0x7E, 0x3F, 0x07, 0xC0, 0x1F, 0x8F, 0xC1, 0xF0, 0x07, 0xE3, 0xF0, 0x7E,
  0x03, 0xF8, 0xFC, 0x1F, 0x80, 0xFE, 0x3F, 0x07, 0xE0, 0x5F, 0x0F, 0xC1,
  0xFC, 0x77, 0xC3, 0xF0, 0x7F, 0xFB, 0xF0, 0xFC, 0x0F, 0xFE, 0xFC, 0x3F,
  0x03, 0xFF, 0x3F, 0x0F, 0xC0, 0x7F, 0x8F, 0xC3, 0xF0, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x07,
  0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8,
  0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x03, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE,
  0x1F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x3F,
  0xC7, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x3F, 0xE1, 0xFC, 0x00, 0x7F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x1C, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xE0, 0x3F, 0x80,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xF0,
  0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xFC, 0x07,
  0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFC, 0x0F, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x03, 0x81, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0xF9, 0xFE, 0x01, 0xFF,
  0xFC, 0xFE, 0x00, 0xFF, 0xFE, 0x7F, 0x00, 0x7F, 0xFF, 0x3F, 0x80, 0x7F,
  0xFF, 0x1F, 0xC0, 0x3F, 0xFF, 0x8F, 0xE0, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x01, 0xF8, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0xF7, 0xE0, 0x3F, 0xFF, 0xFB, 0xF0, 0x1F,
  0xFF, 0xF9, 0xF8, 0x07, 0xFF, 0xF9, 0xFC, 0x01, 0xFF, 0xF8, 0xFE, 0x00,
  0x7F, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x01, 0x00,
  0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xF8,
  0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x01, 0xFF,
  0x00, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x00,
  0x07, 0xF0, 0xFF, 0x80, 0x00, 0x07, 0xF1, 0xFF, 0x00, 0x00, 0x07, 0xF3,
  0xFE, 0x00, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xFC, 0x00,
  0x00, 0x0F, 0xEF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x7F,
  0x00, 0x00, 0x1F, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x3F, 0x80, 0x00,
  0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xDF, 0x81, 0xF9, 0xF0, 0x3E, 0x7E, 0x07, 0xE7, 0xC1, 0xFB, 0xF0, 0x1F,
  0x9F, 0x87, 0xCF, 0xC0, 0x7E, 0x7E, 0x3F, 0x3F, 0x01, 0xF8, 0xF9, 0xF8,
  0xFC, 0x07, 0xE3, 0xE7, 0xE3, 0xF0, 0x3F, 0x8F, 0xBF, 0x1F, 0xC0, 0xFC,
  0x3F, 0xFC, 0x7E, 0x03, 0xF0, 0xFF, 0xE1, 0xF8, 0x0F, 0xC1, 0xFF, 0x07,
  0xE0, 0x3F, 0x07, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0xE0, 0x7E, 0x07, 0xF0,
  0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x80,
  0xF0, 0x0F, 0xC0, 0xFE, 0x01, 0x80, 0x7F, 0x03, 0xF8, 0x06, 0x01, 0xF8,
  0x0F, 0xC0, 0x10, 0x07, 0xE0, 0x3F, 0x00, 0x40, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xF0,
  0x1F, 0xF8, 0x00, 0x3F, 0x01, 0xFF, 0x80, 0x03, 0xF0, 0x1F, 0xF8, 0x00,
  0x3F, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0xFC, 0x00, 0x7F, 0x03, 0xFF,
  0xC0, 0x07, 0xE0, 0x3F, 0xFC, 0x00, 0x7E, 0x03, 0xFF, 0xC0, 0x07, 0xE0,
  0x3F, 0xFE, 0x00, 0x7E, 0x03, 0xF7, 0xE0, 0x0F, 0xE0, 0x7F, 0x7E, 0x00,
  0xFE, 0x07, 0xF7, 0xE0, 0x0F, 0xC0, 0x7E, 0x7E, 0x00, 0xFC, 0x07, 0xE3,
  0xF0, 0x0F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0xC0,
  0x7E, 0x3F, 0x01, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F, 0x80, 0xFC, 0x1F, 0x81,
  0xF8, 0x0F, 0xC1, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0xC1,
  0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x3F, 0x01,
  0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x0F, 0xC3,
  0xF0, 0x1F, 0x80, 0xFC, 0x7F, 0x01, 0xF8, 0x07, 0xE7, 0xF0, 0x3F, 0x80,
  0x7E, 0x7E, 0x03, 0xF0, 0x07, 0xE7, 0xE0, 0x3F, 0x00, 0x7E, 0x7E, 0x03,
  0xF0, 0x07, 0xE7, 0xE0, 0x3F, 0x00, 0x3F, 0xFE, 0x03, 0xF0, 0x03, 0xFF,
  0xE0, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x7E, 0x00,
  0x3F, 0xFC, 0x07, 0xE0, 0x01, 0xFF, 0xC0, 0x7E, 0x00, 0x1F, 0xFC, 0x07,
  0xE0, 0x01, 0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xE0, 0x01, 0xFF,
  0x80, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xE0, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0x00,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x03, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFD,
  0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x02, 0x00, 0x00, 0xFE, 0x00, 0xC0, 0x00,
  0x3F, 0xC0, 0x78, 0x00, 0x07, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x1F,
  0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x00, 0x1E, 0x00, 0xFE, 0x00,
  0x00, 0x60, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x02, 0x00, 0x00, 0x0F, 0xE0, 0x18, 0x00, 0x00, 0xFF, 0x03, 0xE0, 0x00,
  0x07, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x83, 0xFF, 0x00, 0x07, 0xFC, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x1F,
  0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07,
  0xF0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01,
  0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x07,
  0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0xE0, 0x7E,
  0x07, 0xE0, 0x7F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFF, 0x81, 0xF8, 0x1F, 0x81,
  0xFF, 0x03, 0xF0, 0x3F, 0x07, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xFC, 0x1F,
  0x81, 0xF8, 0x3E, 0xF8, 0x3F, 0x03, 0xF0, 0x7D, 0xF0, 0x7E, 0x07, 0xE0,
  0xFB, 0xE1, 0xF8, 0x0F, 0xC3, 0xE7, 0xC3, 0xF0, 0x1F, 0x87, 0xCF, 0x87,
  0xE0, 0x3F, 0x0F, 0x9F, 0x0F, 0xC0, 0x7E, 0x3E, 0x3E, 0x1F, 0x00, 0xFC,
  0x7C, 0x7C, 0x7E, 0x01, 0xF8, 0xF8, 0xF8, 0xFC, 0x03, 0xE3, 0xE1, 0xF1,
  0xF8, 0x0F, 0xC7, 0xC3, 0xE3, 0xE0, 0x1F, 0x8F, 0x87, 0xCF, 0xC0, 0x3F,
  0x3E, 0x0F, 0x9F, 0x80, 0x7E, 0x7C, 0x1F, 0x3F, 0x00, 0xFC, 0xF8, 0x3E,
  0x7E, 0x01, 0xFB, 0xE0, 0x7C, 0xF8, 0x03, 0xF7, 0xC0, 0xFB, 0xF0, 0x07,
  0xEF, 0x01, 0xF7, 0xE0, 0x0F, 0xFE, 0x03, 0xEF, 0xC0, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x01, 0xF9, 0xFE,
  0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x9F,
  0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x07, 0xE0,
  0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x1F, 0xC7, 0x80, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x00, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x03,
  0x83, 0xE3, 0xF8, 0x7F, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xFC,
  0x1F, 0x07, 0xC0, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x7F,
  0x00, 0xFF, 0xFC, 0x7F, 0x03, 0xFF, 0xFE, 0x7F, 0x03, 0xFF, 0xFE, 0x7F,
  0x07, 0xFF, 0xFF, 0x7F, 0x0F, 0xFC, 0x0F, 0x7E, 0x1F, 0xF0, 0x03, 0xFE,
  0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x01, 0xFC,
  0xFF, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0x80, 0x77, 0xF0, 0x7F, 0xC1, 0xF7, 0xFF,
  0x7F, 0xFF, 0xE7, 0xFF, 0x3F, 0xFF, 0xC7, 0xFE, 0x3F, 0xFF, 0x87, 0xFE,
  0x1F, 0xFF, 0x83, 0xFE, 0x0F, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0xF0,
  0x07, 0xF1, 0xFF, 0xF8, 0x07, 0xF3, 0xFF, 0xFC, 0x0F, 0xE3, 0xFF, 0xFE,
  0x0F, 0xE7, 0xFF, 0xFE, 0x0F, 0xEF, 0x83, 0xFE, 0x0F, 0xEE, 0x00, 0xFF,
  0x0F, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0x1F, 0xF0, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFF,
  0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0xFE, 0xE0, 0x3F, 0xF0,
  0xFE, 0xFF, 0xFF, 0xF0, 0xFE, 0x7F, 0xFF, 0xE0, 0xFE, 0x7F, 0xFF, 0xC0,
  0xFE, 0x3F, 0xFF, 0x00, 0xFE, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xC0, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x03, 0xC3, 0xFC, 0x00, 0x08, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x02, 0x0F, 0xE0,
  0x00, 0x0E, 0x3F, 0x80, 0x00, 0x7C, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x1F, 0xFE, 0x0F, 0xE0, 0x07, 0xFF, 0xE1, 0xFC, 0x01, 0xFF,
  0xFE, 0x3F, 0x00, 0x7F, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xFD, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80,
  0x03, 0xFE, 0x07, 0xF8, 0x00, 0xDF, 0xC0, 0x7F, 0x80, 0x3B, 0xF0, 0x0F,
  0xF8, 0x1E, 0xFE, 0x01, 0xFF, 0xFF, 0xDF, 0xC0, 0x1F, 0xFF, 0xF3, 0xF8,
  0x03, 0xFF, 0xFC, 0x7F, 0x00, 0x3F, 0xFF, 0x0F, 0xE0, 0x03, 0xFF, 0xC1,
  0xF8, 0x00, 0x1F, 0xE0, 0x40, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x00,
  0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0xFF, 0x00, 0x03,
  0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFF,
  0x9F, 0xC0, 0x07, 0xFE, 0x3F, 0x80, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x60, 0xFE, 0x00, 0x00, 0xE0, 0xFE, 0x00, 0x03, 0xF1, 0xFC,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x03, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0x80, 0x1F, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0x80,
  0x00, 0x01, 0xFF, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xE3, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC1, 0xFC, 0x00, 0xFF, 0xFC, 0x3F, 0x80, 0x3F, 0xFF, 0xC7,
  0xE0, 0x0F, 0xFF, 0xFD, 0xFC, 0x03, 0xFF, 0xFF, 0xBF, 0x80, 0xFF, 0xC0,
  0x77, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0xDF,
  0xC0, 0x7F, 0x80, 0x3B, 0xF8, 0x0F, 0xF8, 0x1E, 0x7E, 0x00, 0xFF, 0xFF,
  0xDF, 0xC0, 0x1F, 0xFF, 0xF3, 0xF8, 0x01, 0xFF, 0xFC, 0x7F, 0x00, 0x3F,
  0xFF, 0x0F, 0xE0, 0x01, 0xFF, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x60, 0x00,
  0x7F, 0x80, 0x1E, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFC, 0x1F, 0xFC, 0x03,
  0xF8, 0xFF, 0xFC, 0x07, 0xF1, 0xFF, 0xF8, 0x0F, 0xE7, 0xFF, 0xF8, 0x1F,
  0xDF, 0xFF, 0xF0, 0x7F, 0x7C, 0x1F, 0xF0, 0xFE, 0xE0, 0x1F, 0xE1, 0xFF,
  0x80, 0x1F, 0xC3, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xF8, 0xFE, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC,
  0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x01, 0x00,
  0x0F, 0xE0, 0x0E, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0xFE, 0x03, 0xF8, 0x03,
  0xF0, 0x1F, 0xF0, 0x0F, 0xC0, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC,
  0x3F, 0xC0, 0x07, 0xF3, 0xFE, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x0C, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0xFC, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xF1, 0xFC, 0x00, 0x0F, 0xF9, 0xFC, 0x00,
  0x07, 0xF9, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xFF, 0x00, 0x1F, 0xC3, 0xFF, 0xE0,
  0x07, 0xF1, 0xFF, 0xFC, 0x01, 0xFC, 0xFF, 0xFF, 0x00, 0x7F, 0x7F, 0xFF,
  0xE0, 0x3F, 0xBE, 0x0F, 0xF8, 0x0F, 0xEE, 0x01, 0xFE, 0x03, 0xFF, 0x00,
  0x3F, 0x80, 0xFF, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0x8F, 0xF8, 0x00,
  0x0F, 0xE7, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xC0,
  0x08, 0x3F, 0x87, 0xF0, 0x06, 0x1F, 0xC1, 0xFC, 0x03, 0xC7, 0xF0, 0x3F,
  0x81, 0xF9, 0xFC, 0x0F, 0xE0, 0xFF, 0x7F, 0x01, 0xFC, 0x7F, 0x9F, 0xC0,
  0x7F, 0x3F, 0xC7, 0xF0, 0x1F, 0xFF, 0xE3, 0xF8, 0x03, 0xFF, 0xF0, 0xFE,
  0x00, 0xFF, 0xF8, 0x3F, 0x80, 0x1F, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x01, 0x00,
  0x3F, 0x80, 0x38, 0x03, 0xF0, 0x07, 0xC0, 0x7F, 0x00, 0xFE, 0x07, 0xF0,
  0x1F, 0xF0, 0x7F, 0x07, 0xFC, 0x07, 0xF0, 0xFF, 0x80, 0x7E, 0x1F, 0xF0,
  0x07, 0xE3, 0xFE, 0x00, 0xFE, 0x7F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x1F, 0xE0,
  0xFF, 0x81, 0xF9, 0xFF, 0x0F, 0xFC, 0x0F, 0xCF, 0xFC, 0xFF, 0xF0, 0x7E,
  0xFF, 0xE7, 0xFF, 0x83, 0xFF, 0xFF, 0x7F, 0xFC, 0x1F, 0xE1, 0xFB, 0x8F,
  0xE0, 0xFE, 0x0F, 0xF8, 0x3F, 0x0F, 0xE0, 0x7F, 0x81, 0xF8, 0x7F, 0x01,
  0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0xFC, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x7E, 0x01, 0xF8,
  0x0F, 0xC3, 0xF0, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0xFC,
  0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x3F, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x0F,
  0xC3, 0xF0, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0xFC, 0x07,
  0xE0, 0x1F, 0x87, 0xE0, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x07, 0xC1,
  0xF0, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0xFC, 0x03, 0xE0,
  0x1F, 0x87, 0xE0, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x07, 0xE1, 0xF8,
  0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x1F,
  0x87, 0xE0, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0xFF, 0xE0, 0x1F, 0xC7, 0xFF, 0xE0, 0x3F, 0x8F, 0xFF, 0xC0, 0x7F, 0x3F,
  0xFF, 0xC0, 0xFC, 0xFF, 0xFF, 0x83, 0xFB, 0xE0, 0xFF, 0x87, 0xF7, 0x00,
  0xFF, 0x0F, 0xFC, 0x00, 0xFE, 0x1F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x03,
  0xF8, 0x7F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F,
  0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x01,
  0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xF9, 0xFE, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFF, 0x7E,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xFF, 0xC0, 0x03, 0xF8, 0xFF, 0xFC, 0x00,
  0x7F, 0x3F, 0xFF, 0xC0, 0x1F, 0xC7, 0xFF, 0xFC, 0x03, 0xF9, 0xFF, 0xFF,
  0x80, 0x7F, 0x7C, 0x1F, 0xF0, 0x0F, 0xEE, 0x00, 0xFF, 0x01, 0xFF, 0x80,
  0x1F, 0xE0, 0x3F, 0xE0, 0x01, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFF,
  0x81, 0xFD, 0xC0, 0x7F, 0xE0, 0x3F, 0xBF, 0xFF, 0xFC, 0x07, 0xF3, 0xFF,
  0xFF, 0x00, 0xFE, 0x7F, 0xFF, 0xC0, 0x1F, 0xC7, 0xFF, 0xE0, 0x03, 0xF8,
  0x7F, 0xF8, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0x0F,
  0xE0, 0x3F, 0xFF, 0xC7, 0xE0, 0x3F, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xFB,
  0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x1F, 0xE0, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x01, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x80,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xFC, 0x3F,
  0xC0, 0x06, 0xFE, 0x0F, 0xF0, 0x07, 0x7E, 0x07, 0xFC, 0x0F, 0x7F, 0x03,
  0xFF, 0xFF, 0xBF, 0x80, 0xFF, 0xFF, 0x9F, 0xC0, 0x7F, 0xFF, 0x8F, 0xE0,
  0x1F, 0xFF, 0x87, 0xF0, 0x07, 0xFF, 0x83, 0xF0, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xF7, 0xFF, 0xF1, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0xCF,
  0xFF, 0x80, 0x3F, 0xBC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFD, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0x00,
  0xFF, 0x03, 0xF8, 0x00, 0x3C, 0x0F, 0xE0, 0x00, 0x30, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x10,
  0x00, 0x07, 0xF0, 0x70, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x8F, 0xFC,
  0x03, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x10, 0x03, 0xF8, 0x00, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x03, 0xFE, 0x03, 0xF0, 0x3F, 0xF0, 0x1F, 0xC1, 0xFF,
  0x80, 0x7F, 0x1F, 0xF8, 0x01, 0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F,
  0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xF0, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0x00, 0xFF, 0xE0, 0x7F, 0xC1, 0xEF, 0xE0, 0x7F,
  0xFF, 0xCF, 0xE0, 0x7F, 0xFF, 0xCF, 0xE0, 0x3F, 0xFF, 0x8F, 0xE0, 0x1F,
  0xFF, 0x1F, 0xC0, 0x0F, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x7F, 0xFC, 0x00, 0x7C, 0x7F, 0xFC, 0x01, 0xFE, 0x7F,
  0xFC, 0x00, 0xFE, 0x7F, 0xFC, 0x00, 0xFE, 0x7F, 0xFC, 0x00, 0xFE, 0x7F,
  0xFC, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07,
  0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xFC, 0x07,
  0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x7F, 0xC0, 0x0F,
  0xC1, 0xFF, 0xC0, 0x0F, 0xC7, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x01, 0x81,
  0xF8, 0x0F, 0xC1, 0xF0, 0x3E, 0x01, 0xF0, 0x7F, 0x0F, 0xC0, 0x3E, 0x07,
  0xE1, 0xF8, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x0F, 0x87, 0xE0, 0x3F,
  0x01, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x1F, 0x00, 0xF8, 0x07, 0xE3, 0xE0,
  0x1F, 0x00, 0xFC, 0xFC, 0x07, 0xE0, 0x1F, 0x9F, 0x80, 0xFC, 0x03, 0xF3,
  0xF0, 0x1F, 0x80, 0x7E, 0x7E, 0x03, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x01,
  0xF1, 0xF0, 0x0F, 0x80, 0x7E, 0x7E, 0x03, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E,
  0x01, 0xF9, 0xF8, 0x0F, 0xC0, 0x3F, 0x3E, 0x01, 0xF8, 0x07, 0xE7, 0xC0,
  0x3F, 0x01, 0xF8, 0xF8, 0x07, 0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0x07, 0xE7,
  0xE0, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE0, 0x3F, 0x1F, 0x81, 0xFC, 0x0F,
  0xC3, 0xF0, 0x7F, 0x81, 0xF8, 0x7F, 0x1F, 0xF0, 0x7E, 0x0F, 0xFF, 0xBF,
  0x1F, 0xC1, 0xFF, 0xF7, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0x03, 0xFF,
  0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x03, 0xFF,
  0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xCF, 0x9F, 0x1F, 0xC7, 0xFC, 0x3E,
  0x78, 0x3F, 0x3F, 0xE0, 0xFD, 0xC0, 0xFC, 0x7E, 0x03, 0xFE, 0x03, 0xF0,
  0xF0, 0x0F, 0xF8, 0x0F, 0xC1, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x00, 0xFF,
  0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0xC0,
  0x00, 0x3F, 0x00, 0xFF, 0x00, 0x30, 0xFC, 0x03, 0xFC, 0x03, 0xC3, 0xF0,
  0x1D, 0xF8, 0x1F, 0x8F, 0xC0, 0x77, 0xE1, 0xFF, 0x3F, 0x83, 0xDF, 0x8F,
  0xF8, 0xFE, 0x1E, 0x7E, 0x7F, 0x83, 0xFF, 0xF9, 0xFF, 0xFC, 0x07, 0xFF,
  0xC3, 0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF8,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x06, 0xFE,
  0x01, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0xF7, 0xF0, 0x07, 0xFF, 0xFE,
  0xFE, 0x00, 0x7F, 0xFF, 0x9F, 0xC0, 0x0F, 0xFF, 0xE3, 0xF8, 0x00, 0xFF,
  0xF8, 0x7F, 0x00, 0x0F, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x06, 0x00, 0x07,
  0xF8, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x03, 0xF0, 0x1F, 0xFF,
  0xC0, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0x07, 0xFF, 0xFF, 0x9F, 0xC1, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0x00, 0x3F, 0xFE, 0x0F,
  0xC0, 0x03, 0xFF, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x7F, 0xC0,
  0x3E, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x20, 0x00, 0x3F, 0xC0, 0x1C, 0x00, 0x3F, 0xE0, 0x1F, 0x00, 0x1F,
  0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x00, 0xF8, 0x07, 0xF8, 0x00, 0x3E, 0x03,
  0xFC, 0x00, 0x0F, 0xC1, 0xFF, 0xC0, 0x03, 0xF1, 0xFF, 0xFF, 0x80, 0x7C,
  0x7F, 0xFF, 0xFF, 0x1F, 0x1F, 0xBF, 0xFF, 0xFF, 0xC7, 0xE1, 0xFF, 0xFF,
  0xF1, 0xF8, 0x1F, 0xFF, 0xF8, 0x7E, 0x00, 0xFF, 0xFE, 0x3F, 0x80, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x0F, 0xFF,
  0x00, 0x1F, 0x83, 0xFF, 0xE0, 0x03, 0xE0, 0xFF, 0xFE, 0x00, 0xFC, 0x3F,
  0xFF, 0xE0, 0x1F, 0x87, 0xF1, 0xFC, 0x07, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x3F, 0x01, 0xFC, 0x7F, 0x07, 0xC0, 0x3F, 0xFF, 0xE1, 0xF8, 0x03, 0xFF,
  0xF8, 0x3F, 0x00, 0x3F, 0xFE, 0x07, 0xC0, 0x07, 0xFF, 0x81, 0xF8, 0x00,
  0x3F, 0xE0, 0x06, 0x00, 0x03, 0xF0, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 16, 46, 38, 12, -45 },
  { 93, 22, 19, 38, 12, -47 },
  { 146, 40, 45, 38, 0, -45 },
  { 371, 37, 60, 38, 1, -52 },
  { 649, 44, 46, 38, -2, -45 },
  { 902, 38, 46, 38, 0, -45 },
  { 1121, 9, 19, 38, 18, -47 },
  { 1143, 26, 58, 38, 12, -49 },
  { 1332, 25, 58, 38, 2, -49 },
  { 1514, 33, 32, 38, 3, -35 },
  { 1646, 31, 32, 38, 4, -36 },
  { 1770, 16, 19, 38, 8, -10 },
  { 1808, 20, 6, 38, 10, -22 },
  { 1823, 11, 11, 38, 12, -10 },
  { 1839, 37, 58, 38, 1, -49 },
  { 2108, 34, 46, 38, 3, -45 },
  { 2304, 31, 45, 38, 3, -45 },
  { 2479, 35, 45, 38, 1, -45 },
  { 2676, 35, 46, 38, 1, -45 },
  { 2878, 35, 45, 38, 1, -45 },
  { 3075, 35, 46, 38, 2, -45 },
  { 3277, 32, 46, 38, 3, -45 },
  { 3461, 33, 45, 38, 6, -45 },
  { 3647, 35, 46, 38, 2, -45 },
  { 3849, 32, 45, 38, 5, -45 },
  { 4029, 15, 35, 38, 12, -34 },
  { 4095, 19, 43, 38, 8, -34 },
  { 4198, 31, 37, 38, 5, -38 },
  { 4342, 33, 19, 38, 3, -29 },
  { 4421, 31, 37, 38, 3, -38 },
  { 4565, 28, 46, 38, 8, -45 },
  { 4726, 34, 52, 38, 3, -45 },
  { 4947, 35, 45, 38, -1, -45 },
  { 5144, 33, 45, 38, 3, -45 },
  { 5330, 34, 46, 38, 4, -45 },
  { 5526, 34, 45, 38, 3, -45 },
  { 5718, 35, 45, 38, 3, -45 },
  { 5915, 36, 45, 38, 3, -45 },
  { 6118, 33, 46, 38, 4, -45 },
  { 6308, 36, 45, 38, 2, -45 },
  { 6511, 36, 45, 38, 2, -45 },
  { 6714, 33, 46, 38, 3, -45 },
  { 6904, 40, 45, 38, 2, -45 },
  { 7129, 29, 45, 38, 4, -45 },
  { 7293, 38, 45, 38, 1, -45 },
  { 7507, 36, 45, 38, 2, -45 },
  { 7710, 34, 46, 38, 3, -45 },
  { 7906, 35, 45, 38, 3, -45 },
  { 8103, 34, 57, 38, 3, -45 },
  { 8346, 35, 45, 38, 3, -45 },
  { 8543, 37, 46, 38, 1, -45 },
  { 8756, 37, 45, 38, 5, -45 },
  { 8965, 35, 46, 38, 4, -45 },
  { 9167, 35, 45, 38, 6, -45 },
  { 9364, 39, 45, 38, 2, -45 },
  { 9584, 42, 45, 38, -1, -45 },
  { 9821, 37, 45, 38, 5, -45 },
  { 10030, 39, 45, 38, 0, -45 },
  { 10250, 29, 58, 38, 9, -49 },
  { 10461, 18, 58, 38, 11, -49 },
  { 10592, 29, 58, 38, 1, -49 },
  { 10803, 34, 27, 38, 3, -45 },
  { 10918, 31, 6, 38, 0, 5 },
  { 10942, 10, 14, 38, 13, -51 },
  { 10960, 32, 35, 38, 3, -34 },
  { 11100, 32, 48, 38, 3, -47 },
  { 11292, 30, 35, 38, 4, -34 },
  { 11424, 35, 48, 38, 3, -47 },
  { 11634, 31, 35, 38, 4, -34 },
  { 11770, 42, 61, 38, -1, -47 },
  { 12091, 35, 48, 38, 1, -34 },
  { 12301, 31, 47, 38, 3, -47 },
  { 12484, 30, 49, 38, 5, -48 },
  { 12668, 32, 62, 38, 2, -48 },
  { 12916, 34, 48, 38, 3, -47 },
  { 13120, 28, 48, 38, 6, -47 },
  { 13288, 37, 34, 38, 0, -34 },
  { 13446, 31, 34, 38, 3, -34 },
  { 13578, 31, 35, 38, 4, -34 },
  { 13714, 35, 47, 38, 0, -34 },
  { 13920, 33, 47, 38, 3, -34 },
  { 14114, 31, 33, 38, 7, -33 },
  { 14242, 31, 35, 38, 3, -34 },
  { 14378, 30, 46, 38, 5, -45 },
  { 14551, 32, 34, 38, 4, -33 },
  { 14687, 32, 35, 38, 3, -34 },
  { 14827, 35, 34, 38, 2, -33 },
  { 14976, 38, 35, 38, 0, -34 },
  { 15143, 35, 47, 38, 1, -33 },
  { 15349, 34, 35, 38, 2, -34 },
  { 15498, 30, 58, 38, 7, -49 },
  { 15716, 16, 58, 38, 12, -49 },
  { 15832, 31, 58, 38, 2, -49 },
  { 16057, 35, 15, 38, 2, -27 },
};

const GFXfont IBMPlexMono_MediumItalic64pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic64pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic64pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _IBMPLEXMONO_MEDIUMITALIC64PT7B_H_
