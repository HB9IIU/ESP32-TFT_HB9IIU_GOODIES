#ifndef _IBMPLEXMONO_MEDIUMITALIC11PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x24, 0x36, 0xDB, 0xA0, 0x14, 0x29, 0x99, 0x42, 0x99, 0x94,
  0x28, 0x08, 0xF7, 0x54, 0x70, 0x71, 0x6B, 0x78, 0x80, 0x72, 0xA9, 0x63,
  0x00, 0xC6, 0x95, 0x4E, 0x38, 0x48, 0x91, 0x4D, 0x12, 0x27, 0xB6, 0x68,
  0x12, 0x44, 0x88, 0x88, 0x46, 0x30, 0x82, 0x10, 0x84, 0x42, 0x26, 0x00,
  0x25, 0x7E, 0xCD, 0x00, 0x21, 0x3E, 0x46, 0x00, 0x69, 0x60, 0xE0, 0xF0,
  0x06, 0x08, 0x20, 0x41, 0x02, 0x08, 0x30, 0x41, 0x80, 0x7E, 0x63, 0x5A,
  0xC6, 0x5E, 0x18, 0xA4, 0x86, 0x10, 0x41, 0x3F, 0x39, 0x90, 0x43, 0x18,
  0xC4, 0x3F, 0x3D, 0x10, 0x4E, 0x0C, 0x38, 0x9E, 0x0C, 0x53, 0xCA, 0x4B,
  0xF0, 0x82, 0x3C, 0x84, 0x16, 0x64, 0x14, 0xFE, 0x3B, 0x11, 0x6C, 0xC6,
  0x7E, 0xFE, 0x21, 0x84, 0x30, 0x84, 0x30, 0x3D, 0x94, 0x4E, 0x47, 0x1C,
  0xDE, 0x7E, 0x63, 0x1F, 0x88, 0xD8, 0x68, 0x0D, 0x80, 0x32, 0x00, 0x64,
  0x4C, 0x09, 0xB1, 0x83, 0x08, 0xF8, 0x3E, 0x83, 0x06, 0x36, 0x40, 0x7E,
  0x42, 0x66, 0x01, 0x8C, 0x7E, 0x6F, 0x5C, 0xE6, 0xF0, 0xF0, 0x18, 0x62,
  0x8A, 0x69, 0xFC, 0xE1, 0x3D, 0x94, 0x5E, 0x45, 0x14, 0xFE, 0x39, 0x28,
  0x60, 0x82, 0x09, 0x9C, 0x38, 0x96, 0x51, 0x45, 0x14, 0xBE, 0x3E, 0x41,
  0x03, 0xE4, 0x08, 0x10, 0x7C, 0x3E, 0x41, 0x03, 0xE4, 0x08, 0x10, 0x60,
  0x7A, 0x61, 0x0B, 0xC6, 0x7E, 0x26, 0xC9, 0x13, 0xE4, 0x49, 0x93, 0x64,
  0x3E, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x7C, 0x3C, 0x10, 0x43, 0x08, 0x2C,
  0x9C, 0x26, 0xD9, 0x62, 0x87, 0x89, 0x12, 0x66, 0x42, 0x11, 0x8C, 0x42,
  0x1F, 0x66, 0xCD, 0xB2, 0xA5, 0x4C, 0xA1, 0x46, 0x26, 0xC9, 0x52, 0xA5,
  0x4A, 0x97, 0x64, 0x7E, 0x63, 0x18, 0xC6, 0x5E, 0x3C, 0x96, 0x51, 0x79,
  0x04, 0x30, 0x7E, 0x63, 0x18, 0xC6, 0x5E, 0x29, 0x80, 0x3C, 0x96, 0x51,
  0x79, 0x64, 0xB3, 0x3D, 0x94, 0x1C, 0x0C, 0x1C, 0xDE, 0xFC, 0x82, 0x08,
  0x20, 0x86, 0x18, 0xCF, 0x28, 0xA2, 0x8A, 0x29, 0x3C, 0x86, 0x2C, 0xB6,
  0x51, 0x46, 0x18, 0x42, 0x85, 0x4B, 0xA7, 0x4E, 0xB5, 0x64, 0x66, 0x48,
  0xA0, 0xC3, 0x05, 0x12, 0x46, 0x87, 0x25, 0x94, 0x20, 0x86, 0x18, 0x7E,
  0x08, 0x20, 0xC3, 0x0C, 0x10, 0x7E, 0x74, 0x44, 0x88, 0x88, 0x8E, 0x92,
  0x24, 0x92, 0x24, 0x38, 0x42, 0x11, 0x08, 0x42, 0x17, 0x80, 0x33, 0x93,
  0x18, 0x80, 0xF8, 0xD0, 0x6C, 0xE7, 0x39, 0x7C, 0x20, 0x87, 0xD9, 0x45,
  0x14, 0xFE, 0x76, 0x61, 0x09, 0xF8, 0x0C, 0x26, 0xA6, 0x8A, 0x69, 0x3C,
  0x7C, 0x7D, 0x29, 0xF8, 0x0E, 0x31, 0xF8, 0x81, 0x02, 0x04, 0x58, 0xE0,
  0xC0, 0x35, 0x34, 0x53, 0x49, 0xE8, 0x9C, 0x20, 0x87, 0x99, 0x45, 0x34,
  0xB2, 0x31, 0x81, 0xC2, 0x31, 0x2A, 0x60, 0x0C, 0x30, 0x0E, 0x08, 0x21,
  0x84, 0x91, 0x43, 0x00, 0x20, 0x87, 0xD9, 0x49, 0xC5, 0x76, 0xE1, 0x08,
  0xC4, 0x29, 0x6C, 0x75, 0x75, 0x65, 0x96, 0x90, 0x79, 0x94, 0x53, 0x4B,
  0x20, 0x74, 0x63, 0x19, 0xF8, 0x7D, 0x94, 0x51, 0x4F, 0xEC, 0x20, 0x6C,
  0xE3, 0x39, 0x78, 0x42, 0xEC, 0xC6, 0x10, 0x41, 0x00, 0x3D, 0x27, 0x06,
  0x8D, 0xE0, 0x21, 0x3E, 0x84, 0x29, 0x6C, 0xCC, 0x63, 0x39, 0x78, 0xDA,
  0x73, 0x39, 0x70, 0x55, 0x55, 0x65, 0xB7, 0x60, 0x3D, 0xA4, 0x40, 0x8B,
  0x5B, 0x00, 0x65, 0x14, 0x53, 0x49, 0xE8, 0x9C, 0x7D, 0x31, 0x8A, 0x67,
  0xF0, 0x39, 0x08, 0x2E, 0x10, 0x88, 0x43, 0x80, 0x29, 0x24, 0x94, 0x90,
  0x38, 0x21, 0x08, 0x1C, 0xC2, 0x04, 0x13, 0x80, 0x65, 0x59, 0x80,
};

const GFXglyph IBMPlexMono_MediumItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 8, 7, 2, -8 },
  { 4, 4, 3, 7, 2, -8 },
  { 6, 7, 8, 7, 0, -8 },
  { 13, 6, 10, 7, 0, -9 },
  { 21, 7, 8, 7, 0, -8 },
  { 28, 7, 8, 7, 0, -8 },
  { 35, 2, 3, 7, 3, -8 },
  { 36, 4, 10, 7, 2, -8 },
  { 41, 5, 10, 7, 0, -8 },
  { 48, 5, 5, 7, 1, -6 },
  { 52, 5, 5, 7, 1, -6 },
  { 56, 3, 4, 7, 1, -2 },
  { 58, 3, 1, 7, 2, -4 },
  { 59, 2, 2, 7, 2, -2 },
  { 60, 7, 10, 7, 0, -8 },
  { 69, 5, 8, 7, 1, -8 },
  { 74, 6, 8, 7, 0, -8 },
  { 80, 6, 8, 7, 0, -8 },
  { 86, 6, 8, 7, 0, -8 },
  { 92, 6, 8, 7, 0, -8 },
  { 98, 6, 8, 7, 0, -8 },
  { 104, 5, 8, 7, 1, -8 },
  { 109, 6, 8, 7, 1, -8 },
  { 115, 6, 8, 7, 0, -8 },
  { 121, 5, 8, 7, 1, -8 },
  { 126, 3, 6, 7, 2, -6 },
  { 129, 4, 8, 7, 1, -6 },
  { 133, 5, 6, 7, 1, -6 },
  { 137, 5, 3, 7, 1, -5 },
  { 139, 5, 6, 7, 1, -6 },
  { 143, 5, 8, 7, 1, -8 },
  { 148, 5, 9, 7, 1, -8 },
  { 154, 6, 8, 7, 0, -8 },
  { 160, 6, 8, 7, 0, -8 },
  { 166, 6, 8, 7, 1, -8 },
  { 172, 6, 8, 7, 0, -8 },
  { 178, 7, 8, 7, 0, -8 },
  { 185, 7, 8, 7, 0, -8 },
  { 192, 5, 8, 7, 1, -8 },
  { 197, 7, 8, 7, 0, -8 },
  { 204, 7, 8, 7, 0, -8 },
  { 211, 6, 8, 7, 0, -8 },
  { 217, 7, 8, 7, 0, -8 },
  { 224, 5, 8, 7, 1, -8 },
  { 229, 7, 8, 7, 0, -8 },
  { 236, 7, 8, 7, 0, -8 },
  { 243, 5, 8, 7, 1, -8 },
  { 248, 6, 8, 7, 0, -8 },
  { 254, 5, 10, 7, 1, -8 },
  { 261, 6, 8, 7, 0, -8 },
  { 267, 6, 8, 7, 0, -8 },
  { 273, 6, 8, 7, 1, -8 },
  { 279, 6, 8, 7, 1, -8 },
  { 285, 6, 8, 7, 1, -8 },
  { 291, 7, 8, 7, 0, -8 },
  { 298, 7, 8, 7, 0, -8 },
  { 305, 6, 8, 7, 1, -8 },
  { 311, 7, 8, 7, 0, -8 },
  { 318, 4, 10, 7, 2, -8 },
  { 323, 3, 10, 7, 2, -8 },
  { 327, 5, 10, 7, 0, -8 },
  { 334, 5, 5, 7, 1, -8 },
  { 338, 5, 1, 7, 0, 1 },
  { 339, 2, 2, 7, 2, -9 },
  { 340, 5, 6, 7, 1, -6 },
  { 344, 6, 8, 7, 0, -8 },
  { 350, 5, 6, 7, 1, -6 },
  { 354, 6, 8, 7, 1, -8 },
  { 360, 5, 6, 7, 1, -6 },
  { 364, 7, 10, 7, 0, -8 },
  { 373, 6, 8, 7, 0, -6 },
  { 379, 6, 8, 7, 0, -8 },
  { 385, 5, 9, 7, 1, -9 },
  { 391, 6, 11, 7, 0, -9 },
  { 400, 6, 8, 7, 0, -8 },
  { 406, 5, 8, 7, 1, -8 },
  { 411, 6, 6, 7, 0, -6 },
  { 416, 6, 6, 7, 0, -6 },
  { 421, 5, 6, 7, 1, -6 },
  { 425, 6, 8, 7, 0, -6 },
  { 431, 5, 8, 7, 1, -6 },
  { 436, 6, 6, 7, 1, -6 },
  { 441, 6, 6, 7, 0, -6 },
  { 446, 5, 8, 7, 1, -8 },
  { 451, 5, 6, 7, 1, -6 },
  { 455, 5, 6, 7, 1, -6 },
  { 459, 6, 6, 7, 0, -6 },
  { 464, 7, 6, 7, 0, -6 },
  { 470, 6, 8, 7, 0, -6 },
  { 476, 6, 6, 7, 0, -6 },
  { 481, 5, 10, 7, 1, -8 },
  { 488, 3, 10, 7, 2, -8 },
  { 492, 6, 10, 7, 0, -8 },
  { 500, 6, 3, 7, 0, -5 },
};

const GFXfont IBMPlexMono_MediumItalic11pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic11pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic11pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _IBMPLEXMONO_MEDIUMITALIC11PT7B_H_
