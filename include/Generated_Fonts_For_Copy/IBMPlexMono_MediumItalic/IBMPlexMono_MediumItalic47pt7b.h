#ifndef _IBMPLEXMONO_MEDIUMITALIC47PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x81, 0xF8, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0x7C, 0x00, 0x3E,
  0x1F, 0x3C, 0x1F, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x78, 0x3E, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF0, 0x7C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0xF0, 0x78, 0x03, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0xF8, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x3E, 0x00,
  0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF,
  0x87, 0xFF, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3E, 0x1E,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFE, 0x7B,
  0xFC, 0x1F, 0x0F, 0x1F, 0x07, 0xE1, 0xC1, 0xC0, 0xF8, 0x38, 0x20, 0x1F,
  0x07, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x87, 0x80,
  0x01, 0xF8, 0xE0, 0x00, 0x3F, 0x9C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0E, 0xFF, 0x00, 0x01, 0xC7, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x0F,
  0x0F, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x38, 0x3F, 0x00, 0x07, 0x07, 0xC0,
  0x80, 0xE0, 0xF8, 0x78, 0x1C, 0x3F, 0x1F, 0x87, 0x8F, 0xC3, 0xFC, 0xF3,
  0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0x00, 0xFF, 0x00, 0x1E, 0x03, 0xFF, 0x80, 0x3E, 0x03, 0xFF, 0xC0, 0x3C,
  0x07, 0xC3, 0xC0, 0x78, 0x07, 0x83, 0xC0, 0xF8, 0x0F, 0x01, 0xC0, 0xF0,
  0x0F, 0x03, 0xC1, 0xE0, 0x0F, 0x03, 0xC1, 0xE0, 0x0F, 0x03, 0xC3, 0xC0,
  0x0E, 0x03, 0xC7, 0x80, 0x0F, 0x07, 0xC7, 0x80, 0x0F, 0x0F, 0x8F, 0x00,
  0x0F, 0xFF, 0x9E, 0x00, 0x07, 0xFF, 0x1E, 0x00, 0x03, 0xFE, 0x20, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x78, 0xFF, 0xE0, 0x00, 0xF1, 0xFF, 0xE0, 0x00, 0xF1, 0xF1, 0xF0,
  0x01, 0xE3, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0xF0, 0x07, 0xC3, 0xC0, 0xF0,
  0x07, 0x87, 0x80, 0xF0, 0x0F, 0x07, 0x80, 0xF0, 0x1F, 0x07, 0x81, 0xF0,
  0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x03, 0xC3, 0xE0, 0x78, 0x03, 0xFF, 0xC0,
  0x78, 0x03, 0xFF, 0x80, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x0F,
  0x00, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF0, 0x00,
  0xF0, 0x0F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0xCF, 0x80, 0x07, 0xFF, 0xF0, 0x01,
  0xFB, 0xFC, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00,
  0xF8, 0x07, 0xC0, 0x8F, 0x80, 0x7E, 0x0E, 0xF8, 0x07, 0xE1, 0xFF, 0xC0,
  0x5E, 0x1E, 0x7C, 0x0D, 0xF3, 0xC7, 0xE1, 0xDF, 0x3C, 0x7F, 0xF8, 0xFF,
  0x83, 0xFF, 0x8F, 0xF8, 0x1F, 0xF0, 0x7F, 0x00, 0x7C, 0x03, 0xE0, 0x3E,
  0x7C, 0xF9, 0xF3, 0xC7, 0x9F, 0x3E, 0x7C, 0xF9, 0xE3, 0xCF, 0x9F, 0x00,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0x00, 0x78,
  0x04, 0x70, 0x3C, 0x0E, 0x7F, 0x1E, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xE3, 0xE0, 0x03,
  0xE1, 0xF0, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x0F, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF0, 0xFE, 0x0F, 0xC1,
  0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0xF8, 0x0F, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xE0,
  0x1F, 0x3F, 0x9F, 0xEF, 0xF7, 0xFF, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0x07, 0xF0, 0x3F,
  0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F,
  0x80, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xFB,
  0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xF8, 0x3C, 0x1F, 0x7C, 0x3F, 0x1F,
  0xBE, 0x1F, 0x8F, 0xDF, 0x0F, 0xC7, 0xFF, 0x87, 0xC3, 0xEF, 0xC0, 0x01,
  0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7C, 0xF8, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x07, 0xE0,
  0x1F, 0x81, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xBE, 0x00, 0x7E, 0x7C, 0x01,
  0xF8, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xC0, 0x7E, 0x0F, 0x80, 0x7C,
  0x1F, 0x00, 0x70, 0x3E, 0x00, 0xC0, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x03, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x0E, 0x00, 0x3E, 0x02,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x04, 0x00,
  0x1F, 0x8F, 0x00, 0x0F, 0xCF, 0xC0, 0x0F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x0F,
  0x87, 0xC0, 0x0F, 0x83, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x07,
  0xC0, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x07,
  0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x7C, 0xFF, 0xC0, 0x3C, 0xFF, 0xF0, 0x1E, 0xFF,
  0xFC, 0x0F, 0xE0, 0xFF, 0x0F, 0xC0, 0x1F, 0x80, 0x40, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x04, 0x00, 0x1F, 0x8F, 0x00, 0x1F, 0x8F,
  0xC0, 0x1F, 0xC7, 0xF8, 0x1F, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x8F,
  0xE0, 0x3F, 0x3F, 0xF0, 0x3F, 0x7F, 0xFC, 0x3E, 0xFF, 0xFC, 0x7F, 0xC0,
  0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x3F, 0x03,
  0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xF1, 0xE0, 0x01, 0xF8, 0xF0,
  0x01, 0xF8, 0x78, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0x03,
  0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xE1, 0xE0, 0x03, 0xE0, 0xF8,
  0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xE0, 0x7F, 0x07, 0xC0, 0x0F, 0xC7,
  0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7E,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x0F,
  0xCF, 0xC0, 0x0F, 0xC7, 0xF8, 0x1F, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8, 0x1F, 0xC7, 0xE0,
  0x0F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFE, 0xFF, 0x07, 0x7C, 0xFF, 0xFD, 0xF8,
  0xFF, 0xF3, 0xE0, 0xFF, 0xCF, 0xC0, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0xFE, 0x0F, 0xF0,
  0xFF, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x07,
  0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F, 0x03, 0xE0, 0x00, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x7F, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xF7, 0x00, 0x1F,
  0x10, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0x78, 0x3E, 0x00,
  0x3E, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x01, 0xE3, 0xC7, 0x83,
  0xF9, 0xE7, 0xC3, 0xFE, 0xF3, 0xC3, 0xFF, 0xF9, 0xE1, 0xF0, 0xF9, 0xF1,
  0xF0, 0x3C, 0xF8, 0xF8, 0x1E, 0x7C, 0x78, 0x0F, 0x3C, 0x7C, 0x07, 0x9E,
  0x3E, 0x07, 0xCF, 0x1F, 0x03, 0xC7, 0x8F, 0x01, 0xE7, 0xC7, 0x80, 0xF3,
  0xE3, 0xC0, 0xF9, 0xE1, 0xE0, 0x7C, 0xF0, 0xF8, 0x7E, 0x78, 0x7E, 0xFE,
  0x3C, 0x1F, 0xEF, 0x1E, 0x0F, 0xF7, 0x8F, 0x83, 0xF3, 0xC3, 0xC0, 0x40,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x03,
  0xE1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0,
  0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x07,
  0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0x80, 0x0F, 0x87,
  0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x0F,
  0xCF, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x7C, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07,
  0xC3, 0xF0, 0x07, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0x80,
  0x3F, 0x07, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x3F, 0x87, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F,
  0x07, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x1F,
  0x00, 0x0E, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x30, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x8F, 0x80,
  0x1F, 0x87, 0xE0, 0x1F, 0x81, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7C, 0x07,
  0xE0, 0x3E, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x0F, 0x80,
  0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F,
  0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE3,
  0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x3F,
  0x07, 0xC0, 0x7F, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1C,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xFE,
  0xFC, 0x1F, 0xFE, 0xF8, 0x1F, 0xFC, 0xF8, 0x1F, 0xFC, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0x7C, 0x03, 0xF8,
  0x7F, 0x06, 0xF8, 0x3F, 0xFE, 0xF0, 0x3F, 0xFC, 0xF0, 0x1F, 0xF9, 0xF0,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x80,
  0x0F, 0x83, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x01,
  0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F,
  0x00, 0x1F, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x3F, 0x00,
  0x3F, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03,
  0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x0C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0x7E, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x7F, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x3E, 0x00,
  0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xC0, 0x3F, 0x80, 0x3E, 0x03, 0xF8, 0x01, 0xF0, 0x3F, 0x80, 0x0F,
  0x81, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3E, 0x1F,
  0x80, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7D, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFB, 0xE0, 0x00, 0x7F, 0x9F, 0x80, 0x03, 0xF8, 0x7C, 0x00, 0x1F, 0x83,
  0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x03, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x07,
  0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x0F,
  0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xF7, 0x83,
  0xFE, 0x0F, 0x78, 0x7B, 0xE0, 0xF7, 0x8F, 0xBC, 0x1F, 0x7C, 0xF3, 0xC1,
  0xF3, 0xDF, 0x3C, 0x1F, 0x3D, 0xE7, 0xC1, 0xE3, 0xFC, 0x7C, 0x1E, 0x3F,
  0xC7, 0xC1, 0xE1, 0xF8, 0x78, 0x3E, 0x1F, 0x87, 0x83, 0xE1, 0xF0, 0x78,
  0x3E, 0x1F, 0x0F, 0x83, 0xC0, 0xE0, 0xF8, 0x3C, 0x0E, 0x0F, 0x83, 0xC0,
  0xC0, 0xF0, 0x7C, 0x08, 0x0F, 0x07, 0xC0, 0x80, 0xF0, 0x7C, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0xF8,
  0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xE0, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x03, 0xE0, 0x7F, 0x00, 0x7C,
  0x1F, 0xE0, 0x0F, 0x83, 0xFC, 0x01, 0xF0, 0x7F, 0xC0, 0x3C, 0x0F, 0xF8,
  0x07, 0x81, 0xFF, 0x00, 0xF0, 0x3D, 0xE0, 0x3E, 0x0F, 0xBC, 0x07, 0xC1,
  0xF7, 0xC0, 0xF8, 0x3E, 0xF8, 0x1E, 0x07, 0xCF, 0x03, 0xC0, 0xF1, 0xE0,
  0x78, 0x1E, 0x3C, 0x1F, 0x07, 0xC7, 0xC3, 0xE0, 0xF8, 0xF8, 0x7C, 0x1F,
  0x0F, 0x0F, 0x03, 0xE1, 0xE1, 0xE0, 0x78, 0x3C, 0x3C, 0x0F, 0x07, 0xCF,
  0x83, 0xE0, 0xF9, 0xF0, 0x7C, 0x0F, 0x3E, 0x0F, 0x81, 0xE7, 0xC1, 0xF0,
  0x3C, 0xF0, 0x3C, 0x07, 0xDE, 0x07, 0x80, 0xFF, 0xC0, 0xF0, 0x0F, 0xF8,
  0x3E, 0x01, 0xFF, 0x07, 0xC0, 0x3F, 0xE0, 0xF8, 0x07, 0xF8, 0x1E, 0x00,
  0xFF, 0x03, 0xC0, 0x0F, 0xE0, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0x07,
  0xF0, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0x8F, 0x80, 0x07, 0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xEF,
  0xC0, 0x01, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7C,
  0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F,
  0x87, 0xE0, 0x1F, 0x81, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xC0, 0x1F,
  0x81, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F, 0x80,
  0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F,
  0x80, 0x1F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x07, 0xF0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0x07, 0xF0,
  0x3E, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0x7C, 0x00,
  0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xEF, 0xC0,
  0x01, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0x03,
  0xF0, 0x7F, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x81, 0x80, 0x07, 0xC1,
  0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xC0, 0x1F,
  0x81, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F, 0x80,
  0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F,
  0x80, 0x1F, 0x87, 0xC0, 0x07, 0xC1, 0xF0, 0x07, 0xF0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0xF8, 0x3E,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8,
  0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01,
  0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x81,
  0xFC, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x00, 0xE0, 0x7C, 0x00, 0x10, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x40, 0x00, 0xFC, 0x3C, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE1, 0xFF, 0x03,
  0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x8F, 0xC0,
  0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xF8, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3,
  0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7E,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x07,
  0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x0F, 0xC0,
  0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x03,
  0xF3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F,
  0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x0F, 0x3E, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x78,
  0x78, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x1E, 0x0F, 0xC1, 0xE0, 0xF0,
  0x7E, 0x0F, 0x07, 0x83, 0xF0, 0x78, 0x7C, 0x3F, 0x87, 0xC3, 0xE1, 0xFC,
  0x3C, 0x1F, 0x0F, 0xE1, 0xE0, 0xF8, 0xFF, 0x0F, 0x07, 0x87, 0x78, 0xF8,
  0x3C, 0x3B, 0xC7, 0xC1, 0xE3, 0xDE, 0x3C, 0x0F, 0x1C, 0xF1, 0xE0, 0x78,
  0xE7, 0x8F, 0x03, 0xCF, 0x1C, 0xF8, 0x1E, 0x70, 0xE7, 0x81, 0xF3, 0x87,
  0x3C, 0x0F, 0xBC, 0x39, 0xE0, 0x7D, 0xC1, 0xDF, 0x03, 0xDE, 0x0E, 0xF0,
  0x1E, 0xF0, 0x77, 0x80, 0xF7, 0x03, 0xBC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F,
  0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xE0,
  0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xC0,
  0x03, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x07, 0xEF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC3,
  0xE0, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xF8, 0x07,
  0xE0, 0x1F, 0x01, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x07,
  0xC3, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF7, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xEF, 0x80,
  0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x3E,
  0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xFC, 0x01,
  0xF0, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0x3E, 0x00,
  0x07, 0xEE, 0x00, 0x03, 0xC2, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x10, 0xF3, 0xE3, 0xC7,
  0xC7, 0x8F, 0x0F, 0x1E, 0x10, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x1F, 0x07,
  0xFF, 0x9F, 0x0F, 0xFF, 0xBE, 0x1F, 0xC1, 0xFE, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xFC,
  0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8,
  0x01, 0xF8, 0xFC, 0x03, 0xF8, 0x7C, 0x06, 0xF8, 0x7E, 0x0F, 0xFF, 0x7F,
  0xFC, 0xFE, 0x3F, 0xF8, 0xFE, 0x1F, 0xF0, 0x7E, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xF0, 0x0F, 0x8F, 0xF8, 0x0F,
  0x9F, 0xFC, 0x1F, 0x3F, 0xFE, 0x1F, 0x70, 0x7E, 0x1F, 0x60, 0x3E, 0x1F,
  0xC0, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3E,
  0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFF, 0x03, 0xF8, 0xFB,
  0xFF, 0xF0, 0xF9, 0xFF, 0xE0, 0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC1,
  0xF8, 0x7E, 0x01, 0xF3, 0xF0, 0x07, 0x0F, 0x80, 0x10, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x43, 0xE0, 0x01,
  0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x3E, 0x7E, 0x03, 0xF1, 0xFC, 0x1F, 0x83,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x07, 0xE1, 0xF0, 0x0F,
  0xFC, 0x7C, 0x07, 0xFF, 0x9F, 0x03, 0xFF, 0xF7, 0xC1, 0xFC, 0x0D, 0xF0,
  0x7E, 0x01, 0xFC, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x03,
  0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xC0,
  0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F,
  0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0xFE,
  0x07, 0xC0, 0x7F, 0x81, 0xF8, 0x3B, 0xE0, 0x7F, 0xFC, 0xF8, 0x0F, 0xFF,
  0x3E, 0x01, 0xFF, 0x9F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xC0, 0xFC, 0x7C, 0x01,
  0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x07, 0xF7,
  0xC1, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFC, 0x0F, 0xFE,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x8F, 0x80, 0x07,
  0x9F, 0x00, 0x3F, 0x7E, 0x01, 0xF9, 0xFC, 0x1F, 0xC3, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x40, 0x7C, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xC7, 0xC0, 0xFF, 0xF3,
  0xE0, 0xFF, 0xFD, 0xF0, 0xFE, 0x06, 0xF8, 0x7E, 0x01, 0xFC, 0x7E, 0x00,
  0x7C, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80,
  0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF8,
  0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x0F,
  0x80, 0x3F, 0x07, 0xC0, 0x3F, 0x83, 0xF8, 0x77, 0xC0, 0xFF, 0xF3, 0xE0,
  0x7F, 0xF9, 0xF0, 0x1F, 0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x02, 0x00, 0x1F, 0x01, 0x80, 0x1F,
  0x81, 0xF0, 0x3F, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x7C, 0x7F, 0xC0, 0xF9, 0xFF, 0xC1, 0xF7, 0xFF, 0x87, 0xEC, 0x3F,
  0x8F, 0xB0, 0x3F, 0x1F, 0x40, 0x3E, 0x3F, 0x00, 0x7C, 0x7E, 0x00, 0xF8,
  0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xF8, 0x01, 0xF3, 0xE0,
  0x03, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x20, 0x0F, 0x81, 0xC0, 0x3E, 0x0F,
  0x81, 0xF0, 0x7F, 0x07, 0xC3, 0xF0, 0x1F, 0x1F, 0x80, 0x7C, 0xFC, 0x01,
  0xF7, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x40, 0x1F, 0x00, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F,
  0xC3, 0xE0, 0x0F, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0xBE, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0xFC, 0x01, 0xF1, 0xFF,
  0x00, 0xF9, 0xFF, 0xC0, 0x7D, 0xFF, 0xF0, 0x7F, 0xC1, 0xF8, 0x3E, 0xC0,
  0x7C, 0x1F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0x7C,
  0x1F, 0x80, 0x3E, 0x7F, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x9F, 0x00, 0x0F,
  0x87, 0xC0, 0x47, 0xC3, 0xE0, 0x73, 0xE0, 0xF8, 0x7D, 0xF0, 0x7C, 0x7C,
  0xF8, 0x3E, 0x7C, 0x7C, 0x0F, 0xFC, 0x7C, 0x07, 0xFC, 0x3E, 0x01, 0xFC,
  0x00, 0x00, 0x78, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x80, 0xF8, 0x1C, 0x1F, 0x03, 0xE1,
  0xF0, 0x7F, 0x1F, 0x0F, 0xC1, 0xF1, 0xF8, 0x1F, 0x3F, 0x01, 0xF7, 0xE0,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x07, 0x81, 0xE7, 0xE3, 0xF8, 0x3D, 0xFE, 0x7F, 0x87, 0xBF, 0xDF, 0xF0,
  0xFC, 0xFE, 0x3E, 0x3F, 0x0F, 0x83, 0xC7, 0xC1, 0xF0, 0x78, 0xF8, 0x3C,
  0x0F, 0x1E, 0x07, 0x81, 0xE3, 0xC1, 0xF0, 0x7C, 0x78, 0x3E, 0x0F, 0x9F,
  0x07, 0x81, 0xE3, 0xC0, 0xF0, 0x3C, 0x78, 0x1E, 0x07, 0x8F, 0x03, 0xC0,
  0xF1, 0xE0, 0xF8, 0x3E, 0x3C, 0x1F, 0x07, 0xCF, 0x83, 0xC0, 0xF1, 0xE0,
  0x78, 0x1E, 0x3C, 0x0F, 0x03, 0xC7, 0x81, 0xE0, 0x78, 0xF0, 0x7C, 0x1F,
  0x3E, 0x0F, 0x83, 0xE7, 0xC1, 0xE0, 0x78, 0xF0, 0x3C, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x1F, 0x1F, 0xF0, 0x3E, 0x7F, 0xF0, 0x7D, 0xFF, 0xE0, 0xFB,
  0x0F, 0xE3, 0xEC, 0x0F, 0xC7, 0xD0, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x80,
  0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x07,
  0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFC,
  0x1F, 0x87, 0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0x3D, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0xFD,
  0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xC7, 0xC0, 0x3F, 0x0F,
  0xC0, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0xFF, 0x80, 0x3E, 0x7F, 0xF0,
  0x1F, 0xBF, 0xFE, 0x07, 0xDC, 0x1F, 0x81, 0xF6, 0x03, 0xE0, 0x7F, 0x00,
  0xFC, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xF0,
  0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07,
  0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xF0,
  0x3F, 0x83, 0xEF, 0xFF, 0xC0, 0xF9, 0xFF, 0xE0, 0x3E, 0x3F, 0xF0, 0x0F,
  0x83, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x1F, 0x07,
  0xFF, 0x9F, 0x0F, 0xFF, 0xDF, 0x1F, 0xC0, 0xDF, 0x1F, 0x80, 0x7F, 0x3F,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xFC,
  0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8,
  0x01, 0xF8, 0xFC, 0x03, 0xF8, 0x7C, 0x07, 0xF8, 0x7E, 0x0E, 0xF8, 0x7F,
  0xFC, 0xF8, 0x3F, 0xF8, 0xF0, 0x1F, 0xF1, 0xF0, 0x07, 0xE1, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xF7, 0xFF, 0x7F, 0xE0, 0x3E,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFC, 0x07, 0xC1, 0xF0,
  0x03, 0x07, 0xC0, 0x04, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF1, 0x80, 0x07, 0xC7, 0x80, 0x0F, 0x9F, 0xC0, 0x7F, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x08, 0x07, 0xC0, 0x38, 0x0F,
  0x80, 0xF0, 0x1F, 0x07, 0xF0, 0x3E, 0x1F, 0x80, 0x7C, 0xFE, 0x01, 0xF3,
  0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF0, 0x01,
  0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7,
  0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0xFC, 0xF8,
  0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x1F, 0xC7, 0xE0, 0x6F, 0x87, 0xE1,
  0xDF, 0x0F, 0xFF, 0x7E, 0x1F, 0xFC, 0xF8, 0x1F, 0xF1, 0xF0, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x19, 0xFF, 0x81, 0xFB, 0xFF, 0x01, 0xF7, 0xFC, 0x03,
  0xEF, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F,
  0x0F, 0x80, 0x3E, 0x1E, 0x00, 0xFC, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1,
  0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x3E,
  0x01, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x1F, 0x81, 0xF0, 0xFE, 0x03, 0xE7,
  0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0x87, 0xC1, 0xE1, 0xE1, 0xE0, 0x78, 0x78, 0x78,
  0x1E, 0x1F, 0x1E, 0x07, 0x87, 0xC7, 0x83, 0xE0, 0xF1, 0xE0, 0xF0, 0x3C,
  0xF8, 0x3C, 0x0F, 0x3C, 0x0F, 0x03, 0xCF, 0x03, 0xC0, 0xF3, 0xC0, 0xF0,
  0x3C, 0xF0, 0x7C, 0x1F, 0x3C, 0x1E, 0x07, 0xDF, 0x07, 0x81, 0xE7, 0x81,
  0xE0, 0x79, 0xE0, 0x78, 0x1E, 0x78, 0x1E, 0x07, 0x9E, 0x0F, 0x83, 0xC7,
  0x83, 0xE0, 0xF3, 0xE0, 0xF0, 0x3C, 0xF8, 0x7C, 0x1E, 0x3E, 0x37, 0x0F,
  0x07, 0xFD, 0xE7, 0xC1, 0xFE, 0x7F, 0xE0, 0x7F, 0x0F, 0xF0, 0x07, 0x81,
  0xF0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0xE1, 0xFE, 0x03, 0xFE, 0x3F,
  0xE0, 0x7F, 0xE3, 0xFF, 0x1F, 0xDF, 0x71, 0xF3, 0xF0, 0xF6, 0x0F, 0x3E,
  0x0F, 0x60, 0xF1, 0x80, 0xFC, 0x0F, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x0F, 0x83, 0xF0, 0x10, 0xF0, 0x3F, 0x01, 0x8F, 0x83, 0x78, 0x7C,
  0xF8, 0x67, 0x8F, 0xCF, 0x8E, 0x7B, 0xF8, 0xFF, 0xE7, 0xFF, 0x07, 0xFC,
  0x7F, 0xC0, 0x7F, 0x83, 0xF8, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x0F,
  0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x3E,
  0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x5F, 0x03, 0xF0, 0xEF, 0x81,
  0xFF, 0xE7, 0xC0, 0x7F, 0xE7, 0xE0, 0x3F, 0xE3, 0xE0, 0x07, 0xE1, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x04, 0x00, 0x3E,
  0x03, 0x00, 0x3F, 0x03, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xFF, 0x07, 0xC3, 0xFF, 0xE3, 0xC3, 0xFF, 0xF9, 0xE1, 0xF0, 0x7F, 0xF0,
  0xF0, 0x0F, 0xF0, 0xF0, 0x03, 0xF0, 0x78, 0x03, 0xF0, 0x3C, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x20, 0x07, 0xE0, 0x70, 0x07, 0xE0,
  0x3C, 0x07, 0xE0, 0x1E, 0x07, 0xE0, 0x0F, 0x87, 0xE0, 0x03, 0xC7, 0xFF,
  0x01, 0xE7, 0xFF, 0xFC, 0xF3, 0xE7, 0xFF, 0xF9, 0xF0, 0x7F, 0xF8, 0xF0,
  0x07, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F,
  0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x00,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x07, 0x07,
  0xF8, 0x03, 0xC7, 0xFE, 0x01, 0xE7, 0xFF, 0x81, 0xE3, 0xE7, 0xC0, 0xF3,
  0xE1, 0xF0, 0xF1, 0xE0, 0x7C, 0xF9, 0xF0, 0x3F, 0xF8, 0xF0, 0x0F, 0xFC,
  0x78, 0x03, 0xF8, 0x18, 0x00, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 11, 33, 28, 9, -33 },
  { 47, 16, 14, 28, 9, -35 },
  { 75, 29, 33, 28, 0, -33 },
  { 195, 27, 44, 28, 1, -38 },
  { 344, 32, 34, 28, -1, -33 },
  { 480, 28, 34, 28, 0, -33 },
  { 599, 7, 14, 28, 13, -35 },
  { 612, 19, 42, 28, 9, -36 },
  { 712, 18, 42, 28, 2, -36 },
  { 807, 25, 23, 28, 2, -26 },
  { 879, 23, 22, 28, 3, -25 },
  { 943, 12, 14, 28, 6, -7 },
  { 964, 15, 4, 28, 7, -17 },
  { 972, 9, 8, 28, 8, -8 },
  { 981, 27, 42, 28, 1, -36 },
  { 1123, 25, 34, 28, 2, -33 },
  { 1230, 23, 33, 28, 2, -33 },
  { 1325, 25, 33, 28, 1, -33 },
  { 1429, 25, 34, 28, 1, -33 },
  { 1536, 25, 33, 28, 1, -33 },
  { 1640, 25, 34, 28, 2, -33 },
  { 1747, 24, 34, 28, 2, -33 },
  { 1849, 25, 33, 28, 4, -33 },
  { 1953, 25, 34, 28, 2, -33 },
  { 2060, 23, 33, 28, 4, -33 },
  { 2155, 12, 26, 28, 8, -26 },
  { 2194, 14, 33, 28, 6, -26 },
  { 2252, 23, 27, 28, 4, -28 },
  { 2330, 25, 14, 28, 2, -21 },
  { 2374, 23, 27, 28, 2, -28 },
  { 2452, 20, 33, 28, 6, -33 },
  { 2535, 25, 38, 28, 2, -33 },
  { 2654, 26, 33, 28, -1, -33 },
  { 2762, 25, 33, 28, 2, -33 },
  { 2866, 25, 34, 28, 3, -33 },
  { 2973, 25, 33, 28, 2, -33 },
  { 3077, 26, 33, 28, 2, -33 },
  { 3185, 27, 33, 28, 2, -33 },
  { 3297, 24, 34, 28, 3, -33 },
  { 3399, 27, 33, 28, 1, -33 },
  { 3511, 26, 33, 28, 2, -33 },
  { 3619, 25, 34, 28, 2, -33 },
  { 3726, 29, 33, 28, 2, -33 },
  { 3846, 21, 33, 28, 3, -33 },
  { 3933, 28, 33, 28, 1, -33 },
  { 4049, 27, 33, 28, 1, -33 },
  { 4161, 25, 34, 28, 2, -33 },
  { 4268, 26, 33, 28, 2, -33 },
  { 4376, 25, 42, 28, 2, -33 },
  { 4508, 26, 33, 28, 2, -33 },
  { 4616, 27, 34, 28, 1, -33 },
  { 4731, 27, 33, 28, 4, -33 },
  { 4843, 25, 34, 28, 3, -33 },
  { 4950, 25, 33, 28, 5, -33 },
  { 5054, 29, 33, 28, 1, -33 },
  { 5174, 31, 33, 28, -1, -33 },
  { 5302, 27, 33, 28, 4, -33 },
  { 5414, 29, 33, 28, 0, -33 },
  { 5534, 21, 42, 28, 7, -36 },
  { 5645, 13, 42, 28, 8, -36 },
  { 5714, 21, 42, 28, 1, -36 },
  { 5825, 25, 20, 28, 2, -33 },
  { 5888, 23, 4, 28, 0, 4 },
  { 5900, 7, 10, 28, 10, -37 },
  { 5909, 24, 26, 28, 2, -25 },
  { 5987, 24, 36, 28, 2, -35 },
  { 6095, 22, 26, 28, 3, -25 },
  { 6167, 26, 36, 28, 2, -35 },
  { 6284, 22, 26, 28, 3, -25 },
  { 6356, 31, 45, 28, -1, -35 },
  { 6531, 25, 35, 28, 1, -25 },
  { 6641, 23, 35, 28, 2, -35 },
  { 6742, 22, 36, 28, 4, -35 },
  { 6841, 23, 45, 28, 2, -35 },
  { 6971, 25, 36, 28, 2, -35 },
  { 7084, 20, 36, 28, 5, -35 },
  { 7174, 27, 25, 28, 0, -25 },
  { 7259, 23, 25, 28, 2, -25 },
  { 7331, 23, 26, 28, 3, -25 },
  { 7406, 26, 34, 28, 0, -25 },
  { 7517, 24, 34, 28, 2, -25 },
  { 7619, 23, 24, 28, 5, -24 },
  { 7688, 23, 26, 28, 2, -25 },
  { 7763, 23, 34, 28, 3, -33 },
  { 7861, 23, 25, 28, 3, -24 },
  { 7933, 23, 25, 28, 3, -25 },
  { 8005, 26, 26, 28, 1, -25 },
  { 8090, 28, 26, 28, 0, -25 },
  { 8181, 25, 34, 28, 1, -24 },
  { 8288, 25, 26, 28, 2, -25 },
  { 8370, 22, 42, 28, 5, -36 },
  { 8486, 11, 42, 28, 9, -36 },
  { 8544, 22, 42, 28, 2, -36 },
  { 8660, 25, 11, 28, 2, -20 },
};

const GFXfont IBMPlexMono_MediumItalic47pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic47pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic47pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _IBMPLEXMONO_MEDIUMITALIC47PT7B_H_
