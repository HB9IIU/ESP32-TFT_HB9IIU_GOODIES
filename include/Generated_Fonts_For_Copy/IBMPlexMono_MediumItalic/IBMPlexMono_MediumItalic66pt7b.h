#ifndef _IBMPLEXMONO_MEDIUMITALIC66PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x1F,
  0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8,
  0x0F, 0xC3, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81,
  0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F,
  0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0,
  0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x40, 0x7E,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x3E, 0x7F, 0xE0,
  0x1F, 0xF0, 0xF8, 0x7F, 0xC0, 0x7F, 0x83, 0xE0, 0xFC, 0x03, 0xFC, 0x0F,
  0x80, 0xE0, 0x0F, 0xE0, 0x3E, 0x03, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0x01,
  0xFE, 0x07, 0xC0, 0x00, 0x07, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0xE0, 0x7C,
  0x00, 0x00, 0x7F, 0x81, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0x03,
  0xFC, 0x1E, 0x00, 0x00, 0x0F, 0xF8, 0x78, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x1F, 0xF0, 0x00, 0x00, 0x78, 0x3F,
  0xE0, 0x00, 0x03, 0xE0, 0x7F, 0x80, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0x00,
  0x3E, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x3F,
  0x80, 0x00, 0x0F, 0x00, 0xFE, 0x01, 0x00, 0x3C, 0x07, 0xF8, 0x0C, 0x01,
  0xF0, 0x1F, 0xC0, 0xF8, 0x07, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0x07, 0xFC,
  0x3F, 0xF0, 0x7C, 0x3F, 0xE0, 0x7F, 0xF9, 0xF3, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x7C, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x7C, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0x07,
  0xC0, 0xFC, 0x00, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0x87,
  0xE0, 0x00, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0x7E, 0x1F, 0x87, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x1F, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xF8, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xC3, 0xF8, 0x7E, 0x00, 0x00,
  0x3F, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x00, 0x07,
  0xC1, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x03,
  0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x3E, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x7E,
  0x00, 0x3F, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x87, 0xF0, 0x00, 0xFE, 0x01, 0xCF, 0xE0, 0x01, 0xFC, 0x07,
  0xFF, 0xE0, 0x03, 0xFC, 0x0F, 0xFF, 0xC0, 0x0D, 0xF8, 0x3F, 0x3F, 0x80,
  0x1B, 0xF8, 0xFE, 0x7F, 0x80, 0x77, 0xF1, 0xF8, 0xFF, 0x83, 0xC7, 0xF7,
  0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0x01, 0xFF,
  0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x1F, 0x8F, 0xCF, 0xE7, 0xF3, 0xF9,
  0xF8, 0xFC, 0x7E, 0x7F, 0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF9, 0xFC,
  0xFE, 0x7E, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x02, 0x00, 0x3F, 0x00,
  0x18, 0xF8, 0x07, 0xE0, 0x1F, 0x1F, 0xE0, 0xFC, 0x1F, 0xE7, 0xFF, 0x9F,
  0x9F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF8, 0x1F, 0x83, 0xFE, 0x7F, 0xEF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xC7, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00,
  0x0F, 0xE7, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x07, 0xF7, 0xF8, 0x0F, 0x80, 0xFE, 0xFF, 0x07, 0xF8, 0x3F, 0xDF,
  0xE0, 0xFF, 0x07, 0xFB, 0xFC, 0x1F, 0xE0, 0xFF, 0x7F, 0x03, 0xFC, 0x1F,
  0xEF, 0xE0, 0xFF, 0x83, 0xF9, 0xFC, 0x0F, 0xE0, 0x7F, 0x7F, 0x80, 0xF8,
  0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x9F,
  0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0xFF, 0x9F,
  0xC0, 0x01, 0xFF, 0x1F, 0xC0, 0x03, 0xFE, 0x1F, 0xC0, 0x07, 0xFC, 0x1F,
  0xC0, 0x0F, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x0F, 0x80, 0x3F, 0x80, 0x07, 0x00, 0x3F, 0x80, 0x02, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x5F,
  0x80, 0x00, 0xFF, 0x00, 0x30, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0x80,
  0x00, 0xFF, 0x00, 0x30, 0x00, 0x0F, 0xF0, 0x02, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x04,
  0x00, 0x00, 0x7F, 0x81, 0xE0, 0x00, 0x07, 0xF8, 0x3E, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x03, 0xF1, 0xFF, 0xF0, 0x00, 0x7E, 0x3F,
  0xFF, 0x80, 0x07, 0xE7, 0xFF, 0xFE, 0x00, 0x7E, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x40, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x60, 0x00,
  0x07, 0xF8, 0x0E, 0x00, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x01, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0xFC, 0x03, 0xFC,
  0x7F, 0xFF, 0x01, 0xFC, 0xFF, 0xFF, 0xC0, 0xFE, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0x78, 0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0x3F,
  0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x0F,
  0xF3, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x0F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE7, 0xF0, 0x00, 0x07, 0xF9,
  0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0xFF, 0x1F, 0x80, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0x1F, 0xE1, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03,
  0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x00,
  0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0xC0,
  0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x3D,
  0xFC, 0x3F, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0xFE, 0xFF, 0x07, 0xFF, 0xFE,
  0x7F, 0x01, 0xFF, 0xFE, 0x7F, 0x80, 0x3F, 0xFC, 0x7F, 0x80, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE,
  0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xC0, 0xFF, 0xCF, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFE, 0x38, 0x00, 0x0F, 0xF0, 0x40, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC3, 0xF0, 0x1F, 0xF1,
  0xF8, 0xFC, 0x07, 0xFF, 0x3F, 0x1F, 0x81, 0xFF, 0xF7, 0xE3, 0xF0, 0x3F,
  0xFE, 0xF8, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0x83, 0xF8, 0x0F, 0xE3, 0xF0,
  0x7F, 0x00, 0xFC, 0x7E, 0x0F, 0xC0, 0x1F, 0x8F, 0xC3, 0xF8, 0x03, 0xF3,
  0xF8, 0x7E, 0x00, 0x7C, 0x7E, 0x0F, 0xC0, 0x1F, 0x8F, 0xC1, 0xF8, 0x03,
  0xF1, 0xF8, 0x7F, 0x00, 0x7E, 0x3F, 0x0F, 0xE0, 0x0F, 0xC7, 0xE1, 0xF8,
  0x01, 0xF8, 0xFC, 0x3F, 0x00, 0x3E, 0x3F, 0x07, 0xE0, 0x0F, 0xC7, 0xE0,
  0xFC, 0x01, 0xF8, 0xFC, 0x1F, 0x80, 0x3F, 0x1F, 0x83, 0xF0, 0x0F, 0xE3,
  0xF0, 0x7E, 0x03, 0xFC, 0x7E, 0x0F, 0xE0, 0xDF, 0x0F, 0xC0, 0xFE, 0x3F,
  0xE1, 0xF8, 0x1F, 0xFE, 0xFC, 0x3F, 0x03, 0xFF, 0xDF, 0x87, 0xE0, 0x3F,
  0xF3, 0xF0, 0xFC, 0x03, 0xFC, 0x7E, 0x0F, 0x80, 0x1E, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC,
  0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80,
  0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x00,
  0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0xE1, 0xFC,
  0x00, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00,
  0x00, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x08, 0x01, 0xFC, 0x00,
  0x01, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xC0, 0x03,
  0xFE, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x1E, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x01, 0xFF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0x3F, 0xC0, 0x3F, 0xFF, 0xCF,
  0xF0, 0x0F, 0xFF, 0xF3, 0xFC, 0x03, 0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xFE,
  0x3F, 0x80, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xC0,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x1D, 0xF8, 0x0F, 0xFC, 0x0F, 0x7E, 0x03, 0xFF, 0xFF, 0x9F, 0x80,
  0x7F, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0xF3, 0xF8, 0x03, 0xFF, 0xF8, 0xFE,
  0x00, 0x3F, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFC, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x3F, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x60, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0x80,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x00, 0x0F,
  0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x7F,
  0xC0, 0x00, 0x03, 0xF8, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x7F, 0xC0, 0x00,
  0x00, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xBF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xCF, 0xE0, 0x00, 0x03, 0xFF, 0xC7, 0xF8, 0x00, 0x01, 0xFF,
  0xC1, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x7E, 0xFC,
  0x07, 0xF7, 0xE0, 0xFD, 0xFC, 0x07, 0xF7, 0xE0, 0xF9, 0xF8, 0x07, 0xE3,
  0xE1, 0xF9, 0xF8, 0x07, 0xE3, 0xF3, 0xF1, 0xF8, 0x07, 0xE3, 0xF3, 0xF1,
  0xF8, 0x07, 0xE3, 0xF7, 0xE3, 0xF8, 0x0F, 0xE1, 0xF7, 0xE3, 0xF8, 0x0F,
  0xE1, 0xFF, 0xC3, 0xF0, 0x0F, 0xE1, 0xFF, 0xC3, 0xF0, 0x0F, 0xC1, 0xFF,
  0x83, 0xF0, 0x0F, 0xC1, 0xFF, 0x03, 0xF0, 0x0F, 0xC0, 0xFF, 0x07, 0xF0,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x1F, 0xC0,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x80, 0x78, 0x07,
  0xE0, 0x1F, 0x80, 0x78, 0x0F, 0xE0, 0x3F, 0x80, 0x70, 0x0F, 0xE0, 0x3F,
  0x80, 0x60, 0x0F, 0xC0, 0x3F, 0x80, 0x20, 0x0F, 0xC0, 0x3F, 0x00, 0x40,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xE0,
  0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0xF0, 0x00, 0x7E, 0x01, 0xFF, 0xC0,
  0x03, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0x80,
  0xFF, 0xF8, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xF0, 0x0F, 0xFF, 0x80,
  0x0F, 0xC0, 0x3F, 0x7E, 0x00, 0x7F, 0x00, 0xFD, 0xFC, 0x01, 0xFC, 0x03,
  0xF3, 0xF0, 0x07, 0xF0, 0x1F, 0xCF, 0xC0, 0x1F, 0x80, 0x7F, 0x3F, 0x00,
  0x7E, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0x07, 0xE3, 0xF8, 0x0F, 0xE0, 0x1F,
  0x87, 0xE0, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x7E, 0x03,
  0xF0, 0x0F, 0xE1, 0xF8, 0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x3F, 0x00, 0xFC,
  0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x1F,
  0xC0, 0x7F, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x0F, 0xE1, 0xF8, 0x07, 0xF0,
  0x1F, 0x87, 0xE0, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0xFE,
  0x01, 0xF8, 0x07, 0xE3, 0xF8, 0x0F, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x80,
  0x3F, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0xFC, 0x03, 0xF0, 0x03, 0xF7, 0xF0,
  0x0F, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0x00, 0x3F, 0xFF, 0x01, 0xFC, 0x00,
  0x7F, 0xF8, 0x07, 0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0xC0, 0x07, 0xFF, 0x80,
  0x7E, 0x00, 0x1F, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xE0, 0x00,
  0xFF, 0xE0, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x03,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03,
  0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00,
  0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x01, 0xFC,
  0xFF, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x03, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xE0,
  0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xE0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFC, 0x3F,
  0x80, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F,
  0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x02,
  0x00, 0x00, 0xFE, 0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x3E, 0x00, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xE0, 0x01, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x0F,
  0xF0, 0x00, 0x07, 0x80, 0x3F, 0xC0, 0x00, 0x0C, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x04, 0x00, 0x00, 0x1F, 0xC0,
  0x30, 0x00, 0x00, 0xFF, 0x03, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xE8, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01,
  0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xC0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00,
  0x3F, 0xCF, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC,
  0x3F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0xF0, 0x0F,
  0xC0, 0xFC, 0x07, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xFC, 0x07, 0xE0, 0x3F,
  0x03, 0xFF, 0x03, 0xF0, 0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x0F, 0xC0, 0xFF,
  0xC1, 0xFC, 0x07, 0xE0, 0xFF, 0xE0, 0xFC, 0x03, 0xF0, 0x7D, 0xF0, 0x7E,
  0x03, 0xF8, 0x3E, 0xF8, 0x3F, 0x01, 0xFC, 0x3E, 0x7C, 0x1F, 0x80, 0xFC,
  0x1F, 0x3E, 0x1F, 0x80, 0x7E, 0x0F, 0x9F, 0x0F, 0xC0, 0x3F, 0x0F, 0x8F,
  0x87, 0xE0, 0x1F, 0x87, 0xC7, 0xC3, 0xF0, 0x0F, 0xC3, 0xE3, 0xE3, 0xF0,
  0x07, 0xE3, 0xE1, 0xF1, 0xF8, 0x03, 0xF1, 0xF0, 0xF8, 0xFC, 0x01, 0xF8,
  0xF8, 0x7C, 0x7E, 0x01, 0xFC, 0xF8, 0x3E, 0x7E, 0x00, 0xFC, 0x7C, 0x1F,
  0x3F, 0x00, 0x7E, 0x3E, 0x0F, 0x9F, 0x80, 0x3F, 0x3E, 0x07, 0xCF, 0xC0,
  0x1F, 0x9F, 0x03, 0xE7, 0xC0, 0x0F, 0xCF, 0x81, 0xF7, 0xE0, 0x07, 0xEF,
  0x80, 0xFB, 0xF0, 0x03, 0xF7, 0xC0, 0x7D, 0xF8, 0x01, 0xFF, 0xE0, 0x3E,
  0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xF0, 0x00, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x78, 0x00, 0x00,
  0x1C, 0x02, 0x00, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x04, 0x07, 0x0F, 0xE3, 0xF8, 0x7F,
  0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0x81, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0x0F,
  0xE0, 0x3F, 0xFF, 0xC7, 0xF0, 0x3F, 0xFF, 0xF3, 0xF8, 0x3F, 0xFF, 0xF9,
  0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xF1, 0xFE, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x3F, 0x8F, 0xF0,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xFE, 0x0F, 0xE0, 0x03, 0x7F, 0x07, 0xF8, 0x03, 0xBF, 0x83,
  0xFE, 0x07, 0x9F, 0xFD, 0xFF, 0xFF, 0xCF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFE,
  0x1F, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0xFF, 0xF0, 0x07,
  0xF0, 0xFF, 0xFC, 0x03, 0xF8, 0xFF, 0xFF, 0x01, 0xFC, 0xFF, 0xFF, 0xC0,
  0xFE, 0xFF, 0xFF, 0xE0, 0xFF, 0x78, 0x1F, 0xF0, 0x7F, 0x78, 0x07, 0xFC,
  0x3F, 0xB0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F,
  0x87, 0xF8, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x3F, 0xCF, 0xE0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0,
  0x01, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x0F, 0xE7, 0xFF, 0xFF, 0x07, 0xF3,
  0xFF, 0xFF, 0x03, 0xF8, 0xFF, 0xFF, 0x81, 0xFC, 0x7F, 0xFF, 0x00, 0xFE,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xF0, 0x7F,
  0x00, 0x01, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x10, 0x7F, 0x80, 0x00, 0x38, 0x7F, 0x00, 0x00, 0xF8, 0xFE, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF,
  0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x03, 0xFF, 0xC1, 0xFC, 0x00, 0xFF, 0xFE, 0x1F, 0xC0, 0x1F, 0xFF, 0xF3,
  0xFC, 0x03, 0xFF, 0xFF, 0xBF, 0x80, 0x7F, 0xFF, 0xFB, 0xF8, 0x07, 0xFE,
  0x03, 0xBF, 0x80, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xF0, 0x01, 0xFF,
  0xC0, 0x7F, 0x80, 0x3B, 0xF8, 0x07, 0xFE, 0x0F, 0xBF, 0x80, 0x3F, 0xFF,
  0xF3, 0xF8, 0x03, 0xFF, 0xFF, 0x3F, 0x80, 0x1F, 0xFF, 0xE3, 0xF8, 0x00,
  0xFF, 0xFC, 0x7F, 0x80, 0x07, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0x00, 0x0F,
  0xFC, 0x7F, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x40, 0x7F, 0x00, 0x00, 0x70, 0x7F, 0x00, 0x00, 0xF8, 0x7F, 0x00, 0x01,
  0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x0F, 0xE0, 0x00,
  0x00, 0x1C, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xFB, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x7F, 0x00, 0x3F, 0xFF,
  0x87, 0xF0, 0x07, 0xFF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xEF, 0xE0, 0x1F,
  0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0x80, 0xEF, 0xE0, 0x3F, 0xE0, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFE,
  0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xE0, 0x03,
  0x7F, 0x01, 0xFE, 0x00, 0xF7, 0xF0, 0x1F, 0xF8, 0x3E, 0xFE, 0x00, 0xFF,
  0xFF, 0xCF, 0xE0, 0x0F, 0xFF, 0xFC, 0xFE, 0x00, 0x7F, 0xFF, 0x8F, 0xE0,
  0x03, 0xFF, 0xF0, 0xFE, 0x00, 0x1F, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x80, 0x00, 0x7F, 0x80,
  0x0C, 0x00, 0x0F, 0xF0, 0x01, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x7F,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0xF0, 0x07, 0xF8, 0xFF,
  0xFC, 0x07, 0xF1, 0xFF, 0xFC, 0x07, 0xF1, 0xFF, 0xFE, 0x07, 0xF3, 0xFF,
  0xFE, 0x07, 0xF7, 0x83, 0xFF, 0x07, 0xF7, 0x00, 0xFF, 0x0F, 0xFE, 0x00,
  0xFF, 0x0F, 0xEC, 0x00, 0x7F, 0x0F, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0xC0, 0x03, 0xF8, 0x03, 0xC0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F,
  0xC0, 0x3F, 0x81, 0xFF, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0xFE, 0x1F, 0xF0,
  0x01, 0xF8, 0x7F, 0xC0, 0x07, 0xF1, 0xFF, 0x00, 0x0F, 0xE7, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x20, 0x01, 0xFC,
  0x00, 0x18, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xF1,
  0xFC, 0x00, 0x07, 0xFD, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x1F, 0xC1, 0xFF, 0xC0, 0x07, 0xF0, 0xFF, 0xFC, 0x00, 0xFE, 0x3F,
  0xFF, 0xC0, 0x1F, 0xCF, 0xFF, 0xF8, 0x03, 0xF9, 0xFF, 0xFF, 0x80, 0x7F,
  0x78, 0x1F, 0xF0, 0x0F, 0xFE, 0x01, 0xFE, 0x03, 0xFB, 0x00, 0x1F, 0xC0,
  0x7F, 0xE0, 0x03, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x3F, 0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x03, 0xF8, 0x7F, 0xE0, 0x00,
  0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0x7F, 0x0F, 0xE0, 0x02, 0x0F, 0xE0, 0xFE, 0x00, 0xE1, 0xFC, 0x1F,
  0xC0, 0x3E, 0x7F, 0x03, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F, 0x83, 0xFD, 0xFC,
  0x07, 0xF8, 0xFF, 0x3F, 0x80, 0x7F, 0x3F, 0xC7, 0xF0, 0x0F, 0xFF, 0xF0,
  0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0x80, 0x1F, 0xFF, 0x07, 0xF0, 0x01, 0xFF,
  0x80, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x10, 0x07, 0xF0, 0x03,
  0x80, 0x7F, 0x00, 0x7C, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFF, 0x07,
  0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x1F,
  0xE0, 0x0F, 0xE3, 0xFC, 0x00, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC7,
  0xF0, 0x3F, 0xE0, 0x3F, 0x3F, 0xE1, 0xFF, 0x81, 0xF9, 0xFF, 0xCF, 0xFF,
  0x07, 0xEF, 0xFF, 0x7F, 0xFC, 0x1F, 0xBF, 0xFD, 0xFF, 0xF0, 0x7F, 0xC7,
  0xFF, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0xC0, 0xFC,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0xFE, 0x03, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0xFC, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0x1F, 0x87,
  0xE0, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x80,
  0x7E, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x07, 0xE1, 0xF8,
  0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0xF0,
  0x07, 0xF0, 0xFF, 0xFC, 0x07, 0xF1, 0xFF, 0xFC, 0x07, 0xF1, 0xFF, 0xFE,
  0x07, 0xF3, 0xFF, 0xFE, 0x07, 0xF7, 0x83, 0xFF, 0x07, 0xF7, 0x00, 0xFF,
  0x0F, 0xFE, 0x00, 0xFF, 0x0F, 0xEC, 0x00, 0x7F, 0x0F, 0xF8, 0x00, 0x7F,
  0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC,
  0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFE,
  0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF8,
  0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0xF0, 0x00, 0xFE, 0x1F,
  0xFF, 0x80, 0x0F, 0xE3, 0xFF, 0xFC, 0x00, 0xFE, 0x7F, 0xFF, 0xE0, 0x0F,
  0xEF, 0xFF, 0xFE, 0x01, 0xFE, 0xF0, 0x3F, 0xE0, 0x1F, 0xDE, 0x01, 0xFF,
  0x01, 0xFD, 0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x3F,
  0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF0, 0x1F, 0xCF, 0xFF, 0xFE, 0x01, 0xFC, 0xFF, 0xFF, 0xC0,
  0x1F, 0xC7, 0xFF, 0xFC, 0x01, 0xFC, 0x7F, 0xFF, 0x00, 0x1F, 0xC1, 0xFF,
  0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x07, 0xF0, 0x0F, 0xFF, 0xE1,
  0xFC, 0x07, 0xFF, 0xFC, 0xFF, 0x03, 0xFF, 0xFF, 0xBF, 0x81, 0xFF, 0xFF,
  0xEF, 0xE0, 0x7F, 0xE0, 0x3B, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x1F, 0xF0,
  0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x1F, 0xC7,
  0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x03,
  0xF8, 0xFF, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x01, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0xC1, 0xFC, 0x00, 0x7F, 0xF0, 0x7F,
  0x80, 0x3B, 0xF8, 0x1F, 0xF8, 0x3E, 0xFE, 0x03, 0xFF, 0xFF, 0x3F, 0x80,
  0xFF, 0xFF, 0x8F, 0xE0, 0x1F, 0xFF, 0xE3, 0xF8, 0x03, 0xFF, 0xF1, 0xFE,
  0x00, 0x7F, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x7F, 0xFF, 0x80, 0xFF, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFE, 0xFF, 0xFF, 0x3F, 0xFE, 0xFF, 0xFF, 0x7F, 0xFE,
  0x00, 0xFE, 0x78, 0x00, 0x00, 0xFE, 0xE0, 0x00, 0x00, 0xFE, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3C,
  0x07, 0xF0, 0x00, 0x18, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x08, 0x00, 0x01, 0xFC, 0x3C, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF8,
  0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x20,
  0x03, 0xF8, 0x01, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0xE0,
  0x3F, 0x80, 0xFF, 0xC0, 0x7F, 0x03, 0xFE, 0x00, 0xFE, 0x1F, 0xF8, 0x01,
  0xFC, 0x7F, 0xE0, 0x07, 0xFB, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x1F, 0xF0, 0xFE,
  0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x6F, 0xE0, 0xFF, 0x00, 0xEF, 0xE0, 0xFF,
  0x83, 0xCF, 0xE0, 0xFF, 0xFF, 0xCF, 0xE0, 0x7F, 0xFF, 0x9F, 0xE0, 0x7F,
  0xFF, 0x1F, 0xC0, 0x3F, 0xFE, 0x1F, 0xC0, 0x1F, 0xFC, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0xFF, 0xFC, 0x00, 0x7C, 0xFF,
  0xFC, 0x01, 0xFE, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0xF8, 0x00, 0xFE, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x0F,
  0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x0F,
  0xE0, 0x07, 0xF8, 0x0F, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xF0, 0x1F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xC0, 0x7F, 0xC0, 0x1F, 0xC1, 0xFF, 0x80, 0x1F,
  0xCF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0xC0, 0xFC, 0x03, 0xE0, 0x7C,
  0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0x7E,
  0x07, 0xE1, 0xF8, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0x7E, 0x03, 0xF1, 0xF8,
  0x07, 0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xC0, 0x3F,
  0x1F, 0x00, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xC0, 0x3F, 0x3F, 0x00, 0xFC,
  0x03, 0xF3, 0xF0, 0x0F, 0x80, 0x3F, 0x3F, 0x01, 0xF8, 0x03, 0xF3, 0xF0,
  0x1F, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x80, 0x7E,
  0x7E, 0x01, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x00, 0x7E, 0x7E, 0x03, 0xF0,
  0x07, 0xE7, 0xE0, 0x3F, 0x00, 0xFC, 0x7C, 0x03, 0xF0, 0x0F, 0xCF, 0xC0,
  0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xF0, 0x1F, 0x8F, 0xC0, 0x7F, 0x01, 0xF8,
  0xFC, 0x0F, 0xF0, 0x3F, 0x0F, 0xC0, 0xDF, 0x03, 0xF0, 0xFE, 0x3D, 0xF0,
  0x7E, 0x0F, 0xFF, 0xDF, 0x8F, 0xE0, 0xFF, 0xF9, 0xFF, 0xFC, 0x07, 0xFF,
  0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0xC1, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC7, 0xFF, 0xE0, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF,
  0x3F, 0x3E, 0x3F, 0x87, 0xFC, 0x7E, 0x70, 0x3F, 0x1F, 0xE0, 0xFD, 0xE0,
  0x7E, 0x3F, 0x81, 0xFB, 0x80, 0xFC, 0x3C, 0x01, 0xF7, 0x01, 0xF8, 0x30,
  0x03, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x08, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0xFF,
  0x00, 0x20, 0xFC, 0x01, 0xFE, 0x00, 0xE1, 0xF8, 0x07, 0x7C, 0x03, 0xE3,
  0xF0, 0x0E, 0xF8, 0x0F, 0xC7, 0xE0, 0x39, 0xF0, 0x7F, 0xCF, 0xE0, 0xF3,
  0xF1, 0xFF, 0x1F, 0xC3, 0xE7, 0xEF, 0xF8, 0x1F, 0xFF, 0x8F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x1F,
  0xF0, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF0,
  0x0E, 0xFE, 0x00, 0xFF, 0x81, 0xCF, 0xE0, 0x0F, 0xFF, 0xFC, 0xFE, 0x00,
  0x7F, 0xFF, 0x8F, 0xE0, 0x07, 0xFF, 0xF1, 0xFE, 0x00, 0x3F, 0xFF, 0x1F,
  0xC0, 0x01, 0xFF, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x08, 0x00, 0x07, 0xF8, 0x00, 0xC0, 0x00, 0xFF,
  0x00, 0x1E, 0x00, 0x1F, 0xF0, 0x03, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0x01, 0xFF,
  0xFE, 0x07, 0xE0, 0x3F, 0xFF, 0xF8, 0x7E, 0x03, 0xFF, 0xFF, 0xCF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x7E, 0x00, 0x7F,
  0xFC, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xC0,
  0x03, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x04, 0x00,
  0x03, 0xFC, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x3E, 0x00, 0x1F, 0xF0, 0x03,
  0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x0F, 0xF0,
  0x00, 0x1F, 0x81, 0xFF, 0xE0, 0x01, 0xF8, 0x7F, 0xFF, 0xF0, 0x0F, 0x87,
  0xFF, 0xFF, 0xF8, 0xF8, 0x7F, 0x7F, 0xFF, 0xFF, 0x87, 0xE1, 0xFF, 0xFF,
  0xF8, 0x7E, 0x03, 0xFF, 0xFF, 0x07, 0xE0, 0x0F, 0xFF, 0xF0, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x7F,
  0xFE, 0x00, 0x3E, 0x07, 0xFF, 0xE0, 0x07, 0xE0, 0xFF, 0xFF, 0x00, 0x7E,
  0x1F, 0xC7, 0xF8, 0x0F, 0xC1, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x81, 0xFC,
  0x1F, 0xC3, 0xF0, 0x0F, 0xE3, 0xF8, 0x3E, 0x00, 0xFF, 0xFF, 0x07, 0xE0,
  0x07, 0xFF, 0xF0, 0x7E, 0x00, 0x7F, 0xFE, 0x07, 0xC0, 0x03, 0xFF, 0xC0,
  0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xC0, 0x00, 0x7E, 0x00,
};

const GFXglyph IBMPlexMono_MediumItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 16, 47, 40, 12, -46 },
  { 95, 23, 20, 40, 12, -49 },
  { 153, 41, 46, 40, 0, -46 },
  { 389, 38, 62, 40, 1, -54 },
  { 684, 46, 48, 40, -2, -47 },
  { 960, 39, 48, 40, 0, -47 },
  { 1194, 9, 20, 40, 19, -49 },
  { 1217, 26, 59, 40, 13, -50 },
  { 1409, 26, 59, 40, 2, -50 },
  { 1601, 35, 33, 40, 3, -36 },
  { 1746, 32, 32, 40, 4, -36 },
  { 1874, 17, 20, 40, 8, -10 },
  { 1917, 21, 6, 40, 10, -24 },
  { 1933, 12, 11, 40, 12, -10 },
  { 1950, 38, 59, 40, 1, -50 },
  { 2231, 35, 48, 40, 3, -47 },
  { 2441, 32, 46, 40, 3, -46 },
  { 2625, 36, 47, 40, 1, -47 },
  { 2837, 36, 48, 40, 1, -47 },
  { 3053, 36, 46, 40, 1, -46 },
  { 3260, 36, 47, 40, 2, -46 },
  { 3472, 33, 47, 40, 3, -46 },
  { 3666, 34, 46, 40, 6, -46 },
  { 3862, 36, 48, 40, 2, -47 },
  { 4078, 33, 47, 40, 5, -47 },
  { 4272, 16, 36, 40, 12, -35 },
  { 4344, 20, 45, 40, 8, -35 },
  { 4457, 32, 38, 40, 6, -39 },
  { 4609, 35, 20, 40, 3, -30 },
  { 4697, 32, 38, 40, 3, -39 },
  { 4849, 29, 48, 40, 8, -47 },
  { 5023, 35, 54, 40, 3, -47 },
  { 5260, 37, 46, 40, -1, -46 },
  { 5473, 34, 46, 40, 3, -46 },
  { 5669, 35, 48, 40, 4, -47 },
  { 5879, 35, 46, 40, 3, -46 },
  { 6081, 36, 46, 40, 3, -46 },
  { 6288, 37, 46, 40, 3, -46 },
  { 6501, 34, 48, 40, 4, -47 },
  { 6705, 38, 46, 40, 2, -46 },
  { 6924, 36, 46, 40, 3, -46 },
  { 7131, 34, 47, 40, 3, -46 },
  { 7331, 41, 46, 40, 2, -46 },
  { 7567, 30, 46, 40, 4, -46 },
  { 7740, 40, 46, 40, 1, -46 },
  { 7970, 38, 46, 40, 2, -46 },
  { 8189, 35, 48, 40, 3, -47 },
  { 8399, 36, 46, 40, 3, -46 },
  { 8606, 35, 60, 40, 3, -47 },
  { 8869, 36, 46, 40, 3, -46 },
  { 9076, 38, 48, 40, 1, -47 },
  { 9304, 38, 46, 40, 5, -46 },
  { 9523, 36, 47, 40, 4, -46 },
  { 9735, 36, 46, 40, 7, -46 },
  { 9942, 41, 46, 40, 2, -46 },
  { 10178, 45, 46, 40, -2, -46 },
  { 10437, 38, 46, 40, 6, -46 },
  { 10656, 40, 46, 40, 0, -46 },
  { 10886, 30, 59, 40, 9, -50 },
  { 11108, 18, 59, 40, 11, -50 },
  { 11241, 30, 59, 40, 1, -50 },
  { 11463, 35, 28, 40, 3, -46 },
  { 11586, 32, 6, 40, 0, 6 },
  { 11610, 10, 14, 40, 14, -52 },
  { 11628, 33, 36, 40, 3, -35 },
  { 11777, 33, 50, 40, 3, -49 },
  { 11984, 31, 36, 40, 4, -35 },
  { 12124, 36, 50, 40, 3, -49 },
  { 12349, 32, 36, 40, 4, -35 },
  { 12493, 44, 63, 40, -1, -49 },
  { 12840, 36, 49, 40, 1, -35 },
  { 13061, 32, 49, 40, 3, -49 },
  { 13257, 31, 50, 40, 5, -49 },
  { 13451, 33, 63, 40, 2, -49 },
  { 13711, 35, 50, 40, 3, -49 },
  { 13930, 28, 50, 40, 7, -49 },
  { 14105, 38, 35, 40, 0, -35 },
  { 14272, 32, 35, 40, 3, -35 },
  { 14412, 32, 36, 40, 4, -35 },
  { 14556, 36, 48, 40, 0, -35 },
  { 14772, 34, 48, 40, 3, -35 },
  { 14976, 32, 34, 40, 7, -34 },
  { 15112, 32, 36, 40, 3, -35 },
  { 15256, 31, 47, 40, 5, -46 },
  { 15439, 32, 35, 40, 5, -34 },
  { 15579, 32, 36, 40, 4, -35 },
  { 15723, 36, 35, 40, 2, -34 },
  { 15881, 39, 36, 40, 0, -35 },
  { 16057, 36, 48, 40, 1, -34 },
  { 16273, 36, 36, 40, 2, -35 },
  { 16435, 32, 59, 40, 7, -50 },
  { 16671, 16, 59, 40, 12, -50 },
  { 16789, 32, 59, 40, 2, -50 },
  { 17025, 36, 16, 40, 2, -28 },
};

const GFXfont IBMPlexMono_MediumItalic66pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic66pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic66pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _IBMPLEXMONO_MEDIUMITALIC66PT7B_H_
