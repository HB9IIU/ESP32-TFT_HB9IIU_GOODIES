#ifndef _IBMPLEXMONO_MEDIUMITALIC42PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0,
  0x78, 0x00, 0x3C, 0x3C, 0xF0, 0xF7, 0xC3, 0xDE, 0x1F, 0x78, 0x79, 0xE1,
  0xE7, 0x87, 0x9E, 0x1E, 0xF8, 0x7B, 0xC3, 0xEF, 0x0F, 0x3C, 0x3C, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78,
  0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0,
  0xE0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF1, 0xFF, 0x87, 0xFC, 0x7F,
  0xC3, 0xFF, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x1E, 0x00,
  0x07, 0x87, 0x80, 0x01, 0xE1, 0xC0, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F,
  0xE1, 0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xFE, 0x01, 0xE1, 0xE0, 0x00, 0x70,
  0x78, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x87, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xC7,
  0x7F, 0x0F, 0x8E, 0x1E, 0x1F, 0x0E, 0x0C, 0x1F, 0x0E, 0x00, 0x1F, 0x0E,
  0x00, 0x1F, 0x0E, 0x00, 0x1F, 0x8E, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x38, 0xFC, 0x00, 0x38, 0x7C, 0x00, 0x38, 0x7C, 0x00, 0x38,
  0x7C, 0x20, 0x38, 0x7C, 0x70, 0x70, 0x7C, 0xF8, 0x70, 0xF8, 0xFE, 0x73,
  0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x78, 0x0F, 0xF0, 0x07, 0x80, 0xFF, 0xC0, 0x78,
  0x0F, 0x1E, 0x03, 0x80, 0xF0, 0x70, 0x3C, 0x07, 0x83, 0x83, 0xC0, 0x38,
  0x1E, 0x3C, 0x03, 0xC0, 0xE1, 0xC0, 0x1E, 0x07, 0x1E, 0x00, 0xF0, 0x79,
  0xE0, 0x03, 0x83, 0xCE, 0x00, 0x1E, 0x3C, 0xF0, 0x00, 0xFF, 0xC8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xBE, 0x3C, 0x00, 0x79, 0xE0, 0xE0, 0x03, 0x8E,
  0x07, 0x00, 0x3C, 0xF0, 0x38, 0x03, 0xC7, 0x83, 0xC0, 0x3C, 0x3C, 0x1E,
  0x01, 0xC1, 0xC0, 0xF0, 0x1E, 0x0F, 0x07, 0x01, 0xE0, 0x78, 0x78, 0x0E,
  0x01, 0xFF, 0x80, 0xF0, 0x07, 0xF8, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0x0F, 0xC0, 0x0F, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78,
  0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x1F,
  0x00, 0x0F, 0x1F, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7E, 0xFC,
  0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x07, 0x80, 0x1F, 0x03,
  0xE0, 0x0F, 0x80, 0xF0, 0x47, 0xC0, 0x7C, 0x3B, 0xE0, 0x3E, 0x1F, 0xF0,
  0x3F, 0x9E, 0x7C, 0x3B, 0xDF, 0x3F, 0xF9, 0xFF, 0x1F, 0xFC, 0x7F, 0x07,
  0xFC, 0x3F, 0x80, 0xF8, 0x0F, 0x00, 0x3C, 0xF7, 0xDE, 0x79, 0xE7, 0x9E,
  0xFB, 0xCF, 0x3C, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x07, 0x03, 0xC1, 0x9F, 0x9E, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xE0, 0x03, 0xE7, 0xC0, 0x1F, 0x0F, 0x00, 0xF8, 0x3E, 0x07, 0xC0,
  0x78, 0x0F, 0x01, 0xD0, 0x08, 0x02, 0x00, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xE1, 0xF8,
  0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x01, 0xE0,
  0x78, 0x00, 0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0x7D, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC0, 0xF8,
  0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x0F, 0x3E, 0x00, 0x3C, 0xF0,
  0x00, 0xF7, 0xC0, 0x03, 0xDF, 0x00, 0x0F, 0x7C, 0x38, 0x7D, 0xF1, 0xF1,
  0xFF, 0x87, 0xC7, 0xFE, 0x3F, 0x1F, 0xF8, 0x78, 0x7F, 0xE0, 0x01, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xF3, 0xE0, 0x07, 0xCF, 0x80,
  0x1F, 0x1F, 0x00, 0xF8, 0x7E, 0x0F, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xEF, 0x80, 0xFC, 0xF8, 0x1F, 0x8F, 0x03,
  0xF0, 0xF0, 0x3E, 0x0F, 0x01, 0xC1, 0xF0, 0x10, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7E, 0x0F, 0xC1, 0xF0, 0x0F,
  0x87, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x02, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFE, 0x0F, 0xC0, 0xF0, 0x0F,
  0xC0, 0xC0, 0x0F, 0x81, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x82, 0x00, 0x1F, 0x1C, 0x00,
  0x7C, 0x7C, 0x01, 0xF8, 0xFE, 0x07, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78,
  0x78, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x03, 0xC0,
  0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xF0, 0x3C, 0x01,
  0xF0, 0x3C, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x80, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x7E, 0x00, 0x7B, 0xFF, 0x00, 0xEF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x82, 0x00,
  0x1F, 0x0E, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0xFE, 0x07, 0xF0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC7, 0xE0, 0x7C, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFE,
  0x0F, 0xCF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7B, 0xE0, 0x07, 0xCF, 0x80,
  0x7C, 0x7E, 0x0F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFE, 0x78, 0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x00, 0x1E, 0x3C, 0x00,
  0xF8, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7E,
  0x07, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x3E, 0x1E, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x3F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0x81, 0xF8,
  0x7C, 0x01, 0xF1, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0x80, 0x07, 0xDF,
  0x00, 0x0F, 0xBE, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7E, 0x03, 0xF8, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3, 0xF8, 0x3F,
  0x1F, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x78, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFD,
  0xF8, 0x1F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFD, 0xE0, 0xFF, 0xDF, 0x01, 0xF8,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0x87, 0xE3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE1,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x07, 0x80, 0x01, 0xF0, 0x1F,
  0x81, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFC, 0x01,
  0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xE0, 0xFC, 0xF8, 0x0F, 0xBE,
  0x00, 0xF1, 0x80, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x07, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC0, 0xF8, 0x3E, 0x00, 0xF1, 0xF0,
  0x03, 0xC7, 0x80, 0x0F, 0x3C, 0x0F, 0x3C, 0xF0, 0xFE, 0xF3, 0xC7, 0xFF,
  0xDE, 0x1F, 0xFF, 0x78, 0xF8, 0x7D, 0xE3, 0xC0, 0xE7, 0x9F, 0x03, 0x9E,
  0x78, 0x1E, 0x71, 0xE0, 0x7B, 0xC7, 0x81, 0xEF, 0x1E, 0x07, 0x3C, 0x78,
  0x3C, 0xF1, 0xE1, 0xF3, 0xC7, 0xFF, 0xCF, 0x1F, 0xEF, 0x3C, 0x3F, 0xBC,
  0xF0, 0x7C, 0xE3, 0xC0, 0x80, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78,
  0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x7C, 0x01, 0xE0,
  0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xC0, 0x3C, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0x00, 0x3E, 0x1F, 0x00,
  0x3E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0x1E, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0x00, 0xF8, 0x3C, 0x01, 0xF0,
  0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x78, 0x7C, 0x03, 0xE1, 0xE0,
  0x0F, 0x87, 0x80, 0x7C, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x3C, 0x03, 0xF0, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x1F,
  0x00, 0x3E, 0x7C, 0x00, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1F, 0x1E, 0x00,
  0xFC, 0xF8, 0x07, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xFF, 0xFC, 0x0F, 0xC1, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x07, 0xCF, 0x80,
  0x1F, 0x3E, 0x00, 0x41, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01,
  0xC3, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x3F, 0x01, 0xF8, 0x7E, 0x0F, 0xC1,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0x81,
  0xF8, 0x3C, 0x03, 0xE0, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0x7C, 0x00, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x1E, 0x00, 0x7C, 0xF8,
  0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3C, 0x00, 0x7C, 0xF0, 0x03,
  0xE3, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xC7,
  0x80, 0x3F, 0x1E, 0x01, 0xF8, 0x78, 0x0F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE0, 0xF8,
  0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x3E, 0x00, 0x20, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC1, 0xFF, 0x9F, 0x07, 0xFE, 0xF8, 0x1F, 0xFB, 0xE0, 0x7F, 0xEF,
  0x80, 0x0F, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0xF1, 0xE0, 0x07, 0xC7, 0xC0,
  0x1F, 0x1F, 0x00, 0xFC, 0x7E, 0x0F, 0xE0, 0xFF, 0xF7, 0x83, 0xFF, 0x9E,
  0x07, 0xFE, 0x78, 0x07, 0xE3, 0xE0, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F,
  0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1E,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x3E,
  0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0x78,
  0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF8,
  0x7C, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0x78, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x1F, 0x0F, 0x80, 0x7C,
  0x3E, 0x03, 0xE0, 0x7C, 0x1F, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x1F, 0x83,
  0xE0, 0x1F, 0x81, 0xE0, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x0F, 0xC0,
  0x07, 0x8F, 0xC0, 0x07, 0xCF, 0xC0, 0x03, 0xEF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xBE, 0x00, 0x3F, 0x8F,
  0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC1, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x80,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F,
  0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x07,
  0xF8, 0x7B, 0x83, 0xFC, 0x3D, 0xE3, 0xDE, 0x1E, 0xF3, 0xCF, 0x0F, 0x79,
  0xEF, 0x07, 0x9D, 0xE7, 0x83, 0xCF, 0xF3, 0xC3, 0xC7, 0xF1, 0xE1, 0xE3,
  0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x3E,
  0x1C, 0x1E, 0x1E, 0x06, 0x0F, 0x0F, 0x02, 0x07, 0x87, 0x82, 0x07, 0x83,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0xE0, 0x0F, 0x07, 0xF0, 0x0F, 0x07, 0xF0, 0x0F, 0x07, 0xF0,
  0x1F, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x1E, 0x0F, 0x78, 0x1E, 0x0F, 0x78,
  0x1E, 0x0F, 0x78, 0x1E, 0x0F, 0x78, 0x3E, 0x1F, 0x78, 0x3C, 0x1E, 0x3C,
  0x3C, 0x1E, 0x3C, 0x3C, 0x1E, 0x3C, 0x3C, 0x1E, 0x3C, 0x3C, 0x1E, 0x3C,
  0x7C, 0x3E, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1E,
  0x78, 0x3C, 0x0E, 0x78, 0x3C, 0x0F, 0xF8, 0x7C, 0x0F, 0xF0, 0x78, 0x0F,
  0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x07, 0xF0, 0x78, 0x07, 0xF0, 0x78, 0x07,
  0xF0, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0x01, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xCF,
  0x80, 0x0F, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0xF7, 0xC0, 0x03, 0xDF, 0x00,
  0x0F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8,
  0x00, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x1F, 0x00, 0xF8, 0x7E, 0x0F,
  0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0xF8, 0x07, 0xC1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0xF0, 0x03, 0xE1, 0xE0,
  0x07, 0xC7, 0xC0, 0x3F, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0xC1, 0xF8, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x0F, 0x3E, 0x00,
  0x3C, 0xF8, 0x00, 0xF7, 0xC0, 0x03, 0xDF, 0x00, 0x0F, 0x7C, 0x00, 0x7D,
  0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x07,
  0xCF, 0x80, 0x3F, 0x1F, 0x00, 0xF8, 0x7E, 0x0F, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x80, 0x0F,
  0x83, 0x00, 0x1F, 0x1E, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xF8, 0x07, 0xC1, 0xE0, 0x07, 0xC3,
  0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C,
  0x00, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x07, 0xC7, 0xC0, 0x3F, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xF0, 0xF8,
  0x03, 0xE0, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xE0, 0x1F, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0x78, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x07,
  0xC0, 0x1F, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0x80, 0x1E,
  0x0F, 0x00, 0x0C, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x20, 0x00, 0x78,
  0x70, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xFE, 0x03, 0xF0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x3C, 0x78, 0x01, 0xF1, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E,
  0x00, 0x7C, 0xF8, 0x01, 0xE3, 0xE0, 0x07, 0x8F, 0x00, 0x3E, 0x3C, 0x00,
  0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3C, 0x78, 0x00, 0xF1,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xE3, 0xE0,
  0x07, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xE3, 0xC0, 0x0F,
  0x0F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0xFC, 0x1F, 0x83, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7B, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xE7, 0x80, 0x0F, 0x8F, 0x00,
  0x1F, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xF8, 0x07,
  0xC1, 0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x81, 0xF0,
  0x0F, 0x03, 0xE0, 0x1E, 0x07, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3C, 0x00,
  0xF8, 0xF8, 0x01, 0xF1, 0xE0, 0x01, 0xE7, 0xC0, 0x03, 0xCF, 0x00, 0x07,
  0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0x87, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x7C, 0x3C, 0x3C, 0x1F,
  0x0F, 0x0F, 0x0F, 0xC3, 0xC3, 0xC3, 0xF0, 0xF0, 0xF1, 0xFC, 0x38, 0x3C,
  0x77, 0x1E, 0x0F, 0x1D, 0xC7, 0x83, 0xCF, 0x71, 0xE0, 0xE3, 0x9C, 0x70,
  0x78, 0xE7, 0x3C, 0x1E, 0x79, 0xCF, 0x07, 0x9C, 0x73, 0xC1, 0xE7, 0x1C,
  0xE0, 0x7B, 0xC7, 0x78, 0x1E, 0xE1, 0xDE, 0x07, 0xB8, 0x77, 0x81, 0xFE,
  0x1D, 0xE0, 0x7F, 0x07, 0x70, 0x1F, 0xC1, 0xFC, 0x07, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x3E,
  0x00, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x1F,
  0x80, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x7C, 0x7C, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x0F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0x7C, 0x01, 0xF8, 0x3C, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0x1E, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x0F, 0x1F,
  0x00, 0x0F, 0xBE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x03,
  0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x38, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07,
  0xCF, 0x00, 0x1E, 0x3E, 0x00, 0xF8, 0x78, 0x07, 0xC1, 0xE0, 0x1E, 0x07,
  0xC0, 0xF8, 0x0F, 0x07, 0xC0, 0x3C, 0x1E, 0x00, 0xF8, 0xF0, 0x01, 0xE7,
  0xC0, 0x07, 0xBE, 0x00, 0x0F, 0x70, 0x00, 0x38, 0x40, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x13, 0xCF, 0x9E,
  0x78, 0xF3, 0xC7, 0x18, 0x01, 0xF8, 0x78, 0x3F, 0xE7, 0xC3, 0xFF, 0xBE,
  0x3F, 0xFD, 0xF3, 0xF8, 0x3F, 0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80,
  0x3E, 0x78, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x79, 0xF0, 0x03, 0xCF,
  0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xF8, 0x0F,
  0xC7, 0xE1, 0xDE, 0x1F, 0xFC, 0xFE, 0xFF, 0xE7, 0xF3, 0xFE, 0x3F, 0x07,
  0xC0, 0xF8, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x7C, 0x07, 0xCF, 0xF8, 0x3E, 0xFF, 0xE1, 0xEF, 0xFF,
  0x0F, 0x60, 0xFC, 0xFE, 0x03, 0xE7, 0xE0, 0x1F, 0x3E, 0x00, 0x79, 0xF0,
  0x03, 0xCF, 0x00, 0x1E, 0x78, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D,
  0xF0, 0x03, 0xCF, 0x00, 0x3E, 0x78, 0x01, 0xF3, 0xE0, 0x1F, 0x3F, 0x83,
  0xF9, 0xFF, 0xFF, 0x8F, 0xBF, 0xF8, 0x78, 0xFF, 0x83, 0xC3, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xF0, 0x7E,
  0x7C, 0x03, 0xDF, 0x00, 0x63, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0x3C, 0x00, 0x77,
  0xC0, 0x1F, 0xF8, 0x07, 0xCF, 0xC3, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01,
  0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0xF8, 0x1F, 0xF9,
  0xE0, 0x7F, 0xF3, 0xC1, 0xFF, 0xFF, 0x87, 0xF0, 0x7F, 0x0F, 0x80, 0x7E,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0xC7,
  0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x78, 0x7C,
  0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x1F, 0xC3, 0xF0, 0x6F, 0x83, 0xFF,
  0xDF, 0x07, 0xFF, 0x3C, 0x07, 0xFC, 0x78, 0x03, 0xE1, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0x83, 0xF3,
  0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x83, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x01,
  0x0F, 0x80, 0x1C, 0xF8, 0x03, 0xE7, 0xC0, 0xFC, 0x7F, 0xFF, 0x83, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x03,
  0x03, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x7C, 0x3C,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x3E, 0x07, 0xFC, 0x78, 0x1F, 0xFC, 0xF0, 0x7F, 0xFD, 0xE1, 0xFC,
  0x1F, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x1E, 0x1F, 0x00, 0x3C, 0x3E, 0x00,
  0x78, 0x78, 0x00, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7C, 0x07, 0xF0,
  0x7C, 0x1F, 0xE0, 0xFF, 0xF7, 0x80, 0xFF, 0xCF, 0x01, 0xFF, 0x1E, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x30, 0x07, 0xC0, 0xF0,
  0x3F, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0xF8, 0x1F, 0x3F, 0xE1, 0xF7, 0xFE, 0x1F, 0x7F, 0xF1, 0xEE,
  0x1F, 0x1E, 0x81, 0xF3, 0xF0, 0x0F, 0x3F, 0x00, 0xF3, 0xE0, 0x0F, 0x3E,
  0x00, 0xF3, 0xC0, 0x1F, 0x3C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xE7,
  0xC0, 0x1E, 0x7C, 0x01, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x03, 0xCF, 0x80, 0x3C, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0xC0, 0x3C, 0x1E, 0x07, 0xC3, 0xF0, 0x7C,
  0x7C, 0x07, 0x8F, 0x80, 0x79, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x02, 0x03, 0xE0, 0x70, 0x3E, 0x0F, 0x03, 0xC0,
  0xF8, 0x3C, 0x07, 0xC7, 0xC0, 0x7E, 0x7C, 0x03, 0xF7, 0xC0, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x3E, 0x01,
  0xF3, 0xFE, 0x07, 0xDF, 0xFC, 0x1F, 0x7F, 0xF0, 0x7B, 0x87, 0xC1, 0xE8,
  0x0F, 0x0F, 0xC0, 0x3C, 0x3F, 0x00, 0xF0, 0xF8, 0x07, 0x83, 0xE0, 0x3E,
  0x0F, 0x01, 0xE0, 0x3C, 0x3F, 0x01, 0xF7, 0xE0, 0x07, 0xCF, 0x80, 0x1F,
  0x3E, 0x04, 0x7C, 0x7C, 0x39, 0xE1, 0xF1, 0xF7, 0x83, 0xCF, 0xBE, 0x0F,
  0xFC, 0xF8, 0x1F, 0xE3, 0xE0, 0x7F, 0x0F, 0x00, 0xF0, 0x00, 0x7F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x01, 0x03, 0xC0, 0xE0,
  0xF0, 0x78, 0x7C, 0x3F, 0x1F, 0x1F, 0x87, 0x8F, 0xC1, 0xE7, 0xE0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x3C, 0x1E, 0x1E,
  0x7E, 0x7F, 0x1E, 0xFE, 0x7F, 0x1E, 0xFE, 0xFF, 0x1F, 0x9E, 0x8F, 0x1F,
  0x1F, 0x0F, 0x1E, 0x1F, 0x0F, 0x3E, 0x1E, 0x0F, 0x3C, 0x1E, 0x0F, 0x3C,
  0x1E, 0x0F, 0x3C, 0x1E, 0x0E, 0x3C, 0x1E, 0x0E, 0x3C, 0x1C, 0x1E, 0x78,
  0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1C, 0x78,
  0x38, 0x3C, 0x78, 0x78, 0x3C, 0xF0, 0x78, 0x3C, 0xF0, 0x78, 0x3C, 0xF0,
  0x78, 0x3C, 0x1F, 0x0F, 0x81, 0xF3, 0xFE, 0x1F, 0x7F, 0xE1, 0xE7, 0xFF,
  0x1E, 0xE1, 0xF1, 0xE8, 0x1F, 0x3F, 0x00, 0xF3, 0xF0, 0x0F, 0x3E, 0x00,
  0xF3, 0xE0, 0x0F, 0x3C, 0x01, 0xF3, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0,
  0x1E, 0x7C, 0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xF8, 0x3F, 0x1F, 0x00,
  0x78, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFB, 0xE0, 0x07,
  0xCF, 0x00, 0x3E, 0x7C, 0x03, 0xE3, 0xF0, 0x7E, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0xC3, 0xE0, 0x0F, 0x9F,
  0xF0, 0x1E, 0x7F, 0xF0, 0x3D, 0xFF, 0xE0, 0x7B, 0x07, 0xE1, 0xFC, 0x07,
  0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0x87,
  0x80, 0x1F, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0xF8, 0x7F, 0x07, 0xF0, 0xFF,
  0xFF, 0xC1, 0xF7, 0xFF, 0x03, 0xC7, 0xFC, 0x07, 0x87, 0xE0, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x7C, 0x1F, 0xF9, 0xE0, 0xFF, 0xE7, 0x87, 0xFF, 0xFE, 0x3F, 0x83, 0xF8,
  0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xE0,
  0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xE3, 0xE0, 0x07,
  0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0xF8, 0x0F, 0xE3, 0xF0, 0x6F, 0x87,
  0xFF, 0xBC, 0x1F, 0xFC, 0xF0, 0x3F, 0xE3, 0xC0, 0x3E, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x7F, 0xE1, 0xFB,
  0xFF, 0x3F, 0xDF, 0xFB, 0xFD, 0xFF, 0x9F, 0xE0, 0x3D, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xF8, 0x1E, 0x0F, 0x00, 0x20, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x30, 0x03, 0xE3, 0xE0, 0x3F, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x08, 0x0F, 0x81, 0xC0, 0xF8, 0x3E,
  0x0F, 0x07, 0xE0, 0xF1, 0xFC, 0x0F, 0x3F, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF3, 0xE0, 0x0F, 0x3C,
  0x01, 0xF3, 0xC0, 0x1F, 0x3C, 0x01, 0xF7, 0xC0, 0x1E, 0x7C, 0x01, 0xE7,
  0xC0, 0x1E, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xEF, 0x80, 0x3C,
  0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0xFC, 0xF8, 0x1F,
  0xCF, 0xC3, 0x78, 0xFF, 0xF7, 0x87, 0xFE, 0x78, 0x3F, 0xCF, 0x81, 0xF0,
  0xF8, 0x7F, 0x80, 0x33, 0xFC, 0x0F, 0xBF, 0xE0, 0x3D, 0xFF, 0x01, 0xF0,
  0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x00,
  0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x3C, 0x3E, 0x03, 0xE1, 0xE0, 0x1F, 0x0F,
  0x01, 0xF0, 0x78, 0x1F, 0x83, 0xC1, 0xF8, 0x1E, 0x1F, 0x81, 0xF3, 0xFC,
  0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x1E,
  0x1E, 0x0C, 0x3C, 0x3C, 0x78, 0x70, 0x78, 0x79, 0xE0, 0xF0, 0xF3, 0xC1,
  0xE1, 0xE7, 0x83, 0x83, 0xCF, 0x0F, 0x07, 0x9C, 0x1E, 0x0F, 0x38, 0x3C,
  0x1E, 0xF0, 0x78, 0x3D, 0xE0, 0xF0, 0x7B, 0xC1, 0xC0, 0xF7, 0x87, 0x81,
  0xCE, 0x0F, 0x07, 0x9C, 0x1E, 0x0F, 0x78, 0x3C, 0x1C, 0xF0, 0xF8, 0x79,
  0xF3, 0x70, 0xE3, 0xFE, 0xE3, 0xC3, 0xF9, 0xFF, 0x07, 0xF3, 0xFC, 0x07,
  0x83, 0xE0, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0xFC, 0x3F, 0x81, 0xFF, 0x3F,
  0xC1, 0xFF, 0x9F, 0xF1, 0xFB, 0xDC, 0x79, 0xF1, 0xEC, 0x3C, 0xF0, 0x74,
  0x1E, 0x20, 0x3E, 0x0F, 0x00, 0x3F, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x03, 0x81, 0xF0, 0x03, 0xC1,
  0xF8, 0x11, 0xE0, 0xFC, 0x3C, 0xF0, 0xFE, 0x3F, 0x7C, 0xEF, 0x7E, 0x3F,
  0xF7, 0xFE, 0x0F, 0xF1, 0xFE, 0x07, 0xF0, 0xFE, 0x01, 0xF0, 0x3C, 0x00,
  0x0F, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x0F,
  0x00, 0x7C, 0x7C, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x1E, 0x00,
  0xF8, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x3E, 0x00, 0xF0,
  0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x3E, 0x07, 0xF0, 0xFC,
  0x37, 0x83, 0xFF, 0xDE, 0x07, 0xFE, 0x78, 0x0F, 0xF3, 0xE0, 0x1F, 0x8F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x20, 0x0F, 0xC1, 0xE0, 0x7E, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF0, 0x3C, 0x3F, 0xF9, 0xF1, 0xFF, 0xF7, 0xC7, 0xFF, 0xFE, 0x3E, 0x1F,
  0xF8, 0xF0, 0x0F, 0xC3, 0x80, 0x3E, 0x0E, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x20, 0x1F,
  0x03, 0x81, 0xF8, 0x0F, 0x0F, 0xC0, 0x3C, 0x7F, 0x80, 0x73, 0xFF, 0xF1,
  0xCF, 0xFF, 0xFF, 0x3C, 0xFF, 0xFC, 0xF0, 0xFF, 0xE3, 0xC0, 0x7F, 0x00,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x40, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xC0, 0x0C, 0x1F,
  0xE0, 0x3C, 0x7F, 0xE0, 0x78, 0xFF, 0xC0, 0xE3, 0xE7, 0xC3, 0xC7, 0x87,
  0xCF, 0x9E, 0x0F, 0xFE, 0x3C, 0x0F, 0xF8, 0x70, 0x0F, 0xE1, 0x60, 0x0F,
  0x80,
};

const GFXglyph IBMPlexMono_MediumItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 10, 29, 25, 8, -29 },
  { 38, 14, 12, 25, 8, -31 },
  { 59, 26, 29, 25, 0, -29 },
  { 154, 24, 37, 25, 1, -33 },
  { 265, 29, 29, 25, -1, -29 },
  { 371, 25, 29, 25, 0, -29 },
  { 462, 6, 12, 25, 12, -31 },
  { 471, 17, 38, 25, 8, -32 },
  { 552, 17, 38, 25, 1, -32 },
  { 633, 22, 21, 25, 2, -23 },
  { 691, 20, 20, 25, 3, -23 },
  { 741, 11, 12, 25, 5, -6 },
  { 758, 14, 4, 25, 6, -15 },
  { 765, 7, 7, 25, 8, -7 },
  { 772, 24, 38, 25, 1, -32 },
  { 886, 22, 29, 25, 2, -29 },
  { 966, 20, 29, 25, 2, -29 },
  { 1039, 23, 29, 25, 1, -29 },
  { 1123, 23, 29, 25, 1, -29 },
  { 1207, 24, 29, 25, 0, -29 },
  { 1294, 23, 29, 25, 1, -29 },
  { 1378, 21, 29, 25, 2, -29 },
  { 1455, 22, 29, 25, 4, -29 },
  { 1535, 23, 29, 25, 1, -29 },
  { 1619, 21, 29, 25, 3, -29 },
  { 1696, 10, 23, 25, 8, -23 },
  { 1725, 13, 29, 25, 5, -23 },
  { 1773, 20, 24, 25, 4, -25 },
  { 1833, 22, 13, 25, 2, -19 },
  { 1869, 20, 24, 25, 2, -25 },
  { 1929, 19, 29, 25, 5, -29 },
  { 1998, 22, 34, 25, 2, -29 },
  { 2092, 24, 29, 25, -1, -29 },
  { 2179, 22, 29, 25, 2, -29 },
  { 2259, 22, 29, 25, 3, -29 },
  { 2339, 22, 29, 25, 2, -29 },
  { 2419, 23, 29, 25, 2, -29 },
  { 2503, 24, 29, 25, 2, -29 },
  { 2590, 22, 29, 25, 2, -29 },
  { 2670, 24, 29, 25, 1, -29 },
  { 2757, 23, 29, 25, 2, -29 },
  { 2841, 22, 29, 25, 2, -29 },
  { 2921, 25, 29, 25, 2, -29 },
  { 3012, 18, 29, 25, 3, -29 },
  { 3078, 25, 29, 25, 1, -29 },
  { 3169, 24, 29, 25, 1, -29 },
  { 3256, 22, 29, 25, 2, -29 },
  { 3336, 23, 29, 25, 2, -29 },
  { 3420, 22, 37, 25, 2, -29 },
  { 3522, 23, 29, 25, 2, -29 },
  { 3606, 24, 29, 25, 1, -29 },
  { 3693, 24, 29, 25, 3, -29 },
  { 3780, 22, 29, 25, 3, -29 },
  { 3860, 23, 29, 25, 4, -29 },
  { 3944, 26, 29, 25, 1, -29 },
  { 4039, 28, 29, 25, -1, -29 },
  { 4141, 24, 29, 25, 4, -29 },
  { 4228, 26, 29, 25, 0, -29 },
  { 4323, 19, 38, 25, 6, -32 },
  { 4414, 12, 38, 25, 7, -32 },
  { 4471, 18, 38, 25, 1, -32 },
  { 4557, 22, 18, 25, 2, -29 },
  { 4607, 20, 4, 25, 0, 4 },
  { 4617, 6, 9, 25, 9, -33 },
  { 4624, 21, 22, 25, 2, -22 },
  { 4682, 21, 31, 25, 2, -31 },
  { 4764, 19, 22, 25, 3, -22 },
  { 4817, 23, 31, 25, 2, -31 },
  { 4907, 20, 22, 25, 3, -22 },
  { 4962, 28, 39, 25, -1, -31 },
  { 5099, 23, 30, 25, 1, -22 },
  { 5186, 20, 31, 25, 2, -31 },
  { 5264, 20, 32, 25, 3, -32 },
  { 5344, 20, 40, 25, 2, -32 },
  { 5444, 22, 31, 25, 2, -31 },
  { 5530, 18, 31, 25, 4, -31 },
  { 5600, 24, 22, 25, 0, -22 },
  { 5666, 20, 22, 25, 2, -22 },
  { 5721, 21, 22, 25, 2, -22 },
  { 5779, 23, 30, 25, 0, -22 },
  { 5866, 22, 30, 25, 2, -22 },
  { 5949, 21, 22, 25, 4, -22 },
  { 6007, 21, 22, 25, 2, -22 },
  { 6065, 20, 29, 25, 3, -29 },
  { 6138, 20, 22, 25, 3, -22 },
  { 6193, 21, 22, 25, 2, -22 },
  { 6251, 23, 22, 25, 1, -22 },
  { 6315, 25, 22, 25, 0, -22 },
  { 6384, 22, 30, 25, 1, -22 },
  { 6467, 22, 22, 25, 2, -22 },
  { 6528, 21, 38, 25, 4, -32 },
  { 6628, 10, 38, 25, 8, -32 },
  { 6676, 21, 38, 25, 1, -32 },
  { 6776, 23, 10, 25, 1, -18 },
};

const GFXfont IBMPlexMono_MediumItalic42pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic42pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _IBMPLEXMONO_MEDIUMITALIC42PT7B_H_
