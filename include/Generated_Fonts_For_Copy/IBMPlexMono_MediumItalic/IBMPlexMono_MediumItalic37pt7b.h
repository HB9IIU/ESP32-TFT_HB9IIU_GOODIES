#ifndef _IBMPLEXMONO_MEDIUMITALIC37PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E, 0x0F,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x00, 0x00, 0x00, 0x07,
  0x87, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x00, 0x38, 0x7B, 0xC3, 0x9E, 0x3C,
  0xF1, 0xE7, 0x8F, 0x38, 0x79, 0xC3, 0x9E, 0x1C, 0xF1, 0xE7, 0x8F, 0x3C,
  0x78, 0x00, 0x1C, 0x38, 0x00, 0x78, 0xF0, 0x00, 0xE1, 0xC0, 0x01, 0xC3,
  0x80, 0x07, 0x8F, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x78, 0xF0,
  0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF8, 0x0E, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x78, 0xF0, 0x00, 0xE1, 0xC0, 0x3F, 0xC3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x1F, 0xE0, 0x1C, 0x38, 0x00, 0x78, 0xF0, 0x00, 0xE1,
  0xC0, 0x01, 0xC3, 0x80, 0x07, 0x8F, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xF3,
  0xBF, 0x1F, 0x1C, 0x70, 0xF0, 0xC2, 0x07, 0x86, 0x00, 0x3C, 0x70, 0x01,
  0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x7E, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xE7, 0xC0, 0x07, 0x1E, 0x00,
  0x30, 0xF0, 0x03, 0x87, 0x80, 0x1C, 0x3C, 0x20, 0xE1, 0xE7, 0x87, 0x1E,
  0x3F, 0x3B, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x03, 0xC0, 0xFF, 0x01, 0xE0, 0x7F, 0xC0, 0x70, 0x3C, 0x70, 0x38, 0x0E,
  0x0E, 0x1C, 0x07, 0x83, 0x8F, 0x01, 0xC1, 0xE3, 0x80, 0x70, 0x71, 0xC0,
  0x1C, 0x1C, 0xF0, 0x07, 0x8F, 0x38, 0x00, 0xFF, 0x9C, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x80, 0x07,
  0xBF, 0xF0, 0x03, 0xCE, 0x1C, 0x00, 0xE7, 0x87, 0x00, 0x71, 0xC1, 0xC0,
  0x3C, 0x70, 0x70, 0x0E, 0x1C, 0x1C, 0x07, 0x07, 0x0F, 0x03, 0xC1, 0xC3,
  0x80, 0xE0, 0x7F, 0xE0, 0x70, 0x0F, 0xF0, 0x3C, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x78, 0xF8, 0x03, 0xC1,
  0xE0, 0x0F, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0xF0, 0x38, 0x03, 0xC1, 0xE0,
  0x0F, 0x07, 0x80, 0x1E, 0x3C, 0x00, 0x79, 0xE0, 0x0F, 0xFF, 0x00, 0xFB,
  0xF0, 0x03, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x70, 0x78, 0x03, 0xC0, 0xF0,
  0x0F, 0x03, 0xC0, 0x3C, 0x07, 0x86, 0xF0, 0x3E, 0x3F, 0xE0, 0xB8, 0xE7,
  0x86, 0xF7, 0x1F, 0xF1, 0xFC, 0x3F, 0xC7, 0xE0, 0x7C, 0x0F, 0x00, 0x3C,
  0xF3, 0x8E, 0x79, 0xE7, 0x9E, 0x71, 0xCF, 0x00, 0x00, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0xC1, 0xE0, 0xDE, 0x3C, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xC1, 0xFF, 0xC0,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1E, 0xF0, 0x07, 0x8F, 0x01,
  0xE0, 0xF0, 0x78, 0x1E, 0x06, 0x01, 0x80, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x01, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x8F,
  0x8F, 0xC7, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x38, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7B, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xC3, 0xE1, 0xE0, 0x1E,
  0x3C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3D,
  0xE3, 0xC7, 0xFC, 0x78, 0xFF, 0x9F, 0x1F, 0xE3, 0xE3, 0xFC, 0x38, 0x7F,
  0x80, 0x1F, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xCF,
  0x00, 0x78, 0xF0, 0x1E, 0x1F, 0x0F, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0x78, 0x0F,
  0xBC, 0x07, 0xCF, 0x03, 0xE3, 0xC1, 0xF0, 0xF0, 0x38, 0x3C, 0x04, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x3E, 0x1F,
  0x01, 0xE1, 0xE0, 0x1F, 0x04, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xE0, 0xF8, 0x3E, 0x1E, 0x01, 0xF0, 0x40, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0xF0,
  0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x60, 0x07, 0xCF, 0x00,
  0x78, 0xFC, 0x1F, 0x87, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x3C, 0x00, 0xF1, 0xE0, 0x0F,
  0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x78, 0x3C, 0x07, 0x81, 0xE0,
  0x78, 0x0F, 0x07, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x3C, 0x1F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x7E, 0x01,
  0xCF, 0xF8, 0x1D, 0xFF, 0xC1, 0xF0, 0x7C, 0x3C, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x30, 0x03,
  0xC7, 0x80, 0x7C, 0xFC, 0x0F, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xC7, 0xE1, 0xF7, 0xFC, 0x7B, 0xFF, 0x9F, 0x83, 0xFF, 0xC0, 0x7F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07,
  0xBE, 0x03, 0xE7, 0xC1, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x01, 0xF8, 0x00,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0x80, 0x3E, 0x78, 0x03,
  0xC7, 0x00, 0x7C, 0x70, 0x07, 0x8F, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x07, 0xFF,
  0xE0, 0xFC, 0x1F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0,
  0x0F, 0x1E, 0x00, 0xF0, 0xE0, 0x1E, 0x0F, 0x83, 0xC0, 0x7F, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0x07, 0xC3, 0xC0, 0x3E, 0x78, 0x01, 0xE7,
  0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x00, 0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x7C,
  0x7C, 0x0F, 0xC3, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x3E, 0x7C, 0x03, 0xDE, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xFC, 0x1F, 0xDF, 0xFD, 0xE3, 0xFE, 0xF8, 0x3E, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0xFC, 0xFC, 0xFC, 0xFC, 0xF8, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x7C, 0x3F, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xE0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x00, 0x80, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xFF,
  0x0F, 0xFF, 0xCF, 0x83, 0xE7, 0x80, 0xFF, 0x80, 0x7C, 0x40, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0xFF, 0x80, 0x7F, 0x80,
  0x3F, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07,
  0xC1, 0xE1, 0xE0, 0x1E, 0x38, 0x01, 0xCF, 0x00, 0x39, 0xC1, 0xE7, 0x38,
  0x7E, 0xEF, 0x1F, 0xDD, 0xC7, 0x87, 0xB8, 0xF0, 0xF7, 0x1C, 0x1F, 0xE7,
  0x83, 0xBC, 0xF0, 0x77, 0x9C, 0x0E, 0xE3, 0x81, 0xDC, 0x70, 0x7B, 0x8E,
  0x0F, 0x71, 0xE3, 0xCE, 0x3F, 0xF9, 0xC3, 0xF7, 0x38, 0x7C, 0xE7, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1C, 0xE0, 0x01, 0xE7, 0x00, 0x0F,
  0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0,
  0x3E, 0x1E, 0x01, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x1E,
  0x00, 0x78, 0xF0, 0x03, 0xCF, 0x80, 0x1F, 0x78, 0x00, 0x7F, 0xC0, 0x03,
  0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0x01, 0xE1, 0xE0,
  0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x3C, 0x03, 0xC7, 0x80,
  0x78, 0xF0, 0x1E, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xFE, 0x1E, 0x03,
  0xE3, 0xC0, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03,
  0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x07, 0xC7, 0xFF, 0xF8, 0xFF, 0xFC,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7C,
  0x3E, 0x0F, 0x01, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xE3, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x01, 0x07, 0x80, 0x3C, 0x78, 0x07, 0xC7, 0xC0, 0x78, 0x3E, 0x1F,
  0x03, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0x03, 0xE1, 0xE0, 0x3C, 0x3C, 0x03, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00,
  0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xDF, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x03,
  0xCF, 0x00, 0x79, 0xE0, 0x1F, 0x3C, 0x03, 0xCF, 0x80, 0xF9, 0xE0, 0x1E,
  0x3C, 0x0F, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0x83,
  0xFF, 0xF8, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x07, 0xC1, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x00,
  0x71, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x7F, 0xBE, 0x1F, 0xF7, 0x83, 0xFE, 0xF0, 0x03,
  0xDE, 0x00, 0x7B, 0xC0, 0x0E, 0x78, 0x03, 0xCF, 0x80, 0x78, 0xF0, 0x1F,
  0x1F, 0x07, 0xE1, 0xFF, 0xBC, 0x1F, 0xE7, 0x01, 0xF1, 0xE0, 0x0F, 0x80,
  0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x07,
  0x80, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07,
  0x87, 0x80, 0x78, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xF0,
  0x07, 0x87, 0x80, 0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x1E, 0x00, 0xF0,
  0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x1F, 0x0F, 0x00,
  0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x87, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x18, 0x07, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x3E, 0x1F, 0x03, 0xFF,
  0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0x80, 0x3E, 0x1E, 0x00, 0xF8,
  0x3C, 0x03, 0xE0, 0x78, 0x0F, 0x80, 0xF0, 0x3E, 0x01, 0xE0, 0xF8, 0x03,
  0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x1E, 0x3E, 0x00, 0x3C, 0x78, 0x00, 0x79,
  0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xEF,
  0x00, 0x1F, 0x9F, 0x00, 0x3E, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x7C,
  0x03, 0xE0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xF0,
  0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC1, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xF1, 0xF8,
  0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xDC, 0x7F,
  0x87, 0x71, 0xDE, 0x3D, 0xCF, 0x70, 0xF3, 0xB9, 0xC3, 0xCF, 0xC7, 0x0E,
  0x3F, 0x3C, 0x38, 0xF8, 0xF0, 0xE3, 0xE3, 0xC7, 0x87, 0x0E, 0x1E, 0x1C,
  0x38, 0x78, 0x61, 0xE1, 0xE1, 0x87, 0x87, 0x04, 0x1E, 0x1C, 0x00, 0x78,
  0xF0, 0x01, 0xC3, 0xC0, 0x07, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xE0,
  0x03, 0xC3, 0x80, 0x0F, 0x00, 0x0F, 0xC0, 0x78, 0x7E, 0x03, 0xC3, 0xF0,
  0x1E, 0x1F, 0x80, 0xF0, 0xFE, 0x07, 0x07, 0xF0, 0x38, 0x7B, 0x83, 0xC3,
  0xDC, 0x1E, 0x1E, 0xF0, 0xF0, 0xF7, 0x87, 0x87, 0x3C, 0x38, 0x38, 0xE1,
  0xC3, 0xC7, 0x1E, 0x1E, 0x3C, 0xF0, 0xF1, 0xE7, 0x87, 0x8F, 0x3C, 0x38,
  0x39, 0xC1, 0xC1, 0xCE, 0x1E, 0x0F, 0xF0, 0xF0, 0x7F, 0x87, 0x83, 0xFC,
  0x3C, 0x0F, 0xE1, 0xC0, 0x7F, 0x0E, 0x03, 0xF0, 0xF0, 0x1F, 0x87, 0x80,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xC3, 0xE1,
  0xF0, 0x3E, 0x7C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x78, 0x01, 0xEF,
  0x00, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78,
  0x03, 0xCF, 0x00, 0x78, 0xF0, 0x1E, 0x1F, 0x0F, 0x81, 0xFF, 0xE0, 0x1F,
  0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1,
  0xE0, 0x3E, 0x1E, 0x01, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x1F,
  0x3E, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x7C, 0x3F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xC3, 0xE1, 0xF0, 0x3E, 0x3C, 0x03, 0xCF,
  0x00, 0x79, 0xE0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xCF, 0x00, 0x78, 0xF0,
  0x1E, 0x1F, 0x0F, 0xC1, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x60, 0x0F, 0x1E, 0x00, 0xF7, 0x80, 0x1F, 0xE0, 0x01,
  0xF8, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1,
  0xE0, 0x3E, 0x1E, 0x01, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x1F,
  0x3E, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x7C, 0x3F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x83,
  0xC0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0xF8, 0x1E, 0x0F, 0x01, 0xE0, 0xF0,
  0x1F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0x03, 0xF1, 0xF0, 0x07, 0x0F, 0x00,
  0x10, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC6, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xF0, 0x3E, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0,
  0x0F, 0x1E, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C,
  0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xE7, 0x80, 0x3C, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0xCF, 0x00, 0x78,
  0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x87, 0x80, 0xF0, 0x7C, 0x1F,
  0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0xF0, 0x01, 0xFF, 0x00,
  0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x78, 0xF0,
  0x07, 0x87, 0x80, 0xF8, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x07, 0x87, 0x80,
  0x38, 0x78, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xDE, 0x00, 0x3D, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x71, 0xE0, 0x00,
  0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8E, 0x1F, 0x0E, 0x1C, 0x3E, 0x1C,
  0x38, 0x7C, 0x38, 0x71, 0xF8, 0xF0, 0xE3, 0xF1, 0xC3, 0xC7, 0xE3, 0x87,
  0x9D, 0xC7, 0x0F, 0x3B, 0x9E, 0x1E, 0x77, 0x3C, 0x3D, 0xCE, 0x70, 0x73,
  0x9C, 0xE0, 0xE7, 0x3B, 0xC1, 0xDC, 0x77, 0x83, 0xB8, 0xEE, 0x07, 0x71,
  0xDC, 0x0F, 0xC3, 0xB8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xC0, 0xFC, 0x1F,
  0x81, 0xF8, 0x3F, 0x00, 0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x0F, 0x80, 0xF0,
  0x0F, 0x80, 0x7C, 0x07, 0x80, 0x1E, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x03,
  0xC7, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xF3, 0xC0,
  0x00, 0xF1, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x3E, 0x00, 0x78, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0x9E, 0x00, 0x7C, 0xF8, 0x07,
  0xC3, 0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0x78, 0x3E, 0x03, 0xC1, 0xE0, 0x1E,
  0x1F, 0x00, 0x79, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0,
  0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x07, 0x9E, 0x01, 0xE1, 0xC0, 0x78, 0x3C,
  0x0F, 0x07, 0x83, 0xC0, 0x70, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x1F,
  0xE0, 0x03, 0xDC, 0x00, 0x39, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x23, 0xCF, 0x1C, 0x78, 0xE3, 0x85, 0x03, 0xE3, 0xC3, 0xFE,
  0xF1, 0xFF, 0xBC, 0xF8, 0x3F, 0x7C, 0x07, 0xDE, 0x01, 0xF7, 0x80, 0x7B,
  0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x3E, 0xF0,
  0x0F, 0x3C, 0x07, 0xCF, 0x03, 0xF3, 0xE1, 0xBC, 0x7F, 0xCF, 0xDF, 0xF3,
  0xF1, 0xF0, 0x7C, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x1F,
  0x03, 0xCF, 0xF8, 0x7B, 0xFF, 0x0F, 0x61, 0xF1, 0xF8, 0x1E, 0x3E, 0x03,
  0xC7, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07,
  0x9E, 0x00, 0xF3, 0xC0, 0x3E, 0xF0, 0x07, 0x9F, 0x01, 0xF3, 0xF0, 0x7C,
  0x7B, 0xFF, 0x0F, 0x7F, 0xC3, 0xE3, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7C, 0x1E, 0x3E, 0x03, 0xCF, 0x00, 0x87, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78,
  0x03, 0x1E, 0x01, 0xE7, 0x80, 0xF1, 0xF0, 0x7C, 0x3F, 0xFE, 0x07, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x03,
  0xE1, 0xE0, 0xFF, 0x9E, 0x1F, 0xFF, 0xC3, 0xE0, 0xFC, 0x3C, 0x07, 0xC7,
  0x80, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78,
  0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0xF0, 0x1F,
  0x0F, 0x86, 0xF0, 0x7F, 0xEF, 0x07, 0xFC, 0xF0, 0x1F, 0x0F, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x1F, 0x3C, 0x03, 0xCF, 0x00,
  0xF7, 0x80, 0x7D, 0xE0, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFC, 0x03,
  0xC0, 0x00, 0xF0, 0x02, 0x1E, 0x00, 0xE7, 0x80, 0x79, 0xF0, 0x7C, 0x3F,
  0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC7, 0x80,
  0x01, 0xE3, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0xF0, 0x7F, 0xCE, 0x0F, 0xFF,
  0xE1, 0xF8, 0x7E, 0x1E, 0x03, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE7, 0xC0,
  0x1C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78,
  0x07, 0xC7, 0x80, 0x78, 0x78, 0x0F, 0x87, 0xC3, 0xF8, 0x3F, 0xF7, 0x81,
  0xFE, 0x78, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x02, 0x01, 0xE0,
  0x70, 0x3E, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x3E, 0x07, 0x9F, 0xC3, 0xCF, 0xF8, 0xF6,
  0x1E, 0x3F, 0x07, 0xCF, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x78, 0x07,
  0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xEF,
  0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x80, 0xF0, 0xE0, 0xF0, 0xF8, 0x78, 0xF8, 0x3C, 0xF8,
  0x1E, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x08, 0x0F, 0x07, 0x07, 0x83, 0xE1, 0xE0,
  0x3C, 0x78, 0x0F, 0x9E, 0x01, 0xF7, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x3E, 0x03,
  0xCF, 0xF0, 0xF3, 0xFE, 0x1E, 0xC3, 0xE3, 0xF0, 0x3C, 0x7C, 0x07, 0x8F,
  0x00, 0xE1, 0xE0, 0x3C, 0x78, 0x0F, 0x0F, 0x07, 0xC1, 0xE7, 0xC0, 0x3D,
  0xF0, 0x07, 0x9E, 0x04, 0xF1, 0xE1, 0xFC, 0x3C, 0x7F, 0x87, 0xDE, 0xF0,
  0x7F, 0x9E, 0x0F, 0xE3, 0xC0, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0x83, 0xFF,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x10, 0xF0, 0x73, 0xE1, 0xE7, 0x8F,
  0x8F, 0x3E, 0x1E, 0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0x7C, 0x00, 0x1E, 0x70,
  0xF0, 0xE7, 0xCF, 0xC7, 0x7E, 0xFE, 0x3C, 0x74, 0x73, 0xE3, 0xC3, 0x9E,
  0x1E, 0x1C, 0xF0, 0xE0, 0xE7, 0x07, 0x07, 0x38, 0x38, 0x79, 0xC3, 0xC3,
  0xDE, 0x1E, 0x1C, 0xF0, 0xE0, 0xE7, 0x87, 0x07, 0x38, 0x38, 0x39, 0xC1,
  0xC3, 0xCE, 0x1E, 0x1E, 0xF0, 0xF0, 0xE7, 0x87, 0x07, 0x3C, 0x38, 0x38,
  0x1E, 0x3E, 0x07, 0x9F, 0xC3, 0xCF, 0xF8, 0xF6, 0x1E, 0x3F, 0x07, 0xCF,
  0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80,
  0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xEF, 0x00, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0x80,
  0xFF, 0xF0, 0x7C, 0x3E, 0x3C, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07,
  0xBC, 0x01, 0xE7, 0x80, 0xF1, 0xF0, 0xFC, 0x3F, 0xFE, 0x07, 0xFE, 0x00,
  0x7E, 0x00, 0x07, 0x8F, 0x80, 0xF3, 0xFE, 0x0F, 0x7F, 0xE0, 0xF6, 0x1F,
  0x0F, 0xC0, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00,
  0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x01, 0xF3, 0xC0,
  0x1E, 0x3E, 0x03, 0xE3, 0xF0, 0x7C, 0x3D, 0xFF, 0x83, 0xDF, 0xF0, 0x38,
  0x7C, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE1, 0xE1, 0xFF, 0x38,
  0x7F, 0xFF, 0x1F, 0x07, 0xE3, 0xC0, 0x7C, 0xF0, 0x07, 0x9E, 0x00, 0xF7,
  0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF,
  0x00, 0xF9, 0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0xC3, 0xF8, 0x7F, 0xEF, 0x0F,
  0xF9, 0xE0, 0x7C, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0x87, 0xFF,
  0xE7, 0xFF, 0xFB, 0xF8, 0x1F, 0x80, 0x0F, 0x40, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xFC, 0x78,
  0x1E, 0x3C, 0x01, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x01, 0xE6,
  0x00, 0xF3, 0xE0, 0x7C, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x83, 0xC0, 0xE1, 0xE1, 0xF8, 0xF1, 0xF0, 0x7B, 0xE0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xC0, 0x00, 0x3C, 0x03, 0xDE, 0x01, 0xE7,
  0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xFB, 0xC0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0xF0, 0x1F,
  0x3C, 0x0F, 0x8F, 0x03, 0xE3, 0xE3, 0x78, 0xFF, 0xDE, 0x1F, 0xE7, 0x83,
  0xE3, 0xC0, 0xFF, 0x01, 0xBF, 0xC1, 0xEF, 0xF0, 0x3C, 0x3C, 0x0F, 0x1E,
  0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80,
  0xF1, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x0F, 0x07, 0xC3, 0xC3, 0xE0,
  0xF3, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0x3C, 0x38, 0x63,
  0xC3, 0x8F, 0x38, 0x38, 0x73, 0x87, 0x87, 0x38, 0x78, 0x73, 0x87, 0x07,
  0x78, 0x70, 0x77, 0x87, 0x07, 0x70, 0x70, 0x77, 0x0F, 0x07, 0x70, 0xF0,
  0xF7, 0x0F, 0x0E, 0xF0, 0xE0, 0xEF, 0x0E, 0x0E, 0xE1, 0xE1, 0xCF, 0x3E,
  0x1C, 0xFF, 0x63, 0x87, 0xE7, 0xF0, 0x3C, 0x3C, 0x00, 0x01, 0xE0, 0xF0,
  0x1F, 0xC7, 0xE0, 0xFF, 0x3F, 0xCF, 0xDD, 0xCF, 0x7C, 0x76, 0x1C, 0xE1,
  0xD0, 0x72, 0x07, 0xC1, 0xC0, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0xF8, 0x23, 0xC2, 0xE1, 0xCF,
  0x1B, 0x8F, 0xBC, 0xEE, 0xFC, 0xFF, 0x3F, 0xC1, 0xFC, 0x7E, 0x03, 0xC1,
  0xE0, 0x00, 0x0F, 0x00, 0xF1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E,
  0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xC3, 0xC0, 0x3C, 0x3C, 0x03,
  0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0x83, 0xC0,
  0xF8, 0x3C, 0x0F, 0x83, 0xE3, 0x78, 0x3F, 0xF7, 0x81, 0xFE, 0x78, 0x0F,
  0x8F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x02, 0x01, 0xE0, 0x70, 0x3E, 0x0F,
  0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0xF0, 0xFF, 0xCF,
  0x1F, 0xFF, 0xF1, 0xE1, 0xFF, 0x1C, 0x07, 0xE3, 0xC0, 0x78, 0x38, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x1C, 0x0F, 0x81, 0xC1, 0xF0, 0x1C, 0x3F, 0x01, 0xE7, 0xFF, 0x8E, 0x77,
  0xFF, 0xC7, 0x0F, 0xFC, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF8, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x07, 0x83,
  0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC1,
  0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0,
  0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0x80, 0x71, 0xFC, 0x07, 0x3F, 0xE0, 0xF3, 0xCF,
  0x0E, 0x78, 0x79, 0xE7, 0x07, 0xFC, 0x70, 0x3F, 0x8E, 0x01, 0xF0,
};

const GFXglyph IBMPlexMono_MediumItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 9, 26, 22, 7, -26 },
  { 31, 13, 11, 22, 7, -27 },
  { 49, 23, 26, 22, 0, -26 },
  { 124, 21, 34, 22, 1, -30 },
  { 214, 26, 26, 22, -1, -26 },
  { 299, 22, 26, 22, 0, -26 },
  { 371, 6, 11, 22, 10, -27 },
  { 380, 15, 33, 22, 7, -28 },
  { 442, 15, 33, 22, 1, -28 },
  { 504, 19, 18, 22, 2, -20 },
  { 547, 18, 17, 22, 2, -20 },
  { 586, 9, 11, 22, 5, -6 },
  { 599, 11, 3, 22, 6, -13 },
  { 604, 6, 6, 22, 7, -6 },
  { 609, 21, 33, 22, 1, -28 },
  { 696, 19, 26, 22, 2, -26 },
  { 758, 18, 26, 22, 2, -26 },
  { 817, 20, 26, 22, 1, -26 },
  { 882, 20, 26, 22, 1, -26 },
  { 947, 21, 26, 22, 0, -26 },
  { 1016, 20, 26, 22, 1, -26 },
  { 1081, 18, 26, 22, 2, -26 },
  { 1140, 20, 26, 22, 3, -26 },
  { 1205, 20, 26, 22, 1, -26 },
  { 1270, 18, 26, 22, 3, -26 },
  { 1329, 8, 20, 22, 7, -20 },
  { 1349, 10, 25, 22, 5, -20 },
  { 1381, 18, 22, 22, 3, -22 },
  { 1431, 19, 11, 22, 2, -17 },
  { 1458, 18, 22, 22, 2, -22 },
  { 1508, 17, 26, 22, 4, -26 },
  { 1564, 19, 30, 22, 2, -26 },
  { 1636, 21, 26, 22, -1, -26 },
  { 1705, 19, 26, 22, 2, -26 },
  { 1767, 20, 26, 22, 2, -26 },
  { 1832, 19, 26, 22, 2, -26 },
  { 1894, 20, 26, 22, 2, -26 },
  { 1959, 20, 26, 22, 2, -26 },
  { 2024, 19, 26, 22, 2, -26 },
  { 2086, 21, 26, 22, 1, -26 },
  { 2155, 21, 26, 22, 1, -26 },
  { 2224, 19, 26, 22, 2, -26 },
  { 2286, 23, 26, 22, 1, -26 },
  { 2361, 17, 26, 22, 2, -26 },
  { 2417, 22, 26, 22, 1, -26 },
  { 2489, 21, 26, 22, 1, -26 },
  { 2558, 19, 26, 22, 2, -26 },
  { 2620, 20, 26, 22, 2, -26 },
  { 2685, 19, 33, 22, 2, -26 },
  { 2764, 20, 26, 22, 2, -26 },
  { 2829, 21, 26, 22, 1, -26 },
  { 2898, 21, 26, 22, 3, -26 },
  { 2967, 20, 26, 22, 2, -26 },
  { 3032, 20, 26, 22, 4, -26 },
  { 3097, 23, 26, 22, 1, -26 },
  { 3172, 25, 26, 22, -1, -26 },
  { 3254, 21, 26, 22, 3, -26 },
  { 3323, 23, 26, 22, 0, -26 },
  { 3398, 17, 33, 22, 5, -28 },
  { 3469, 11, 33, 22, 6, -28 },
  { 3515, 16, 33, 22, 1, -28 },
  { 3581, 19, 16, 22, 2, -26 },
  { 3619, 18, 3, 22, 0, 3 },
  { 3626, 6, 8, 22, 8, -29 },
  { 3632, 18, 19, 22, 2, -19 },
  { 3675, 19, 27, 22, 1, -27 },
  { 3740, 18, 19, 22, 2, -19 },
  { 3783, 20, 27, 22, 2, -27 },
  { 3851, 18, 19, 22, 2, -19 },
  { 3894, 25, 34, 22, -1, -27 },
  { 4001, 20, 26, 22, 1, -19 },
  { 4066, 18, 27, 22, 2, -27 },
  { 4127, 17, 27, 22, 3, -27 },
  { 4185, 18, 34, 22, 1, -27 },
  { 4262, 19, 27, 22, 2, -27 },
  { 4327, 15, 27, 22, 4, -27 },
  { 4378, 21, 19, 22, 0, -19 },
  { 4428, 18, 19, 22, 2, -19 },
  { 4471, 18, 19, 22, 2, -19 },
  { 4514, 20, 26, 22, 0, -19 },
  { 4579, 19, 26, 22, 2, -19 },
  { 4641, 18, 19, 22, 4, -19 },
  { 4684, 18, 19, 22, 2, -19 },
  { 4727, 17, 26, 22, 3, -26 },
  { 4783, 18, 19, 22, 3, -19 },
  { 4826, 18, 19, 22, 2, -19 },
  { 4869, 20, 19, 22, 1, -19 },
  { 4917, 22, 19, 22, 0, -19 },
  { 4970, 20, 26, 22, 1, -19 },
  { 5035, 20, 19, 22, 1, -19 },
  { 5083, 18, 33, 22, 4, -28 },
  { 5158, 9, 33, 22, 7, -28 },
  { 5196, 18, 33, 22, 1, -28 },
  { 5271, 20, 8, 22, 1, -15 },
};

const GFXfont IBMPlexMono_MediumItalic37pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic37pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic37pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _IBMPLEXMONO_MEDIUMITALIC37PT7B_H_
