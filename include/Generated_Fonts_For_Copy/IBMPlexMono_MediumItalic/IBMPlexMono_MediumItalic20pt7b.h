#ifndef _IBMPLEXMONO_MEDIUMITALIC20PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x63, 0x10, 0x84, 0x40, 0x01, 0xCE, 0x70, 0x6F, 0x9B,
  0x36, 0x6C, 0xD9, 0x80, 0x03, 0x20, 0x66, 0x06, 0x60, 0x6C, 0x3C, 0xF3,
  0xCF, 0x4D, 0x81, 0x98, 0xF9, 0xEF, 0x3E, 0x33, 0x03, 0x30, 0x26, 0x06,
  0x60, 0x01, 0x80, 0x10, 0x0F, 0xC1, 0xFE, 0x3B, 0x73, 0x34, 0x33, 0x03,
  0xA0, 0x1F, 0x80, 0x7C, 0x06, 0xE0, 0x66, 0x44, 0x6E, 0x4C, 0x7F, 0xC1,
  0xF0, 0x0C, 0x00, 0xC0, 0x0E, 0x0C, 0x7C, 0x63, 0x11, 0x8C, 0x4C, 0x33,
  0x60, 0xFD, 0x01, 0xE8, 0x00, 0x3C, 0x0D, 0xF0, 0x64, 0x41, 0xB1, 0x8C,
  0xCC, 0x63, 0xF3, 0x87, 0x80, 0x07, 0x80, 0xFC, 0x1C, 0xC1, 0x8C, 0x18,
  0xC0, 0xCC, 0x3F, 0x87, 0xE0, 0xE6, 0x0C, 0x60, 0xC3, 0x2E, 0x77, 0x7D,
  0xE7, 0x9C, 0x7B, 0x6D, 0x80, 0x07, 0x0C, 0x18, 0x30, 0x20, 0x60, 0x40,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x38, 0x18,
  0x0C, 0x06, 0x06, 0x06, 0x02, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x04,
  0x0C, 0x18, 0x18, 0x30, 0xE0, 0x06, 0x01, 0x80, 0x43, 0xB3, 0xFF, 0xC7,
  0x81, 0xE0, 0xD8, 0x63, 0x10, 0x80, 0x06, 0x01, 0x80, 0x60, 0x30, 0xFF,
  0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x06, 0x00, 0x3C, 0xE3, 0x1C, 0x63, 0x00,
  0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x60, 0x0E, 0x00, 0x0F, 0x83, 0xF8, 0xC3, 0x38,
  0x66, 0x0F, 0xD9, 0xFB, 0xB6, 0x66, 0xC0, 0xD8, 0x1B, 0x06, 0x71, 0xC7,
  0xF0, 0x7C, 0x00, 0x0F, 0x07, 0xC3, 0xB1, 0xCC, 0x67, 0x11, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0xFF, 0xFF, 0xE0, 0x07, 0x83, 0xFC,
  0xE3, 0x98, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60,
  0x38, 0x07, 0xFD, 0xFF, 0x80, 0x07, 0xC3, 0xFC, 0xE3, 0x88, 0x30, 0x06,
  0x01, 0x83, 0xE0, 0x7C, 0x00, 0xC0, 0x19, 0x03, 0x70, 0xE7, 0xF8, 0x7E,
  0x00, 0x00, 0xE0, 0x3C, 0x0F, 0x03, 0x60, 0xCC, 0x19, 0x86, 0x31, 0x8E,
  0x61, 0x9F, 0xFF, 0xFF, 0x80, 0xC0, 0x18, 0x07, 0x00, 0x3F, 0xE7, 0xF8,
  0xC0, 0x18, 0x02, 0x00, 0xDE, 0x1F, 0xE3, 0x0E, 0x01, 0xC0, 0x39, 0x07,
  0x71, 0xCF, 0xF0, 0x7C, 0x00, 0x03, 0xC3, 0x81, 0xC0, 0xE0, 0x30, 0x1B,
  0xC7, 0xFB, 0x87, 0xE0, 0xF0, 0x3C, 0x1F, 0x8E, 0x7F, 0x0F, 0x80, 0xFF,
  0xFF, 0xFC, 0x1F, 0x06, 0xC3, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x01,
  0x80, 0xC0, 0x70, 0x38, 0x00, 0x0F, 0x87, 0xF8, 0xC3, 0x30, 0x76, 0x0C,
  0x63, 0x8F, 0xC1, 0xFC, 0xE1, 0xD8, 0x1B, 0x07, 0x60, 0xCF, 0xF8, 0x7C,
  0x00, 0x1E, 0x3F, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0xFB, 0x7B, 0x03,
  0x81, 0x83, 0x83, 0x87, 0x80, 0x77, 0x70, 0x00, 0x0E, 0xEE, 0x1C, 0x71,
  0xC0, 0x00, 0x00, 0x0F, 0x38, 0xC7, 0x18, 0xC0, 0x00, 0x80, 0xC1, 0xE3,
  0xC7, 0x87, 0x03, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x20, 0x7F, 0xDF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x20, 0x0C, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0x70, 0x38, 0x1C, 0x1E, 0x1E, 0x0E, 0x02, 0x00, 0x1F, 0x3F, 0xD8,
  0xF8, 0x30, 0x18, 0x18, 0x78, 0x30, 0x38, 0x00, 0x00, 0x07, 0x07, 0x83,
  0x80, 0x0F, 0x87, 0xF3, 0x0D, 0x81, 0x67, 0x5B, 0xDC, 0xCF, 0x63, 0xD8,
  0xF6, 0x7D, 0xEB, 0x3E, 0xC0, 0x38, 0x07, 0xE0, 0xF8, 0x03, 0x80, 0xF0,
  0x1E, 0x06, 0xC0, 0xCC, 0x39, 0x86, 0x30, 0xC6, 0x3F, 0xC7, 0xF9, 0x83,
  0x30, 0x6E, 0x0F, 0x81, 0xC0, 0x3F, 0x8F, 0xF3, 0x0C, 0xC3, 0x70, 0xD8,
  0x77, 0xF9, 0xFE, 0x61, 0xD8, 0x3E, 0x1F, 0x06, 0xFF, 0xBF, 0x80, 0x0F,
  0x83, 0xF8, 0xE3, 0xB8, 0x36, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C,
  0x23, 0x87, 0x30, 0xC7, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xF0, 0xC7, 0x18,
  0x67, 0x0C, 0xC1, 0xD8, 0x33, 0x06, 0x60, 0xCC, 0x3B, 0x86, 0x61, 0xCF,
  0xF1, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x1F,
  0xF3, 0xFC, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0F, 0xF9, 0xFF, 0x00, 0x3F,
  0xE7, 0xFC, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x1F, 0xF3, 0xFC, 0x60, 0x0C,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x0F, 0x83, 0xF8, 0xE3, 0x38,
  0x76, 0x00, 0xC0, 0x38, 0x07, 0x3E, 0xC7, 0xD8, 0x1B, 0x86, 0x71, 0xC7,
  0xF8, 0x7B, 0x00, 0x30, 0x66, 0x0C, 0xC3, 0xB8, 0x66, 0x0C, 0xC1, 0x9F,
  0xF3, 0xFE, 0x61, 0xDC, 0x33, 0x06, 0x60, 0xCC, 0x19, 0x87, 0x00, 0x3F,
  0xE7, 0xFC, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0E, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0x0C, 0x03,
  0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xEC, 0x3B, 0x8C, 0x7F, 0x0F,
  0x00, 0x30, 0x73, 0x0E, 0x31, 0xC7, 0x38, 0x67, 0x06, 0xE0, 0x7E, 0x07,
  0xE0, 0x76, 0x0E, 0x30, 0xE3, 0x0C, 0x38, 0xC1, 0x8C, 0x1C, 0x18, 0x1C,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x07,
  0xFF, 0xFC, 0x18, 0x73, 0xC7, 0x3C, 0xF3, 0xCF, 0x3D, 0xB3, 0x72, 0x27,
  0x66, 0x66, 0x66, 0x66, 0x46, 0x60, 0x66, 0x0C, 0x40, 0xCC, 0x0C, 0x38,
  0x67, 0x0C, 0xE1, 0xB6, 0x66, 0xCC, 0xD9, 0x9B, 0x33, 0x66, 0x46, 0xD8,
  0xF3, 0x1E, 0x63, 0xCC, 0x79, 0x87, 0x00, 0x0F, 0x83, 0xF8, 0xC3, 0x38,
  0x66, 0x0F, 0xC1, 0xF8, 0x36, 0x06, 0xC0, 0xD8, 0x3B, 0x06, 0x71, 0xC7,
  0xF0, 0x7C, 0x00, 0x3F, 0x87, 0xF8, 0xC3, 0x98, 0x37, 0x0E, 0xE1, 0xD8,
  0x33, 0xFE, 0x7F, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x00, 0x0F,
  0x83, 0xF8, 0xC3, 0x38, 0x66, 0x0F, 0xC1, 0xF8, 0x36, 0x06, 0xC0, 0xD8,
  0x3B, 0x06, 0x71, 0xC7, 0xF0, 0x7C, 0x03, 0x20, 0x76, 0x07, 0x80, 0x60,
  0x3F, 0x87, 0xF8, 0xC3, 0x98, 0x37, 0x0E, 0xE1, 0xD8, 0x33, 0xFE, 0x7F,
  0x0C, 0xC3, 0x9C, 0x71, 0x8C, 0x39, 0x83, 0x00, 0x07, 0xC1, 0xFE, 0x38,
  0x73, 0x04, 0x30, 0x03, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xE0, 0x0E, 0x40,
  0xEE, 0x0C, 0x7F, 0xC1, 0xF0, 0xFF, 0xFF, 0xFC, 0x30, 0x06, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60,
  0x00, 0x30, 0x66, 0x0D, 0xC3, 0xB0, 0x66, 0x0C, 0xC1, 0x98, 0x33, 0x06,
  0xE1, 0xD8, 0x33, 0x06, 0x71, 0xC7, 0xF0, 0x7C, 0x00, 0xC0, 0xF8, 0x1B,
  0x03, 0x70, 0xC6, 0x18, 0xC6, 0x18, 0xC3, 0x38, 0x66, 0x0C, 0xC1, 0xB0,
  0x36, 0x07, 0x80, 0x70, 0x00, 0x60, 0x36, 0x03, 0x60, 0x64, 0x66, 0x4E,
  0x6C, 0xA6, 0xCA, 0x4D, 0xAC, 0xD2, 0xCD, 0x2C, 0xF2, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0x38, 0x38, 0xC3, 0x87, 0x18, 0x19, 0x80, 0xDC, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0xCC, 0x0E, 0x60, 0xE3, 0x86, 0x0C, 0x60,
  0x70, 0xC0, 0xFC, 0x19, 0x86, 0x31, 0xC7, 0x30, 0x6C, 0x0F, 0x81, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x00, 0x1F, 0xF1, 0xFF,
  0x20, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xFF, 0xCF, 0xFC, 0x1F, 0x8F, 0xCC, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80,
  0xFC, 0x7E, 0x00, 0xC1, 0x86, 0x18, 0x60, 0x83, 0x0C, 0x30, 0xC1, 0x06,
  0x18, 0x61, 0x82, 0x0C, 0x30, 0x1F, 0x8F, 0xC0, 0x60, 0x30, 0x18, 0x08,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x7E,
  0x7E, 0x00, 0x07, 0x03, 0xC0, 0xF8, 0x66, 0x31, 0x9C, 0x36, 0x0F, 0x03,
  0xFF, 0xFF, 0xF0, 0xCD, 0x90, 0x1C, 0xDF, 0xB7, 0x1F, 0x86, 0xC1, 0xB0,
  0x6C, 0x3B, 0x96, 0xFF, 0xDE, 0x70, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x1D, 0xE6, 0xFD, 0xC7, 0x60, 0xD8, 0x36, 0x0F, 0x07, 0xE3, 0xBF, 0xCD,
  0xE0, 0x1F, 0x0F, 0xE7, 0x1D, 0x84, 0xE0, 0x38, 0x0E, 0x19, 0x8E, 0x7F,
  0x0F, 0x80, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x3D, 0x8F, 0xF3,
  0x8E, 0xE0, 0xD8, 0x33, 0x06, 0x60, 0xCE, 0x79, 0xFB, 0x1E, 0xE0, 0x0F,
  0x0F, 0xF7, 0x0D, 0x87, 0xFF, 0xBF, 0x8C, 0x11, 0x86, 0x7F, 0x0F, 0x80,
  0x00, 0xF8, 0x0F, 0xC0, 0xE0, 0x06, 0x00, 0x30, 0x0F, 0xF8, 0xFF, 0xC0,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x02, 0x38,
  0x19, 0x80, 0xEC, 0x03, 0xE0, 0x0E, 0x00, 0x0F, 0x63, 0xEC, 0xE3, 0xB8,
  0x36, 0x0C, 0xC1, 0x98, 0x33, 0x8E, 0x7E, 0xC7, 0xB8, 0x06, 0x21, 0xCF,
  0xF0, 0x7C, 0x00, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1D, 0xE7, 0xF9,
  0xA7, 0x71, 0xD8, 0x66, 0x1B, 0x86, 0xE1, 0xB0, 0x6C, 0x38, 0x0C, 0x0E,
  0x03, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x30, 0x18, 0x18, 0x0C, 0x46, 0x73,
  0x71, 0xF0, 0xE0, 0x01, 0x80, 0xC0, 0xE0, 0x00, 0x01, 0xFC, 0xFC, 0x06,
  0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x31, 0x19, 0xCC, 0x6E, 0x1E, 0x07,
  0x00, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xEF, 0x1F, 0xF3, 0x8E,
  0x71, 0x8C, 0x31, 0xB8, 0x7E, 0x2E, 0xED, 0x8F, 0xF1, 0xC0, 0xFC, 0x7E,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x46, 0xF6,
  0xE3, 0xE0, 0xE0, 0x3E, 0xE2, 0xEF, 0x77, 0x36, 0x62, 0x66, 0x66, 0x66,
  0x66, 0x6C, 0x66, 0xCC, 0x6C, 0xCC, 0x37, 0x9F, 0xE6, 0x9D, 0xC7, 0x61,
  0x98, 0x66, 0x1B, 0x86, 0xC1, 0xB0, 0xE0, 0x1F, 0x0F, 0xE7, 0x1D, 0x83,
  0xE0, 0xF0, 0x7C, 0x1B, 0x8E, 0x7F, 0x0F, 0x80, 0x3B, 0xC6, 0xFC, 0xE3,
  0x98, 0x33, 0x06, 0x60, 0xD8, 0x3B, 0x8E, 0x7F, 0x8D, 0xE1, 0x80, 0x30,
  0x0E, 0x01, 0x80, 0x00, 0x1E, 0xCF, 0xF7, 0x1F, 0x83, 0xC1, 0xB0, 0x6C,
  0x1B, 0x8E, 0xFD, 0x9E, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xF9, 0xFE,
  0xF1, 0xC0, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x00, 0x1F,
  0x0F, 0xF7, 0x09, 0xC0, 0x3F, 0x07, 0xE0, 0x19, 0x06, 0xFF, 0x0F, 0x80,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x7F, 0xDF, 0xF9, 0x80, 0x60, 0x18, 0x06,
  0x23, 0x98, 0xDF, 0x3E, 0x07, 0x00, 0x70, 0xD8, 0x36, 0x0D, 0x87, 0x61,
  0x98, 0x6E, 0x3B, 0x96, 0x7F, 0x9E, 0xC0, 0xF1, 0xBC, 0x33, 0x0C, 0xC3,
  0x30, 0xCC, 0x66, 0x39, 0x9C, 0x7E, 0x0F, 0x00, 0x66, 0xD1, 0x1C, 0x47,
  0x31, 0xCC, 0x73, 0x38, 0xCE, 0x72, 0xED, 0xB9, 0xC0, 0x1C, 0xE3, 0xFF,
  0x77, 0x34, 0x73, 0x06, 0x00, 0x60, 0xCE, 0x2C, 0xEE, 0xFF, 0xC7, 0x38,
  0x38, 0x66, 0x0C, 0xC1, 0x98, 0x73, 0x0C, 0x61, 0x9C, 0x73, 0x96, 0x3F,
  0xC7, 0xB0, 0x06, 0x21, 0xCF, 0xF0, 0x7C, 0x00, 0x3E, 0xDF, 0xF6, 0x3C,
  0x0C, 0x0E, 0x07, 0x03, 0x1B, 0xE3, 0xFF, 0xF3, 0xE0, 0x07, 0xC3, 0xE0,
  0xC0, 0x20, 0x0C, 0x03, 0x00, 0x60, 0x30, 0xFC, 0x3E, 0x00, 0xC0, 0x30,
  0x18, 0x0C, 0x02, 0x00, 0x80, 0x7E, 0x0F, 0x80, 0x18, 0x8C, 0x63, 0x18,
  0xC4, 0x63, 0x18, 0xC6, 0x23, 0x18, 0xC6, 0x00, 0x1F, 0x0F, 0x88, 0xC0,
  0x60, 0x60, 0x60, 0x20, 0x18, 0x0F, 0x87, 0xC6, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x18, 0xF8, 0x7C, 0x00, 0x38, 0x6F, 0x9B, 0x33, 0x63, 0xC8, 0x70,
};

const GFXglyph IBMPlexMono_MediumItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 5, 14, 12, 4, -14 },
  { 10, 7, 6, 12, 4, -15 },
  { 16, 12, 14, 12, 0, -14 },
  { 37, 12, 18, 12, 0, -16 },
  { 64, 14, 14, 12, -1, -14 },
  { 89, 12, 14, 12, 0, -14 },
  { 110, 3, 6, 12, 6, -15 },
  { 113, 8, 18, 12, 4, -15 },
  { 131, 8, 18, 12, 1, -15 },
  { 149, 10, 10, 12, 1, -11 },
  { 162, 10, 10, 12, 1, -11 },
  { 175, 6, 6, 12, 2, -3 },
  { 180, 6, 2, 12, 3, -7 },
  { 182, 3, 3, 12, 4, -3 },
  { 184, 12, 18, 12, 0, -15 },
  { 211, 11, 14, 12, 1, -14 },
  { 231, 10, 14, 12, 1, -14 },
  { 249, 11, 14, 12, 0, -14 },
  { 269, 11, 14, 12, 0, -14 },
  { 289, 11, 14, 12, 0, -14 },
  { 309, 11, 14, 12, 1, -14 },
  { 329, 10, 14, 12, 1, -14 },
  { 347, 10, 14, 12, 2, -14 },
  { 365, 11, 14, 12, 1, -14 },
  { 385, 9, 14, 12, 2, -14 },
  { 401, 4, 10, 12, 4, -10 },
  { 406, 6, 13, 12, 2, -10 },
  { 416, 9, 12, 12, 2, -12 },
  { 430, 10, 6, 12, 1, -9 },
  { 438, 10, 12, 12, 1, -12 },
  { 453, 9, 14, 12, 2, -14 },
  { 469, 10, 16, 12, 1, -14 },
  { 489, 11, 14, 12, 0, -14 },
  { 509, 10, 14, 12, 1, -14 },
  { 527, 11, 14, 12, 1, -14 },
  { 547, 11, 14, 12, 1, -14 },
  { 567, 11, 14, 12, 1, -14 },
  { 587, 11, 14, 12, 1, -14 },
  { 607, 11, 14, 12, 1, -14 },
  { 627, 11, 14, 12, 1, -14 },
  { 647, 11, 14, 12, 1, -14 },
  { 667, 10, 14, 12, 1, -14 },
  { 685, 12, 14, 12, 1, -14 },
  { 706, 9, 14, 12, 1, -14 },
  { 722, 12, 14, 12, 0, -14 },
  { 743, 11, 14, 12, 1, -14 },
  { 763, 11, 14, 12, 1, -14 },
  { 783, 11, 14, 12, 1, -14 },
  { 803, 11, 18, 12, 1, -14 },
  { 828, 11, 14, 12, 1, -14 },
  { 848, 12, 14, 12, 0, -14 },
  { 869, 11, 14, 12, 2, -14 },
  { 889, 11, 14, 12, 1, -14 },
  { 909, 11, 14, 12, 2, -14 },
  { 929, 12, 14, 12, 1, -14 },
  { 950, 13, 14, 12, 0, -14 },
  { 973, 11, 14, 12, 2, -14 },
  { 993, 12, 14, 12, 0, -14 },
  { 1014, 9, 18, 12, 3, -15 },
  { 1035, 6, 18, 12, 3, -15 },
  { 1049, 9, 18, 12, 0, -15 },
  { 1070, 10, 8, 12, 1, -14 },
  { 1080, 10, 2, 12, 0, 2 },
  { 1083, 3, 4, 12, 4, -16 },
  { 1085, 10, 10, 12, 1, -10 },
  { 1098, 10, 15, 12, 1, -15 },
  { 1117, 10, 10, 12, 1, -10 },
  { 1130, 11, 15, 12, 1, -15 },
  { 1151, 10, 10, 12, 1, -10 },
  { 1164, 13, 19, 12, 0, -15 },
  { 1195, 11, 14, 12, 0, -10 },
  { 1215, 10, 15, 12, 1, -15 },
  { 1234, 9, 15, 12, 2, -15 },
  { 1251, 9, 19, 12, 1, -15 },
  { 1273, 11, 15, 12, 1, -15 },
  { 1294, 9, 15, 12, 2, -15 },
  { 1311, 12, 10, 12, 0, -10 },
  { 1326, 10, 10, 12, 1, -10 },
  { 1339, 10, 10, 12, 1, -10 },
  { 1352, 11, 14, 12, 0, -10 },
  { 1372, 10, 14, 12, 1, -10 },
  { 1390, 10, 10, 12, 2, -10 },
  { 1403, 10, 10, 12, 1, -10 },
  { 1416, 10, 14, 12, 1, -14 },
  { 1434, 10, 10, 12, 1, -10 },
  { 1447, 10, 10, 12, 1, -10 },
  { 1460, 10, 10, 12, 1, -10 },
  { 1473, 12, 10, 12, 0, -10 },
  { 1488, 11, 14, 12, 0, -10 },
  { 1508, 10, 10, 12, 1, -10 },
  { 1521, 10, 18, 12, 2, -15 },
  { 1544, 5, 18, 12, 4, -15 },
  { 1556, 9, 18, 12, 1, -15 },
  { 1577, 11, 5, 12, 1, -9 },
};

const GFXfont IBMPlexMono_MediumItalic20pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic20pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _IBMPLEXMONO_MEDIUMITALIC20PT7B_H_
