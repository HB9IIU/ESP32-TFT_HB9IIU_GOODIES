#ifndef _IBMPLEXMONO_MEDIUMITALIC33PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C,
  0x1C, 0x18, 0x18, 0x18, 0x00, 0x00, 0x00, 0x78, 0xFC, 0xFC, 0xF8, 0x70,
  0x38, 0xEF, 0x1D, 0xE3, 0xB8, 0x77, 0x1E, 0xE3, 0xDC, 0x73, 0x8E, 0xF1,
  0xDC, 0x38, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3,
  0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x03, 0xF8, 0xFF, 0x1F,
  0xC7, 0xF0, 0xFE, 0x3F, 0x88, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x70, 0xE0,
  0x3F, 0x8F, 0xE3, 0xFC, 0x7F, 0x1F, 0xC3, 0xF8, 0x0E, 0x38, 0x00, 0x71,
  0xC0, 0x07, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x1C, 0x38, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0xF1, 0xF3, 0x7C, 0x71, 0xC6, 0x3C, 0x71, 0x0F,
  0x1C, 0x03, 0xC6, 0x00, 0xF9, 0x80, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFC, 0x00, 0xDF, 0x80, 0x31, 0xE0, 0x0C, 0x78, 0x07, 0x1E,
  0x21, 0xC7, 0xBC, 0x71, 0xCF, 0x99, 0xF1, 0xFF, 0xF8, 0x3F, 0xFC, 0x03,
  0xFC, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x0E,
  0x0F, 0xE0, 0x38, 0x3F, 0xE0, 0xE0, 0x71, 0xC3, 0x81, 0xC1, 0x86, 0x03,
  0x87, 0x1C, 0x07, 0x0E, 0x70, 0x0E, 0x1D, 0xC0, 0x1C, 0x73, 0x00, 0x3F,
  0xE8, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0x1C, 0x01, 0xDC, 0x38, 0x07, 0x38, 0x70, 0x1C, 0x60,
  0xE0, 0x70, 0xC1, 0xC0, 0xE1, 0xC7, 0x03, 0x83, 0xFE, 0x0E, 0x03, 0xF8,
  0x38, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x3C, 0x78, 0x07, 0x83, 0x80, 0x78, 0x38, 0x07, 0x83, 0x80, 0x78, 0x38,
  0x03, 0x87, 0x80, 0x38, 0x70, 0x0F, 0xDE, 0x03, 0xFF, 0xC0, 0x79, 0xE0,
  0x07, 0x0E, 0x00, 0x70, 0xF0, 0x0F, 0x07, 0x00, 0xF0, 0x78, 0x4F, 0x07,
  0x86, 0xF0, 0x7C, 0xFF, 0x8D, 0xDC, 0x7F, 0x9F, 0xC3, 0xF8, 0xF8, 0x1E,
  0x07, 0x00, 0x39, 0xDE, 0xF7, 0x39, 0xCE, 0x77, 0x80, 0x00, 0x78, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x07, 0x8E, 0x3B,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8, 0x03, 0xE0, 0x03, 0xF8, 0x03, 0xDC,
  0x01, 0xCF, 0x01, 0xE3, 0xC1, 0xE0, 0xE0, 0x60, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x1F, 0x1F, 0x1E, 0x3E, 0x3C,
  0x38, 0x78, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7B, 0xFF, 0xFE,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE1,
  0xE3, 0xC0, 0x79, 0xC0, 0x3D, 0xE0, 0x0E, 0xF0, 0x07, 0x70, 0x03, 0xF8,
  0xE3, 0xFC, 0xF9, 0xFE, 0x78, 0xFF, 0x1C, 0x7F, 0x00, 0x3B, 0x80, 0x3D,
  0xC0, 0x1E, 0xE0, 0x0F, 0x70, 0x0F, 0x3C, 0x07, 0x9F, 0x0F, 0x87, 0xFF,
  0x81, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0xFB, 0xC0, 0xF9, 0xC0, 0xF8, 0xE0, 0x38, 0xF0, 0x18, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x07,
  0xFF, 0xFB, 0xFF, 0xFB, 0xFF, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x7C, 0x3E, 0x1E, 0x07, 0x8F, 0x00, 0xF0, 0x80, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x01, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x3E, 0x0C, 0x07, 0xC2, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x3F, 0xC0, 0x0F,
  0xC0, 0x03, 0xFE, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x08, 0x03, 0xCE, 0x01, 0xF3, 0xE0, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xB8, 0x00, 0xE7, 0x00, 0x3D, 0xE0, 0x0F, 0x3C, 0x01, 0xC7, 0x80,
  0x70, 0xE0, 0x1C, 0x1C, 0x07, 0x83, 0x81, 0xE0, 0xF0, 0x38, 0x1E, 0x0E,
  0x03, 0xC3, 0x80, 0x70, 0x7F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0xFF, 0xFC, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0xF8, 0x07, 0x7F, 0x83, 0xBF, 0xF0, 0xF8, 0x7C,
  0x18, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x88,
  0x03, 0xC7, 0x00, 0xF3, 0xE0, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0xF8, 0x7B, 0xFC, 0x77, 0xFE, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0E, 0xF0, 0x1E, 0xF8, 0x3C, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEE, 0x00, 0xEF, 0x00, 0xF7, 0x00, 0xF3,
  0x80, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x00, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x7C, 0x1F, 0x1E, 0x03, 0xC7,
  0x00, 0xF1, 0xC0, 0x3C, 0x70, 0x0E, 0x1E, 0x0F, 0x03, 0xFF, 0x80, 0x3F,
  0x80, 0x7F, 0xF8, 0x3C, 0x0F, 0x1E, 0x01, 0xE7, 0x00, 0x7B, 0xC0, 0x1E,
  0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0xF1, 0xE0, 0x7C, 0x7F, 0xFE, 0x0F,
  0xFF, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x1E,
  0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xF8, 0x3E, 0xFF, 0xFE, 0x7F, 0xDC, 0x1F, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0xFC, 0x00, 0x1E, 0x3F, 0x3F, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0xFC, 0xFC, 0xF8, 0xF8, 0x07, 0x83, 0xF0, 0xFC, 0x3E,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x07,
  0xC1, 0xE0, 0xF8, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x38, 0x00, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00,
  0x08, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80,
  0x00, 0x07, 0xE0, 0x7F, 0xE3, 0xFF, 0xDE, 0x1F, 0xF0, 0x3D, 0x80, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x03, 0xE0, 0xFF, 0x03, 0xF0, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0x80,
  0x7E, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xC1, 0xE3, 0xC0, 0x79, 0xC0, 0x1C, 0xE0, 0x0E, 0xE0, 0xE7, 0x71,
  0xFB, 0xB9, 0xFF, 0xFC, 0xF1, 0xDC, 0x70, 0xEE, 0x78, 0x77, 0x38, 0x3B,
  0x9C, 0x1D, 0xCE, 0x1E, 0xE7, 0x0E, 0x63, 0xFF, 0x30, 0xFB, 0x98, 0x7D,
  0xCE, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7F, 0xF0, 0x1F,
  0xF8, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0x70, 0x01, 0xEF, 0x00, 0x39, 0xE0, 0x0F, 0x3C, 0x01,
  0xE7, 0x80, 0x38, 0x70, 0x0F, 0x0E, 0x01, 0xC1, 0xC0, 0x78, 0x38, 0x0E,
  0x07, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xC0, 0x78, 0xF0,
  0x0F, 0x1E, 0x00, 0xE7, 0x80, 0x1C, 0xF0, 0x03, 0xFC, 0x00, 0x78, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x38, 0x1E, 0x1E, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x3C, 0x78, 0x0E, 0x1C, 0x07, 0x87, 0x03, 0xC3, 0xFF, 0xE0,
  0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0x03, 0xC3, 0x80, 0x78, 0xE0, 0x1E, 0x78,
  0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF1, 0xC0, 0x7C, 0x7F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7C, 0x3E,
  0x1E, 0x07, 0x8F, 0x00, 0xE3, 0xC0, 0x25, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x3C, 0x03, 0xC7, 0x81, 0xE1, 0xF0, 0xF0,
  0x3F, 0xFC, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0xFF, 0xF0, 0x38, 0x3E, 0x1E, 0x03, 0x87, 0x80, 0xF1, 0xE0, 0x3C, 0x78,
  0x0F, 0x1C, 0x03, 0xC7, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03,
  0xCF, 0x00, 0xE3, 0x80, 0x78, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x03, 0xC7,
  0x81, 0xF1, 0xE0, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xFF,
  0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xE3, 0xE0, 0x79,
  0xE0, 0x3D, 0xE0, 0x10, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x1F, 0xEF, 0x0F, 0xF7, 0x87, 0xFB, 0xC0, 0x3D, 0xE0, 0x1C, 0xF0,
  0x0E, 0x78, 0x0F, 0x3C, 0x07, 0x8F, 0x0F, 0xC7, 0xFD, 0xE1, 0xFE, 0xE0,
  0x7C, 0x70, 0x0E, 0x01, 0xE1, 0xC0, 0x3C, 0x78, 0x07, 0x0F, 0x00, 0xE1,
  0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x00, 0xF0, 0xE0, 0x1E, 0x3C, 0x03, 0x87,
  0x80, 0x70, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x70, 0x0F, 0x1E,
  0x01, 0xC3, 0xC0, 0x38, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xC0, 0x3C, 0x38,
  0x07, 0x8F, 0x00, 0xE1, 0xE0, 0x1C, 0x3C, 0x07, 0x80, 0x0F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x70, 0x1E, 0x38, 0x1E, 0x1E, 0x1F, 0x07, 0xFF,
  0x03, 0xFF, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0xF8, 0x70, 0x0F, 0x03, 0x80,
  0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0xF8, 0x03,
  0x8F, 0x80, 0x1C, 0xF8, 0x01, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0x7F, 0xE0,
  0x03, 0xF7, 0x00, 0x1F, 0xBC, 0x00, 0xF9, 0xE0, 0x0F, 0x87, 0x80, 0x78,
  0x3C, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x00, 0xF0,
  0x78, 0x07, 0x83, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x80, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3F,
  0x0F, 0xC7, 0xF1, 0xDC, 0x7E, 0x1D, 0xCE, 0xE1, 0xDC, 0xEE, 0x1C, 0xDC,
  0xE1, 0xCF, 0xCE, 0x1C, 0xF9, 0xE3, 0xCF, 0x9C, 0x38, 0xF1, 0xC3, 0x86,
  0x1C, 0x38, 0x61, 0xC3, 0x84, 0x1C, 0x38, 0x43, 0xC7, 0x80, 0x38, 0x70,
  0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0xF0, 0x07, 0x80,
  0x0F, 0x81, 0xE1, 0xF0, 0x3C, 0x7E, 0x07, 0x0F, 0xC0, 0xE1, 0xFC, 0x1C,
  0x3B, 0x83, 0x87, 0x70, 0xF0, 0xEE, 0x1E, 0x3D, 0xC3, 0x87, 0xBC, 0x70,
  0xE3, 0x8E, 0x1C, 0x71, 0xC3, 0x8E, 0x78, 0x71, 0xCF, 0x1E, 0x3D, 0xC3,
  0xC3, 0xB8, 0x70, 0x77, 0x0E, 0x0E, 0xE1, 0xC1, 0xFC, 0x38, 0x3F, 0x8F,
  0x03, 0xE1, 0xE0, 0x7C, 0x38, 0x0F, 0x80, 0x01, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0xC3, 0xE1, 0xE3, 0xC0, 0x79, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F,
  0x70, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3B, 0x80, 0x3D, 0xC0, 0x1E, 0xE0, 0x0F, 0x78, 0x0F, 0x3C, 0x0F, 0x9F,
  0x0F, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x38, 0x0F, 0x1E, 0x01, 0xC7, 0x80, 0x71, 0xE0, 0x1C,
  0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x00, 0xF3, 0xC0, 0x78, 0xFF, 0xFE, 0x3F,
  0xFF, 0x0F, 0xFF, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xE3, 0xC0, 0x79, 0xE0,
  0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x70, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3B, 0x80, 0x3D, 0xC0, 0x1E, 0xE0, 0x0F,
  0x78, 0x0F, 0x3C, 0x0F, 0x9F, 0x0F, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0x00, 0x07, 0x04, 0x03, 0xC7, 0x00, 0xF7, 0xC0, 0x3F, 0x80, 0x1F, 0x80,
  0x07, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x38, 0x0F, 0x1E,
  0x01, 0xC7, 0x80, 0x71, 0xE0, 0x1C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x00,
  0xF3, 0xC0, 0x78, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0x87, 0x00,
  0xE1, 0xE0, 0x78, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x70,
  0x1E, 0x1C, 0x07, 0x8F, 0x00, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF,
  0xFC, 0x7C, 0x1F, 0x1E, 0x01, 0x8F, 0x00, 0x43, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x88, 0x01, 0xEF, 0x00,
  0xF3, 0xE0, 0x7C, 0x7F, 0xFE, 0x0F, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x1C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0E, 0x3C,
  0x07, 0x8E, 0x01, 0xE3, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x1E, 0x01,
  0xC7, 0x80, 0xF1, 0xC0, 0x3C, 0x70, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xE3,
  0xC0, 0x38, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xC3, 0xE1, 0xF0, 0x7F,
  0xF8, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x00,
  0x79, 0xC0, 0x1E, 0x70, 0x07, 0x1E, 0x03, 0xC7, 0x80, 0xE1, 0xE0, 0x78,
  0x78, 0x1E, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xE0, 0xE0, 0x38, 0x78, 0x0E,
  0x1C, 0x03, 0x8F, 0x00, 0xF3, 0x80, 0x3D, 0xE0, 0x0F, 0x70, 0x03, 0xDC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x38, 0x00,
  0x73, 0x80, 0x07, 0x38, 0x00, 0x73, 0x80, 0x0F, 0x38, 0x00, 0xE3, 0x80,
  0x0E, 0x38, 0xF0, 0xE7, 0x8F, 0x0E, 0x78, 0xF1, 0xC7, 0x1F, 0x1C, 0x71,
  0xB1, 0xC7, 0x1B, 0x1C, 0x73, 0xB3, 0x87, 0x33, 0x38, 0x77, 0x33, 0x87,
  0x73, 0x38, 0x76, 0x37, 0x07, 0xE3, 0x70, 0xEE, 0x37, 0x0E, 0xC3, 0xF0,
  0xFC, 0x3E, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x00, 0x0F, 0x80, 0x3C, 0x1E,
  0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x07, 0x8F,
  0x00, 0x1E, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x78,
  0x07, 0x81, 0xE0, 0x3C, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0xFE, 0x00, 0x79, 0xE0, 0x1E, 0x3C, 0x07, 0x87, 0x80, 0xF0,
  0x78, 0x3C, 0x0F, 0x0F, 0x00, 0xE1, 0xE0, 0x1E, 0x78, 0x03, 0xDE, 0x00,
  0x3B, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x00, 0xE0, 0x70,
  0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x38,
  0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x1C, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x7B, 0xC0,
  0x38, 0xE0, 0x38, 0x78, 0x3C, 0x1C, 0x3C, 0x0E, 0x1C, 0x07, 0x9E, 0x01,
  0xDE, 0x00, 0xFE, 0x00, 0x39, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x27, 0xBC, 0xE3, 0x9C, 0x40, 0x07, 0xC7, 0x1F, 0xEF, 0x3F, 0xFF,
  0x7C, 0x1F, 0x78, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0xE0, 0x1E,
  0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x7C, 0xF0, 0xFC, 0xFF, 0xBF,
  0x7F, 0x3F, 0x3E, 0x1F, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x7C, 0x1E, 0xFF, 0x0E,
  0xFF, 0x87, 0x63, 0xE7, 0xC0, 0xF3, 0xC0, 0x39, 0xE0, 0x1C, 0xE0, 0x0E,
  0x70, 0x0F, 0x38, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xCF, 0x01, 0xE7, 0xC1,
  0xE3, 0xBF, 0xF1, 0xDF, 0xF1, 0xE3, 0xE0, 0x03, 0xF0, 0x1F, 0xF8, 0x7F,
  0xF9, 0xF0, 0xF3, 0x80, 0xEF, 0x01, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x27, 0x80, 0x7F, 0x01, 0xCF, 0x0F, 0x9F, 0xFE, 0x1F,
  0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x1F, 0x1C, 0x1F, 0xE7, 0x0F,
  0xFD, 0xC7, 0xC1, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0x8F, 0x00,
  0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x38, 0x07, 0x8E, 0x03, 0xE3, 0x80, 0xF0,
  0xF0, 0xDC, 0x3F, 0xF7, 0x07, 0xFB, 0xC0, 0xF8, 0xF0, 0x01, 0xF8, 0x0F,
  0xFE, 0x1F, 0xFE, 0x3E, 0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x70, 0x7E, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0x80, 0xF0, 0x00, 0xF0, 0x0C, 0xF0, 0x0E, 0x78,
  0x3C, 0x7F, 0xFC, 0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x08, 0x3C,
  0x00, 0x70, 0xF0, 0x03, 0xE3, 0x80, 0x03, 0xCE, 0x00, 0x0F, 0xB8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE3, 0x87,
  0xF9, 0xC7, 0xFE, 0xE7, 0xC1, 0xF3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1C,
  0xF0, 0x0E, 0x78, 0x07, 0x38, 0x07, 0x9C, 0x03, 0xCE, 0x03, 0xE7, 0x81,
  0xE3, 0xC3, 0x71, 0xFF, 0xB8, 0x7F, 0xBC, 0x1F, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x08, 0x07, 0x87, 0x07, 0x87, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0x80,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x78, 0x1E, 0xFF, 0x0F, 0x7F, 0x87, 0x63, 0xC3,
  0xC0, 0xF3, 0xE0, 0x79, 0xE0, 0x38, 0xF0, 0x1C, 0x70, 0x0E, 0x38, 0x0F,
  0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xC7, 0x80, 0xE3, 0x80, 0x71, 0xC0,
  0x79, 0xE0, 0x3C, 0x01, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x10, 0x38, 0x70, 0x71, 0xF1, 0xE7, 0x83, 0xDE, 0x07, 0xF8, 0x0F, 0xE0,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x20, 0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x3C, 0xE0, 0x3E, 0xE0,
  0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0xF8,
  0x1E, 0xFF, 0x07, 0xFF, 0xC1, 0xD8, 0xF8, 0x78, 0x1E, 0x3E, 0x07, 0x0F,
  0x01, 0xC3, 0xC0, 0xE0, 0xE0, 0xF0, 0x3B, 0xE0, 0x0E, 0x70, 0x07, 0x9E,
  0x19, 0xE3, 0x8F, 0x78, 0xF7, 0x9C, 0x1F, 0xC7, 0x07, 0xE3, 0xC0, 0xF0,
  0x7F, 0xC3, 0xFF, 0x0F, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x08, 0x70, 0x71, 0xC7, 0xC7, 0x3E, 0x3D,
  0xF0, 0xFF, 0x01, 0xF8, 0x07, 0xC0, 0x1C, 0xE3, 0xC3, 0xBE, 0xFC, 0xFF,
  0xDF, 0x9F, 0x3C, 0x73, 0xC7, 0x8E, 0x70, 0xE1, 0xCE, 0x1C, 0x39, 0xC3,
  0x87, 0x78, 0xE1, 0xCE, 0x1C, 0x39, 0xC3, 0x87, 0x38, 0x70, 0xE7, 0x0E,
  0x1C, 0xE1, 0xC3, 0xBC, 0x70, 0xE7, 0x0E, 0x1C, 0xE1, 0xC3, 0x80, 0x1E,
  0x3C, 0x0F, 0x7F, 0x87, 0xBF, 0xC3, 0xB1, 0xE1, 0xE0, 0x79, 0xF0, 0x3C,
  0xF0, 0x1C, 0x78, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x8E, 0x03, 0xCF, 0x01,
  0xE7, 0x80, 0xE3, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x3C, 0xF0, 0x1E, 0x00,
  0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3C, 0x1E, 0x78, 0x0F, 0x70, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E,
  0xF0, 0x1E, 0xF8, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x0F, 0x1F,
  0x03, 0x9F, 0xE0, 0xEF, 0xF8, 0x3B, 0x1F, 0x1F, 0x03, 0xC7, 0x80, 0x71,
  0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xF3, 0xC0, 0x3C, 0xF0,
  0x1E, 0x3C, 0x07, 0x8F, 0x83, 0xC3, 0xBF, 0xF0, 0xEF, 0xF8, 0x78, 0xF8,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC7, 0x1F, 0xE7, 0x3F, 0xF7, 0x7C, 0x1F,
  0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E,
  0xE0, 0x1E, 0xE0, 0x3E, 0xE0, 0x3C, 0xF0, 0xDC, 0xFF, 0xFC, 0x7F, 0xBC,
  0x3E, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x7F, 0x8F, 0xBF, 0xDF, 0xBF, 0xCF, 0xC0, 0xE8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xE3,
  0xC0, 0xE1, 0xC0, 0x20, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xE2, 0x00, 0xF3, 0xC0, 0xF3, 0xFF,
  0xF8, 0x7F, 0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x3F, 0x1E, 0xF8, 0x1F, 0xF0,
  0x0F, 0xC0, 0x0F, 0x80, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x0F, 0x38, 0x0F,
  0x78, 0x0F, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0x1E,
  0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x5C, 0xF8, 0xFC, 0x7F, 0xBC, 0x7F, 0x3C,
  0x3E, 0x3C, 0xFE, 0x06, 0xFE, 0x1E, 0xFE, 0x0F, 0x1C, 0x0F, 0x1C, 0x0F,
  0x1C, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x38, 0x1E,
  0x38, 0x3C, 0x38, 0x78, 0x79, 0xF8, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0x00,
  0x38, 0x71, 0x8E, 0x1C, 0xE3, 0x8E, 0x1C, 0xC3, 0x87, 0x70, 0xE1, 0xDC,
  0x38, 0x77, 0x0E, 0x1D, 0xC3, 0x87, 0x71, 0xC1, 0xF8, 0x70, 0xEE, 0x1C,
  0x3B, 0x87, 0x0E, 0xE3, 0xC7, 0x38, 0xF1, 0xCF, 0xFC, 0xE3, 0xF3, 0xF0,
  0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x7E, 0x7E, 0x1F, 0xEF, 0xE3, 0xEE,
  0xCF, 0x78, 0xE8, 0x73, 0x0F, 0x87, 0x00, 0xF0, 0x70, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0xE0, 0xF0, 0x0E, 0x1F, 0x0C, 0xE1, 0x73, 0xCF,
  0x37, 0x7C, 0xFF, 0x7F, 0x07, 0xE7, 0xE0, 0x3C, 0x3C, 0x00, 0x1E, 0x03,
  0x8E, 0x01, 0xC7, 0x01, 0xE3, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x38, 0xF0,
  0x1C, 0x70, 0x0E, 0x38, 0x0F, 0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC7,
  0x82, 0xE1, 0xE3, 0xF0, 0xFF, 0x78, 0x7F, 0xBC, 0x0F, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x08, 0x07, 0x86, 0x0F, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0x00, 0x07, 0xE3, 0xC7, 0xFE, 0xF1, 0xFF, 0xF8, 0xF0, 0xFE, 0x38, 0x0F,
  0x0E, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x80,
  0xF8, 0x70, 0x78, 0x1C, 0x3C, 0x03, 0x1F, 0xF8, 0xE7, 0xFF, 0xF3, 0xCF,
  0xFC, 0xF0, 0x7E, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x7F, 0xC0, 0x7E, 0x00, 0x7F, 0x80,
  0x83, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0x07, 0xF8,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xFF, 0x00, 0x3F, 0x01, 0xFF, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0x01,
  0x87, 0xE0, 0x73, 0xFC, 0x18, 0xE7, 0x0E, 0x70, 0xE7, 0x9C, 0x3F, 0xCE,
  0x07, 0xE1, 0x80, 0xF0,
};

const GFXglyph IBMPlexMono_MediumItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 8, 23, 20, 6, -23 },
  { 24, 11, 10, 20, 6, -24 },
  { 38, 21, 23, 20, 0, -23 },
  { 99, 18, 29, 20, 1, -26 },
  { 165, 23, 23, 20, -1, -23 },
  { 232, 20, 23, 20, 0, -23 },
  { 290, 5, 10, 20, 9, -24 },
  { 297, 13, 30, 20, 6, -25 },
  { 346, 13, 30, 20, 1, -25 },
  { 395, 17, 16, 20, 2, -18 },
  { 429, 16, 17, 20, 2, -19 },
  { 463, 8, 10, 20, 4, -5 },
  { 473, 10, 3, 20, 5, -12 },
  { 477, 6, 5, 20, 6, -5 },
  { 481, 20, 30, 20, 0, -25 },
  { 556, 17, 23, 20, 2, -23 },
  { 605, 17, 23, 20, 1, -23 },
  { 654, 18, 23, 20, 1, -23 },
  { 706, 18, 23, 20, 1, -23 },
  { 758, 19, 23, 20, 0, -23 },
  { 813, 18, 23, 20, 1, -23 },
  { 865, 16, 23, 20, 2, -23 },
  { 911, 17, 23, 20, 3, -23 },
  { 960, 18, 23, 20, 1, -23 },
  { 1012, 16, 23, 20, 3, -23 },
  { 1058, 8, 17, 20, 6, -17 },
  { 1075, 10, 22, 20, 4, -17 },
  { 1103, 16, 19, 20, 3, -20 },
  { 1141, 17, 10, 20, 2, -15 },
  { 1163, 16, 19, 20, 2, -20 },
  { 1201, 14, 23, 20, 4, -23 },
  { 1242, 17, 27, 20, 2, -23 },
  { 1300, 19, 23, 20, -1, -23 },
  { 1355, 18, 23, 20, 1, -23 },
  { 1407, 18, 23, 20, 2, -23 },
  { 1459, 18, 23, 20, 1, -23 },
  { 1511, 19, 23, 20, 1, -23 },
  { 1566, 19, 23, 20, 1, -23 },
  { 1621, 17, 23, 20, 2, -23 },
  { 1670, 19, 23, 20, 1, -23 },
  { 1725, 19, 23, 20, 1, -23 },
  { 1780, 17, 23, 20, 2, -23 },
  { 1829, 21, 23, 20, 1, -23 },
  { 1890, 15, 23, 20, 2, -23 },
  { 1934, 20, 23, 20, 0, -23 },
  { 1992, 19, 23, 20, 1, -23 },
  { 2047, 17, 23, 20, 2, -23 },
  { 2096, 18, 23, 20, 1, -23 },
  { 2148, 17, 29, 20, 2, -23 },
  { 2210, 18, 23, 20, 1, -23 },
  { 2262, 18, 23, 20, 1, -23 },
  { 2314, 18, 23, 20, 3, -23 },
  { 2366, 18, 23, 20, 2, -23 },
  { 2418, 18, 23, 20, 3, -23 },
  { 2470, 20, 23, 20, 1, -23 },
  { 2528, 22, 23, 20, -1, -23 },
  { 2592, 19, 23, 20, 3, -23 },
  { 2647, 20, 23, 20, 0, -23 },
  { 2705, 14, 30, 20, 5, -25 },
  { 2758, 9, 30, 20, 6, -25 },
  { 2792, 14, 30, 20, 1, -25 },
  { 2845, 17, 14, 20, 2, -23 },
  { 2875, 16, 3, 20, 0, 3 },
  { 2881, 5, 7, 20, 7, -26 },
  { 2886, 16, 17, 20, 2, -17 },
  { 2920, 17, 24, 20, 1, -24 },
  { 2971, 15, 17, 20, 2, -17 },
  { 3003, 18, 24, 20, 2, -24 },
  { 3057, 16, 17, 20, 2, -17 },
  { 3091, 22, 31, 20, -1, -24 },
  { 3177, 17, 24, 20, 1, -17 },
  { 3228, 17, 24, 20, 1, -24 },
  { 3279, 15, 25, 20, 3, -25 },
  { 3326, 16, 32, 20, 1, -25 },
  { 3390, 18, 24, 20, 1, -24 },
  { 3444, 14, 24, 20, 3, -24 },
  { 3486, 19, 17, 20, 0, -17 },
  { 3527, 17, 17, 20, 1, -17 },
  { 3564, 16, 17, 20, 2, -17 },
  { 3598, 18, 24, 20, 0, -17 },
  { 3652, 16, 24, 20, 2, -17 },
  { 3700, 17, 17, 20, 3, -17 },
  { 3737, 17, 17, 20, 1, -17 },
  { 3774, 16, 23, 20, 2, -23 },
  { 3820, 16, 17, 20, 2, -17 },
  { 3854, 16, 17, 20, 2, -17 },
  { 3888, 18, 17, 20, 1, -17 },
  { 3927, 20, 17, 20, 0, -17 },
  { 3970, 17, 24, 20, 1, -17 },
  { 4021, 18, 17, 20, 1, -17 },
  { 4060, 16, 30, 20, 3, -25 },
  { 4120, 8, 30, 20, 6, -25 },
  { 4150, 16, 30, 20, 1, -25 },
  { 4210, 18, 8, 20, 1, -14 },
};

const GFXfont IBMPlexMono_MediumItalic33pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic33pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic33pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _IBMPLEXMONO_MEDIUMITALIC33PT7B_H_
