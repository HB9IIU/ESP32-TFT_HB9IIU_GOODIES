#ifndef _IBMPLEXMONO_MEDIUMITALIC70PT7B_H_
#define _IBMPLEXMONO_MEDIUMITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-MediumItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_MediumItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE,
  0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x01, 0xFC,
  0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xF8,
  0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xFC, 0x08, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xE3, 0xEF, 0xFF, 0x00, 0xFF, 0x83, 0xE1, 0xFF,
  0x01, 0xFF, 0x07, 0xE0, 0xFC, 0x01, 0xFE, 0x07, 0xC0, 0x78, 0x03, 0xFC,
  0x07, 0xC0, 0x30, 0x03, 0xFC, 0x07, 0xC0, 0x00, 0x03, 0xFC, 0x07, 0xC0,
  0x00, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x0F, 0x80, 0x00, 0x03, 0xFC, 0x0F, 0x80, 0x00, 0x03, 0xFC, 0x0F,
  0x80, 0x00, 0x03, 0xFE, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0x0F, 0x80, 0x00,
  0x01, 0xFF, 0xCF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3E,
  0x7F, 0xF0, 0x00, 0x00, 0x3E, 0x1F, 0xF0, 0x00, 0x00, 0x3E, 0x0F, 0xF8,
  0x00, 0x00, 0x3E, 0x07, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xF8, 0x00, 0x00,
  0x7C, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x03,
  0xF8, 0x00, 0x00, 0x7C, 0x07, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xF8, 0x04,
  0x00, 0xFC, 0x07, 0xF8, 0x1E, 0x00, 0xF8, 0x0F, 0xF0, 0x3F, 0x00, 0xF8,
  0x0F, 0xF0, 0x7F, 0x80, 0xF8, 0x1F, 0xE0, 0xFF, 0xE0, 0xF8, 0x7F, 0xE0,
  0x7F, 0xF8, 0xF9, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF0,
  0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF0,
  0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0,
  0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x83, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x87, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0xFF, 0x80, 0x00, 0x07,
  0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC1, 0xFC, 0x1F, 0xC0, 0x00, 0x1F,
  0xC3, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0x00, 0x3F,
  0x03, 0xF0, 0x07, 0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xFC,
  0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0xC0,
  0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7E, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x01, 0xFF, 0xE7, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xFC,
  0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x03, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0xF3, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0x00,
  0x0F, 0xF8, 0x3F, 0x9F, 0xC0, 0x06, 0xFE, 0x0F, 0xC7, 0xF8, 0x01, 0xBF,
  0x87, 0xF1, 0xFE, 0x00, 0xE7, 0xF1, 0xF8, 0x7F, 0xE0, 0xF9, 0xFC, 0xFC,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0x7F,
  0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x00, 0x3F, 0x80, 0x1C,
  0x7F, 0x01, 0xFC, 0x07, 0xE3, 0xFE, 0x0F, 0xE1, 0xFF, 0x3F, 0xFE, 0x7E,
  0x7F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE8, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFC, 0x1F, 0xC3, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0xC0,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x7C,
  0x03, 0xF9, 0xFE, 0x07, 0xF0, 0x3F, 0xDF, 0xF0, 0x7F, 0xC1, 0xFE, 0xFF,
  0x03, 0xFE, 0x0F, 0xF7, 0xF8, 0x1F, 0xE0, 0x7F, 0xBF, 0xC1, 0xFF, 0x03,
  0xFD, 0xFE, 0x07, 0xF8, 0x1F, 0xEF, 0xF0, 0x1F, 0x01, 0xFF, 0x7F, 0x80,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00,
  0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0x00, 0x01, 0xFF,
  0x9F, 0xC0, 0x00, 0xFF, 0xC7, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07,
  0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x7F, 0x80,
  0x03, 0x80, 0x1F, 0xE0, 0x00, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x00, 0x7F, 0x80, 0x08, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xF0, 0x00, 0x0F,
  0xF0, 0x03, 0x80, 0x00, 0x3F, 0xC0, 0x04, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x01, 0x80, 0x00, 0x0F, 0xF8, 0x1E,
  0x00, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x0F,
  0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xBF, 0x80, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0x83, 0xFF, 0xE0, 0x00, 0x3F,
  0x1F, 0xFF, 0xE0, 0x00, 0x7E, 0x7F, 0xFF, 0xE0, 0x01, 0xFD, 0xFF, 0xFF,
  0xE0, 0x03, 0xF7, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x01, 0x80, 0x00, 0x0F, 0xF8, 0x07, 0x80, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFF, 0x80,
  0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC3,
  0xFF, 0xC0, 0x1F, 0xE3, 0xFF, 0xFC, 0x0F, 0xF9, 0xFF, 0xFF, 0x83, 0xFC,
  0xFF, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0xFC, 0x7F, 0xBE, 0x03, 0xFF, 0x9F,
  0xFC, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x87, 0xE0, 0x00, 0x03, 0xFC, 0x7F,
  0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x01, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0x00,
  0x00, 0xFF, 0x83, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00,
  0xFF, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0xFF, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xE1,
  0xFE, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x1F,
  0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0x1F, 0xDF, 0xE0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF,
  0xDF, 0xE0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x03,
  0xFF, 0xC7, 0xFF, 0x01, 0xF7, 0xF0, 0xFF, 0xFF, 0xFD, 0xFE, 0x0F, 0xFF,
  0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0xCF, 0xF0, 0x0F, 0xFF, 0xF1, 0xFE, 0x00,
  0xFF, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x07, 0xFC, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x7F,
  0xC0, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xF9, 0xF0,
  0x00, 0x0F, 0xF0, 0x60, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x07, 0xE1, 0xF8, 0x03, 0xFE, 0x3F,
  0x0F, 0xC0, 0x3F, 0xF9, 0xF8, 0xFE, 0x03, 0xFF, 0xCF, 0xC7, 0xF0, 0x3F,
  0xFF, 0xFE, 0x3F, 0x03, 0xFC, 0x1F, 0xF1, 0xF8, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC1, 0xFC, 0x03, 0xF8, 0xFE, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0xFE, 0x00,
  0x7E, 0x3F, 0x07, 0xF0, 0x03, 0xF1, 0xF8, 0x3F, 0x00, 0x3F, 0x9F, 0xC1,
  0xF8, 0x01, 0xF8, 0xFE, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0, 0xFE, 0x00, 0x7E,
  0x3F, 0x07, 0xF0, 0x03, 0xF1, 0xF8, 0x3F, 0x80, 0x3F, 0x8F, 0xC1, 0xF8,
  0x01, 0xFC, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x7E, 0x00, 0x7E, 0x1F,
  0x83, 0xF0, 0x07, 0xF1, 0xFC, 0x1F, 0x80, 0x3F, 0x8F, 0xE0, 0xFE, 0x03,
  0xFC, 0x7E, 0x07, 0xF0, 0x3F, 0xE3, 0xF0, 0x3F, 0xC7, 0xFE, 0x1F, 0x80,
  0xFF, 0xFB, 0xF0, 0xFC, 0x07, 0xFF, 0xDF, 0x87, 0xE0, 0x3F, 0xFC, 0xFC,
  0x1F, 0x80, 0xFF, 0xC7, 0xE0, 0xFC, 0x03, 0xFC, 0x7F, 0x07, 0xE0, 0x07,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xC0,
  0x01, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x07, 0xE1, 0xFE, 0x00, 0x00, 0x60, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x30, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0xFF, 0x00,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0xFC, 0x01, 0xFC,
  0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0xC3, 0xF8, 0x00,
  0x03, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03,
  0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x1F,
  0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F,
  0x0F, 0xF0, 0x00, 0x07, 0xE0, 0xFF, 0x00, 0x00, 0x60, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x03, 0xFF, 0xFC, 0xFF, 0x80, 0x3F, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0xFC,
  0xFF, 0x00, 0x7F, 0xFF, 0xCF, 0xF0, 0x07, 0xFF, 0xFC, 0xFF, 0x00, 0x7F,
  0xFF, 0xCF, 0xF0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0x8F, 0xF0,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x03, 0xF8,
  0xFF, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x3F, 0xF8, 0x1E, 0xFE, 0x01, 0xFF, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xFC,
  0xFE, 0x00, 0xFF, 0xFF, 0x8F, 0xE0, 0x07, 0xFF, 0xF0, 0xFE, 0x00, 0x1F,
  0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x0F, 0x80, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x00,
  0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xC3, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE7, 0xFC,
  0x00, 0x00, 0x03, 0xFD, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x9F, 0xE0, 0x00, 0x01, 0xFF,
  0xE3, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xE0, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0,
  0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xFB, 0xF0, 0x3F, 0x7F, 0x00, 0xFE,
  0xFC, 0x1F, 0xDF, 0xC0, 0x3F, 0x3F, 0x07, 0xE7, 0xF0, 0x0F, 0xC7, 0xE3,
  0xF9, 0xFC, 0x07, 0xF1, 0xF8, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x7E, 0x1F,
  0x80, 0x7F, 0x1F, 0x9F, 0x8F, 0xE0, 0x1F, 0xC7, 0xEF, 0xC3, 0xF8, 0x07,
  0xE0, 0xFF, 0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0xF8, 0x3F, 0x80, 0xFE, 0x0F,
  0xFE, 0x0F, 0xC0, 0x3F, 0x83, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1,
  0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x38, 0x03, 0xF8, 0x07, 0xE0, 0x06, 0x00, 0xFE,
  0x03, 0xF8, 0x01, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x80, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x00,
  0xFF, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xF0,
  0x00, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFE,
  0x01, 0xFF, 0xF0, 0x00, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFC, 0x01, 0xFF,
  0xF8, 0x01, 0xFC, 0x03, 0xFB, 0xF8, 0x01, 0xFC, 0x03, 0xFB, 0xF8, 0x01,
  0xFC, 0x03, 0xF9, 0xF8, 0x01, 0xFC, 0x03, 0xF9, 0xF8, 0x01, 0xFC, 0x03,
  0xF9, 0xFC, 0x01, 0xF8, 0x03, 0xF1, 0xFC, 0x03, 0xF8, 0x07, 0xF1, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x07, 0xE0,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x1F, 0x80,
  0x1F, 0x9F, 0xC0, 0x3F, 0x80, 0x1F, 0xDF, 0xC0, 0x3F, 0x80, 0x1F, 0xDF,
  0xC0, 0x3F, 0x80, 0x1F, 0xDF, 0xC0, 0x3F, 0x80, 0x0F, 0xFF, 0xC0, 0x3F,
  0x80, 0x0F, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0x00, 0x0F,
  0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xFF, 0x80,
  0x7F, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7E, 0x00,
  0x07, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x3F,
  0xDF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xDF,
  0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xF0,
  0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F,
  0x9F, 0xC0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xE7, 0xF0, 0x00,
  0x01, 0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x8F,
  0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x01, 0xFF, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x0F,
  0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xC7,
  0xF8, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xE7, 0xF8,
  0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x3F,
  0xDF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xEF,
  0xF0, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00,
  0x7F, 0x9F, 0xC0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xE7, 0xF0,
  0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x7F,
  0x8F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFF, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x02, 0x00, 0x00, 0x7F, 0x80, 0x38, 0x00, 0x03, 0xFC, 0x03, 0xF0,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xE0, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0x78, 0x01, 0xFE, 0x00, 0x00, 0x30, 0x03, 0xFC, 0x00, 0x00, 0x20, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x04, 0x00, 0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0xF0,
  0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00,
  0xFF, 0x3F, 0x80, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x03, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0x7F, 0x80, 0x7E, 0x07, 0xF0, 0x1F, 0xF0, 0x1F,
  0xC0, 0xFE, 0x03, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0xC0, 0x7E, 0x03,
  0xF8, 0x1F, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xEF,
  0x81, 0xF8, 0x07, 0xE0, 0xFD, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x3E, 0x0F,
  0xE0, 0x3F, 0x83, 0xE7, 0xC1, 0xF8, 0x07, 0xF0, 0xFC, 0xF8, 0x3F, 0x00,
  0xFE, 0x1F, 0x1F, 0x07, 0xE0, 0x1F, 0xC3, 0xE3, 0xE1, 0xFC, 0x03, 0xF8,
  0xFC, 0x7C, 0x3F, 0x80, 0x7E, 0x1F, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xE1,
  0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x3E, 0x1F, 0x80, 0x3F, 0x1F, 0x07, 0xC7,
  0xF0, 0x07, 0xE3, 0xE0, 0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x1F, 0x1F, 0x80,
  0x3F, 0x9F, 0x03, 0xF3, 0xF0, 0x07, 0xF3, 0xE0, 0x7E, 0xFE, 0x00, 0xFE,
  0xFC, 0x0F, 0xDF, 0x80, 0x1F, 0xDF, 0x01, 0xFB, 0xF0, 0x03, 0xF3, 0xE0,
  0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC1,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x00,
  0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x04, 0x03, 0xC1, 0xF8, 0x7F, 0x0F,
  0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7C,
  0x0F, 0xC0, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0xFF,
  0x00, 0x7F, 0xFF, 0x0F, 0xE0, 0x0F, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xFF,
  0xDF, 0xE0, 0x3F, 0xFF, 0xFD, 0xFE, 0x07, 0xFF, 0x03, 0xDF, 0xE0, 0xFF,
  0xC0, 0x0F, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07,
  0xFE, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xC0, 0x1D, 0xFE, 0x07, 0xFE,
  0x07, 0xDF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFE,
  0x1F, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xFE, 0x00, 0x7F,
  0x87, 0xFF, 0xF0, 0x07, 0xF8, 0xFF, 0xFF, 0x80, 0x7F, 0x9F, 0xFF, 0xF8,
  0x07, 0xFB, 0xFF, 0xFF, 0xC0, 0x7F, 0x3E, 0x0F, 0xFC, 0x07, 0xF7, 0x80,
  0x3F, 0xE0, 0xFF, 0x60, 0x01, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0xFF,
  0xC0, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x78, 0x0F,
  0xFE, 0x07, 0xF7, 0xFF, 0xFF, 0xC0, 0xFF, 0x3F, 0xFF, 0xF8, 0x0F, 0xF1,
  0xFF, 0xFF, 0x00, 0xFF, 0x1F, 0xFF, 0xE0, 0x0F, 0xE0, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7C, 0x3F, 0xC0, 0x00,
  0x30, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x30, 0xFE, 0x00, 0x00,
  0x78, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xFE, 0x07, 0xF0,
  0x00, 0xFF, 0xFF, 0x1F, 0xE0, 0x03, 0xFF, 0xFE, 0x3F, 0xC0, 0x0F, 0xFF,
  0xFE, 0x7F, 0x80, 0x3F, 0xFF, 0xFE, 0xFE, 0x00, 0xFF, 0xE0, 0x3D, 0xFC,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x07,
  0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x03, 0xDF, 0xC0, 0x0F, 0xFC, 0x1F,
  0x3F, 0x80, 0x1F, 0xFF, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0xF9, 0xFE, 0x00,
  0x3F, 0xFF, 0xE3, 0xFC, 0x00, 0x3F, 0xFF, 0x87, 0xF0, 0x00, 0x3F, 0xFE,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x07,
  0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xFD, 0xFE, 0x00,
  0x1F, 0xFC, 0xFF, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x20, 0x7F, 0x00, 0x00, 0x18, 0x3F, 0x80, 0x00, 0x1F, 0x1F,
  0xE0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x1F, 0xE1,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x10, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x1F, 0xC0, 0x0F, 0xFF, 0xF1, 0xFE, 0x00, 0xFF, 0xFF,
  0xCF, 0xF0, 0x0F, 0xFF, 0xFE, 0x7F, 0x80, 0xFF, 0xFF, 0xFB, 0xF8, 0x0F,
  0xFE, 0x03, 0xDF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xE0,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0x80,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xE0,
  0x7F, 0x80, 0x03, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xF0, 0x07,
  0xBF, 0x80, 0x7F, 0xE0, 0xF9, 0xFC, 0x03, 0xFF, 0xFF, 0xCF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x7F, 0x00, 0x7F, 0xFF, 0xC7, 0xF8, 0x01, 0xFF, 0xFC, 0x3F,
  0xC0, 0x03, 0xFF, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x02, 0x00, 0x01,
  0xFE, 0x00, 0x38, 0x00, 0x0F, 0xF0, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xFC, 0x00, 0xFE, 0x1F, 0xFF,
  0x80, 0x3F, 0x87, 0xFF, 0xF0, 0x0F, 0xE3, 0xFF, 0xFE, 0x07, 0xF9, 0xFF,
  0xFF, 0x81, 0xFE, 0xF8, 0x3F, 0xF0, 0x7F, 0xB8, 0x07, 0xFC, 0x1F, 0xDC,
  0x00, 0xFF, 0x07, 0xF6, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xF0, 0xFF,
  0x80, 0x01, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF0, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xC0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFE,
  0x1F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x60, 0x01, 0xFE, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x0F,
  0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x80, 0x03,
  0xF8, 0xFF, 0x80, 0x01, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x60, 0x01, 0xFE,
  0x00, 0x3C, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F,
  0xF8, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03,
  0xFC, 0x1F, 0xFE, 0x00, 0x1F, 0xC1, 0xFF, 0xF8, 0x00, 0xFE, 0x1F, 0xFF,
  0xE0, 0x07, 0xF1, 0xFF, 0xFF, 0x00, 0x7F, 0x9F, 0xFF, 0xFC, 0x03, 0xFD,
  0xF0, 0x7F, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0xE0, 0x07, 0xF8,
  0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x00, 0xFE, 0x03, 0xFE, 0x00,
  0x07, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x0F, 0xFC, 0x00, 0x3F, 0x81, 0xFF, 0x80, 0x01, 0xFC, 0x7F, 0xE0, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x41, 0xFC, 0x0F, 0xF0, 0x07, 0x8F,
  0xE0, 0x7F, 0x80, 0x7E, 0x7F, 0x01, 0xFC, 0x0F, 0xF7, 0xF8, 0x0F, 0xF0,
  0xFF, 0x3F, 0xC0, 0x3F, 0x8F, 0xF1, 0xFE, 0x01, 0xFE, 0xFF, 0x0F, 0xE0,
  0x0F, 0xFF, 0xF0, 0x7F, 0x00, 0x3F, 0xFF, 0x03, 0xF8, 0x01, 0xFF, 0xF0,
  0x3F, 0xC0, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x60, 0x0F, 0xE0,
  0x07, 0xC0, 0x3F, 0x80, 0x3F, 0x81, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x0F,
  0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0x03, 0xFE, 0x01, 0xFC, 0x1F, 0xF0,
  0x07, 0xF0, 0xFF, 0x80, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x01, 0xF8, 0x01, 0xFC, 0x7F, 0x81, 0xFF, 0x00, 0xFC, 0x7F, 0xE3,
  0xFF, 0x80, 0x7E, 0x7F, 0xF1, 0xFF, 0xE0, 0x3F, 0x7F, 0xF9, 0xFF, 0xF0,
  0x3F, 0xBF, 0xFD, 0xFF, 0xF8, 0x1F, 0xF8, 0xFE, 0xE1, 0xFE, 0x0F, 0xF0,
  0x3F, 0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x3F, 0x00,
  0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x80,
  0x7E, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x83,
  0xF0, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x01,
  0xF8, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x0F,
  0xC0, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F,
  0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x3F,
  0x00, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0x87, 0xFF, 0xE0, 0x0F, 0xE1, 0xFF,
  0xFC, 0x03, 0xF8, 0xFF, 0xFF, 0x81, 0xFE, 0x7F, 0xFF, 0xE0, 0x7F, 0xBE,
  0x0F, 0xFC, 0x1F, 0xEE, 0x01, 0xFF, 0x07, 0xF7, 0x00, 0x3F, 0xC1, 0xFD,
  0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x0F,
  0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xFC,
  0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0xFF, 0x3F, 0x80, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0x01, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFB,
  0xF8, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x1F,
  0xCF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xC0,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x07,
  0xFF, 0x80, 0x01, 0xFC, 0x3F, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0xFF, 0x80,
  0x0F, 0xF3, 0xFF, 0xFF, 0x00, 0x1F, 0xEF, 0xFF, 0xFF, 0x00, 0x3F, 0x9F,
  0x07, 0xFE, 0x00, 0x7F, 0x78, 0x03, 0xFE, 0x00, 0xFE, 0xC0, 0x03, 0xFC,
  0x03, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x07,
  0xF7, 0x80, 0xFF, 0xE0, 0x0F, 0xEF, 0xFF, 0xFF, 0x80, 0x3F, 0xCF, 0xFF,
  0xFE, 0x00, 0x7F, 0x8F, 0xFF, 0xF8, 0x00, 0xFF, 0x1F, 0xFF, 0xE0, 0x01,
  0xFC, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0x00, 0x7F,
  0xFF, 0x8F, 0xF0, 0x0F, 0xFF, 0xF8, 0xFF, 0x01, 0xFF, 0xFF, 0xCF, 0xF0,
  0x3F, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0x01, 0xEF, 0xE0, 0x7F, 0xC0, 0x07,
  0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xE0,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x80,
  0x00, 0x3F, 0x87, 0xF8, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x01, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0x80, 0x07, 0xFF, 0x07,
  0xF8, 0x00, 0xEF, 0xE0, 0x7F, 0xC0, 0x1E, 0xFE, 0x03, 0xFF, 0x07, 0xCF,
  0xE0, 0x3F, 0xFF, 0xFD, 0xFE, 0x03, 0xFF, 0xFF, 0x9F, 0xE0, 0x1F, 0xFF,
  0xF1, 0xFE, 0x00, 0xFF, 0xFE, 0x1F, 0xC0, 0x07, 0xFF, 0x81, 0xFC, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xEF, 0xFF, 0xF8, 0x1F, 0xF9,
  0xFF, 0xFF, 0x0F, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0xF8, 0xFF,
  0xFD, 0xFF, 0xFF, 0x1F, 0xFF, 0x80, 0x1F, 0xE7, 0xFF, 0xF0, 0x03, 0xFD,
  0xFF, 0xFC, 0x00, 0x7F, 0xBE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFD, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x00, 0xF8, 0x07, 0xF8, 0x00, 0x0E, 0x00, 0xFE, 0x00, 0x00,
  0x80, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x04, 0x00, 0x00, 0x3F, 0x81, 0xC0, 0x00, 0x0F, 0xF0,
  0x7C, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xFF, 0x80, 0x7F,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x02, 0x00, 0x3F, 0xC0, 0x03, 0x80, 0x1F, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xF8, 0x0F,
  0xFC, 0x03, 0xFC, 0x0F, 0xFC, 0x01, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x1F,
  0xF8, 0x00, 0x7F, 0x9F, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFE,
  0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0x80, 0x01, 0xFF, 0x0F, 0xE0, 0x00,
  0xFF, 0xC3, 0xFC, 0x00, 0x6F, 0xE0, 0xFF, 0x00, 0x3B, 0xF8, 0x3F, 0xE0,
  0x1D, 0xFE, 0x0F, 0xFC, 0x1F, 0x7F, 0x81, 0xFF, 0xFF, 0x9F, 0xE0, 0x7F,
  0xFF, 0xC7, 0xF8, 0x0F, 0xFF, 0xF1, 0xFC, 0x01, 0xFF, 0xF8, 0x7F, 0x00,
  0x3F, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x1F, 0xFF, 0x80, 0x07, 0xC7, 0xFF, 0xE0, 0x0F, 0xFB, 0xFF, 0xF8,
  0x01, 0xFE, 0xFF, 0xFE, 0x00, 0x7F, 0xBF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03,
  0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x3F, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0,
  0x07, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0x9F, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x1F, 0x80, 0x7E, 0x07,
  0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0x3F, 0x81, 0xF8, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x1F,
  0xC3, 0xF0, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x7F, 0x00,
  0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x03, 0xF3, 0xF8, 0x07,
  0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0xFE, 0x01, 0xFC,
  0xFC, 0x03, 0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F,
  0x00, 0x7E, 0x7F, 0x00, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF0, 0x07, 0xE7,
  0xE0, 0x1F, 0xC0, 0x3F, 0x9F, 0x80, 0x7F, 0x00, 0xFC, 0x7E, 0x01, 0xF8,
  0x03, 0xF1, 0xF8, 0x07, 0xE0, 0x0F, 0xCF, 0xE0, 0x1F, 0x80, 0x7E, 0x3F,
  0x80, 0xFE, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0x0F, 0xE3, 0xF8, 0x1F, 0xE0,
  0x3F, 0x0F, 0xE0, 0xEF, 0x81, 0xFC, 0x3F, 0xC7, 0xBE, 0x0F, 0xE0, 0xFF,
  0xFC, 0xFC, 0x7F, 0x03, 0xFF, 0xF3, 0xFF, 0xF8, 0x07, 0xFF, 0x8F, 0xFF,
  0xC0, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x7F,
  0xFE, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0,
  0x7F, 0xE7, 0xE3, 0xE3, 0xFC, 0x3F, 0xF1, 0xF9, 0xE0, 0x7F, 0x1F, 0xF0,
  0x7E, 0x70, 0x1F, 0xC3, 0xF8, 0x1F, 0xDC, 0x07, 0xF0, 0xF8, 0x07, 0xFE,
  0x01, 0xFC, 0x1C, 0x00, 0xFF, 0x80, 0x7F, 0x04, 0x00, 0x3F, 0xC0, 0x1F,
  0xC0, 0x00, 0x1F, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x04, 0x0F, 0xE0, 0x1D, 0xF8,
  0x03, 0x83, 0xF8, 0x07, 0x7E, 0x03, 0xF0, 0xFE, 0x03, 0xDF, 0x81, 0xFE,
  0x3F, 0x80, 0xE7, 0xE0, 0xFF, 0x8F, 0xE0, 0x79, 0xF8, 0xFF, 0xC3, 0xFC,
  0x3C, 0x7E, 0x7F, 0xE0, 0x7F, 0xFF, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x87,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xFC,
  0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F,
  0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x6F,
  0xE0, 0x0F, 0xF8, 0x07, 0x3F, 0x80, 0x1F, 0xF0, 0x3D, 0xFE, 0x00, 0x7F,
  0xFF, 0xE7, 0xF8, 0x01, 0xFF, 0xFF, 0x9F, 0xE0, 0x03, 0xFF, 0xFC, 0x7F,
  0x80, 0x07, 0xFF, 0xE1, 0xFC, 0x00, 0x0F, 0xFF, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x20, 0x00, 0x0F, 0xF0, 0x00, 0xC0, 0x00, 0x7F, 0xC0,
  0x07, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x1F,
  0xC0, 0x7F, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xE0, 0x7F, 0xFF,
  0xFE, 0x7F, 0x03, 0xFF, 0xFF, 0xFB, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0xC1,
  0xFC, 0x00, 0xFF, 0xFE, 0x0F, 0xC0, 0x01, 0xFF, 0xC0, 0x7E, 0x00, 0x03,
  0xFC, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0x07, 0xFC, 0x01, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0x00, 0x00, 0xFF, 0x80,
  0x3C, 0x00, 0x1F, 0xF0, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x1F,
  0xF0, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0x1F, 0xF0, 0x00, 0x1F,
  0x81, 0xFF, 0x00, 0x00, 0xFC, 0x1F, 0xFF, 0x80, 0x07, 0xE1, 0xFF, 0xFF,
  0xE0, 0x3F, 0x1F, 0xFF, 0xFF, 0xF9, 0xF8, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7,
  0xF0, 0x7F, 0xFF, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0xE1, 0xFC, 0x00, 0xFF,
  0xFE, 0x0F, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x60, 0x03, 0xFF, 0x00, 0x03, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xC0,
  0xFF, 0xFC, 0x00, 0x3F, 0x07, 0xFF, 0xF8, 0x01, 0xF8, 0x3F, 0xFF, 0xE0,
  0x07, 0xE0, 0xFE, 0x3F, 0xC0, 0x3F, 0x87, 0xF0, 0x7F, 0x80, 0xFC, 0x1F,
  0x80, 0xFE, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x83, 0xF0, 0x07, 0xFF,
  0xFE, 0x1F, 0xC0, 0x0F, 0xFF, 0xF0, 0x7E, 0x00, 0x1F, 0xFF, 0x81, 0xF8,
  0x00, 0x3F, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0x00, 0x00, 0x7E,
  0x00,
};

const GFXglyph IBMPlexMono_MediumItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 17, 50, 42, 13, -49 },
  { 108, 24, 21, 42, 13, -52 },
  { 171, 44, 49, 42, 0, -49 },
  { 441, 40, 65, 42, 1, -57 },
  { 766, 48, 51, 42, -2, -50 },
  { 1072, 42, 51, 42, 0, -50 },
  { 1340, 10, 21, 42, 20, -52 },
  { 1367, 28, 63, 42, 13, -53 },
  { 1588, 28, 63, 42, 2, -53 },
  { 1809, 37, 35, 42, 3, -38 },
  { 1971, 35, 34, 42, 4, -38 },
  { 2120, 17, 21, 42, 9, -11 },
  { 2165, 23, 8, 42, 10, -25 },
  { 2188, 12, 11, 42, 13, -10 },
  { 2205, 41, 63, 42, 1, -53 },
  { 2528, 37, 51, 42, 4, -50 },
  { 2764, 34, 49, 42, 3, -49 },
  { 2973, 37, 50, 42, 2, -50 },
  { 3205, 38, 51, 42, 1, -50 },
  { 3448, 38, 49, 42, 1, -49 },
  { 3681, 39, 50, 42, 2, -49 },
  { 3925, 34, 50, 42, 4, -49 },
  { 4138, 37, 49, 42, 6, -49 },
  { 4365, 38, 51, 42, 2, -50 },
  { 4608, 35, 50, 42, 5, -50 },
  { 4827, 16, 37, 42, 13, -36 },
  { 4901, 20, 46, 42, 9, -36 },
  { 5016, 34, 41, 42, 6, -42 },
  { 5191, 37, 21, 42, 3, -32 },
  { 5289, 34, 41, 42, 3, -42 },
  { 5464, 31, 51, 42, 8, -50 },
  { 5662, 37, 58, 42, 3, -50 },
  { 5931, 39, 49, 42, -1, -49 },
  { 6170, 36, 49, 42, 3, -49 },
  { 6391, 36, 51, 42, 5, -50 },
  { 6621, 37, 49, 42, 3, -49 },
  { 6848, 39, 49, 42, 3, -49 },
  { 7087, 39, 49, 42, 3, -49 },
  { 7326, 36, 51, 42, 4, -50 },
  { 7556, 40, 49, 42, 2, -49 },
  { 7801, 39, 49, 42, 3, -49 },
  { 8040, 37, 50, 42, 3, -49 },
  { 8272, 43, 49, 42, 3, -49 },
  { 8536, 31, 49, 42, 5, -49 },
  { 8726, 42, 49, 42, 1, -49 },
  { 8984, 40, 49, 42, 2, -49 },
  { 9229, 37, 51, 42, 4, -50 },
  { 9465, 38, 49, 42, 3, -49 },
  { 9698, 37, 63, 42, 4, -50 },
  { 9990, 38, 49, 42, 3, -49 },
  { 10223, 40, 51, 42, 1, -50 },
  { 10478, 39, 49, 42, 6, -49 },
  { 10717, 38, 50, 42, 4, -49 },
  { 10955, 38, 49, 42, 7, -49 },
  { 11188, 43, 49, 42, 2, -49 },
  { 11452, 47, 49, 42, -2, -49 },
  { 11740, 40, 49, 42, 6, -49 },
  { 11985, 43, 49, 42, 0, -49 },
  { 12249, 31, 63, 42, 10, -53 },
  { 12494, 19, 63, 42, 12, -53 },
  { 12644, 31, 63, 42, 1, -53 },
  { 12889, 36, 30, 42, 4, -49 },
  { 13024, 34, 6, 42, 0, 6 },
  { 13050, 11, 15, 42, 15, -56 },
  { 13071, 36, 38, 42, 3, -37 },
  { 13242, 36, 53, 42, 3, -52 },
  { 13481, 32, 38, 42, 5, -37 },
  { 13633, 39, 53, 42, 3, -52 },
  { 13892, 33, 38, 42, 5, -37 },
  { 14049, 47, 67, 42, -2, -52 },
  { 14443, 37, 52, 42, 2, -37 },
  { 14684, 34, 52, 42, 3, -52 },
  { 14905, 33, 54, 42, 5, -53 },
  { 15128, 34, 68, 42, 3, -53 },
  { 15417, 37, 53, 42, 3, -52 },
  { 15663, 30, 53, 42, 7, -52 },
  { 15862, 41, 37, 42, 0, -37 },
  { 16052, 34, 37, 42, 3, -37 },
  { 16210, 34, 38, 42, 4, -37 },
  { 16372, 39, 51, 42, 0, -37 },
  { 16621, 36, 51, 42, 3, -37 },
  { 16851, 35, 36, 42, 7, -36 },
  { 17009, 35, 38, 42, 3, -37 },
  { 17176, 33, 50, 42, 5, -49 },
  { 17383, 34, 37, 42, 5, -36 },
  { 17541, 34, 38, 42, 4, -37 },
  { 17703, 38, 38, 42, 2, -37 },
  { 17884, 42, 38, 42, 0, -37 },
  { 18084, 38, 51, 42, 1, -36 },
  { 18327, 37, 38, 42, 3, -37 },
  { 18503, 34, 63, 42, 7, -53 },
  { 18771, 17, 63, 42, 13, -53 },
  { 18905, 34, 63, 42, 2, -53 },
  { 19173, 38, 16, 42, 2, -29 },
};

const GFXfont IBMPlexMono_MediumItalic70pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_MediumItalic70pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_MediumItalic70pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _IBMPLEXMONO_MEDIUMITALIC70PT7B_H_
