#ifndef _ROBOTOMONO_LIGHT9PT7B_H_
#define _ROBOTOMONO_LIGHT9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x2B, 0xD5, 0xF5, 0x28, 0x69, 0x84, 0x39, 0xA4, 0xF5,
  0x98, 0x75, 0x8C, 0xEA, 0x4D, 0xBF, 0xC0, 0x6A, 0xAA, 0x40, 0xC8, 0x92,
  0x4A, 0xC0, 0x4F, 0x6A, 0x44, 0xF4, 0xC0, 0xE0, 0x80, 0x24, 0xA5, 0x20,
  0xF9, 0xBD, 0x9E, 0xD5, 0x50, 0xF0, 0x84, 0x44, 0x7C, 0xF1, 0x31, 0x97,
  0x11, 0x94, 0xAB, 0x88, 0xF8, 0xE1, 0x9E, 0xE8, 0xE9, 0x9E, 0xF2, 0x24,
  0x48, 0xF9, 0x69, 0x9E, 0xE9, 0x9F, 0x16, 0x88, 0x40, 0xA0, 0x34, 0xC3,
  0xFF, 0x86, 0x78, 0xF1, 0x24, 0x04, 0x7D, 0xF7, 0xBB, 0x38, 0x21, 0x94,
  0xE4, 0xC4, 0xF9, 0xE9, 0x9E, 0xF9, 0x88, 0x9E, 0xE9, 0x99, 0x9E, 0xF8,
  0xE8, 0x8F, 0xF8, 0xE8, 0x88, 0xF8, 0x8B, 0x9F, 0x99, 0xF9, 0x99, 0xF4,
  0x44, 0x4F, 0x08, 0x42, 0x18, 0xB8, 0xBA, 0xCA, 0xA9, 0x88, 0x88, 0x8F,
  0x9B, 0xBD, 0x99, 0x99, 0xDB, 0xB9, 0xF9, 0x99, 0x9E, 0xF9, 0x9E, 0x88,
  0x7C, 0x63, 0x18, 0xB8, 0x20, 0xF9, 0x9E, 0xA9, 0xF8, 0x43, 0x9E, 0xF9,
  0x08, 0x42, 0x10, 0x99, 0x99, 0x9E, 0x8A, 0x54, 0xA2, 0x10, 0xAD, 0x56,
  0xB5, 0x28, 0x4A, 0x88, 0x65, 0x64, 0xCA, 0x88, 0x42, 0x10, 0xF2, 0x44,
  0x8F, 0xEA, 0xAB, 0x89, 0x22, 0x48, 0xFF, 0x56, 0x80, 0xF0, 0xC0, 0xE9,
  0x79, 0xF0, 0x88, 0xE9, 0x99, 0xE0, 0x69, 0x89, 0xE0, 0x11, 0x79, 0x99,
  0xF0, 0x69, 0xF8, 0xF0, 0x34, 0xF4, 0x44, 0x40, 0x79, 0x99, 0xF1, 0xE0,
  0x88, 0xE9, 0x99, 0x90, 0x4C, 0x44, 0x4F, 0x3C, 0x92, 0x4E, 0x88, 0x9E,
  0xCA, 0x90, 0xC4, 0x44, 0x44, 0xF0, 0xFD, 0x6B, 0x5A, 0x80, 0xE9, 0x99,
  0x90, 0x69, 0x99, 0xE0, 0xE9, 0x99, 0xE8, 0x80, 0x79, 0x99, 0xF1, 0x10,
  0xF2, 0x48, 0x69, 0x61, 0xE0, 0x4E, 0x44, 0x47, 0x99, 0x99, 0xF0, 0x8A,
  0x54, 0x62, 0x00, 0xAD, 0x6A, 0xA5, 0x00, 0x9A, 0x46, 0x90, 0x8A, 0x54,
  0x62, 0x11, 0x00, 0xF2, 0x48, 0xF0, 0x29, 0x28, 0x91, 0x20, 0xFE, 0xC9,
  0x22, 0x92, 0x80, 0xF8,
};

const GFXglyph RobotoMono_Light9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 2, 5, 2, -7 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 8, 5, 1, -7 },
  { 11, 5, 6, 5, 0, -6 },
  { 15, 4, 6, 5, 1, -6 },
  { 18, 1, 2, 5, 2, -7 },
  { 19, 2, 9, 5, 2, -7 },
  { 22, 3, 9, 5, 1, -7 },
  { 26, 4, 4, 5, 1, -6 },
  { 28, 4, 4, 5, 1, -5 },
  { 30, 1, 2, 5, 2, -1 },
  { 31, 3, 1, 5, 1, -3 },
  { 32, 1, 1, 5, 2, -1 },
  { 33, 3, 7, 5, 1, -6 },
  { 36, 4, 6, 5, 1, -6 },
  { 39, 2, 6, 5, 1, -6 },
  { 41, 5, 6, 5, 0, -6 },
  { 45, 4, 6, 5, 0, -6 },
  { 48, 5, 6, 5, 0, -6 },
  { 52, 4, 6, 5, 1, -6 },
  { 55, 4, 6, 5, 1, -6 },
  { 58, 4, 6, 5, 1, -6 },
  { 61, 4, 6, 5, 1, -6 },
  { 64, 4, 6, 5, 1, -6 },
  { 67, 1, 5, 5, 3, -5 },
  { 68, 2, 6, 5, 2, -5 },
  { 70, 4, 4, 5, 1, -5 },
  { 72, 4, 2, 5, 1, -4 },
  { 73, 4, 4, 5, 1, -5 },
  { 75, 4, 6, 5, 1, -6 },
  { 78, 5, 6, 5, 0, -6 },
  { 82, 5, 6, 5, 0, -6 },
  { 86, 4, 6, 5, 1, -6 },
  { 89, 4, 6, 5, 1, -6 },
  { 92, 4, 6, 5, 1, -6 },
  { 95, 4, 6, 5, 1, -6 },
  { 98, 4, 6, 5, 1, -6 },
  { 101, 4, 6, 5, 1, -6 },
  { 104, 4, 6, 5, 1, -6 },
  { 107, 4, 6, 5, 1, -6 },
  { 110, 5, 6, 5, 0, -6 },
  { 114, 4, 6, 5, 1, -6 },
  { 117, 4, 6, 5, 1, -6 },
  { 120, 4, 6, 5, 1, -6 },
  { 123, 4, 6, 5, 1, -6 },
  { 126, 4, 6, 5, 1, -6 },
  { 129, 4, 6, 5, 1, -6 },
  { 132, 5, 7, 5, 0, -6 },
  { 137, 4, 6, 5, 1, -6 },
  { 140, 4, 6, 5, 1, -6 },
  { 143, 5, 6, 5, 0, -6 },
  { 147, 4, 6, 5, 1, -6 },
  { 150, 5, 6, 5, 0, -6 },
  { 154, 5, 6, 5, 0, -6 },
  { 158, 5, 6, 5, 0, -6 },
  { 162, 5, 6, 5, 0, -6 },
  { 166, 4, 6, 5, 1, -6 },
  { 169, 2, 8, 5, 2, -7 },
  { 171, 3, 7, 5, 1, -6 },
  { 174, 1, 8, 5, 2, -7 },
  { 175, 3, 3, 5, 1, -6 },
  { 177, 4, 1, 5, 1, 0 },
  { 178, 1, 2, 5, 2, -7 },
  { 179, 4, 5, 5, 1, -5 },
  { 182, 4, 7, 5, 1, -7 },
  { 186, 4, 5, 5, 1, -5 },
  { 189, 4, 7, 5, 1, -7 },
  { 193, 4, 5, 5, 1, -5 },
  { 196, 4, 7, 5, 1, -7 },
  { 200, 4, 7, 5, 1, -5 },
  { 204, 4, 7, 5, 1, -7 },
  { 208, 4, 6, 5, 1, -6 },
  { 211, 3, 8, 5, 1, -6 },
  { 214, 4, 7, 5, 1, -7 },
  { 218, 4, 7, 5, 1, -7 },
  { 222, 5, 5, 5, 0, -5 },
  { 226, 4, 5, 5, 1, -5 },
  { 229, 4, 5, 5, 1, -5 },
  { 232, 4, 7, 5, 1, -5 },
  { 236, 4, 7, 5, 1, -5 },
  { 240, 3, 5, 5, 2, -5 },
  { 242, 4, 5, 5, 1, -5 },
  { 245, 4, 6, 5, 1, -6 },
  { 248, 4, 5, 5, 1, -5 },
  { 251, 5, 5, 5, 0, -5 },
  { 255, 5, 5, 5, 0, -5 },
  { 259, 4, 5, 5, 1, -5 },
  { 262, 5, 7, 5, 0, -5 },
  { 267, 4, 5, 5, 1, -5 },
  { 270, 3, 9, 5, 1, -7 },
  { 274, 1, 7, 5, 2, -6 },
  { 275, 3, 9, 5, 1, -7 },
  { 279, 5, 1, 5, 0, -3 },
};

const GFXfont RobotoMono_Light9pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light9pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOMONO_LIGHT9PT7B_H_
