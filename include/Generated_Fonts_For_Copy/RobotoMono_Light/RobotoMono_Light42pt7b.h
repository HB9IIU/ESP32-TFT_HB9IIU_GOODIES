#ifndef _ROBOTOMONO_LIGHT42PT7B_H_
#define _ROBOTOMONO_LIGHT42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light42pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x00, 0x00, 0x7F,
  0xC0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x05, 0x82, 0xC1, 0x61,
  0x80, 0x00, 0x70, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x03,
  0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0xC0, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x0C, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x38, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x03,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x18, 0x0F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x81, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60,
  0x01, 0x81, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x07, 0xF8, 0x03, 0xFF, 0x83, 0xC0, 0xF0, 0xE0, 0x1E, 0x70, 0x03,
  0x98, 0x00, 0x66, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x01, 0xDC, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x77,
  0x00, 0x38, 0xF0, 0x1C, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0x87, 0x00, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0E, 0x18, 0x18, 0x18, 0x30,
  0x30, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC3, 0x01, 0x81, 0x86, 0x01, 0x87,
  0x18, 0x03, 0xFC, 0x30, 0x03, 0xF0, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC1, 0xE0, 0x01, 0x8F,
  0xF0, 0x06, 0x18, 0x60, 0x0C, 0x60, 0x60, 0x30, 0xC0, 0xC0, 0x61, 0x81,
  0x81, 0x83, 0x03, 0x07, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18,
  0x00, 0x38, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0xC0, 0x07, 0x87, 0x00, 0x38, 0x1C, 0x01, 0x80, 0xE0, 0x1C, 0x03,
  0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x18, 0x0C, 0x00, 0xE0, 0xC0, 0x07,
  0x1E, 0x00, 0x1D, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x03, 0xF8, 0x00, 0x3C, 0xE0, 0x01, 0xC7, 0x01, 0x9C, 0x1C, 0x0D, 0xC0,
  0x70, 0x6E, 0x01, 0xC7, 0x60, 0x07, 0x3B, 0x00, 0x39, 0x98, 0x00, 0xFC,
  0xE0, 0x03, 0xC7, 0x00, 0x0E, 0x1C, 0x00, 0xF8, 0xF0, 0x1F, 0xC3, 0xFF,
  0xC7, 0x07, 0xF8, 0x1C, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x70, 0x30, 0x18,
  0x0E, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18,
  0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x20,
  0x08, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x06,
  0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x38, 0x30, 0x77,
  0xE6, 0x3F, 0x3F, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x33, 0x00, 0x0E, 0x30, 0x03, 0x87, 0x00, 0xE0, 0x70, 0x3C, 0x07, 0x03,
  0x00, 0x40, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x33, 0x33, 0x37, 0x76, 0xE4, 0xFF, 0xFF, 0xFF, 0xFC, 0x6F, 0xF7, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x78, 0x1C, 0x1C, 0x01, 0xC3, 0x00, 0x1C, 0xE0, 0x03, 0x98,
  0x00, 0x33, 0x00, 0x07, 0x60, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xF0,
  0x07, 0x7E, 0x01, 0xC7, 0xC0, 0x70, 0xF8, 0x1C, 0x1F, 0x07, 0x03, 0xE1,
  0xC0, 0x7C, 0x70, 0x0F, 0x98, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0E, 0xE0,
  0x01, 0xD8, 0x00, 0x3B, 0x00, 0x06, 0x70, 0x01, 0xC6, 0x00, 0x38, 0xE0,
  0x0E, 0x0E, 0x03, 0x80, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x20, 0x1C,
  0x1F, 0x8F, 0xBF, 0xC7, 0xE0, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0xF0, 0x3C, 0x1C, 0x01,
  0xC7, 0x00, 0x38, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xC0, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFE,
  0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x70, 0x1C, 0x1C, 0x01,
  0xC7, 0x00, 0x1C, 0xC0, 0x03, 0x98, 0x00, 0x37, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x7C,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xCE, 0x00, 0x39, 0xE0, 0x06, 0x1E, 0x03, 0xC1, 0xFF, 0xF0,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xB0, 0x00, 0x1D, 0x80, 0x01, 0xCC, 0x00, 0x0C, 0x60,
  0x00, 0xE3, 0x00, 0x0E, 0x18, 0x00, 0x60, 0xC0, 0x07, 0x06, 0x00, 0x70,
  0x30, 0x03, 0x01, 0x80, 0x38, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x03, 0x01,
  0xC0, 0x18, 0x1C, 0x00, 0xC0, 0xC0, 0x06, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xCF,
  0xE0, 0x3F, 0xFE, 0x1F, 0x8F, 0xC7, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0x60, 0x01, 0xDC, 0x00, 0xE3, 0x80, 0x78, 0xF8,
  0x7C, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x81, 0x80, 0x31, 0xFE, 0x0E, 0xFF,
  0xF1, 0xF8, 0x0F, 0x3E, 0x00, 0xE7, 0x80, 0x0E, 0xE0, 0x01, 0xDC, 0x00,
  0x1B, 0x80, 0x03, 0x70, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x33, 0x00, 0x06, 0x70, 0x01, 0xC6, 0x00, 0x30, 0xE0, 0x0E, 0x0F, 0x03,
  0x80, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xF0,
  0x3C, 0x1C, 0x01, 0xC7, 0x00, 0x38, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00,
  0x0E, 0xE0, 0x01, 0xCC, 0x00, 0x39, 0x80, 0x06, 0x38, 0x01, 0xC3, 0x80,
  0x70, 0x3E, 0x7C, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x3C, 0x07, 0x0E, 0x00,
  0x71, 0x80, 0x07, 0x70, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0xDC, 0x00, 0x39, 0xC0, 0x0E, 0x1C, 0x03,
  0xC1, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x78,
  0x3C, 0x1C, 0x03, 0xC7, 0x00, 0x38, 0xE0, 0x03, 0x98, 0x00, 0x77, 0x00,
  0x06, 0xE0, 0x00, 0xDC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0E, 0xC0, 0x01, 0xDC, 0x00, 0x7B, 0x80, 0x0F, 0x38, 0x03, 0xE3, 0x81,
  0xD8, 0x3F, 0xF3, 0x03, 0xF8, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF7, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF7, 0x3B, 0xDE, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x63, 0x18, 0xCE, 0x73, 0x39, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0x00,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xC0,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x03, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x78, 0x1C,
  0x70, 0x0E, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80,
  0x0E, 0x03, 0xC0, 0x38, 0x01, 0x80, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x86,
  0x07, 0x83, 0x18, 0x3F, 0x86, 0x30, 0xE1, 0x84, 0xC1, 0x83, 0x0D, 0x86,
  0x04, 0x1B, 0x0C, 0x08, 0x34, 0x10, 0x10, 0x78, 0x60, 0x20, 0xF0, 0xC0,
  0xC1, 0xE1, 0x81, 0x83, 0xC3, 0x03, 0x07, 0x86, 0x06, 0x0B, 0x0C, 0x0C,
  0x16, 0x18, 0x38, 0x64, 0x30, 0x70, 0xCC, 0x33, 0xE3, 0x18, 0x7E, 0x7C,
  0x30, 0x70, 0x70, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x04, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0x70, 0x00, 0x0C, 0xC0, 0x00, 0x73, 0x00, 0x01, 0x8E, 0x00, 0x06, 0x18,
  0x00, 0x38, 0x60, 0x00, 0xC1, 0xC0, 0x03, 0x03, 0x00, 0x1C, 0x0C, 0x00,
  0x60, 0x38, 0x01, 0x80, 0x60, 0x0E, 0x01, 0x80, 0x38, 0x07, 0x00, 0xC0,
  0x0C, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0x80, 0x06,
  0x0E, 0x00, 0x1C, 0x30, 0x00, 0x70, 0xC0, 0x00, 0xC7, 0x00, 0x03, 0x98,
  0x00, 0x0E, 0x60, 0x00, 0x1B, 0x80, 0x00, 0x70, 0xFF, 0xE0, 0x1F, 0xFF,
  0x83, 0x00, 0xF8, 0x60, 0x03, 0x8C, 0x00, 0x39, 0x80, 0x03, 0x30, 0x00,
  0x76, 0x00, 0x0E, 0xC0, 0x01, 0xD8, 0x00, 0x33, 0x00, 0x06, 0x60, 0x01,
  0xCC, 0x00, 0xF1, 0x80, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0xC0, 0x07,
  0x98, 0x00, 0x73, 0x00, 0x07, 0x60, 0x00, 0x6C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x06, 0xC0, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x0E,
  0x60, 0x0F, 0x8F, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xF0, 0x1E, 0x07, 0x83, 0x80, 0x38, 0x30, 0x01, 0xC7, 0x00, 0x0E, 0x60,
  0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x07, 0xE0, 0x00, 0x66, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x00,
  0x1C, 0x38, 0x01, 0xC1, 0xC0, 0x78, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x1F, 0xFE, 0x03, 0x01, 0xF0, 0x60, 0x07, 0x0C, 0x00, 0x71, 0x80,
  0x07, 0x30, 0x00, 0x66, 0x00, 0x0E, 0xC0, 0x00, 0xD8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xB0, 0x00, 0x76, 0x00, 0x0C, 0xC0, 0x03, 0x98, 0x00,
  0xE3, 0x00, 0x38, 0x60, 0x3E, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xC0, 0xF0, 0x38,
  0x03, 0xC1, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0xC0, 0x01, 0xCE, 0x00, 0x06,
  0x60, 0x00, 0x33, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0x0E, 0xC0, 0x00, 0x76, 0x00, 0x03, 0xB8, 0x00,
  0x1D, 0xC0, 0x00, 0xE6, 0x00, 0x07, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xC7,
  0x80, 0x1C, 0x1E, 0x01, 0xE0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0x3B, 0x00, 0x07, 0x60,
  0x00, 0xCE, 0x00, 0x38, 0xE0, 0x0E, 0x0E, 0x03, 0x80, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0xE0, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x03, 0x8E, 0x00, 0x78,
  0xE0, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70,
  0x0E, 0x0E, 0x00, 0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0xE3, 0x80, 0x0E, 0x70,
  0x00, 0xEF, 0x80, 0x0F, 0xDC, 0x00, 0xF9, 0xC0, 0x0F, 0x0E, 0x00, 0xE0,
  0x70, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0xE0, 0x0E, 0x0E,
  0x00, 0xF0, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00, 0x1C,
  0xE0, 0x00, 0xEE, 0x00, 0x07, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x06, 0xFB,
  0x00, 0xDF, 0x60, 0x3B, 0xEE, 0x06, 0x7C, 0xC1, 0xCF, 0x98, 0x31, 0xF3,
  0x86, 0x3E, 0x31, 0xC7, 0xC6, 0x30, 0xF8, 0xE6, 0x1F, 0x0D, 0x83, 0xE1,
  0xB0, 0x7C, 0x3E, 0x0F, 0x83, 0x81, 0xF0, 0x70, 0x3E, 0x06, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFB,
  0x00, 0x3F, 0x70, 0x07, 0xE6, 0x00, 0xFC, 0xE0, 0x1F, 0x8C, 0x03, 0xF1,
  0xC0, 0x7E, 0x1C, 0x0F, 0xC3, 0x81, 0xF8, 0x38, 0x3F, 0x03, 0x07, 0xE0,
  0x70, 0xFC, 0x06, 0x1F, 0x80, 0xE3, 0xF0, 0x0C, 0x7E, 0x01, 0xCF, 0xC0,
  0x19, 0xF8, 0x03, 0xBF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x03, 0xF8, 0x00,
  0xFF, 0xE0, 0x1E, 0x0F, 0x03, 0x80, 0x38, 0x30, 0x01, 0x87, 0x00, 0x1C,
  0x60, 0x00, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0,
  0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0xE6, 0x00, 0x0C, 0x70, 0x00, 0xC3,
  0x00, 0x1C, 0x38, 0x03, 0x81, 0xE0, 0x70, 0x0F, 0xFE, 0x00, 0x3F, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0x80, 0x3E, 0x70, 0x01, 0xCE, 0x00, 0x1D,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xB8, 0x00, 0xE7,
  0x01, 0xF8, 0xFF, 0xFE, 0x1F, 0xFE, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xC1, 0xE0, 0x38, 0x03, 0x83, 0x80,
  0x0E, 0x1C, 0x00, 0x31, 0xC0, 0x01, 0xCE, 0x00, 0x06, 0x60, 0x00, 0x3B,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x76, 0x00, 0x03, 0xB0, 0x00, 0x1D, 0xC0, 0x00,
  0xCE, 0x00, 0x0E, 0x30, 0x00, 0x61, 0xC0, 0x07, 0x07, 0x00, 0x70, 0x1E,
  0x07, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x04, 0xFF, 0xE0, 0x1F, 0xFF,
  0x83, 0x80, 0xF8, 0x70, 0x03, 0x8E, 0x00, 0x39, 0xC0, 0x03, 0xB8, 0x00,
  0x77, 0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x1B, 0x80, 0x03, 0x70, 0x00,
  0xEE, 0x00, 0x19, 0xC0, 0x07, 0x38, 0x03, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0x80, 0xE0, 0x70, 0x0E, 0x0E, 0x00, 0xC1, 0xC0, 0x1C,
  0x38, 0x01, 0x87, 0x00, 0x38, 0xE0, 0x03, 0x1C, 0x00, 0x73, 0x80, 0x06,
  0x70, 0x00, 0xEE, 0x00, 0x0D, 0xC0, 0x01, 0xC0, 0x03, 0xFC, 0x00, 0xFF,
  0xF0, 0x1E, 0x07, 0x83, 0x80, 0x1C, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x60,
  0x00, 0x66, 0x00, 0x07, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x77, 0x00,
  0x0E, 0x78, 0x00, 0xE3, 0xC0, 0x3C, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3B, 0x00, 0x07, 0x70, 0x00, 0xCE, 0x00, 0x38, 0xE0, 0x0E, 0x0F, 0x03,
  0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xD8,
  0x00, 0x0C, 0xC0, 0x00, 0x67, 0x00, 0x07, 0x18, 0x00, 0x38, 0xC0, 0x01,
  0x87, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xC0, 0x06, 0x07, 0x00, 0x70, 0x38,
  0x03, 0x80, 0xC0, 0x18, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0xC0, 0x60,
  0x07, 0x03, 0x00, 0x38, 0x38, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x38,
  0xE0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x3B, 0x80, 0x00, 0xD8, 0x00,
  0x06, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xF8, 0x1E, 0x07,
  0xE0, 0x78, 0x1F, 0x81, 0xE0, 0x66, 0x07, 0x81, 0x98, 0x1E, 0x06, 0x60,
  0xCC, 0x19, 0x83, 0x30, 0x66, 0x0C, 0xC3, 0x9C, 0x33, 0x0E, 0x70, 0xCC,
  0x30, 0xC6, 0x38, 0xC3, 0x18, 0x63, 0x0C, 0x61, 0x8C, 0x31, 0x86, 0x30,
  0xC6, 0x18, 0xC3, 0xB8, 0x77, 0x0E, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0x6C,
  0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x1E, 0x03, 0xE0, 0x78, 0x07,
  0x81, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xF0, 0x00, 0x39, 0xC0, 0x00, 0xE3, 0x80, 0x07, 0x06, 0x00, 0x38, 0x1C,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0xE0, 0x03, 0x07,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x61, 0x80, 0x03, 0x87, 0x00, 0x1C, 0x0C,
  0x00, 0x70, 0x38, 0x03, 0x80, 0x70, 0x0C, 0x00, 0xC0, 0x70, 0x03, 0x83,
  0x80, 0x07, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xF0, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xC3, 0x80, 0x0E,
  0x1C, 0x00, 0x60, 0x70, 0x07, 0x03, 0x80, 0x30, 0x0C, 0x03, 0x80, 0x70,
  0x18, 0x01, 0x81, 0xC0, 0x0E, 0x0C, 0x00, 0x30, 0xE0, 0x01, 0xC6, 0x00,
  0x06, 0x70, 0x00, 0x3B, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0xFF, 0xFC, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFF, 0x01, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x36, 0x00, 0x6C, 0x01, 0xDC, 0x03, 0x18, 0x06, 0x38, 0x1C, 0x30, 0x30,
  0x60, 0xE0, 0xE1, 0x80, 0xC3, 0x01, 0xCE, 0x01, 0x98, 0x03, 0x70, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0x00,
  0xC0, 0x00, 0xFF, 0xC0, 0x7E, 0xFC, 0x1E, 0x01, 0xC3, 0x00, 0x18, 0xE0,
  0x03, 0x9C, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x07,
  0xFF, 0x07, 0xFF, 0xE3, 0xE0, 0x0C, 0x70, 0x01, 0x9C, 0x00, 0x33, 0x00,
  0x06, 0xE0, 0x00, 0xDC, 0x00, 0x39, 0x80, 0x07, 0x38, 0x01, 0xE3, 0x80,
  0xEC, 0x7F, 0xF9, 0xC3, 0xFC, 0x38, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x38, 0x0E, 0x7F, 0x83, 0xBF, 0xF8, 0xF8, 0x0F, 0x3C,
  0x01, 0xCE, 0x00, 0x3B, 0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x6E, 0x00, 0x3B, 0x80, 0x0E, 0xF0, 0x07, 0x37,
  0x03, 0x8C, 0xFF, 0xE3, 0x1F, 0xE0, 0x00, 0x60, 0x00, 0xFF, 0xC0, 0x3F,
  0xFC, 0x0E, 0x01, 0xC3, 0x80, 0x1C, 0x60, 0x03, 0x9C, 0x00, 0x33, 0x00,
  0x07, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0xEE, 0x00,
  0x18, 0xC0, 0x03, 0x1C, 0x00, 0xE1, 0xE0, 0x78, 0x1F, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x30,
  0x7F, 0x8C, 0x3F, 0xFB, 0x1C, 0x06, 0xCE, 0x00, 0xF7, 0x00, 0x1D, 0xC0,
  0x03, 0x60, 0x00, 0xD8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x37,
  0x00, 0x0C, 0xC0, 0x07, 0x38, 0x03, 0xC7, 0x01, 0xB0, 0xFF, 0xEC, 0x1F,
  0xE3, 0x00, 0x60, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0E, 0x03, 0xC3, 0x80,
  0x1C, 0x60, 0x03, 0x9C, 0x00, 0x33, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0x1E, 0x00,
  0x71, 0xE0, 0x3C, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x0F,
  0xFC, 0x03, 0xC0, 0x80, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x03, 0xFF, 0xFE, 0x7F, 0xFF,
  0xC0, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x01, 0xFE, 0x30, 0xFF, 0xEC, 0x70, 0x1B, 0x38, 0x03, 0xDC,
  0x00, 0x77, 0x00, 0x1D, 0x80, 0x03, 0x60, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0D, 0x80, 0x03,
  0x60, 0x00, 0xDC, 0x00, 0x33, 0x00, 0x1C, 0xE0, 0x0F, 0x1C, 0x06, 0xC3,
  0xFF, 0xB0, 0x7F, 0x8C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0xC0, 0x0E, 0x78, 0x07, 0x07, 0x87, 0x80, 0xFF, 0xC0, 0x07, 0xC0,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x0C, 0x3F,
  0xC3, 0x3F, 0xFC, 0xCC, 0x07, 0x36, 0x00, 0xEF, 0x00, 0x3B, 0x80, 0x06,
  0xE0, 0x01, 0xB0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x01, 0xC0, 0x3E, 0x7F, 0xC3, 0xF8, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x0B, 0x80, 0x0E, 0x70, 0x03,
  0x8E, 0x00, 0xE1, 0xC0, 0x38, 0x38, 0x1E, 0x07, 0x07, 0x80, 0xE1, 0xE0,
  0x1C, 0x78, 0x03, 0x9C, 0x00, 0x77, 0x80, 0x0F, 0xF8, 0x01, 0xF3, 0x80,
  0x3C, 0x78, 0x07, 0x07, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0x70,
  0x70, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x0F, 0x38, 0x00, 0xE7, 0x00, 0x0F,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x86, 0x7E,
  0x3F, 0xB7, 0xFB, 0xFD, 0xE0, 0xF0, 0x7E, 0x07, 0x01, 0xE0, 0x38, 0x0F,
  0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C,
  0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78,
  0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x30,
  0xFF, 0x0C, 0xFF, 0xE3, 0x70, 0x1C, 0xD8, 0x03, 0xBC, 0x00, 0xEE, 0x00,
  0x1B, 0x80, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06,
  0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1C, 0x00, 0x40, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xC0, 0x78, 0x38,
  0x03, 0x87, 0x00, 0x1C, 0x60, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0xE6, 0x00, 0x0C, 0x70, 0x01,
  0xC3, 0x80, 0x38, 0x1C, 0x07, 0x80, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00,
  0xC0, 0x31, 0xFE, 0x0C, 0xFF, 0xE3, 0x60, 0x3C, 0xF0, 0x07, 0x38, 0x00,
  0xEE, 0x00, 0x3B, 0x00, 0x06, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xB0, 0x00, 0xEE, 0x00, 0x3B, 0xC0, 0x1C, 0xD8, 0x0E, 0x33, 0xFF,
  0x0C, 0x7F, 0x83, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x01, 0xFE, 0x31, 0xFF, 0xEC, 0x70, 0x1F, 0x38, 0x03, 0xDC, 0x00,
  0x77, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0D, 0x80, 0x03, 0x60,
  0x00, 0xDC, 0x00, 0x33, 0x00, 0x1C, 0xE0, 0x0F, 0x1C, 0x07, 0xC3, 0xFF,
  0xB0, 0x7F, 0x8C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x39, 0xC3, 0xFF, 0x9F, 0xFF, 0x70, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0x01,
  0xFF, 0xF0, 0xE0, 0x1E, 0x70, 0x03, 0x98, 0x00, 0x76, 0x00, 0x1D, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x1D, 0xC0, 0x06, 0x78, 0x07, 0x87, 0xFF, 0xC0, 0xFF, 0xC0, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xB0, 0x01, 0xDC, 0x01, 0xE7, 0x03, 0xB3, 0xFF, 0x98, 0x7F,
  0x8C, 0xE0, 0x00, 0x3B, 0x00, 0x01, 0x9C, 0x00, 0x1C, 0x60, 0x00, 0xC3,
  0x80, 0x0E, 0x0C, 0x00, 0x70, 0x70, 0x03, 0x03, 0x80, 0x38, 0x0C, 0x01,
  0x80, 0x70, 0x1C, 0x01, 0x80, 0xC0, 0x0E, 0x06, 0x00, 0x30, 0x70, 0x01,
  0x83, 0x00, 0x0E, 0x38, 0x00, 0x31, 0x80, 0x01, 0xCC, 0x00, 0x06, 0xC0,
  0x00, 0x36, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x18, 0x06, 0xC0, 0x70, 0x0D, 0x80, 0xE0, 0x3B, 0x01, 0xE0, 0x67, 0x03,
  0xC0, 0xC6, 0x0D, 0x81, 0x8C, 0x1B, 0x03, 0x18, 0x33, 0x0E, 0x30, 0x66,
  0x18, 0x71, 0x8C, 0x30, 0x63, 0x18, 0x60, 0xC6, 0x18, 0xC1, 0x8C, 0x33,
  0x03, 0x30, 0x66, 0x03, 0x60, 0xCC, 0x06, 0xC0, 0xD8, 0x0D, 0x81, 0xB0,
  0x1A, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0xC0, 0x18, 0x00, 0xE0, 0x00, 0xF7, 0x00, 0x1C, 0x38, 0x01, 0xC1, 0xC0,
  0x38, 0x0E, 0x07, 0x00, 0xE0, 0xE0, 0x07, 0x0C, 0x00, 0x39, 0xC0, 0x01,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00,
  0x39, 0x80, 0x03, 0x1C, 0x00, 0x70, 0xE0, 0x0E, 0x07, 0x01, 0xC0, 0x38,
  0x38, 0x03, 0x83, 0x80, 0x1C, 0x70, 0x00, 0xEE, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xE7, 0x00, 0x03, 0x1C, 0x00, 0x1C, 0x30, 0x00, 0x60,
  0xE0, 0x03, 0x81, 0x80, 0x0E, 0x07, 0x00, 0x70, 0x0C, 0x01, 0xC0, 0x38,
  0x06, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x18,
  0x00, 0x38, 0xE0, 0x00, 0x63, 0x80, 0x01, 0xCC, 0x00, 0x03, 0x70, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x03, 0x80, 0xF8, 0x0F, 0x00, 0x7C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xE0, 0x07, 0x80, 0x7C,
  0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x04, 0x7F, 0xC0,
  0x0D, 0xC3, 0xC0, 0x1B, 0x01, 0xC0, 0x6E, 0x01, 0xE1, 0xD8, 0x01, 0xFF,
  0x10, 0x00, 0xFC, 0x00,
};

const GFXglyph RobotoMono_Light42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 3, 30, 25, 11, -30 },
  { 13, 9, 10, 25, 8, -32 },
  { 25, 23, 30, 25, 1, -30 },
  { 112, 18, 38, 25, 4, -34 },
  { 198, 23, 30, 25, 1, -30 },
  { 285, 21, 30, 25, 3, -30 },
  { 364, 2, 10, 25, 11, -32 },
  { 367, 10, 43, 25, 8, -33 },
  { 421, 10, 43, 25, 7, -33 },
  { 475, 19, 18, 25, 4, -30 },
  { 518, 21, 22, 25, 2, -25 },
  { 576, 4, 10, 25, 8, -4 },
  { 581, 15, 2, 25, 5, -14 },
  { 585, 4, 4, 25, 11, -4 },
  { 587, 14, 33, 25, 6, -30 },
  { 645, 19, 30, 25, 3, -30 },
  { 717, 11, 30, 25, 4, -30 },
  { 759, 19, 30, 25, 2, -30 },
  { 831, 19, 30, 25, 2, -30 },
  { 903, 21, 30, 25, 2, -30 },
  { 982, 18, 30, 25, 4, -30 },
  { 1050, 19, 30, 25, 3, -30 },
  { 1122, 19, 30, 25, 3, -30 },
  { 1194, 19, 30, 25, 4, -30 },
  { 1266, 19, 30, 25, 3, -30 },
  { 1338, 4, 22, 25, 12, -22 },
  { 1349, 5, 28, 25, 11, -22 },
  { 1367, 18, 17, 25, 3, -22 },
  { 1406, 18, 11, 25, 4, -19 },
  { 1431, 18, 17, 25, 4, -22 },
  { 1470, 16, 30, 25, 5, -30 },
  { 1530, 23, 30, 25, 1, -30 },
  { 1617, 22, 30, 25, 2, -30 },
  { 1700, 19, 30, 25, 4, -30 },
  { 1772, 20, 30, 25, 3, -30 },
  { 1847, 19, 30, 25, 4, -30 },
  { 1919, 18, 30, 25, 4, -30 },
  { 1987, 18, 30, 25, 4, -30 },
  { 2055, 21, 30, 25, 2, -30 },
  { 2134, 19, 30, 25, 3, -30 },
  { 2206, 17, 30, 25, 4, -30 },
  { 2270, 19, 30, 25, 2, -30 },
  { 2342, 20, 30, 25, 4, -30 },
  { 2417, 17, 30, 25, 5, -30 },
  { 2481, 19, 30, 25, 3, -30 },
  { 2553, 19, 30, 25, 3, -30 },
  { 2625, 20, 30, 25, 3, -30 },
  { 2700, 19, 30, 25, 4, -30 },
  { 2772, 21, 35, 25, 2, -30 },
  { 2864, 19, 30, 25, 4, -30 },
  { 2936, 20, 30, 25, 3, -30 },
  { 3011, 21, 30, 25, 2, -30 },
  { 3090, 19, 30, 25, 3, -30 },
  { 3162, 21, 30, 25, 2, -30 },
  { 3241, 22, 30, 25, 2, -30 },
  { 3324, 22, 30, 25, 2, -30 },
  { 3407, 21, 30, 25, 2, -30 },
  { 3486, 19, 30, 25, 3, -30 },
  { 3558, 7, 40, 25, 9, -34 },
  { 3593, 15, 33, 25, 5, -30 },
  { 3655, 7, 40, 25, 9, -34 },
  { 3690, 15, 16, 25, 5, -30 },
  { 3720, 18, 2, 25, 4, 0 },
  { 3725, 7, 6, 25, 9, -31 },
  { 3731, 19, 23, 25, 3, -23 },
  { 3786, 18, 32, 25, 4, -32 },
  { 3858, 19, 23, 25, 3, -23 },
  { 3913, 18, 32, 25, 3, -32 },
  { 3985, 19, 23, 25, 3, -23 },
  { 4040, 19, 32, 25, 4, -32 },
  { 4116, 18, 32, 25, 3, -23 },
  { 4188, 18, 32, 25, 4, -32 },
  { 4260, 17, 30, 25, 5, -30 },
  { 4324, 13, 39, 25, 4, -30 },
  { 4388, 19, 32, 25, 4, -32 },
  { 4464, 17, 32, 25, 5, -32 },
  { 4532, 21, 23, 25, 2, -23 },
  { 4593, 18, 23, 25, 4, -23 },
  { 4645, 20, 23, 25, 3, -23 },
  { 4703, 18, 32, 25, 4, -23 },
  { 4775, 18, 32, 25, 3, -23 },
  { 4847, 15, 23, 25, 7, -23 },
  { 4891, 18, 23, 25, 4, -23 },
  { 4943, 18, 28, 25, 3, -28 },
  { 5006, 17, 22, 25, 4, -22 },
  { 5053, 21, 22, 25, 2, -22 },
  { 5111, 23, 22, 25, 1, -22 },
  { 5175, 20, 22, 25, 3, -22 },
  { 5230, 22, 31, 25, 2, -22 },
  { 5316, 20, 22, 25, 3, -22 },
  { 5371, 13, 41, 25, 7, -33 },
  { 5438, 2, 37, 25, 12, -30 },
  { 5448, 13, 41, 25, 7, -33 },
  { 5515, 23, 7, 25, 1, -16 },
};

const GFXfont RobotoMono_Light42pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light42pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOMONO_LIGHT42PT7B_H_
