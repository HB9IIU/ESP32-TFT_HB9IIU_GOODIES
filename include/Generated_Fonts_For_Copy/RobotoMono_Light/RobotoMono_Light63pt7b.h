#ifndef _ROBOTOMONO_LIGHT63PT7B_H_
#define _ROBOTOMONO_LIGHT63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light63pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x77, 0xFF, 0xFF, 0x00, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0x80, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1E, 0x00, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0xF8, 0x00, 0xF8, 0x1F, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x1E, 0x00, 0x40, 0x1C, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x38,
  0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x1C, 0x07, 0x00, 0x70, 0x03, 0x81, 0xE0, 0x0E, 0x00, 0x70, 0x38, 0x00,
  0xE0, 0x0E, 0x0F, 0x00, 0x1C, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0x70, 0x70,
  0x00, 0x3C, 0x3C, 0x0E, 0x00, 0x03, 0xFF, 0x83, 0x80, 0x00, 0x3F, 0xE0,
  0x70, 0x00, 0x01, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x07,
  0xFC, 0x00, 0x01, 0xC1, 0xFF, 0xC0, 0x00, 0x70, 0x7C, 0x7C, 0x00, 0x0E,
  0x0E, 0x03, 0x80, 0x03, 0x83, 0xC0, 0x38, 0x00, 0x70, 0x70, 0x07, 0x00,
  0x1C, 0x0E, 0x00, 0xE0, 0x07, 0x81, 0xC0, 0x1C, 0x00, 0xE0, 0x38, 0x03,
  0x80, 0x3C, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x02, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x1C,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x0F, 0x8F, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x0E, 0x1E, 0x07, 0xC0,
  0x0E, 0x3C, 0x03, 0xE0, 0x1E, 0x7C, 0x01, 0xE0, 0x1E, 0x78, 0x00, 0xF0,
  0x1E, 0x78, 0x00, 0x78, 0x1C, 0xF0, 0x00, 0x7C, 0x3C, 0xF0, 0x00, 0x3E,
  0x3C, 0xF0, 0x00, 0x1E, 0x38, 0xF0, 0x00, 0x0F, 0x78, 0xF0, 0x00, 0x07,
  0xF8, 0xF0, 0x00, 0x07, 0xF0, 0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03,
  0xE0, 0x3C, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x0F, 0xF8, 0x1F, 0x80, 0x3F,
  0x7C, 0x0F, 0xFF, 0xFC, 0x3C, 0x07, 0xFF, 0xF8, 0x1E, 0x01, 0xFF, 0xE0,
  0x0F, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x04,
  0x00, 0x38, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x06, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00,
  0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x80, 0x0E, 0x00, 0x2F, 0x00, 0xE0,
  0x0E, 0xFE, 0x0E, 0x07, 0xEF, 0xF8, 0xE1, 0xFF, 0x3F, 0xFE, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x1E, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF0, 0x06, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x71, 0xC7, 0x1C,
  0x73, 0xCF, 0x3C, 0xF3, 0x9E, 0x73, 0xC6, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x73, 0xEF, 0xFF, 0xFD,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1E, 0xFF, 0x00, 0x03, 0xCF, 0xF0, 0x00, 0x78, 0xFF, 0x00,
  0x0F, 0x0F, 0xF0, 0x03, 0xE0, 0xFF, 0x00, 0x7C, 0x0F, 0xF0, 0x0F, 0x00,
  0xFF, 0x01, 0xE0, 0x0F, 0xF0, 0x3C, 0x00, 0xFF, 0x07, 0x80, 0x0F, 0xF0,
  0xF0, 0x00, 0xFF, 0x1E, 0x00, 0x0F, 0xF3, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78,
  0x1F, 0x00, 0x0F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00,
  0x0F, 0x00, 0x3F, 0x01, 0xFF, 0x07, 0xFF, 0x1F, 0xEF, 0xFF, 0x0F, 0xFC,
  0x0F, 0xF0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x70, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E,
  0x7C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0xC0, 0xF8,
  0x01, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00,
  0x3C, 0x38, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0xF0,
  0x0E, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x1F, 0x80, 0x03, 0xCF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0x81, 0xFF,
  0x03, 0xE0, 0x03, 0xF8, 0x08, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0x70, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3C,
  0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xFF,
  0x0F, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x3F,
  0xE0, 0x1E, 0x3F, 0xFF, 0x03, 0xCF, 0xFF, 0xF8, 0x7B, 0xE0, 0x1F, 0x8E,
  0xF0, 0x01, 0xF1, 0xFC, 0x00, 0x0F, 0x3F, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1E, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x07,
  0x8F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xC0, 0x7F, 0x00, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0F, 0x1C,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x3C, 0x1E, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0xF8, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0xF8, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x3C, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x7F, 0x3E,
  0x00, 0x0F, 0xE1, 0xF0, 0x01, 0xEE, 0x0F, 0xC0, 0x7C, 0xE0, 0x7F, 0xFF,
  0x8E, 0x03, 0xFF, 0xF1, 0xE0, 0x0F, 0xF8, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x38, 0xFB, 0xFF, 0xF7, 0xCF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC7, 0xDF, 0xFF, 0xBE, 0x7C, 0x0E, 0x0F, 0x8F, 0xC7, 0xF3, 0xF0,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x83, 0xC1,
  0xE1, 0xE0, 0xF0, 0xF0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x83, 0xE0, 0x03, 0xE3, 0xE0,
  0x00, 0xF1, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78,
  0x00, 0x03, 0xB8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x1C, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x1E, 0x01, 0xC1, 0xC0,
  0x1F, 0xE0, 0x38, 0x70, 0x1F, 0xFC, 0x0E, 0x38, 0x0F, 0x87, 0x83, 0x8E,
  0x03, 0x80, 0xC0, 0x67, 0x01, 0xC0, 0x30, 0x19, 0xC0, 0x70, 0x0C, 0x07,
  0x70, 0x38, 0x03, 0x01, 0xD8, 0x0E, 0x00, 0xC0, 0x7E, 0x03, 0x00, 0x70,
  0x1F, 0x81, 0xC0, 0x1C, 0x07, 0xE0, 0x70, 0x07, 0x01, 0xF8, 0x1C, 0x01,
  0xC0, 0x7E, 0x06, 0x00, 0x70, 0x1F, 0x81, 0x80, 0x18, 0x07, 0xE0, 0x60,
  0x06, 0x01, 0xF8, 0x18, 0x01, 0x80, 0x6E, 0x06, 0x00, 0x60, 0x1B, 0x81,
  0x80, 0x38, 0x06, 0xE0, 0x60, 0x0E, 0x03, 0xB8, 0x1C, 0x07, 0x80, 0xCE,
  0x07, 0x01, 0xE0, 0x73, 0x81, 0xC0, 0xDC, 0x1C, 0x60, 0x38, 0xF7, 0x0E,
  0x1C, 0x0F, 0xF8, 0xFF, 0x07, 0x01, 0xFC, 0x3F, 0x81, 0xE0, 0x1C, 0x03,
  0xC0, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x80, 0x01, 0xF8,
  0x00, 0xE0, 0x00, 0x1F, 0xFB, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x3C, 0x1C, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x78, 0x0E, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0x80,
  0x01, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x03, 0x80, 0x01, 0xE0, 0x03, 0x80, 0x00, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0x00, 0x7F, 0xE0, 0xF0, 0x00, 0x3F, 0x0F, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x1F, 0x0F, 0x00,
  0x07, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x0F, 0x00, 0x1F, 0xE0, 0xF0, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x1F, 0x8F, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0x80, 0x07,
  0xC0, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x78,
  0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3C, 0x03,
  0xFF, 0x00, 0xF0, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x7E, 0x03, 0xC0, 0x0F, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x3C,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0xF1, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3E, 0x0F,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x7C, 0x03, 0xC0,
  0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x3C, 0x07, 0xC0,
  0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x03, 0xCF, 0xE0, 0x00, 0x0F,
  0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0x80, 0x00, 0xFF, 0x1E, 0x00, 0x03, 0xF8,
  0x3C, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3E, 0x0F,
  0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x7C, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x77, 0xFF, 0x00, 0x0F,
  0x7F, 0x70, 0x00, 0xE7, 0xF7, 0x80, 0x0E, 0x7F, 0x78, 0x01, 0xE7, 0xF3,
  0x80, 0x1C, 0x7F, 0x3C, 0x03, 0xC7, 0xF1, 0xC0, 0x3C, 0x7F, 0x1C, 0x03,
  0x87, 0xF1, 0xE0, 0x78, 0x7F, 0x0E, 0x07, 0x07, 0xF0, 0xE0, 0x70, 0x7F,
  0x0F, 0x0F, 0x07, 0xF0, 0x70, 0xE0, 0x7F, 0x07, 0x1E, 0x07, 0xF0, 0x79,
  0xE0, 0x7F, 0x03, 0x9C, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0x00, 0x7F, 0x00,
  0xF0, 0x07, 0xF0, 0x0E, 0x00, 0x7F, 0x00, 0x60, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0x78, 0x00, 0x0F, 0xF7, 0x80, 0x00, 0xFF, 0x3C, 0x00,
  0x0F, 0xF3, 0xC0, 0x00, 0xFF, 0x1E, 0x00, 0x0F, 0xF0, 0xE0, 0x00, 0xFF,
  0x0F, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0xFF, 0x07, 0x80, 0x0F, 0xF0, 0x3C,
  0x00, 0xFF, 0x03, 0xC0, 0x0F, 0xF0, 0x1E, 0x00, 0xFF, 0x01, 0xE0, 0x0F,
  0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x07, 0x80, 0xFF, 0x00,
  0x38, 0x0F, 0xF0, 0x03, 0xC0, 0xFF, 0x00, 0x1E, 0x0F, 0xF0, 0x01, 0xE0,
  0xFF, 0x00, 0x0F, 0x0F, 0xF0, 0x00, 0xF0, 0xFF, 0x00, 0x07, 0x8F, 0xF0,
  0x00, 0x78, 0xFF, 0x00, 0x03, 0xCF, 0xF0, 0x00, 0x3C, 0xFF, 0x00, 0x01,
  0xEF, 0xF0, 0x00, 0x0E, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFC, 0x0F, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x3C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x07, 0x1E, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x07, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x0E, 0x00, 0x1F, 0xE0, 0xE0, 0x00, 0x1F, 0x8E, 0x00, 0x00, 0xF8, 0xE0,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x3E, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3E,
  0xE0, 0x00, 0x07, 0xCE, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x3F, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C,
  0x38, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0x87, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xE0,
  0x07, 0xFC, 0x0F, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF8, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C,
  0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x7D,
  0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xF3, 0x80, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x0F,
  0x80, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x1C, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x01, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x01, 0xE0,
  0x07, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x70,
  0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x1C,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x00,
  0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0x00,
  0x3E, 0x00, 0x7F, 0x80, 0x1F, 0x00, 0x3B, 0xC0, 0x0F, 0x80, 0x1C, 0xE0,
  0x0F, 0xC0, 0x0E, 0x70, 0x07, 0x70, 0x07, 0x38, 0x03, 0xB8, 0x03, 0x9C,
  0x01, 0xDC, 0x03, 0xCF, 0x00, 0xEE, 0x01, 0xE7, 0x80, 0x77, 0x00, 0xE3,
  0xC0, 0x73, 0xC0, 0x70, 0xE0, 0x38, 0xE0, 0x38, 0x70, 0x1C, 0x70, 0x1C,
  0x38, 0x0E, 0x38, 0x0E, 0x1C, 0x07, 0x1C, 0x0F, 0x0F, 0x07, 0x8F, 0x07,
  0x87, 0x83, 0x83, 0x83, 0xC3, 0xC1, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x70, 0x70, 0x70, 0x70, 0x38, 0x78, 0x38, 0x38, 0x1C, 0x38, 0x1E,
  0x1C, 0x0F, 0x1C, 0x07, 0x1E, 0x07, 0x8E, 0x03, 0x8F, 0x03, 0xC7, 0x01,
  0xC7, 0x00, 0xE7, 0x80, 0xE3, 0x80, 0x73, 0x80, 0x79, 0xC0, 0x39, 0xC0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0x78, 0x07, 0xB8,
  0x03, 0xBC, 0x03, 0xFC, 0x01, 0xDC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3E,
  0x1E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xF0, 0x03, 0xC0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0xF8,
  0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1D, 0xE0,
  0x00, 0x73, 0x80, 0x03, 0xCF, 0x00, 0x0E, 0x1C, 0x00, 0x78, 0x78, 0x01,
  0xC1, 0xE0, 0x0F, 0x03, 0x80, 0x3C, 0x0F, 0x00, 0xE0, 0x1C, 0x07, 0x80,
  0x78, 0x1C, 0x01, 0xE0, 0xF0, 0x03, 0x83, 0xC0, 0x0F, 0x0E, 0x00, 0x1C,
  0x78, 0x00, 0x79, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x1E,
  0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C,
  0x78, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x1E, 0x1F,
  0x80, 0x01, 0xE3, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x1E, 0x70, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0x78, 0x00,
  0x0F, 0xE7, 0xC0, 0x01, 0xFE, 0x3F, 0x00, 0x7D, 0xE1, 0xFF, 0xFF, 0x9E,
  0x0F, 0xFF, 0xE1, 0xE0, 0x3F, 0xF8, 0x0F, 0x00, 0x30, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x00, 0x3C, 0x3F,
  0xFC, 0x07, 0x9F, 0xFF, 0xC0, 0xF7, 0xE1, 0xFC, 0x1F, 0xE0, 0x07, 0xC3,
  0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x79, 0xE0, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x3C, 0xF8, 0x00, 0x07, 0x9F, 0x80, 0x01, 0xE3, 0xF8, 0x00, 0x7C,
  0x7F, 0xC0, 0x3F, 0x0F, 0x7F, 0xFF, 0xC1, 0xE3, 0xFF, 0xF0, 0x3C, 0x3F,
  0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0x80, 0x1F, 0x81, 0xF0,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0E,
  0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x78, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x7E, 0x03, 0xC0, 0x7F, 0xF8, 0x78, 0x1F,
  0xFF, 0x8F, 0x07, 0xF1, 0xFD, 0xE1, 0xF0, 0x07, 0xBC, 0x7C, 0x00, 0x3F,
  0x9F, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1F, 0x3C,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x87, 0xE0, 0x1E,
  0xF0, 0x7F, 0xFF, 0xDE, 0x07, 0xFF, 0xE3, 0xC0, 0x3F, 0xF0, 0x78, 0x00,
  0x60, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x00, 0x78, 0x1E,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3E, 0x38, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x04, 0x1F, 0x00, 0x00, 0xE0, 0xF8, 0x00, 0x3E, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x20, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x3C, 0x0F, 0xFF, 0xC7, 0x83, 0xF8, 0xFE,
  0xF0, 0xF8, 0x03, 0xDE, 0x3E, 0x00, 0x1F, 0xCF, 0x80, 0x01, 0xF9, 0xE0,
  0x00, 0x1F, 0x78, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x7E, 0x3E, 0x00, 0x1F, 0xC3, 0xF0, 0x0F, 0xF8, 0x3F, 0xFF, 0xEF, 0x03,
  0xFF, 0xF1, 0xE0, 0x1F, 0xF8, 0x3C, 0x00, 0x30, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x80,
  0x00, 0x1E, 0x18, 0x00, 0x07, 0x87, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x7C,
  0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x0F,
  0x07, 0xFF, 0x83, 0xC3, 0xFF, 0xF0, 0xF3, 0xF0, 0xFF, 0x3D, 0xE0, 0x07,
  0xCF, 0x70, 0x00, 0xFB, 0xF8, 0x00, 0x1E, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x3F,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xB8, 0x00, 0x03, 0xE7, 0x00,
  0x00, 0xF8, 0xE0, 0x00, 0x3E, 0x1C, 0x00, 0x0F, 0x83, 0x80, 0x03, 0xC0,
  0x70, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x1F, 0x00, 0x38, 0x07,
  0xC0, 0x07, 0x01, 0xF0, 0x00, 0xE0, 0x7C, 0x00, 0x1C, 0x1F, 0x00, 0x03,
  0x87, 0xC0, 0x00, 0x71, 0xF0, 0x00, 0x0E, 0x7E, 0x00, 0x01, 0xDF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x1E,
  0x03, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x7C,
  0x01, 0xC0, 0x07, 0xC0, 0x38, 0x00, 0x7C, 0x07, 0x00, 0x07, 0xC0, 0xE0,
  0x00, 0x7C, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00, 0x78, 0x70, 0x00, 0x0F,
  0x8E, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x0F, 0xB8, 0x00, 0x00, 0xF8, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0xE3, 0xFE, 0x0F, 0xF8, 0xE7, 0xFF,
  0x3F, 0xFC, 0xEF, 0x1F, 0xBE, 0x7E, 0xFC, 0x07, 0xF0, 0x1E, 0xF8, 0x07,
  0xE0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xE0, 0x03,
  0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03,
  0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03,
  0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03,
  0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03,
  0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03,
  0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03,
  0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03,
  0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03,
  0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0xC0, 0x38, 0x1F, 0xFE,
  0x0E, 0x0F, 0xFF, 0xC3, 0x8F, 0xC3, 0xF8, 0xE7, 0x80, 0x1F, 0x3D, 0xC0,
  0x03, 0xEF, 0xE0, 0x00, 0x7B, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFE, 0x1F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x1E, 0x1F, 0xFE, 0x03, 0xCF, 0xFF, 0xE0, 0x7B, 0xF9, 0xFE, 0x0F, 0xF0,
  0x03, 0xE1, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x3C,
  0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0xF1, 0xFC,
  0x00, 0x3E, 0x3F, 0xC0, 0x1F, 0x87, 0xBF, 0xFF, 0xE0, 0xF3, 0xFF, 0xF8,
  0x1E, 0x1F, 0xFC, 0x03, 0xC0, 0x18, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x3C, 0x0F, 0xFF, 0xE7, 0x87, 0xF8,
  0xFE, 0xF0, 0xF8, 0x01, 0xFE, 0x3E, 0x00, 0x1F, 0xCF, 0x80, 0x01, 0xF9,
  0xE0, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x7E, 0x3E, 0x00, 0x1F, 0xC3, 0xF0, 0x0F, 0xF8, 0x3F, 0xFF, 0xEF,
  0x03, 0xFF, 0xF1, 0xE0, 0x1F, 0xFC, 0x3C, 0x00, 0x30, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xFB, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF3, 0xE0, 0x03, 0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xF0, 0xFF, 0x81, 0xF0, 0x01, 0xF8, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xE0, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0x3C, 0x00, 0x1F,
  0xC7, 0xC0, 0x1E, 0xF1, 0xFF, 0xFF, 0x3C, 0x1F, 0xFF, 0x8F, 0x03, 0xFF,
  0x83, 0xC0, 0x1D, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x00, 0x01,
  0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x77, 0x00, 0x1E,
  0x00, 0x3D, 0xC0, 0x07, 0x80, 0x0E, 0x70, 0x01, 0xF0, 0x03, 0x9E, 0x00,
  0xFC, 0x00, 0xE7, 0x80, 0x3F, 0x00, 0x38, 0xE0, 0x0E, 0xC0, 0x1E, 0x38,
  0x03, 0x38, 0x07, 0x0E, 0x01, 0xCE, 0x01, 0xC3, 0xC0, 0x73, 0x80, 0x70,
  0x70, 0x1C, 0xE0, 0x1C, 0x1C, 0x07, 0x1C, 0x0E, 0x07, 0x03, 0x87, 0x03,
  0x81, 0xC0, 0xE1, 0xC0, 0xE0, 0x78, 0x38, 0x70, 0x38, 0x0E, 0x0E, 0x0E,
  0x0E, 0x03, 0x87, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0xE1, 0xC0, 0x38, 0x70,
  0x38, 0x70, 0x07, 0x1C, 0x07, 0x1C, 0x01, 0xCE, 0x01, 0xCE, 0x00, 0x73,
  0x80, 0x73, 0x80, 0x1C, 0xE0, 0x1C, 0xE0, 0x07, 0x30, 0x03, 0xB8, 0x00,
  0xFC, 0x00, 0xEE, 0x00, 0x3F, 0x00, 0x3B, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x03,
  0xE0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x07,
  0x80, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x3C, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x1C,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0xFE,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x73, 0xFF, 0xF0, 0x00, 0x1C,
  0xF0, 0x7E, 0x00, 0x07, 0x78, 0x07, 0xC0, 0x03, 0x9C, 0x00, 0xFC, 0x00,
  0xEE, 0x00, 0x0F, 0x80, 0x7B, 0x80, 0x01, 0xFC, 0x7C, 0xE0, 0x00, 0x3F,
  0xFE, 0x38, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00,
};

const GFXglyph RobotoMono_Light63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 5, 45, 38, 16, -45 },
  { 30, 13, 13, 38, 12, -47 },
  { 52, 34, 45, 38, 2, -45 },
  { 244, 28, 58, 38, 5, -52 },
  { 447, 35, 46, 38, 1, -45 },
  { 649, 32, 46, 38, 4, -45 },
  { 833, 3, 13, 38, 16, -47 },
  { 838, 15, 64, 38, 12, -50 },
  { 958, 14, 64, 38, 11, -50 },
  { 1070, 28, 28, 38, 6, -45 },
  { 1168, 30, 33, 38, 4, -37 },
  { 1292, 6, 15, 38, 12, -6 },
  { 1304, 23, 4, 38, 7, -22 },
  { 1316, 6, 6, 38, 17, -6 },
  { 1321, 22, 49, 38, 9, -45 },
  { 1456, 28, 46, 38, 5, -45 },
  { 1617, 16, 45, 38, 7, -45 },
  { 1707, 29, 45, 38, 3, -45 },
  { 1871, 28, 46, 38, 3, -45 },
  { 2032, 31, 45, 38, 3, -45 },
  { 2207, 28, 46, 38, 6, -45 },
  { 2368, 27, 46, 38, 5, -45 },
  { 2524, 29, 45, 38, 4, -45 },
  { 2688, 29, 46, 38, 5, -45 },
  { 2855, 28, 45, 38, 5, -45 },
  { 3013, 7, 33, 38, 18, -33 },
  { 3042, 9, 42, 38, 16, -33 },
  { 3090, 26, 26, 38, 5, -33 },
  { 3175, 28, 16, 38, 5, -28 },
  { 3231, 27, 26, 38, 6, -33 },
  { 3319, 25, 45, 38, 7, -45 },
  { 3460, 34, 45, 38, 2, -45 },
  { 3652, 32, 45, 38, 3, -45 },
  { 3832, 28, 45, 38, 6, -45 },
  { 3990, 30, 46, 38, 4, -45 },
  { 4163, 30, 45, 38, 5, -45 },
  { 4332, 27, 45, 38, 6, -45 },
  { 4484, 27, 45, 38, 6, -45 },
  { 4636, 30, 46, 38, 4, -45 },
  { 4809, 28, 45, 38, 5, -45 },
  { 4967, 26, 45, 38, 6, -45 },
  { 5114, 29, 46, 38, 3, -45 },
  { 5281, 30, 45, 38, 6, -45 },
  { 5450, 26, 45, 38, 7, -45 },
  { 5597, 28, 45, 38, 5, -45 },
  { 5755, 28, 45, 38, 5, -45 },
  { 5913, 30, 46, 38, 4, -45 },
  { 6086, 28, 45, 38, 7, -45 },
  { 6244, 32, 53, 38, 3, -45 },
  { 6456, 29, 45, 38, 6, -45 },
  { 6620, 30, 46, 38, 4, -45 },
  { 6793, 32, 45, 38, 3, -45 },
  { 6973, 28, 46, 38, 5, -45 },
  { 7134, 32, 45, 38, 3, -45 },
  { 7314, 33, 45, 38, 3, -45 },
  { 7500, 32, 45, 38, 3, -45 },
  { 7680, 33, 45, 38, 2, -45 },
  { 7866, 29, 45, 38, 4, -45 },
  { 8030, 11, 61, 38, 14, -51 },
  { 8114, 22, 49, 38, 8, -45 },
  { 8249, 11, 61, 38, 13, -51 },
  { 8333, 22, 24, 38, 8, -45 },
  { 8399, 27, 3, 38, 5, 0 },
  { 8410, 10, 8, 38, 14, -46 },
  { 8420, 28, 35, 38, 5, -34 },
  { 8543, 27, 48, 38, 6, -47 },
  { 8705, 28, 35, 38, 5, -34 },
  { 8828, 27, 48, 38, 5, -47 },
  { 8990, 28, 35, 38, 5, -34 },
  { 9113, 29, 48, 38, 6, -48 },
  { 9287, 27, 47, 38, 5, -34 },
  { 9446, 26, 47, 38, 6, -47 },
  { 9599, 27, 45, 38, 7, -45 },
  { 9751, 20, 58, 38, 6, -45 },
  { 9896, 27, 47, 38, 7, -47 },
  { 10055, 27, 47, 38, 7, -47 },
  { 10214, 32, 34, 38, 3, -34 },
  { 10350, 26, 34, 38, 6, -34 },
  { 10461, 30, 35, 38, 4, -34 },
  { 10593, 27, 47, 38, 6, -34 },
  { 10752, 27, 47, 38, 5, -34 },
  { 10911, 22, 34, 38, 11, -34 },
  { 11005, 27, 35, 38, 6, -34 },
  { 11124, 27, 43, 38, 5, -42 },
  { 11270, 26, 34, 38, 6, -33 },
  { 11381, 31, 33, 38, 3, -33 },
  { 11509, 34, 33, 38, 2, -33 },
  { 11650, 31, 33, 38, 4, -33 },
  { 11778, 33, 46, 38, 2, -33 },
  { 11968, 29, 33, 38, 5, -33 },
  { 12088, 21, 61, 38, 10, -49 },
  { 12249, 3, 55, 38, 17, -45 },
  { 12270, 21, 61, 38, 10, -49 },
  { 12431, 34, 11, 38, 2, -24 },
};

const GFXfont RobotoMono_Light63pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light63pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light63pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _ROBOTOMONO_LIGHT63PT7B_H_
