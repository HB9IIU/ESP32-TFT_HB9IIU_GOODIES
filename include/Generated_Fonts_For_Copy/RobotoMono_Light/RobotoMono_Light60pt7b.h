#ifndef _ROBOTOMONO_LIGHT60PT7B_H_
#define _ROBOTOMONO_LIGHT60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light60pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x9F, 0xFF, 0xDC, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x06, 0xE0, 0x60,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x1C, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x03, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xF8,
  0x0F, 0xC0, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x78,
  0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1E, 0x38, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x39, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0xF8,
  0x3F, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x20, 0x0E,
  0x00, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x38, 0x1C,
  0x00, 0xE0, 0x0E, 0x07, 0x00, 0x1C, 0x03, 0x83, 0x80, 0x07, 0x01, 0xC1,
  0xE0, 0x00, 0xE0, 0xF0, 0x70, 0x00, 0x3F, 0xF8, 0x38, 0x00, 0x07, 0xFC,
  0x0E, 0x00, 0x00, 0x7E, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xC0, 0xFF,
  0x00, 0x00, 0x70, 0x7F, 0xE0, 0x00, 0x38, 0x3C, 0x3C, 0x00, 0x0E, 0x0E,
  0x03, 0x80, 0x07, 0x07, 0x00, 0xE0, 0x01, 0xC1, 0xC0, 0x38, 0x00, 0xE0,
  0x70, 0x07, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x07,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x30, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x78, 0x07, 0x80,
  0x01, 0xE0, 0x07, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x38, 0x78, 0x0F, 0x00, 0x70, 0xF0, 0x1F,
  0x00, 0xE3, 0xC0, 0x1E, 0x01, 0xC7, 0x00, 0x1E, 0x03, 0x9E, 0x00, 0x1E,
  0x0F, 0x3C, 0x00, 0x1E, 0x1C, 0x78, 0x00, 0x3E, 0x38, 0xE0, 0x00, 0x3C,
  0xF1, 0xE0, 0x00, 0x3D, 0xC3, 0xC0, 0x00, 0x3F, 0x87, 0x80, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF8, 0x0F, 0x00, 0x07, 0xF8,
  0x1F, 0x80, 0x3E, 0x78, 0x1F, 0xE7, 0xF8, 0xF8, 0x0F, 0xFF, 0xE0, 0xF8,
  0x0F, 0xFF, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x04, 0x00, 0x30, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x10, 0x40, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0,
  0x01, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x60, 0x0E, 0x00, 0x4F, 0x00, 0xC0,
  0x3D, 0xFC, 0x18, 0x3F, 0xFF, 0xF3, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0x38, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x78, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x0F, 0x00, 0x0F, 0x00, 0x40, 0x01, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x0E, 0x3C,
  0x78, 0xE3, 0xC7, 0x1E, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x21, 0xEF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x0F, 0x78, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7D, 0xC0, 0x00, 0x1F, 0xB8,
  0x00, 0x07, 0xF7, 0x00, 0x01, 0xEE, 0xE0, 0x00, 0x79, 0xFC, 0x00, 0x1E,
  0x3F, 0x80, 0x07, 0x87, 0xF0, 0x01, 0xE0, 0xFE, 0x00, 0x78, 0x1F, 0xC0,
  0x3E, 0x03, 0xF8, 0x0F, 0x00, 0x7F, 0x03, 0xC0, 0x0F, 0xE0, 0xF0, 0x01,
  0xFC, 0x3C, 0x00, 0x3F, 0x8F, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0xEF, 0xF0,
  0x00, 0x1D, 0xFC, 0x00, 0x03, 0xBF, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0E,
  0xF0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0E, 0x3C, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x70, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x80,
  0x7C, 0x01, 0xE0, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x3F, 0x00,
  0xFF, 0x07, 0xFF, 0x1F, 0xEF, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x1E, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x70,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07,
  0x38, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x0F, 0x80,
  0x03, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x38, 0x07,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0xFF,
  0xC0, 0x0E, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xF0, 0x3C,
  0x00, 0xFE, 0x06, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0xC1, 0xF0, 0x03,
  0xF0, 0x7F, 0x07, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0xFE, 0x00, 0x78,
  0xFF, 0xF8, 0x0E, 0x3F, 0xFF, 0x81, 0xCF, 0x81, 0xF8, 0x3B, 0xC0, 0x0F,
  0x87, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF7, 0xC0,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0x3C, 0x00,
  0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x03, 0xFD, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x3C, 0x00,
  0x1F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x39, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x1C, 0xF0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x1E,
  0x00, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0xF8, 0x03, 0xF8, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7C,
  0x01, 0xF0, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3C, 0x78, 0x00,
  0x07, 0x8F, 0x80, 0x01, 0xE0, 0xFC, 0x00, 0xF8, 0x0F, 0xF9, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3E, 0x03, 0xF0, 0x1E,
  0x00, 0x3E, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C,
  0x70, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x0E, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0xFC, 0xF0, 0x00, 0x7F, 0x1E, 0x00, 0x3B, 0xC7, 0xE0, 0x7E, 0xF0, 0x7F,
  0xFE, 0x3C, 0x0F, 0xFF, 0x0E, 0x00, 0xFE, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x10, 0xF9, 0xF7, 0xF7, 0xCF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x43, 0xE7, 0xDF, 0xDF, 0x3E, 0x04, 0x1F,
  0x1F, 0x3F, 0x1F, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x38,
  0x70, 0xF0, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0x80, 0xFC, 0x3E, 0x00, 0x3C,
  0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0C, 0x1C, 0x01, 0xF8, 0x0E, 0x1C, 0x07,
  0xFC, 0x0E, 0x38, 0x0F, 0xFE, 0x06, 0x38, 0x1E, 0x06, 0x07, 0x70, 0x1C,
  0x06, 0x07, 0x70, 0x38, 0x06, 0x07, 0x60, 0x38, 0x06, 0x03, 0x60, 0x70,
  0x0E, 0x03, 0xE0, 0x70, 0x0E, 0x03, 0xE0, 0x60, 0x0E, 0x03, 0xE0, 0x60,
  0x0E, 0x03, 0xE0, 0xE0, 0x0C, 0x03, 0xC0, 0xE0, 0x0C, 0x03, 0xC0, 0xE0,
  0x0C, 0x03, 0xC0, 0xE0, 0x0C, 0x07, 0xC0, 0xE0, 0x0C, 0x07, 0xC0, 0xE0,
  0x0C, 0x07, 0xC0, 0xE0, 0x1C, 0x06, 0xE0, 0xE0, 0x1C, 0x06, 0xE0, 0xE0,
  0x3C, 0x0E, 0xE0, 0x60, 0x7C, 0x0C, 0xE0, 0x70, 0xEE, 0x1C, 0x60, 0x7F,
  0xCF, 0x38, 0x70, 0x3F, 0x87, 0xF0, 0x70, 0x1F, 0x03, 0xE0, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03, 0x00, 0x03, 0xFC,
  0x3F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x38, 0x01, 0xE0, 0x00,
  0x70, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0x00,
  0x00, 0x70, 0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x78, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0x80, 0x3F, 0xE0, 0xE0, 0x00,
  0x7C, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3C, 0xE0,
  0x00, 0x07, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E,
  0xE0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x3C, 0xE0, 0x00, 0x1F, 0x38, 0x00, 0x0F, 0x8E, 0x00, 0x0F, 0xC3, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0E, 0x00, 0x3F, 0xC3,
  0x80, 0x00, 0xF8, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x03,
  0xEE, 0x00, 0x01, 0xF3, 0x80, 0x03, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0x81, 0xE0,
  0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x1C,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x80, 0x7C, 0x01,
  0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x60, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x00, 0xFC, 0x0F, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x1F,
  0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x3F, 0x80, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF9, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x7C, 0x00, 0x7C, 0x07, 0xC0,
  0x01, 0xF0, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0x87, 0xC0, 0x00, 0x3C, 0x1F, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x3C,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0xC0, 0x7C, 0x01, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x1E, 0x38, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x1F, 0x0E, 0x00, 0x01, 0xF0,
  0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0xF0, 0x07, 0x00, 0x0F, 0x80, 0x38, 0x00, 0xF8, 0x01, 0xC0, 0x0F,
  0x80, 0x0E, 0x00, 0x78, 0x00, 0x70, 0x07, 0x80, 0x03, 0x80, 0x78, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0xE0, 0x7C, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x38,
  0x7C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0E, 0x3F, 0x00, 0x00, 0x73, 0xFC,
  0x00, 0x03, 0xBD, 0xF0, 0x00, 0x1F, 0xC7, 0x80, 0x00, 0xFC, 0x1E, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xF0, 0x03, 0x80, 0x07, 0xC0, 0x1C, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0xC3,
  0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x0F, 0xB8, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xBF, 0x70, 0x00, 0xF7, 0xEE, 0x00, 0x1C, 0xFD, 0xE0, 0x03, 0x9F,
  0x9C, 0x00, 0xF3, 0xF3, 0x80, 0x1C, 0xFE, 0x78, 0x03, 0x9F, 0xC7, 0x00,
  0xE3, 0xF8, 0xE0, 0x1C, 0x7F, 0x0E, 0x07, 0x8F, 0xE1, 0xC0, 0xE1, 0xFC,
  0x3C, 0x1C, 0x3F, 0x83, 0x87, 0x87, 0xF0, 0x70, 0xE0, 0xFE, 0x0F, 0x3C,
  0x1F, 0xC0, 0xE7, 0x03, 0xF8, 0x1C, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x0F, 0x00,
  0xFE, 0x01, 0xE0, 0x1F, 0xC0, 0x18, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xEF, 0x00, 0x01, 0xF9, 0xC0, 0x00,
  0x7E, 0x78, 0x00, 0x1F, 0x8E, 0x00, 0x07, 0xE3, 0xC0, 0x01, 0xF8, 0x70,
  0x00, 0x7E, 0x1E, 0x00, 0x1F, 0x83, 0xC0, 0x07, 0xE0, 0xF0, 0x01, 0xF8,
  0x1E, 0x00, 0x7E, 0x07, 0x80, 0x1F, 0x80, 0xF0, 0x07, 0xE0, 0x1C, 0x01,
  0xF8, 0x07, 0x80, 0x7E, 0x00, 0xE0, 0x1F, 0x80, 0x3C, 0x07, 0xE0, 0x07,
  0x01, 0xF8, 0x01, 0xE0, 0x7E, 0x00, 0x3C, 0x1F, 0x80, 0x0F, 0x07, 0xE0,
  0x01, 0xE1, 0xF8, 0x00, 0x78, 0x7E, 0x00, 0x0F, 0x1F, 0x80, 0x01, 0xC7,
  0xE0, 0x00, 0x79, 0xF8, 0x00, 0x0E, 0x7E, 0x00, 0x03, 0xDF, 0x80, 0x00,
  0x77, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1C,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1E, 0x78,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0x38,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x78, 0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0xFF, 0x0F,
  0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x1E, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x0F, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x7E,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFC, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x0E,
  0x78, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xC3, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x60, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x70, 0x01, 0xFC, 0x0E, 0x00, 0x07,
  0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3C,
  0x70, 0x00, 0x0F, 0x8E, 0x00, 0x03, 0xE1, 0xC0, 0x01, 0xF8, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x78, 0x03,
  0x80, 0x07, 0x00, 0x70, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x01, 0xC0, 0x01,
  0xE0, 0x38, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x1C,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x78, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x7F,
  0x01, 0xF8, 0x00, 0xFC, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x0F,
  0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x06,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x0F, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x78, 0x07,
  0x80, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x3C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0xB8, 0x00, 0xE0, 0x03, 0x9C, 0x00, 0x70,
  0x01, 0xCE, 0x00, 0x7C, 0x00, 0xE7, 0x00, 0x3E, 0x00, 0x73, 0xC0, 0x1F,
  0x00, 0x39, 0xE0, 0x0F, 0x80, 0x3C, 0xF0, 0x07, 0xC0, 0x1E, 0x38, 0x07,
  0x70, 0x0E, 0x1C, 0x03, 0xB8, 0x07, 0x0E, 0x01, 0xDC, 0x03, 0x87, 0x00,
  0xEE, 0x01, 0xC3, 0x80, 0x77, 0x00, 0xE1, 0xE0, 0x31, 0xC0, 0xF0, 0xF0,
  0x38, 0xE0, 0x78, 0x38, 0x1C, 0x70, 0x38, 0x1C, 0x0E, 0x38, 0x1C, 0x0E,
  0x07, 0x1C, 0x0E, 0x07, 0x03, 0x86, 0x07, 0x03, 0x83, 0x83, 0x83, 0x81,
  0xE1, 0xC1, 0xC1, 0xC0, 0xF0, 0xE0, 0xE1, 0xE0, 0x38, 0x70, 0x70, 0xE0,
  0x1C, 0x38, 0x38, 0x70, 0x0E, 0x38, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x1C,
  0x03, 0x8E, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xC7, 0x00, 0xF3, 0x80, 0xE7,
  0x80, 0x3B, 0xC0, 0x3B, 0x80, 0x1D, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x07, 0x70, 0x07, 0x70, 0x03, 0xB8, 0x03, 0xB8, 0x01, 0xDC, 0x01,
  0xDC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0xF0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0xF8, 0xF0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x00,
  0x00, 0x70, 0x1E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1C, 0xE0,
  0x00, 0x73, 0x80, 0x03, 0xCF, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x78, 0x01,
  0xC0, 0xE0, 0x07, 0x03, 0x80, 0x3C, 0x0F, 0x00, 0xE0, 0x1C, 0x07, 0x80,
  0x78, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x83, 0xC0, 0x0F, 0x0E, 0x00, 0x1C,
  0x78, 0x00, 0x79, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x7E, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x1F, 0xF8, 0x03,
  0x8F, 0xC0, 0x00, 0xE7, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x0E, 0xF0, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0,
  0x00, 0x07, 0xBC, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF9, 0xE0, 0x00, 0xFE,
  0x7E, 0x00, 0xFB, 0xCF, 0xFF, 0xFC, 0xF0, 0xFF, 0xFC, 0x3C, 0x1F, 0xFC,
  0x0F, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x03, 0xFC,
  0x03, 0x87, 0xFF, 0x81, 0xCF, 0xFF, 0xF0, 0xEF, 0x80, 0xFC, 0x7F, 0x00,
  0x1E, 0x3F, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x3B, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x3C, 0xFC, 0x00,
  0x3C, 0x77, 0x80, 0x7E, 0x39, 0xFF, 0xFE, 0x1C, 0x7F, 0xFE, 0x0E, 0x0F,
  0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xC3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x0E, 0x78, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0x78,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x3C,
  0x0F, 0x80, 0x3E, 0x01, 0xFE, 0x7F, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x07, 0xFC,
  0x1C, 0x0F, 0xFF, 0x0E, 0x0F, 0xFF, 0xE7, 0x0F, 0x80, 0x7B, 0x8F, 0x80,
  0x1F, 0xCF, 0x00, 0x07, 0xE7, 0x80, 0x01, 0xF7, 0x80, 0x00, 0x7B, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0x1E, 0x00,
  0x1F, 0x8F, 0xC0, 0x3D, 0xC3, 0xFF, 0xFC, 0xE0, 0x7F, 0xFC, 0x70, 0x1F,
  0xF8, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0xF0,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x08,
  0x1F, 0x00, 0x00, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0x3F,
  0xCF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0xFE, 0x03, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0x83, 0x81, 0xFF, 0xF1,
  0xC1, 0xFF, 0xFC, 0xE1, 0xF0, 0x0F, 0x71, 0xF0, 0x03, 0xF9, 0xE0, 0x00,
  0xFC, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xE3, 0xC0, 0x03, 0xF1, 0xF8, 0x07,
  0xB8, 0x7F, 0xFF, 0x9C, 0x0F, 0xFF, 0x8E, 0x03, 0xFF, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0x3F,
  0x00, 0x7C, 0x07, 0xF1, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x01, 0xFF, 0x03, 0x83,
  0xFF, 0xC1, 0xC7, 0xFF, 0xF8, 0xE7, 0xC0, 0x7E, 0x77, 0x80, 0x0F, 0x3B,
  0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x77, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x80, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF, 0x01,
  0xFE, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xEF,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x3E,
  0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x0F, 0x01, 0xE0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x3C,
  0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xDF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xDE, 0x00, 0x0F, 0xE3, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0xF0, 0x1F,
  0x00, 0x3C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xC0, 0x0F, 0x00, 0xF0,
  0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0,
  0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x1E, 0xF0, 0x00, 0x03, 0xC0, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE3, 0xF8, 0x0F, 0xE3,
  0x9F, 0xF8, 0xFF, 0xCE, 0xFF, 0xE7, 0xFF, 0xBF, 0x07, 0xF8, 0x1F, 0xF0,
  0x0F, 0xC0, 0x3F, 0xC0, 0x1E, 0x00, 0x7E, 0x00, 0x78, 0x01, 0xF8, 0x01,
  0xE0, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x1E, 0x00, 0x7E, 0x00, 0x78,
  0x01, 0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x1E, 0x00,
  0x7E, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0x1F,
  0x80, 0x1E, 0x00, 0x7E, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0xE0,
  0x07, 0x80, 0x1F, 0x80, 0x1E, 0x00, 0x7E, 0x00, 0x78, 0x01, 0xF8, 0x01,
  0xE0, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x1E, 0x00, 0x7E, 0x00, 0x78,
  0x01, 0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x1E, 0x00,
  0x7E, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x3F, 0xC0, 0x70,
  0x7F, 0xF8, 0x38, 0xFF, 0xFF, 0x1C, 0xF0, 0x0F, 0x8E, 0xF0, 0x01, 0xE7,
  0x60, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x07,
  0x70, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E,
  0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xE0, 0xFF, 0x80, 0x71,
  0xFF, 0xF0, 0x39, 0xFF, 0xFC, 0x1D, 0xE0, 0x1F, 0x0F, 0xE0, 0x07, 0xC7,
  0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0F,
  0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0E, 0xE0,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0x9F, 0x80, 0x07, 0x8E,
  0xE0, 0x0F, 0xC7, 0x7F, 0xBF, 0xC3, 0x8F, 0xFF, 0xC1, 0xC1, 0xFF, 0x80,
  0xE0, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x83, 0x81, 0xFF, 0xF1, 0xC1, 0xFF, 0xFC, 0xE1,
  0xF0, 0x0F, 0x71, 0xF0, 0x03, 0xF9, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x3E,
  0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x03, 0xBC, 0x00, 0x03, 0xCF,
  0x00, 0x03, 0xE3, 0xC0, 0x03, 0xF1, 0xF8, 0x07, 0xB8, 0x7F, 0xBF, 0xDC,
  0x0F, 0xFF, 0x8E, 0x03, 0xFF, 0x07, 0x00, 0x18, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x3F, 0xFF, 0x07,
  0xFF, 0xB8, 0x7F, 0xFD, 0xCF, 0xE0, 0x2E, 0x78, 0x00, 0x77, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xE0, 0x0F, 0xC3, 0xC0, 0x01, 0xF3,
  0xC0, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xE3,
  0xE0, 0x03, 0xF0, 0xFF, 0x9F, 0xF0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00,
  0x3F, 0x3E, 0x00, 0xF7, 0x1F, 0xFF, 0xE7, 0x0F, 0xFF, 0xC7, 0x07, 0xFF,
  0x07, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x78, 0x0E, 0x00,
  0x01, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0xE0, 0x07, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xF0, 0x00, 0xE0, 0x03,
  0xBC, 0x00, 0xF0, 0x01, 0xCE, 0x00, 0x78, 0x00, 0xE7, 0x00, 0x3E, 0x00,
  0xF3, 0x80, 0x1F, 0x00, 0x71, 0xC0, 0x1F, 0x80, 0x38, 0xF0, 0x0E, 0xC0,
  0x1C, 0x38, 0x07, 0x70, 0x0E, 0x1C, 0x03, 0x38, 0x0F, 0x0E, 0x03, 0x9C,
  0x07, 0x07, 0x01, 0xCE, 0x03, 0x81, 0xC0, 0xE3, 0x81, 0xC0, 0xE0, 0x61,
  0xC0, 0xE0, 0x70, 0x70, 0xE0, 0xE0, 0x38, 0x38, 0x70, 0x70, 0x1C, 0x1C,
  0x1C, 0x38, 0x07, 0x0C, 0x0E, 0x1C, 0x03, 0x8E, 0x07, 0x0E, 0x01, 0xC7,
  0x03, 0x8E, 0x00, 0xE3, 0x80, 0xE7, 0x00, 0x31, 0x80, 0x73, 0x80, 0x1D,
  0xC0, 0x39, 0xC0, 0x0E, 0xE0, 0x1C, 0xC0, 0x07, 0x70, 0x06, 0xE0, 0x03,
  0xB0, 0x03, 0xF0, 0x00, 0xD8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x03, 0x80, 0xF8, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x07, 0x80,
  0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x3C,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x03, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0x80,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x70, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x11, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x0F, 0xE0,
  0x01, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x1E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x1E, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0x3F, 0xFE, 0x00, 0x07, 0x7C, 0x3F, 0x00, 0x07, 0x70, 0x0F,
  0xC0, 0x07, 0xF0, 0x03, 0xE0, 0x0E, 0xE0, 0x01, 0xF0, 0x1E, 0xE0, 0x00,
  0xFF, 0xFC, 0xE0, 0x00, 0x3F, 0xF8, 0x20, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0x80,
};

const GFXglyph RobotoMono_Light60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 5, 43, 36, 15, -43 },
  { 28, 12, 13, 36, 12, -45 },
  { 48, 32, 43, 36, 2, -43 },
  { 220, 27, 55, 36, 5, -49 },
  { 406, 34, 44, 36, 1, -43 },
  { 593, 31, 44, 36, 4, -43 },
  { 764, 3, 13, 36, 15, -45 },
  { 769, 14, 62, 36, 11, -48 },
  { 878, 14, 62, 36, 10, -48 },
  { 987, 27, 26, 36, 5, -43 },
  { 1075, 30, 31, 36, 3, -35 },
  { 1192, 7, 15, 36, 11, -6 },
  { 1206, 22, 3, 36, 7, -21 },
  { 1215, 6, 6, 36, 16, -6 },
  { 1220, 21, 47, 36, 8, -43 },
  { 1344, 27, 44, 36, 5, -43 },
  { 1493, 16, 43, 36, 6, -43 },
  { 1579, 28, 43, 36, 3, -43 },
  { 1730, 27, 44, 36, 3, -43 },
  { 1879, 31, 43, 36, 2, -43 },
  { 2046, 26, 44, 36, 6, -43 },
  { 2189, 27, 44, 36, 4, -43 },
  { 2338, 28, 43, 36, 4, -43 },
  { 2489, 27, 44, 36, 5, -43 },
  { 2638, 26, 43, 36, 5, -43 },
  { 2778, 7, 32, 36, 17, -32 },
  { 2806, 8, 41, 36, 15, -32 },
  { 2847, 25, 25, 36, 5, -32 },
  { 2926, 26, 15, 36, 5, -27 },
  { 2975, 26, 25, 36, 5, -32 },
  { 3057, 24, 43, 36, 6, -43 },
  { 3186, 32, 43, 36, 2, -43 },
  { 3358, 31, 43, 36, 3, -43 },
  { 3525, 26, 43, 36, 6, -43 },
  { 3665, 28, 44, 36, 4, -43 },
  { 3819, 28, 43, 36, 5, -43 },
  { 3970, 25, 43, 36, 6, -43 },
  { 4105, 25, 43, 36, 6, -43 },
  { 4240, 29, 44, 36, 3, -43 },
  { 4400, 26, 43, 36, 5, -43 },
  { 4540, 24, 43, 36, 6, -43 },
  { 4669, 27, 44, 36, 3, -43 },
  { 4818, 29, 43, 36, 6, -43 },
  { 4974, 26, 43, 36, 6, -43 },
  { 5114, 27, 43, 36, 5, -43 },
  { 5260, 26, 43, 36, 5, -43 },
  { 5400, 28, 44, 36, 4, -43 },
  { 5554, 27, 43, 36, 6, -43 },
  { 5700, 30, 50, 36, 3, -43 },
  { 5888, 27, 43, 36, 6, -43 },
  { 6034, 29, 44, 36, 4, -43 },
  { 6194, 30, 43, 36, 3, -43 },
  { 6356, 26, 44, 36, 5, -43 },
  { 6499, 30, 43, 36, 3, -43 },
  { 6661, 33, 43, 36, 2, -43 },
  { 6839, 31, 43, 36, 3, -43 },
  { 7006, 31, 43, 36, 2, -43 },
  { 7173, 27, 43, 36, 4, -43 },
  { 7319, 10, 58, 36, 13, -49 },
  { 7392, 21, 47, 36, 8, -43 },
  { 7516, 10, 58, 36, 13, -49 },
  { 7589, 22, 23, 36, 7, -43 },
  { 7653, 26, 3, 36, 5, 0 },
  { 7663, 10, 8, 36, 13, -44 },
  { 7673, 26, 33, 36, 5, -32 },
  { 7781, 25, 46, 36, 6, -45 },
  { 7925, 26, 33, 36, 5, -32 },
  { 8033, 25, 46, 36, 5, -45 },
  { 8177, 28, 33, 36, 4, -32 },
  { 8293, 28, 46, 36, 5, -46 },
  { 8454, 25, 45, 36, 5, -32 },
  { 8595, 25, 45, 36, 6, -45 },
  { 8736, 26, 43, 36, 6, -43 },
  { 8876, 18, 56, 36, 6, -43 },
  { 9002, 26, 45, 36, 6, -45 },
  { 9149, 26, 45, 36, 6, -45 },
  { 9296, 30, 32, 36, 3, -32 },
  { 9416, 25, 32, 36, 6, -32 },
  { 9516, 28, 33, 36, 4, -32 },
  { 9632, 25, 44, 36, 6, -32 },
  { 9770, 25, 44, 36, 5, -32 },
  { 9908, 21, 32, 36, 11, -32 },
  { 9992, 25, 33, 36, 6, -32 },
  { 10096, 25, 41, 36, 5, -40 },
  { 10225, 24, 33, 36, 6, -32 },
  { 10324, 30, 32, 36, 3, -32 },
  { 10444, 33, 32, 36, 2, -32 },
  { 10576, 29, 32, 36, 4, -32 },
  { 10692, 32, 45, 36, 2, -32 },
  { 10872, 28, 32, 36, 4, -32 },
  { 10984, 19, 59, 36, 10, -47 },
  { 11125, 3, 53, 36, 17, -43 },
  { 11145, 19, 59, 36, 10, -47 },
  { 11286, 32, 11, 36, 2, -23 },
};

const GFXfont RobotoMono_Light60pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light60pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light60pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _ROBOTOMONO_LIGHT60PT7B_H_
