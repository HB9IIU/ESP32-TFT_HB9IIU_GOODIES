#ifndef _ROBOTOMONO_LIGHT6PT7B_H_
#define _ROBOTOMONO_LIGHT6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light6pt7bBitmaps[] PROGMEM = {
  0x00, 0xE0, 0xC0, 0x7D, 0x50, 0xB9, 0xE0, 0xF5, 0xB0, 0xEA, 0xF0, 0xC0,
  0x6A, 0xB0, 0xFC, 0xF0, 0x4B, 0xA0, 0xC0, 0xC0, 0x80, 0x5A, 0xF7, 0xF0,
  0xF0, 0xE5, 0x70, 0xEC, 0xF0, 0x2F, 0x90, 0xF7, 0x7E, 0xF0, 0xE5, 0x20,
  0xFF, 0xF5, 0xB0, 0x90, 0x98, 0x7C, 0xF0, 0xB0, 0xD8, 0xF6, 0xF0, 0x4F,
  0xD0, 0xFF, 0xF2, 0x70, 0xFF, 0xFB, 0xFA, 0xF2, 0xF0, 0xBE, 0xD0, 0xEB,
  0x24, 0xF0, 0xEB, 0xAB, 0xBF, 0xD0, 0xBE, 0xD0, 0xF6, 0xF0, 0xFA, 0xF6,
  0xF2, 0xFF, 0xE8, 0xF0, 0xE9, 0x20, 0xB6, 0xF0, 0xB5, 0x20, 0xFE, 0xB0,
  0xE9, 0x50, 0xA9, 0x20, 0xE9, 0x70, 0xFC, 0xA9, 0xFC, 0xB0, 0xE0, 0x80,
  0xEF, 0x80, 0xAF, 0xC0, 0xF3, 0x80, 0x2E, 0xDE, 0xFB, 0x80, 0x7A, 0x80,
  0xF6, 0xF0, 0xAF, 0xC0, 0x2B, 0x78, 0xAE, 0xC0, 0xAA, 0xC0, 0xFF, 0x80,
  0xFC, 0xF7, 0x80, 0xFE, 0xF7, 0x90, 0xE8, 0xDC, 0xE9, 0x30, 0xFC, 0xAD,
  0x00, 0xEE, 0x80, 0xEA, 0x80, 0xAD, 0x60, 0xEB, 0x80, 0x6A, 0x90, 0xF8,
  0xA9, 0xA0, 0xE0,
};

const GFXglyph RobotoMono_Light6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 1, 2, 4, 1, -5 },
  { 3, 3, 4, 4, 0, -4 },
  { 5, 2, 6, 4, 1, -5 },
  { 7, 3, 4, 4, 0, -4 },
  { 9, 3, 4, 4, 0, -4 },
  { 11, 1, 2, 4, 1, -5 },
  { 12, 2, 6, 4, 1, -5 },
  { 14, 1, 6, 4, 1, -5 },
  { 15, 2, 2, 4, 1, -4 },
  { 16, 3, 4, 4, 0, -4 },
  { 18, 1, 2, 4, 1, -1 },
  { 19, 2, 1, 4, 1, -2 },
  { 20, 1, 1, 4, 1, -1 },
  { 21, 2, 4, 4, 1, -4 },
  { 22, 3, 4, 4, 0, -4 },
  { 24, 1, 4, 4, 1, -4 },
  { 25, 3, 4, 4, 0, -4 },
  { 27, 3, 4, 4, 0, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 2, 4, 4, 1, -4 },
  { 32, 3, 4, 4, 0, -4 },
  { 34, 3, 4, 4, 0, -4 },
  { 36, 2, 4, 4, 1, -4 },
  { 37, 3, 4, 4, 0, -4 },
  { 39, 1, 4, 4, 2, -4 },
  { 40, 1, 5, 4, 1, -4 },
  { 41, 3, 2, 4, 0, -3 },
  { 42, 2, 2, 4, 1, -3 },
  { 43, 2, 2, 4, 1, -3 },
  { 44, 2, 4, 4, 1, -4 },
  { 45, 3, 4, 4, 0, -4 },
  { 47, 3, 4, 4, 0, -4 },
  { 49, 2, 4, 4, 1, -4 },
  { 50, 3, 4, 4, 0, -4 },
  { 52, 2, 4, 4, 1, -4 },
  { 53, 2, 4, 4, 1, -4 },
  { 54, 2, 4, 4, 1, -4 },
  { 55, 3, 4, 4, 0, -4 },
  { 57, 3, 4, 4, 0, -4 },
  { 59, 2, 4, 4, 1, -4 },
  { 60, 3, 4, 4, 0, -4 },
  { 62, 2, 4, 4, 1, -4 },
  { 63, 2, 4, 4, 1, -4 },
  { 64, 3, 4, 4, 0, -4 },
  { 66, 3, 4, 4, 0, -4 },
  { 68, 3, 4, 4, 0, -4 },
  { 70, 2, 4, 4, 1, -4 },
  { 71, 3, 5, 4, 0, -4 },
  { 73, 2, 4, 4, 1, -4 },
  { 74, 3, 4, 4, 0, -4 },
  { 76, 3, 4, 4, 0, -4 },
  { 78, 3, 4, 4, 0, -4 },
  { 80, 3, 4, 4, 0, -4 },
  { 82, 3, 4, 4, 0, -4 },
  { 84, 3, 4, 4, 0, -4 },
  { 86, 3, 4, 4, 0, -4 },
  { 88, 3, 4, 4, 0, -4 },
  { 90, 1, 6, 4, 1, -5 },
  { 91, 2, 4, 4, 1, -4 },
  { 92, 1, 6, 4, 1, -5 },
  { 93, 2, 2, 4, 1, -4 },
  { 94, 3, 1, 4, 0, 0 },
  { 95, 1, 1, 4, 1, -5 },
  { 96, 3, 3, 4, 0, -3 },
  { 98, 2, 5, 4, 1, -5 },
  { 100, 3, 3, 4, 0, -3 },
  { 102, 3, 5, 4, 0, -5 },
  { 104, 3, 3, 4, 0, -3 },
  { 106, 2, 5, 4, 1, -5 },
  { 108, 3, 4, 4, 0, -3 },
  { 110, 2, 5, 4, 1, -5 },
  { 112, 2, 4, 4, 1, -4 },
  { 113, 1, 5, 4, 1, -4 },
  { 114, 2, 5, 4, 1, -5 },
  { 116, 2, 5, 4, 1, -5 },
  { 118, 3, 3, 4, 0, -3 },
  { 120, 2, 3, 4, 1, -3 },
  { 121, 3, 3, 4, 0, -3 },
  { 123, 2, 4, 4, 1, -3 },
  { 124, 3, 4, 4, 0, -3 },
  { 126, 2, 3, 4, 1, -3 },
  { 127, 2, 3, 4, 1, -3 },
  { 128, 3, 4, 4, 0, -4 },
  { 130, 2, 3, 4, 1, -3 },
  { 131, 3, 3, 4, 0, -3 },
  { 133, 3, 3, 4, 0, -3 },
  { 135, 3, 3, 4, 0, -3 },
  { 137, 3, 4, 4, 0, -3 },
  { 139, 3, 3, 4, 0, -3 },
  { 141, 2, 6, 4, 1, -5 },
  { 143, 1, 5, 4, 1, -4 },
  { 144, 2, 6, 4, 1, -5 },
  { 146, 3, 1, 4, 0, -2 },
};

const GFXfont RobotoMono_Light6pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light6pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOMONO_LIGHT6PT7B_H_
