#ifndef _ROBOTOMONO_LIGHT10PT7B_H_
#define _ROBOTOMONO_LIGHT10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xFC, 0x28, 0xA7, 0xCA, 0xF9, 0x45, 0x00, 0x2D, 0x98, 0x61,
  0x9D, 0x20, 0xE2, 0xAF, 0x08, 0x3D, 0x51, 0xC0, 0xE5, 0x28, 0x8A, 0xCB,
  0xA0, 0xE0, 0x5A, 0xAA, 0x90, 0xA5, 0x55, 0x60, 0x2F, 0x2D, 0x44, 0xF4,
  0x40, 0xC0, 0xF0, 0x80, 0x12, 0x22, 0x44, 0x48, 0xF9, 0x9F, 0x99, 0xF0,
  0x74, 0x92, 0x48, 0x74, 0x42, 0x22, 0x21, 0xE0, 0x74, 0x42, 0x60, 0xC5,
  0xC0, 0x11, 0x4A, 0x9F, 0x84, 0x20, 0xF8, 0xE1, 0x19, 0x70, 0x68, 0xE9,
  0x99, 0xF0, 0xF1, 0x22, 0x24, 0x40, 0xF9, 0x96, 0x99, 0xF0, 0xF9, 0x99,
  0x71, 0x60, 0x88, 0x8C, 0x3C, 0x61, 0xFF, 0xC3, 0x68, 0xF9, 0x12, 0x40,
  0x40, 0x79, 0x5B, 0x75, 0xD6, 0xA7, 0x80, 0x10, 0xC3, 0x12, 0x79, 0x28,
  0x40, 0xF9, 0x9F, 0x99, 0xF0, 0xF9, 0x88, 0x89, 0xF0, 0xE9, 0x99, 0x99,
  0xE0, 0xF8, 0x8F, 0x88, 0xF0, 0xF8, 0x8F, 0x88, 0x80, 0xF9, 0x8A, 0x99,
  0x70, 0x99, 0x9F, 0x99, 0x90, 0xF4, 0x44, 0x44, 0xF0, 0x11, 0x11, 0x19,
  0xE0, 0x9D, 0x31, 0x8A, 0x4A, 0x20, 0x88, 0x88, 0x88, 0xF0, 0x99, 0xBF,
  0xD9, 0x90, 0x99, 0xDB, 0xB9, 0x90, 0xF9, 0x99, 0x99, 0x60, 0xF4, 0x63,
  0xE8, 0x42, 0x00, 0xF4, 0xA3, 0x18, 0xC9, 0xC2, 0xF4, 0xA5, 0xEA, 0x4A,
  0x60, 0xF9, 0x86, 0x19, 0xF0, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x00, 0x99,
  0x99, 0x99, 0xF0, 0x85, 0x24, 0x92, 0x30, 0xC2, 0x00, 0x96, 0x57, 0x5E,
  0x59, 0x24, 0x80, 0x9C, 0x98, 0x46, 0x4A, 0x60, 0xCD, 0x23, 0x0C, 0x20,
  0x82, 0x00, 0xF1, 0x24, 0x48, 0xF0, 0xEA, 0xAA, 0xB0, 0x84, 0x44, 0x22,
  0x11, 0xD5, 0x55, 0x70, 0x46, 0x99, 0xF0, 0xC0, 0xF1, 0xF9, 0xF0, 0x88,
  0xE9, 0x99, 0x9F, 0xF9, 0x89, 0x70, 0x11, 0x79, 0x99, 0x9F, 0xF9, 0xE8,
  0x70, 0x34, 0xF4, 0x44, 0x44, 0xF9, 0x99, 0xF1, 0xE0, 0x88, 0xAD, 0x99,
  0x99, 0x2C, 0x22, 0x22, 0xF0, 0x38, 0x92, 0x49, 0xE0, 0x88, 0x8B, 0xCC,
  0xA9, 0xE2, 0x22, 0x22, 0x2F, 0xFE, 0x9A, 0x69, 0xA4, 0xF9, 0x99, 0x90,
  0xF9, 0x99, 0xF0, 0xF9, 0x99, 0xF8, 0x80, 0xF9, 0x99, 0xF1, 0x10, 0xF2,
  0x48, 0xF8, 0x71, 0xF0, 0x4F, 0x44, 0x44, 0x30, 0x99, 0x99, 0xF0, 0x99,
  0xA6, 0x40, 0x96, 0xD7, 0x92, 0x48, 0x96, 0x26, 0x90, 0xCD, 0x24, 0x8C,
  0x10, 0x86, 0x00, 0xF2, 0x48, 0xF0, 0x29, 0x29, 0x12, 0x44, 0xFF, 0x80,
  0x89, 0x24, 0xD2, 0x50, 0x66, 0x60,
};

const GFXglyph RobotoMono_Light10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 7, 6, 2, -7 },
  { 2, 2, 3, 6, 2, -8 },
  { 3, 6, 7, 6, 0, -7 },
  { 9, 4, 9, 6, 1, -8 },
  { 14, 6, 7, 6, 0, -7 },
  { 20, 5, 7, 6, 1, -7 },
  { 25, 1, 3, 6, 2, -8 },
  { 26, 2, 10, 6, 2, -8 },
  { 29, 2, 10, 6, 2, -8 },
  { 32, 4, 4, 6, 1, -7 },
  { 34, 4, 5, 6, 1, -6 },
  { 37, 1, 2, 6, 2, -1 },
  { 38, 4, 1, 6, 1, -4 },
  { 39, 1, 1, 6, 3, -1 },
  { 40, 4, 8, 6, 1, -7 },
  { 44, 4, 7, 6, 1, -7 },
  { 48, 3, 7, 6, 1, -7 },
  { 51, 5, 7, 6, 0, -7 },
  { 56, 5, 7, 6, 0, -7 },
  { 61, 5, 7, 6, 0, -7 },
  { 66, 4, 7, 6, 1, -7 },
  { 70, 4, 7, 6, 1, -7 },
  { 74, 4, 7, 6, 1, -7 },
  { 78, 4, 7, 6, 1, -7 },
  { 82, 4, 7, 6, 1, -7 },
  { 86, 1, 5, 6, 3, -5 },
  { 87, 1, 6, 6, 3, -5 },
  { 88, 4, 4, 6, 1, -5 },
  { 90, 4, 2, 6, 1, -4 },
  { 91, 4, 4, 6, 1, -5 },
  { 93, 4, 7, 6, 1, -7 },
  { 97, 6, 7, 6, 0, -7 },
  { 103, 6, 7, 6, 0, -7 },
  { 109, 4, 7, 6, 1, -7 },
  { 113, 4, 7, 6, 1, -7 },
  { 117, 4, 7, 6, 1, -7 },
  { 121, 4, 7, 6, 1, -7 },
  { 125, 4, 7, 6, 1, -7 },
  { 129, 4, 7, 6, 1, -7 },
  { 133, 4, 7, 6, 1, -7 },
  { 137, 4, 7, 6, 1, -7 },
  { 141, 4, 7, 6, 1, -7 },
  { 145, 5, 7, 6, 1, -7 },
  { 150, 4, 7, 6, 1, -7 },
  { 154, 4, 7, 6, 1, -7 },
  { 158, 4, 7, 6, 1, -7 },
  { 162, 4, 7, 6, 1, -7 },
  { 166, 5, 7, 6, 1, -7 },
  { 171, 5, 8, 6, 1, -7 },
  { 176, 5, 7, 6, 1, -7 },
  { 181, 4, 7, 6, 1, -7 },
  { 185, 6, 7, 6, 0, -7 },
  { 191, 4, 7, 6, 1, -7 },
  { 195, 6, 7, 6, 0, -7 },
  { 201, 6, 7, 6, 0, -7 },
  { 207, 5, 7, 6, 1, -7 },
  { 212, 6, 7, 6, 0, -7 },
  { 218, 4, 7, 6, 1, -7 },
  { 222, 2, 10, 6, 2, -8 },
  { 225, 4, 8, 6, 1, -7 },
  { 229, 2, 10, 6, 2, -8 },
  { 232, 4, 4, 6, 1, -7 },
  { 234, 4, 1, 6, 1, 0 },
  { 235, 2, 1, 6, 2, -7 },
  { 236, 4, 5, 6, 1, -5 },
  { 239, 4, 8, 6, 1, -8 },
  { 243, 4, 5, 6, 1, -5 },
  { 246, 4, 8, 6, 1, -8 },
  { 250, 4, 5, 6, 1, -5 },
  { 253, 4, 8, 6, 1, -8 },
  { 257, 4, 7, 6, 1, -5 },
  { 261, 4, 8, 6, 1, -8 },
  { 265, 4, 7, 6, 1, -7 },
  { 269, 3, 9, 6, 1, -7 },
  { 273, 4, 8, 6, 1, -8 },
  { 277, 4, 8, 6, 1, -8 },
  { 281, 6, 5, 6, 0, -5 },
  { 285, 4, 5, 6, 1, -5 },
  { 288, 4, 5, 6, 1, -5 },
  { 291, 4, 7, 6, 1, -5 },
  { 295, 4, 7, 6, 1, -5 },
  { 299, 3, 5, 6, 2, -5 },
  { 301, 4, 5, 6, 1, -5 },
  { 304, 4, 7, 6, 1, -7 },
  { 308, 4, 5, 6, 1, -5 },
  { 311, 4, 5, 6, 1, -5 },
  { 314, 6, 5, 6, 0, -5 },
  { 318, 4, 5, 6, 1, -5 },
  { 321, 6, 7, 6, 0, -5 },
  { 327, 4, 5, 6, 1, -5 },
  { 330, 3, 10, 6, 2, -8 },
  { 334, 1, 9, 6, 3, -7 },
  { 336, 3, 10, 6, 2, -8 },
  { 340, 6, 2, 6, 0, -4 },
};

const GFXfont RobotoMono_Light10pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light10pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOMONO_LIGHT10PT7B_H_
