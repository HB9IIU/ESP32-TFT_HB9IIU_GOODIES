#ifndef _ROBOTOMONO_LIGHT66PT7B_H_
#define _ROBOTOMONO_LIGHT66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light66pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1D, 0xFF, 0xFF, 0xC0, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x38, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x1C, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x1E, 0x38, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x3E, 0x3E, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x40, 0x0E, 0x00, 0xF0, 0x03, 0x80, 0xF0,
  0x03, 0x80, 0x38, 0x07, 0x80, 0x1C, 0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x1C,
  0x01, 0xE0, 0x07, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0xF0, 0x01, 0xC0, 0x1E, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x70, 0x00,
  0x78, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x38, 0x00, 0x0F, 0x8F, 0x81,
  0xC0, 0x00, 0x3F, 0xF8, 0x1C, 0x00, 0x00, 0x7F, 0x81, 0xE0, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x1C, 0x07, 0xF8,
  0x00, 0x00, 0xE0, 0x7F, 0xE0, 0x00, 0x0E, 0x07, 0x8F, 0x80, 0x00, 0xF0,
  0x78, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x70, 0x00, 0x78, 0x38, 0x03, 0xC0,
  0x03, 0x81, 0xC0, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x70,
  0x03, 0x80, 0x1C, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x08, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x7C,
  0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00,
  0x7C, 0x78, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x1F, 0x03, 0xE0, 0x07,
  0x8F, 0x80, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x00, 0x71, 0xF0, 0x01, 0xE0,
  0x1C, 0x78, 0x00, 0x7C, 0x0F, 0x1E, 0x00, 0x0F, 0x83, 0xC7, 0x00, 0x01,
  0xF0, 0xF3, 0xC0, 0x00, 0x3C, 0x78, 0xF0, 0x00, 0x0F, 0x9E, 0x3C, 0x00,
  0x01, 0xFF, 0x07, 0x00, 0x00, 0x3F, 0xC1, 0xE0, 0x00, 0x07, 0xE0, 0x78,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0xC0,
  0x7C, 0x00, 0x1F, 0xF8, 0x1F, 0xC0, 0x1F, 0x9E, 0x03, 0xFF, 0xFF, 0x83,
  0xC0, 0x3F, 0xFF, 0xC0, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x06, 0x00, 0x02,
  0x40, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x40, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x38, 0x01, 0xDF, 0x01, 0xC0, 0x7F, 0xFF, 0x0E, 0x0F, 0xF7,
  0xFF, 0x73, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x3E, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x3C,
  0x00, 0x7C, 0x03, 0xC0, 0x01, 0xF0, 0x06, 0x00, 0x06, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0xF1, 0xE7, 0x9F, 0x1C, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0xFD, 0xFF, 0xF7,
  0xEF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x1F, 0x80,
  0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x3C,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x7E, 0xF0, 0x00, 0x03, 0xFB, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xF3, 0xFC, 0x00, 0x0F, 0x8F, 0xF0, 0x00, 0x7C, 0x3F,
  0xC0, 0x03, 0xE0, 0xFF, 0x00, 0x1F, 0x03, 0xFC, 0x00, 0xF8, 0x0F, 0xF0,
  0x07, 0x80, 0x3F, 0xC0, 0x3C, 0x00, 0xFF, 0x01, 0xE0, 0x03, 0xFC, 0x0F,
  0x00, 0x0F, 0xF0, 0x78, 0x00, 0x3F, 0xC7, 0xC0, 0x00, 0xFF, 0x3E, 0x00,
  0x03, 0xFD, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xEF, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3C, 0x03, 0xE0,
  0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x03, 0xC0, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0xFF, 0xBD, 0xFF, 0x1F,
  0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0xF8,
  0x07, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC3, 0xFC, 0x00, 0x39, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x03, 0xF0, 0x0F, 0xF8, 0x7C, 0x00, 0x3F, 0x81, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x9F, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x07, 0xC0, 0x03, 0x83, 0xFF, 0xC0, 0x1C, 0x3F, 0xFF, 0x81, 0xE7, 0xFF,
  0xFE, 0x0F, 0x7C, 0x01, 0xF8, 0x7F, 0x80, 0x03, 0xE3, 0xF8, 0x00, 0x0F,
  0x9F, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x3C, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x03, 0xE0, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x01, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xC0,
  0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE3, 0xE0,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x1F,
  0xC7, 0x80, 0x01, 0xFE, 0x3F, 0x00, 0x1E, 0xF0, 0xFC, 0x03, 0xE7, 0x83,
  0xFF, 0xFE, 0x3C, 0x0F, 0xFF, 0xE1, 0xC0, 0x1F, 0xFC, 0x0E, 0x00, 0x04,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x38, 0xFB, 0xFF, 0xFF,
  0xEF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8F, 0xBF, 0xFF,
  0xFE, 0xF8, 0x1E, 0x0F, 0x8F, 0xE7, 0xF3, 0xF0, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x78,
  0x78, 0x18, 0x04, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0, 0x7E,
  0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x1E, 0x78, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0xFF, 0x01, 0xC1, 0xC0, 0x1F,
  0xF8, 0x0C, 0x1C, 0x03, 0xF7, 0xC0, 0xE3, 0x80, 0x78, 0x1C, 0x0E, 0x38,
  0x0E, 0x01, 0xC0, 0xE3, 0x01, 0xE0, 0x1C, 0x06, 0x70, 0x1C, 0x01, 0x80,
  0x67, 0x01, 0xC0, 0x18, 0x06, 0x70, 0x38, 0x01, 0x80, 0x76, 0x03, 0x80,
  0x18, 0x07, 0xE0, 0x38, 0x03, 0x80, 0x7E, 0x03, 0x00, 0x38, 0x07, 0xE0,
  0x70, 0x03, 0x80, 0x7E, 0x07, 0x00, 0x38, 0x06, 0xE0, 0x70, 0x03, 0x80,
  0x6E, 0x07, 0x00, 0x38, 0x06, 0xE0, 0x70, 0x03, 0x80, 0x6E, 0x07, 0x00,
  0x30, 0x0E, 0xE0, 0x70, 0x07, 0x00, 0xEE, 0x07, 0x00, 0x70, 0x0C, 0xE0,
  0x70, 0x0F, 0x00, 0xCE, 0x07, 0x80, 0xF0, 0x1C, 0xE0, 0x38, 0x1F, 0x81,
  0x87, 0x03, 0xC3, 0xB8, 0x38, 0x70, 0x3F, 0xF1, 0xCF, 0x07, 0x01, 0xFE,
  0x1F, 0xE0, 0x78, 0x0F, 0xC0, 0xFC, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x40, 0x00, 0x3F, 0x00,
  0x1E, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xE0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3C,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0x3E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x7F, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0xFF, 0x83, 0xC0, 0x00,
  0x3F, 0x0F, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0xFC, 0x3C, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3C, 0x01, 0xFF, 0x00, 0xF0, 0x00,
  0x7E, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xE0,
  0x3C, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1D, 0xE0, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x07, 0x1F, 0x00, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x03,
  0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x3C, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xF0, 0x1F, 0x80, 0x7F, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x00,
  0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0xF1, 0xF8, 0x00, 0x00,
  0xF1, 0xFC, 0x00, 0x00, 0xF3, 0xFE, 0x00, 0x00, 0xF7, 0xDF, 0x00, 0x00,
  0xFF, 0x8F, 0x00, 0x00, 0xFF, 0x0F, 0x80, 0x00, 0xFE, 0x07, 0xC0, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF7, 0x00, 0x03, 0xBF, 0xDE,
  0x00, 0x1E, 0xFF, 0x78, 0x00, 0x7B, 0xFC, 0xE0, 0x01, 0xCF, 0xF3, 0xC0,
  0x0F, 0x3F, 0xC7, 0x00, 0x38, 0xFF, 0x1E, 0x01, 0xE3, 0xFC, 0x78, 0x07,
  0x8F, 0xF0, 0xE0, 0x1C, 0x3F, 0xC3, 0xC0, 0xF0, 0xFF, 0x0F, 0x03, 0xC3,
  0xFC, 0x1C, 0x1E, 0x0F, 0xF0, 0x78, 0x78, 0x3F, 0xC1, 0xE1, 0xC0, 0xFF,
  0x03, 0x8F, 0x03, 0xFC, 0x0F, 0x3C, 0x0F, 0xF0, 0x3C, 0xE0, 0x3F, 0xC0,
  0x77, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x0F,
  0xC0, 0x3F, 0xC0, 0x3E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0,
  0x0F, 0xF0, 0x07, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xF7, 0x80, 0x00, 0x3F, 0xBC, 0x00, 0x01, 0xFC, 0xF0,
  0x00, 0x0F, 0xE7, 0x80, 0x00, 0x7F, 0x1E, 0x00, 0x03, 0xF8, 0xF0, 0x00,
  0x1F, 0xC3, 0xC0, 0x00, 0xFE, 0x1F, 0x00, 0x07, 0xF0, 0x78, 0x00, 0x3F,
  0x81, 0xE0, 0x01, 0xFC, 0x0F, 0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x7F, 0x01,
  0xE0, 0x03, 0xF8, 0x07, 0x80, 0x1F, 0xC0, 0x3C, 0x00, 0xFE, 0x00, 0xF0,
  0x07, 0xF0, 0x07, 0x80, 0x3F, 0x80, 0x1E, 0x01, 0xFC, 0x00, 0xF8, 0x0F,
  0xE0, 0x03, 0xC0, 0x7F, 0x00, 0x0F, 0x03, 0xF8, 0x00, 0x78, 0x1F, 0xC0,
  0x01, 0xE0, 0xFE, 0x00, 0x0F, 0x07, 0xF0, 0x00, 0x3C, 0x3F, 0x80, 0x01,
  0xE1, 0xFC, 0x00, 0x07, 0x8F, 0xE0, 0x00, 0x3C, 0x7F, 0x00, 0x00, 0xF3,
  0xF8, 0x00, 0x07, 0xDF, 0xC0, 0x00, 0x1E, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00,
  0x1E, 0x70, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x1E, 0x70, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1C, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x7C, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00,
  0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x1F,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x3F, 0xE0, 0xF0, 0x00, 0x0F, 0xC3,
  0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0xFB, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x7E, 0x3C, 0x00, 0x07, 0xF0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xE3, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x01, 0xC0, 0x07, 0xFC, 0x0E, 0x00, 0x03, 0xF0, 0x70,
  0x00, 0x07, 0xC3, 0x80, 0x00, 0x1F, 0x1C, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x7E, 0x1C, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xC0, 0x03, 0xC0, 0x0E, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x78, 0x03, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0x1F, 0x38, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x03, 0xEE, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3E,
  0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x3C, 0x3E, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xFE, 0x00, 0x3C, 0x00,
  0x3F, 0xC0, 0x07, 0xC0, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0xEF, 0x00, 0x1F,
  0x00, 0x1D, 0xE0, 0x03, 0xE0, 0x03, 0x9C, 0x00, 0xFC, 0x00, 0xF3, 0x80,
  0x1F, 0x80, 0x1E, 0x78, 0x03, 0xF8, 0x03, 0xCF, 0x00, 0x77, 0x00, 0x79,
  0xE0, 0x0E, 0xE0, 0x0F, 0x3C, 0x01, 0xDC, 0x01, 0xC7, 0x80, 0x7B, 0x80,
  0x38, 0x70, 0x0E, 0x78, 0x07, 0x0E, 0x01, 0xC7, 0x01, 0xE1, 0xC0, 0x38,
  0xE0, 0x3C, 0x3C, 0x07, 0x1C, 0x07, 0x87, 0x81, 0xE3, 0x80, 0xF0, 0xF0,
  0x38, 0x78, 0x1C, 0x1E, 0x07, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70,
  0x38, 0x1C, 0x1C, 0x1E, 0x07, 0x07, 0x83, 0x83, 0xC0, 0xF0, 0xF0, 0x70,
  0x78, 0x1E, 0x1C, 0x0F, 0x0F, 0x03, 0xC3, 0x80, 0xE1, 0xC0, 0x78, 0x70,
  0x1C, 0x38, 0x07, 0x0E, 0x03, 0x87, 0x00, 0xE3, 0xC0, 0x70, 0xE0, 0x1C,
  0x70, 0x0F, 0x3C, 0x03, 0xCE, 0x01, 0xE7, 0x80, 0x79, 0xC0, 0x1C, 0xF0,
  0x0F, 0x38, 0x03, 0x9C, 0x01, 0xEF, 0x00, 0x73, 0x80, 0x1D, 0xE0, 0x0F,
  0x70, 0x03, 0xB8, 0x01, 0xEE, 0x00, 0x77, 0x00, 0x1F, 0xC0, 0x0E, 0xE0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xCF, 0x00,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x0F,
  0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF8,
  0x3C, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xEF, 0x00, 0x01, 0xE7, 0x00, 0x01, 0xE7, 0x80, 0x03, 0xC7, 0x80,
  0x03, 0xC3, 0xC0, 0x03, 0x83, 0xC0, 0x07, 0x81, 0xC0, 0x07, 0x01, 0xE0,
  0x0F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x1E, 0x00, 0x70,
  0x1C, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x3C,
  0x78, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x1E, 0x03, 0xC0,
  0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFC, 0x01, 0xFC,
  0x0F, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x1F, 0x00,
  0x00, 0x79, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0xC7, 0xC0,
  0x03, 0xFE, 0x3F, 0x80, 0x7E, 0x78, 0xFF, 0xFF, 0xE3, 0xC1, 0xFF, 0xFC,
  0x1E, 0x07, 0xFF, 0x80, 0xF0, 0x03, 0xA0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x08, 0x00, 0x1E, 0x07, 0xFE, 0x00, 0xF0, 0xFF, 0xFC, 0x07, 0x9F,
  0xFF, 0xF0, 0x3D, 0xF8, 0x0F, 0xC1, 0xEE, 0x00, 0x1F, 0x0F, 0xE0, 0x00,
  0x7C, 0x7E, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07,
  0x8F, 0xE0, 0x00, 0x7C, 0x7F, 0x80, 0x07, 0xC3, 0xDF, 0x00, 0xFC, 0x1E,
  0x7F, 0xFF, 0xC0, 0xF1, 0xFF, 0xFC, 0x07, 0x83, 0xFF, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xC0, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x78, 0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x7C, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x04, 0x00, 0xF0, 0x07, 0xFE,
  0x0F, 0x01, 0xFF, 0xF8, 0xF0, 0x3F, 0xFF, 0xCF, 0x07, 0xE0, 0x3E, 0xF0,
  0xF8, 0x00, 0xFF, 0x1F, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0x3F, 0x3C, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x7F, 0x07, 0xE0,
  0x1F, 0xF0, 0x3F, 0xFF, 0xEF, 0x01, 0xFF, 0xF8, 0xF0, 0x0F, 0xFE, 0x07,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC1, 0xF0, 0x00, 0x07,
  0x83, 0xF0, 0x00, 0x7C, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x04, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x07, 0xFE, 0x07, 0x01, 0xFF, 0xF8, 0x70, 0x3F, 0xFF,
  0xC7, 0x07, 0xE0, 0x3E, 0xF0, 0xF8, 0x00, 0xFF, 0x1F, 0x00, 0x07, 0xF1,
  0xE0, 0x00, 0x3F, 0x3C, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xFF, 0xEF, 0x01, 0xFF,
  0xF8, 0xF0, 0x0F, 0xFF, 0x0F, 0x00, 0x06, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x18, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x07,
  0xC1, 0xF8, 0x01, 0xF8, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x01, 0x80, 0x0F, 0x01,
  0xFF, 0x80, 0xF0, 0x7F, 0xFE, 0x0F, 0x0F, 0xFF, 0xF0, 0xF1, 0xE0, 0x1F,
  0x8F, 0x38, 0x00, 0x7C, 0xF7, 0x00, 0x03, 0xCF, 0xE0, 0x00, 0x1E, 0xFC,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x82, 0x03, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x80, 0x78, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x80, 0x07, 0x80, 0xF8,
  0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0x78, 0xF8, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x1E, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xF9, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x3E,
  0x00, 0x0F, 0x00, 0xF8, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xC0, 0x3C,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x30, 0x00, 0x40, 0x38, 0x7F, 0x80, 0xFF, 0x0E, 0x7F, 0xF8, 0xFF,
  0xE3, 0xBF, 0xFE, 0x7F, 0xFC, 0xEE, 0x07, 0xFC, 0x0F, 0xBE, 0x00, 0xFC,
  0x01, 0xEF, 0x80, 0x3F, 0x00, 0x7B, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01,
  0xE0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xC0,
  0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xFF,
  0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x03,
  0xFC, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0x80,
  0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E,
  0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x00,
  0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xF0,
  0x01, 0xE0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3F,
  0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x78, 0x00,
  0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x01, 0x80,
  0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x7F, 0xFE, 0x0F, 0x1F, 0xFF, 0xF0, 0xF3,
  0xE0, 0x1F, 0x8F, 0x38, 0x00, 0x7C, 0xF7, 0x00, 0x03, 0xCF, 0xE0, 0x00,
  0x3E, 0xFC, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x02, 0x00, 0x0F, 0x07, 0xFF, 0x00, 0xF0, 0xFF,
  0xFC, 0x0F, 0x3F, 0xFF, 0xE0, 0xF7, 0xC0, 0x7F, 0x0F, 0xF0, 0x01, 0xF8,
  0xFE, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3C,
  0xFC, 0x00, 0x07, 0xCF, 0xF0, 0x00, 0xF8, 0xF7, 0xC0, 0x3F, 0x0F, 0x3F,
  0xFF, 0xE0, 0xF1, 0xFF, 0xFC, 0x0F, 0x07, 0xFF, 0x00, 0xF0, 0x07, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0xFE, 0x07, 0x01, 0xFF, 0xF8, 0x70, 0x3F, 0xFF, 0xCF, 0x07, 0xE0, 0x3E,
  0xF0, 0xF8, 0x00, 0xFF, 0x1F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F, 0x3C,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0xF3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x7F, 0x07,
  0xE0, 0x1F, 0xF0, 0x3F, 0xFF, 0xEF, 0x01, 0xFF, 0xF8, 0xF0, 0x07, 0xFF,
  0x0F, 0x00, 0x06, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xC1, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xF7, 0x0F, 0xFF, 0xEE, 0x3F,
  0xC0, 0xDC, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xC0, 0x1F,
  0xC1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x1F, 0x78,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x1F,
  0x80, 0x0F, 0xC0, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x07, 0xBC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x0F,
  0xCF, 0x80, 0x07, 0xB8, 0xFC, 0x03, 0xE7, 0x0F, 0xFF, 0xF8, 0xE0, 0xFF,
  0xFE, 0x1C, 0x07, 0xFF, 0x03, 0x80, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x38, 0x07, 0x80,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0x1C, 0x1E, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x70, 0x00, 0xF0, 0x00, 0xF7,
  0x00, 0x0F, 0x00, 0x0E, 0x70, 0x00, 0xF8, 0x00, 0xE7, 0x80, 0x1F, 0x80,
  0x1E, 0x78, 0x01, 0xF8, 0x01, 0xE3, 0x80, 0x1F, 0x80, 0x1C, 0x38, 0x01,
  0x9C, 0x01, 0xC3, 0xC0, 0x39, 0xC0, 0x1C, 0x3C, 0x03, 0x9C, 0x03, 0xC1,
  0xC0, 0x39, 0xC0, 0x3C, 0x1C, 0x03, 0x9E, 0x03, 0x81, 0xC0, 0x70, 0xE0,
  0x38, 0x1E, 0x07, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0xE0, 0x78, 0x0E, 0x07,
  0x0F, 0x07, 0x00, 0xE0, 0xE0, 0x70, 0x70, 0x0E, 0x0E, 0x07, 0x07, 0x00,
  0xF0, 0xE0, 0x70, 0x70, 0x07, 0x0E, 0x07, 0x8F, 0x00, 0x71, 0xC0, 0x38,
  0xE0, 0x07, 0x1C, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x38, 0xE0, 0x07, 0x9C,
  0x03, 0x8E, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x03, 0xB8, 0x01, 0xDC, 0x00,
  0x3B, 0x80, 0x1D, 0xC0, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0x3E, 0x3C, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1E, 0x7C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x3C,
  0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x23, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x0F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0x1F, 0xFF, 0x80, 0x00, 0xF3, 0xE1, 0xFC, 0x00, 0x0E, 0x78,
  0x03, 0xE0, 0x00, 0xE7, 0x00, 0x1F, 0x80, 0x1E, 0xF0, 0x00, 0xFC, 0x03,
  0xCE, 0x00, 0x07, 0xF0, 0xFC, 0xE0, 0x00, 0x1F, 0xFF, 0x8E, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
};

const GFXglyph RobotoMono_Light66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 5, 47, 40, 17, -47 },
  { 31, 13, 15, 40, 13, -50 },
  { 56, 36, 47, 40, 2, -47 },
  { 268, 29, 61, 40, 6, -54 },
  { 490, 37, 49, 40, 1, -48 },
  { 717, 34, 49, 40, 4, -48 },
  { 926, 3, 15, 40, 17, -50 },
  { 932, 16, 68, 40, 12, -53 },
  { 1068, 16, 68, 40, 11, -53 },
  { 1204, 29, 29, 40, 6, -47 },
  { 1310, 32, 34, 40, 4, -39 },
  { 1446, 7, 16, 40, 12, -6 },
  { 1460, 24, 4, 40, 8, -23 },
  { 1472, 7, 6, 40, 17, -6 },
  { 1478, 23, 51, 40, 9, -47 },
  { 1625, 30, 49, 40, 5, -48 },
  { 1809, 17, 47, 40, 7, -47 },
  { 1909, 31, 48, 40, 3, -48 },
  { 2095, 30, 49, 40, 3, -48 },
  { 2279, 33, 47, 40, 3, -47 },
  { 2473, 28, 48, 40, 7, -47 },
  { 2641, 29, 48, 40, 5, -47 },
  { 2815, 31, 47, 40, 4, -47 },
  { 2998, 30, 49, 40, 6, -48 },
  { 3182, 29, 48, 40, 5, -48 },
  { 3356, 7, 34, 40, 19, -34 },
  { 3386, 9, 44, 40, 17, -34 },
  { 3436, 28, 28, 40, 5, -35 },
  { 3534, 28, 17, 40, 6, -30 },
  { 3594, 28, 28, 40, 6, -35 },
  { 3692, 26, 48, 40, 7, -48 },
  { 3848, 36, 47, 40, 2, -47 },
  { 4060, 34, 47, 40, 3, -47 },
  { 4260, 30, 47, 40, 6, -47 },
  { 4437, 31, 49, 40, 4, -48 },
  { 4627, 30, 47, 40, 6, -47 },
  { 4804, 28, 47, 40, 6, -47 },
  { 4969, 28, 47, 40, 7, -47 },
  { 5134, 31, 49, 40, 4, -48 },
  { 5324, 29, 47, 40, 5, -47 },
  { 5495, 27, 47, 40, 6, -47 },
  { 5654, 29, 48, 40, 4, -47 },
  { 5828, 32, 47, 40, 6, -47 },
  { 6016, 28, 47, 40, 7, -47 },
  { 6181, 30, 47, 40, 5, -47 },
  { 6358, 29, 47, 40, 5, -47 },
  { 6529, 32, 49, 40, 4, -48 },
  { 6725, 30, 47, 40, 7, -47 },
  { 6902, 33, 56, 40, 3, -48 },
  { 7133, 29, 47, 40, 7, -47 },
  { 7304, 32, 49, 40, 4, -48 },
  { 7500, 34, 47, 40, 3, -47 },
  { 7700, 30, 48, 40, 5, -47 },
  { 7880, 34, 47, 40, 3, -47 },
  { 8080, 35, 47, 40, 3, -47 },
  { 8286, 34, 47, 40, 3, -47 },
  { 8486, 34, 47, 40, 2, -47 },
  { 8686, 30, 47, 40, 4, -47 },
  { 8863, 11, 64, 40, 15, -54 },
  { 8951, 23, 51, 40, 8, -47 },
  { 9098, 11, 64, 40, 14, -54 },
  { 9186, 24, 25, 40, 8, -47 },
  { 9261, 28, 3, 40, 6, 0 },
  { 9272, 10, 8, 40, 15, -48 },
  { 9282, 29, 37, 40, 5, -36 },
  { 9417, 29, 51, 40, 6, -50 },
  { 9602, 29, 37, 40, 5, -36 },
  { 9737, 28, 51, 40, 5, -50 },
  { 9916, 30, 37, 40, 5, -36 },
  { 10055, 30, 51, 40, 6, -51 },
  { 10247, 28, 50, 40, 5, -36 },
  { 10422, 28, 50, 40, 6, -50 },
  { 10597, 28, 47, 40, 7, -47 },
  { 10762, 21, 61, 40, 6, -47 },
  { 10923, 29, 50, 40, 7, -50 },
  { 11105, 28, 50, 40, 7, -50 },
  { 11280, 34, 36, 40, 3, -36 },
  { 11433, 28, 36, 40, 6, -36 },
  { 11559, 31, 37, 40, 4, -36 },
  { 11703, 28, 49, 40, 6, -36 },
  { 11875, 28, 49, 40, 5, -36 },
  { 12047, 23, 36, 40, 12, -36 },
  { 12151, 28, 37, 40, 6, -36 },
  { 12281, 28, 45, 40, 5, -44 },
  { 12439, 27, 36, 40, 6, -35 },
  { 12561, 33, 35, 40, 3, -35 },
  { 12706, 36, 35, 40, 2, -35 },
  { 12864, 32, 35, 40, 4, -35 },
  { 13004, 35, 49, 40, 2, -35 },
  { 13219, 30, 35, 40, 5, -35 },
  { 13351, 21, 64, 40, 11, -51 },
  { 13519, 3, 58, 40, 18, -47 },
  { 13541, 21, 64, 40, 11, -51 },
  { 13709, 36, 11, 40, 2, -25 },
};

const GFXfont RobotoMono_Light66pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light66pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light66pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _ROBOTOMONO_LIGHT66PT7B_H_
