#ifndef _ROBOTOMONO_LIGHT17PT7B_H_
#define _ROBOTOMONO_LIGHT17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light17pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0x03, 0x99, 0x99, 0x09, 0x82, 0x40, 0x91, 0xFF, 0x11,
  0x04, 0x41, 0x20, 0x48, 0xFF, 0x88, 0x82, 0x20, 0x90, 0x08, 0x08, 0x3E,
  0x42, 0x41, 0x40, 0x60, 0x38, 0x06, 0x03, 0x81, 0x41, 0x43, 0x3E, 0x08,
  0x08, 0x70, 0x22, 0x48, 0x92, 0x28, 0x74, 0x01, 0x00, 0x80, 0x2E, 0x12,
  0x45, 0x12, 0x24, 0x0E, 0x3C, 0x22, 0x11, 0x08, 0x82, 0x81, 0x81, 0xC0,
  0x92, 0x85, 0x41, 0xB0, 0xCF, 0xB0, 0xF0, 0x11, 0x24, 0x44, 0x88, 0x88,
  0x88, 0x44, 0x42, 0x21, 0x88, 0x42, 0x22, 0x11, 0x11, 0x11, 0x22, 0x24,
  0x48, 0x10, 0x22, 0x4B, 0xE3, 0x05, 0x11, 0x00, 0x08, 0x08, 0x08, 0x08,
  0xFF, 0x08, 0x08, 0x08, 0x08, 0x57, 0xFC, 0x70, 0x04, 0x10, 0x82, 0x08,
  0x41, 0x08, 0x20, 0x84, 0x10, 0x80, 0x3C, 0x42, 0x41, 0x83, 0x85, 0x89,
  0x91, 0xA1, 0xC1, 0x41, 0x42, 0x3C, 0x1F, 0x91, 0x11, 0x11, 0x11, 0x11,
  0x7C, 0x82, 0x82, 0x02, 0x02, 0x04, 0x08, 0x18, 0x30, 0x20, 0x40, 0xFF,
  0x7D, 0x86, 0x08, 0x10, 0x27, 0x81, 0x01, 0x03, 0x07, 0x0B, 0xE0, 0x04,
  0x0C, 0x0C, 0x14, 0x24, 0x24, 0x44, 0x84, 0xFF, 0x04, 0x04, 0x04, 0x7E,
  0x82, 0x04, 0x0B, 0x99, 0x81, 0x81, 0x03, 0x07, 0x1B, 0xE0, 0x1C, 0x20,
  0x40, 0x40, 0xBC, 0xC2, 0x82, 0x81, 0x81, 0x41, 0x42, 0x3C, 0xFF, 0x01,
  0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x3E, 0x43,
  0x41, 0x41, 0x42, 0x3C, 0x22, 0x41, 0x81, 0x41, 0x43, 0x3E, 0x3C, 0x42,
  0x42, 0x81, 0x81, 0x41, 0x43, 0x3D, 0x02, 0x02, 0x04, 0x38, 0xB0, 0x02,
  0xC0, 0x4C, 0x00, 0x02, 0x4B, 0x00, 0x02, 0x18, 0xC6, 0x03, 0x01, 0x80,
  0x80, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xC0, 0x60, 0x31, 0xCC, 0x20,
  0x00, 0x7D, 0x0A, 0x18, 0x20, 0x41, 0x04, 0x08, 0x20, 0x00, 0x01, 0x80,
  0x1F, 0x08, 0x24, 0x49, 0x29, 0x52, 0x64, 0x99, 0x26, 0x49, 0x56, 0x92,
  0x42, 0x00, 0x78, 0x08, 0x0C, 0x05, 0x02, 0x82, 0x41, 0x20, 0x88, 0x84,
  0x7E, 0x20, 0xA0, 0x50, 0x30, 0xF9, 0x0A, 0x0C, 0x18, 0x5F, 0x21, 0x41,
  0x83, 0x06, 0x1F, 0xC0, 0x3E, 0x42, 0x41, 0x81, 0x80, 0x80, 0x80, 0x80,
  0x81, 0x41, 0x42, 0x3C, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x82, 0xFC, 0xFF, 0x02, 0x04, 0x08, 0x1F, 0xA0, 0x40, 0x81,
  0x02, 0x07, 0xF0, 0xFF, 0x02, 0x04, 0x08, 0x1F, 0xA0, 0x40, 0x81, 0x02,
  0x04, 0x00, 0x3E, 0x42, 0xC1, 0x80, 0x80, 0x80, 0x8F, 0x81, 0x81, 0x41,
  0x41, 0x3E, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x47,
  0xF0, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x82, 0x42,
  0x7C, 0x82, 0x84, 0x88, 0x90, 0xB0, 0xE0, 0xD0, 0x98, 0x88, 0x84, 0x86,
  0x83, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x07, 0xF0,
  0xC3, 0xC3, 0xA3, 0xA5, 0xA5, 0x95, 0x99, 0x99, 0x81, 0x81, 0x81, 0x81,
  0xC1, 0xC1, 0xA1, 0xA1, 0x91, 0x91, 0x89, 0x89, 0x85, 0x83, 0x83, 0x81,
  0x3C, 0x42, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42, 0x3C,
  0xFD, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0x40, 0x81, 0x02, 0x04, 0x00, 0x3C,
  0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x02,
  0x01, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0xBE, 0x44, 0x8D, 0x0A, 0x0C, 0x10,
  0x3E, 0x43, 0xC1, 0x40, 0x40, 0x38, 0x06, 0x01, 0x01, 0x81, 0x41, 0x3E,
  0xFF, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42, 0x3C,
  0x81, 0x81, 0x41, 0x42, 0x42, 0x22, 0x24, 0x24, 0x24, 0x18, 0x18, 0x18,
  0x88, 0xC4, 0x66, 0x53, 0x29, 0x54, 0xA9, 0x94, 0xCA, 0x65, 0x31, 0x18,
  0x88, 0x40, 0xC1, 0x21, 0x08, 0x84, 0x81, 0x40, 0xC0, 0x60, 0x28, 0x24,
  0x31, 0x10, 0x50, 0x30, 0x81, 0xC3, 0x42, 0x64, 0x24, 0x38, 0x18, 0x10,
  0x10, 0x10, 0x10, 0x10, 0xFF, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x20, 0x40, 0x40, 0xFF, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0xE0, 0x81,
  0x04, 0x10, 0x20, 0x81, 0x04, 0x10, 0x20, 0x81, 0x04, 0xD5, 0x55, 0x55,
  0x55, 0xC0, 0x30, 0xC2, 0x92, 0x4A, 0x10, 0xFF, 0xD0, 0x3C, 0x42, 0x41,
  0x01, 0x3F, 0x41, 0x81, 0x43, 0x7D, 0x81, 0x02, 0x04, 0x0F, 0x90, 0xA0,
  0xC1, 0x83, 0x06, 0x0C, 0x2F, 0x80, 0x3C, 0x42, 0x41, 0x80, 0x80, 0x80,
  0x41, 0x42, 0x3C, 0x01, 0x01, 0x01, 0x01, 0x3D, 0x43, 0x41, 0x81, 0x81,
  0x81, 0x41, 0x43, 0x3D, 0x3C, 0x42, 0x41, 0x81, 0xFF, 0x80, 0x40, 0x41,
  0x3E, 0x0F, 0x18, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x3D, 0x43, 0x41, 0x81, 0x81, 0x81, 0x41, 0x43, 0x3D, 0x01,
  0x42, 0x66, 0x18, 0x81, 0x02, 0x04, 0x0B, 0xD8, 0xA0, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x20, 0x10, 0x00, 0x07, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x47, 0xF0, 0x18, 0x01, 0xF0, 0x84, 0x21, 0x08, 0x42, 0x10, 0x8C, 0xD8,
  0x81, 0x02, 0x04, 0x08, 0x71, 0x24, 0x50, 0xE1, 0x22, 0x24, 0x28, 0x60,
  0xF0, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8F, 0xE0,
  0xF7, 0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0xBD, 0x8A, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x82, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x42, 0x3C, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0xF9, 0x02, 0x04,
  0x00, 0x3D, 0x43, 0x41, 0x81, 0x81, 0x81, 0x41, 0x43, 0x3D, 0x01, 0x01,
  0x01, 0xBF, 0x08, 0x20, 0x82, 0x08, 0x20, 0x80, 0x7D, 0x0E, 0x0E, 0x03,
  0x80, 0xE0, 0xC1, 0x7C, 0x10, 0x10, 0xFE, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x0F, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x7A, 0x81,
  0x41, 0x42, 0x42, 0x24, 0x24, 0x14, 0x18, 0x18, 0x88, 0xCC, 0x66, 0x53,
  0x29, 0x53, 0x29, 0x98, 0xC4, 0x42, 0x00, 0xC1, 0x62, 0x24, 0x18, 0x08,
  0x1C, 0x24, 0x42, 0xC1, 0x81, 0xC0, 0x90, 0x88, 0x42, 0x61, 0x20, 0x50,
  0x30, 0x08, 0x08, 0x04, 0x04, 0x0C, 0x00, 0xFF, 0x02, 0x04, 0x08, 0x18,
  0x10, 0x20, 0x40, 0xFF, 0x18, 0x88, 0x42, 0x10, 0x88, 0xC1, 0x08, 0x42,
  0x10, 0x43, 0xFF, 0xFE, 0xC2, 0x08, 0x42, 0x10, 0x82, 0x19, 0x08, 0x42,
  0x11, 0x18, 0x20, 0x16, 0x18, 0x78,
};

const GFXglyph RobotoMono_Light17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 12, 10, 4, -12 },
  { 4, 4, 4, 10, 3, -13 },
  { 6, 10, 12, 10, 0, -12 },
  { 21, 8, 16, 10, 1, -14 },
  { 37, 10, 12, 10, 0, -12 },
  { 52, 9, 12, 10, 1, -12 },
  { 66, 1, 4, 10, 4, -13 },
  { 67, 4, 18, 10, 3, -14 },
  { 76, 4, 18, 10, 3, -14 },
  { 85, 7, 7, 10, 2, -12 },
  { 92, 8, 9, 10, 1, -10 },
  { 101, 2, 4, 10, 3, -2 },
  { 102, 6, 1, 10, 2, -6 },
  { 103, 2, 2, 10, 4, -2 },
  { 104, 6, 13, 10, 2, -12 },
  { 114, 8, 12, 10, 1, -12 },
  { 126, 4, 12, 10, 2, -12 },
  { 132, 8, 12, 10, 1, -12 },
  { 144, 7, 12, 10, 1, -12 },
  { 155, 8, 12, 10, 1, -12 },
  { 167, 7, 12, 10, 2, -12 },
  { 178, 8, 12, 10, 1, -12 },
  { 190, 8, 12, 10, 1, -12 },
  { 202, 8, 12, 10, 1, -12 },
  { 214, 8, 12, 10, 1, -12 },
  { 226, 2, 9, 10, 5, -9 },
  { 229, 3, 11, 10, 4, -9 },
  { 234, 7, 7, 10, 1, -9 },
  { 241, 8, 5, 10, 1, -8 },
  { 246, 7, 7, 10, 2, -9 },
  { 253, 7, 12, 10, 2, -12 },
  { 264, 10, 12, 10, 0, -12 },
  { 279, 9, 12, 10, 1, -12 },
  { 293, 7, 12, 10, 2, -12 },
  { 304, 8, 12, 10, 1, -12 },
  { 316, 8, 12, 10, 1, -12 },
  { 328, 7, 12, 10, 2, -12 },
  { 339, 7, 12, 10, 2, -12 },
  { 350, 8, 12, 10, 1, -12 },
  { 362, 8, 12, 10, 1, -12 },
  { 374, 7, 12, 10, 2, -12 },
  { 385, 8, 12, 10, 1, -12 },
  { 397, 8, 12, 10, 2, -12 },
  { 409, 7, 12, 10, 2, -12 },
  { 420, 8, 12, 10, 1, -12 },
  { 432, 8, 12, 10, 1, -12 },
  { 444, 8, 12, 10, 1, -12 },
  { 456, 7, 12, 10, 2, -12 },
  { 467, 8, 14, 10, 1, -12 },
  { 481, 7, 12, 10, 2, -12 },
  { 492, 8, 12, 10, 1, -12 },
  { 504, 8, 12, 10, 1, -12 },
  { 516, 8, 12, 10, 1, -12 },
  { 528, 8, 12, 10, 1, -12 },
  { 540, 9, 12, 10, 1, -12 },
  { 554, 9, 12, 10, 1, -12 },
  { 568, 8, 12, 10, 1, -12 },
  { 580, 8, 12, 10, 1, -12 },
  { 592, 3, 17, 10, 4, -14 },
  { 599, 6, 13, 10, 2, -12 },
  { 609, 2, 17, 10, 4, -14 },
  { 614, 6, 6, 10, 2, -12 },
  { 619, 8, 1, 10, 1, 0 },
  { 620, 2, 2, 10, 4, -12 },
  { 621, 8, 9, 10, 1, -9 },
  { 630, 7, 13, 10, 2, -13 },
  { 642, 8, 9, 10, 1, -9 },
  { 651, 8, 13, 10, 1, -13 },
  { 664, 8, 9, 10, 1, -9 },
  { 673, 8, 13, 10, 1, -13 },
  { 686, 8, 13, 10, 1, -9 },
  { 699, 7, 13, 10, 2, -13 },
  { 711, 7, 12, 10, 2, -12 },
  { 722, 5, 16, 10, 2, -12 },
  { 732, 7, 13, 10, 2, -13 },
  { 744, 7, 13, 10, 2, -13 },
  { 756, 8, 9, 10, 1, -9 },
  { 765, 7, 9, 10, 2, -9 },
  { 773, 8, 9, 10, 1, -9 },
  { 782, 7, 12, 10, 2, -9 },
  { 793, 8, 12, 10, 1, -9 },
  { 805, 6, 9, 10, 3, -9 },
  { 812, 7, 9, 10, 2, -9 },
  { 820, 8, 11, 10, 1, -11 },
  { 831, 7, 9, 10, 2, -9 },
  { 839, 8, 9, 10, 1, -9 },
  { 848, 9, 9, 10, 1, -9 },
  { 859, 8, 9, 10, 1, -9 },
  { 868, 9, 13, 10, 1, -9 },
  { 883, 8, 9, 10, 1, -9 },
  { 892, 5, 16, 10, 3, -13 },
  { 902, 1, 15, 10, 5, -12 },
  { 904, 5, 16, 10, 3, -13 },
  { 914, 10, 3, 10, 0, -7 },
};

const GFXfont RobotoMono_Light17pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light17pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOMONO_LIGHT17PT7B_H_
