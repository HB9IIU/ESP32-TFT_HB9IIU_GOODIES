#ifndef _ROBOTOMONO_LIGHT53PT7B_H_
#define _ROBOTOMONO_LIGHT53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light53pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xFF,
  0xB8, 0xE0, 0xFC, 0x1D, 0x83, 0xB0, 0x76, 0x0E, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0,
  0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x38, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30,
  0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x03, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x1C, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xC0, 0x18,
  0x00, 0x0C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01,
  0xC0, 0x30, 0x00, 0x1C, 0x03, 0x00, 0x01, 0x80, 0x70, 0x0F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x30, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x70, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x1C, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0x00, 0xF0, 0x78, 0x00, 0xF0,
  0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C,
  0x00, 0x07, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xEE, 0x00, 0x03, 0x9E, 0x00, 0x0F, 0x1F,
  0x00, 0x3C, 0x1F, 0xC7, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x1C, 0x0C, 0x00, 0x00, 0x60, 0x38, 0x00, 0x03, 0x80, 0x60, 0x1C, 0x0E,
  0x01, 0x80, 0x60, 0x38, 0x06, 0x03, 0x80, 0xE0, 0x18, 0x1C, 0x03, 0x80,
  0x60, 0x70, 0x0E, 0x01, 0x83, 0x80, 0x38, 0x0E, 0x0C, 0x00, 0x60, 0x38,
  0x70, 0x01, 0xC1, 0xC1, 0x80, 0x03, 0xFF, 0x0E, 0x00, 0x07, 0xF8, 0x30,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0xC1, 0xFC, 0x00, 0x07, 0x0F, 0xFC, 0x00, 0x18, 0x38, 0x70, 0x00,
  0xE1, 0xC0, 0xE0, 0x03, 0x06, 0x01, 0x80, 0x1C, 0x18, 0x06, 0x00, 0x60,
  0xE0, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x1C, 0x0E, 0x01, 0xC0, 0x70, 0x38,
  0x07, 0x03, 0x80, 0x60, 0x18, 0x02, 0x01, 0x80, 0x60, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x03, 0x80,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x80,
  0x38, 0x00, 0x70, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00,
  0x1E, 0x1C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x78, 0x78, 0x03, 0x0E, 0x07, 0x00, 0x63, 0xC0, 0xF0,
  0x1C, 0xF0, 0x0F, 0x03, 0x9C, 0x00, 0xF0, 0x73, 0x80, 0x0F, 0x0E, 0x70,
  0x00, 0xE3, 0x8E, 0x00, 0x1E, 0x71, 0xC0, 0x01, 0xFE, 0x38, 0x00, 0x1F,
  0x87, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0xC1, 0xF0,
  0x03, 0xFC, 0x1F, 0x83, 0xF3, 0xC1, 0xFF, 0xF8, 0x38, 0x0F, 0xFC, 0x03,
  0xC0, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x07,
  0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0F, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x20,
  0x1C, 0x01, 0xF0, 0x38, 0x1F, 0xFC, 0x71, 0xFD, 0xFF, 0x6F, 0xF0, 0x7F,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x77,
  0x00, 0x01, 0xC7, 0x00, 0x07, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x78, 0x0F,
  0x00, 0xE0, 0x0F, 0x03, 0xC0, 0x0E, 0x03, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0xF3, 0xCF, 0x3C, 0xE3, 0x8E, 0x79, 0xC7, 0x38, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x77, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0x00, 0xF0, 0x1E,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xE7, 0xE0, 0x03, 0xC7, 0xE0,
  0x07, 0x87, 0xE0, 0x0F, 0x07, 0xE0, 0x1E, 0x07, 0xE0, 0x3C, 0x07, 0xE0,
  0x70, 0x07, 0xE0, 0xE0, 0x07, 0xE1, 0xC0, 0x07, 0xE3, 0x80, 0x07, 0xEF,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x3C, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x0F, 0x81, 0xF0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x08, 0x01, 0xC0,
  0x3E, 0x0F, 0xF1, 0xFF, 0xFF, 0x1F, 0xE0, 0xFC, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3E, 0x01, 0xF0, 0x38, 0x00,
  0x78, 0x70, 0x00, 0x38, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xBF,
  0x80, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x8F, 0x00, 0x07, 0x9C, 0x00, 0x07,
  0x78, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0x70, 0x00, 0x1C, 0xF0, 0x00, 0x78, 0xF0, 0x01, 0xE0, 0xFC, 0x1F, 0x80,
  0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x0E, 0x00,
  0x07, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x07,
  0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x07,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x3F,
  0xC0, 0x1D, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7C, 0x0F, 0xE0, 0xE0, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xEE, 0x00, 0x03, 0xDC, 0x00, 0x07, 0xB8,
  0x00, 0x1E, 0x38, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0x7C, 0x07, 0xE0, 0x7F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x07, 0xC0, 0x1C, 0x7F, 0xF0, 0x71, 0xFF, 0xF0, 0xEF, 0x81, 0xF1,
  0xFC, 0x00, 0xF3, 0xE0, 0x00, 0xE7, 0x80, 0x01, 0xEF, 0x00, 0x01, 0xDC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xEE, 0x00,
  0x01, 0xDC, 0x00, 0x07, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0x78, 0x00,
  0xF0, 0x78, 0x03, 0xC0, 0x7E, 0x1F, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0,
  0x1E, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x70, 0x00, 0x1C,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1E,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0x3C, 0x00, 0x78, 0x1F, 0x01, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x1F, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x3C,
  0x70, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x1F, 0x83, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xF8, 0x0F, 0x83,
  0xC0, 0x07, 0x87, 0x00, 0x07, 0x1E, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0x70,
  0x00, 0x1D, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x7B, 0xC0, 0x01, 0xF3, 0xC0, 0x07,
  0xE3, 0xC0, 0x1D, 0xC7, 0xE0, 0xFB, 0x83, 0xFF, 0xE7, 0x03, 0xFF, 0x0E,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0x31, 0xEF, 0xDF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x7B, 0xF7, 0xDE, 0x18,
  0x79, 0xFB, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x38, 0x71, 0xC3, 0x82, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x78,
  0x07, 0xC7, 0x80, 0x0E, 0x78, 0x00, 0x7B, 0x80, 0x01, 0xDC, 0x00, 0x0E,
  0xE0, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0E,
  0x1C, 0x03, 0xE0, 0x30, 0xE0, 0x7F, 0xC1, 0x86, 0x07, 0x8E, 0x0E, 0x70,
  0x30, 0x30, 0x33, 0x03, 0x81, 0x81, 0x98, 0x38, 0x0C, 0x0D, 0xC1, 0x80,
  0x60, 0x6C, 0x0C, 0x03, 0x03, 0x60, 0xE0, 0x18, 0x1B, 0x07, 0x00, 0xC0,
  0xD8, 0x30, 0x0E, 0x06, 0xC1, 0x80, 0x60, 0x36, 0x0C, 0x03, 0x01, 0xB0,
  0x60, 0x18, 0x0D, 0x83, 0x00, 0xC0, 0x6C, 0x18, 0x06, 0x06, 0x60, 0xC0,
  0x70, 0x33, 0x07, 0x03, 0x81, 0x98, 0x38, 0x3C, 0x18, 0xE0, 0xE7, 0x31,
  0xC7, 0x07, 0xF1, 0xFC, 0x18, 0x1F, 0x07, 0xC0, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x01, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x70, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x70,
  0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00,
  0x1E, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x1C, 0x78, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x78,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xC0, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xE0, 0x03, 0xF0, 0xE0, 0x00,
  0xF8, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0xF0, 0xE0, 0x01,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xE0, 0x01,
  0xF8, 0xE0, 0x00, 0x7C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x7C, 0xE0, 0x00, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFC,
  0xFE, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0x70, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x77, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x1C, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x1C, 0x00, 0x0F, 0x07,
  0x00, 0x0F, 0x03, 0xC0, 0x0F, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0xE0, 0x0F, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0,
  0xE0, 0x00, 0x78, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0, 0xE0, 0x01, 0xE0,
  0xE0, 0x07, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xF0, 0x0F, 0x80,
  0xF0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x1C, 0x70, 0x00, 0x0F,
  0x38, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E,
  0x78, 0x00, 0x07, 0x1E, 0x00, 0x03, 0x87, 0x80, 0x03, 0xC1, 0xE0, 0x03,
  0xE0, 0x7C, 0x0F, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x10,
  0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xF0, 0x00,
  0x0E, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x1E, 0x00,
  0xF8, 0x1F, 0x83, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x10,
  0x00, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0xF0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x03,
  0x80, 0x0F, 0x00, 0xE0, 0x03, 0xC0, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x03, 0x80, 0x78, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x0F,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0xF8, 0x00, 0x0E,
  0x7E, 0x00, 0x03, 0xBF, 0xC0, 0x00, 0xFE, 0x78, 0x00, 0x3F, 0x0F, 0x00,
  0x0F, 0x83, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0xE0, 0x0F, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x38,
  0x00, 0x38, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x3C,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C, 0xE0, 0x00,
  0x07, 0xB8, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xEE, 0x00, 0x3F, 0xEE,
  0x00, 0x77, 0xEE, 0x00, 0x77, 0xE7, 0x00, 0xE7, 0xE7, 0x00, 0xE7, 0xE7,
  0x00, 0xE7, 0xE3, 0x81, 0xC7, 0xE3, 0x81, 0xC7, 0xE3, 0x81, 0xC7, 0xE1,
  0xC3, 0x87, 0xE1, 0xC3, 0x87, 0xE0, 0xC7, 0x07, 0xE0, 0xE7, 0x07, 0xE0,
  0xE7, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xE0,
  0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x18, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xEE, 0x00, 0x07, 0xEF, 0x00, 0x07, 0xE7,
  0x00, 0x07, 0xE3, 0x80, 0x07, 0xE3, 0x80, 0x07, 0xE1, 0xC0, 0x07, 0xE1,
  0xC0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xF0, 0x07, 0xE0, 0x70, 0x07, 0xE0,
  0x78, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x1C, 0x07, 0xE0,
  0x0E, 0x07, 0xE0, 0x0E, 0x07, 0xE0, 0x07, 0x07, 0xE0, 0x07, 0x87, 0xE0,
  0x03, 0x87, 0xE0, 0x03, 0xC7, 0xE0, 0x01, 0xC7, 0xE0, 0x01, 0xE7, 0xE0,
  0x00, 0xE7, 0xE0, 0x00, 0xF7, 0xE0, 0x00, 0x77, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07,
  0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x1C, 0x00,
  0x1E, 0x03, 0x80, 0x07, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x87, 0xE0, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0x00, 0x1F, 0x8E, 0x00, 0x07, 0x9C,
  0x00, 0x07, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1D, 0xC0, 0x00,
  0x7B, 0x80, 0x03, 0xE7, 0x00, 0x1F, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xE0, 0x00,
  0x1C, 0x78, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x07, 0x80,
  0x07, 0x80, 0xF8, 0x07, 0xC0, 0x1F, 0x87, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x87, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xE0,
  0x03, 0xF0, 0xE0, 0x00, 0xF8, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0, 0xE0,
  0x0F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x07, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0xE0,
  0x01, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0x78, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x0F, 0x83, 0xC0, 0x03, 0xC1,
  0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07,
  0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0E,
  0x78, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x0F, 0x80, 0x0F, 0x81, 0xF8, 0x3F,
  0x80, 0x7F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x38,
  0x00, 0x1C, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0xF8, 0x0F, 0xC3, 0xF0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xF0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x1C, 0x70, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0xF0,
  0x01, 0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x78,
  0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x1C, 0x1C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x3E, 0x00, 0x70, 0x07,
  0xE0, 0x07, 0x00, 0x77, 0x00, 0xF0, 0x07, 0x70, 0x0F, 0x80, 0x77, 0x00,
  0xF8, 0x07, 0x70, 0x0F, 0x80, 0x77, 0x00, 0xD8, 0x06, 0x70, 0x1D, 0x80,
  0xE7, 0x01, 0xD8, 0x0E, 0x38, 0x1D, 0xC0, 0xE3, 0x81, 0xDC, 0x0E, 0x38,
  0x19, 0xC0, 0xE3, 0x81, 0x8C, 0x0E, 0x38, 0x38, 0xC0, 0xC3, 0x83, 0x8E,
  0x0C, 0x38, 0x38, 0xE1, 0xC1, 0x83, 0x0E, 0x1C, 0x1C, 0x30, 0x61, 0xC1,
  0xC7, 0x06, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x18, 0x1C, 0x60,
  0x71, 0x81, 0xC6, 0x07, 0x38, 0x0C, 0xE0, 0x33, 0x80, 0xEE, 0x03, 0x38,
  0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xC0, 0x3B, 0x80, 0xEC,
  0x01, 0xB0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0x80, 0x1F, 0x00, 0x78, 0x00, 0xF0, 0x07,
  0x80, 0x0E, 0x00, 0x78, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x3C,
  0x00, 0x1C, 0x03, 0x80, 0x07, 0x80, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x38,
  0x00, 0x70, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x0E,
  0x0E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x03,
  0xC0, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x03, 0x80, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x07, 0x00, 0x70, 0x00, 0xF0, 0x1E, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0xE0, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x07, 0x1C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x07,
  0x80, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x3C, 0x03, 0x80, 0x03,
  0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x60, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0x70, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x07, 0x1C, 0x00, 0xE1, 0xC0, 0x18,
  0x38, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x0F, 0x07, 0x00, 0xE1, 0xC0,
  0x1C, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x03, 0xB8, 0x00, 0x7E, 0x00,
  0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x70,
  0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x0F, 0x81, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x38,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x1F, 0xC0, 0x0E, 0x3E, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0x70, 0x00, 0x3E, 0x78, 0x00, 0x7E, 0x7C, 0x01, 0xEE, 0x3F,
  0x0F, 0xCE, 0x1F, 0xFF, 0x8E, 0x07, 0xFE, 0x0F, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x80, 0x0E, 0x1F, 0xF0,
  0x1C, 0xFF, 0xF8, 0x3B, 0xE1, 0xF8, 0x77, 0x00, 0xF8, 0xF8, 0x00, 0x71,
  0xF0, 0x00, 0xF3, 0xC0, 0x00, 0xF7, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC,
  0x00, 0x03, 0xB8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xE0, 0x00,
  0x73, 0xC0, 0x01, 0xE7, 0xC0, 0x03, 0x8F, 0xE0, 0x0F, 0x1D, 0xF0, 0xFC,
  0x39, 0xFF, 0xF0, 0x70, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7E, 0x0F, 0x81, 0xF0, 0x07, 0x83,
  0x80, 0x07, 0x8F, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0,
  0x00, 0x1D, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0xEE, 0x00, 0x01,
  0xCE, 0x00, 0x03, 0x9E, 0x00, 0x0F, 0x1C, 0x00, 0x3C, 0x3E, 0x00, 0xF0,
  0x3F, 0x07, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x80, 0x70, 0x1F,
  0xF0, 0xE0, 0xFF, 0xF1, 0xC3, 0xF0, 0xF3, 0x8F, 0x00, 0x77, 0x3C, 0x00,
  0x7E, 0x70, 0x00, 0x7D, 0xE0, 0x00, 0x7B, 0x80, 0x00, 0x77, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xF0,
  0x00, 0x3C, 0xE0, 0x00, 0x79, 0xE0, 0x01, 0xF1, 0xE0, 0x0F, 0xE1, 0xF0,
  0x7D, 0xC1, 0xFF, 0xF3, 0x80, 0xFF, 0x87, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xC1, 0xF0, 0x0F, 0x00,
  0x78, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x04, 0x1E, 0x00,
  0x0E, 0x0F, 0x00, 0x3E, 0x07, 0xC0, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0x03, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFE,
  0x1C, 0x1F, 0xFE, 0x38, 0x7E, 0x1F, 0x71, 0xE0, 0x0E, 0xE7, 0x80, 0x0F,
  0xCE, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x1D,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDE, 0x00,
  0x07, 0x9C, 0x00, 0x0F, 0x3C, 0x00, 0x3E, 0x3C, 0x01, 0xFC, 0x3F, 0x0F,
  0xB8, 0x3F, 0xFE, 0x70, 0x1F, 0xF0, 0xE0, 0x06, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x20, 0x00, 0x78, 0xC0, 0x00, 0xE1,
  0xC0, 0x03, 0xC1, 0xE0, 0x1F, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x02, 0x00, 0xE0,
  0xFF, 0x83, 0x8F, 0xFF, 0x8E, 0x7C, 0x3F, 0x3B, 0x80, 0x3E, 0xEC, 0x00,
  0x7B, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xE3, 0x8F, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x07, 0x9C,
  0x00, 0x1E, 0x38, 0x00, 0x78, 0x70, 0x01, 0xE0, 0xE0, 0x07, 0x81, 0xC0,
  0x3E, 0x03, 0x80, 0xF0, 0x07, 0x03, 0xC0, 0x0E, 0x0F, 0x00, 0x1C, 0x3C,
  0x00, 0x38, 0xF0, 0x00, 0x73, 0xC0, 0x00, 0xEF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xF7, 0x80, 0x07, 0xC7, 0x80, 0x0F, 0x07, 0x80, 0x1C, 0x07, 0x80,
  0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x0F, 0x01, 0xC0, 0x0F, 0x03,
  0x80, 0x0F, 0x07, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x38,
  0x00, 0x1E, 0x70, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x04, 0x0E, 0x7F,
  0x87, 0xF8, 0xEF, 0xFC, 0xFF, 0xCE, 0xE3, 0xFE, 0x3E, 0xF8, 0x1F, 0x80,
  0xEF, 0x00, 0xF0, 0x0E, 0xF0, 0x0F, 0x00, 0xEE, 0x00, 0xE0, 0x07, 0xE0,
  0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0,
  0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E,
  0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E,
  0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07,
  0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00,
  0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00,
  0x70, 0x00, 0x08, 0x03, 0x83, 0xFE, 0x0E, 0x3F, 0xFE, 0x39, 0xF0, 0xFC,
  0xEE, 0x00, 0xFB, 0xB0, 0x01, 0xEF, 0x80, 0x03, 0xBC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x08, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0xF0, 0x03,
  0xC0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x78, 0x00,
  0x07, 0x38, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x1C,
  0x1E, 0x00, 0x1E, 0x07, 0x80, 0x1E, 0x01, 0xF0, 0x7E, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x01, 0xC3, 0xFE,
  0x03, 0x9F, 0xFF, 0x07, 0x7C, 0x3F, 0x0F, 0xC0, 0x1F, 0x1F, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x07, 0xB8, 0x00,
  0x0E, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0x71, 0xF8, 0x03, 0xE3, 0xBC, 0x1F,
  0x87, 0x3F, 0xFE, 0x0E, 0x1F, 0xF0, 0x1C, 0x03, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x1C, 0x1F, 0xFF, 0x38, 0x7C,
  0x1F, 0x71, 0xE0, 0x0E, 0xE7, 0x80, 0x07, 0xCE, 0x00, 0x0F, 0xBC, 0x00,
  0x0F, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x77,
  0x00, 0x00, 0xEE, 0x00, 0x01, 0xDE, 0x00, 0x07, 0x9C, 0x00, 0x0F, 0x3C,
  0x00, 0x3E, 0x3C, 0x00, 0xFC, 0x3E, 0x0F, 0xB8, 0x3F, 0xFE, 0x70, 0x1F,
  0xF0, 0xE0, 0x02, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x02, 0x1C,
  0x0F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xEE, 0x78, 0x01, 0xDC, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0xF8, 0x1F, 0x83, 0xC0, 0x07, 0x8F, 0x00, 0x07, 0x9C,
  0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xFC, 0x0F, 0xE0,
  0x7F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF8, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x04, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x02, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x00, 0x07, 0xDE, 0x00, 0x1F, 0x3C,
  0x01, 0xDC, 0x7C, 0x3E, 0x70, 0xFF, 0xF1, 0xC1, 0xFF, 0x87, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xE0,
  0x70, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x1C, 0x00, 0x38,
  0x07, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0xE0,
  0x00, 0x07, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x06, 0x00, 0x3F,
  0x00, 0x38, 0x03, 0xB8, 0x03, 0xC0, 0x1D, 0xC0, 0x1E, 0x00, 0xE6, 0x00,
  0xF0, 0x07, 0x38, 0x07, 0xC0, 0x31, 0xC0, 0x7E, 0x03, 0x8E, 0x03, 0x30,
  0x1C, 0x70, 0x19, 0x80, 0xE1, 0x80, 0xCE, 0x06, 0x0E, 0x0E, 0x70, 0x30,
  0x70, 0x71, 0x83, 0x83, 0x83, 0x0C, 0x1C, 0x0C, 0x18, 0x70, 0xE0, 0x61,
  0xC3, 0x86, 0x03, 0x8E, 0x0C, 0x30, 0x1C, 0x60, 0x63, 0x80, 0xE3, 0x03,
  0x9C, 0x03, 0x38, 0x1C, 0xC0, 0x1D, 0xC0, 0x66, 0x00, 0xEC, 0x03, 0x30,
  0x07, 0x60, 0x1B, 0x80, 0x1F, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xF0,
  0x38, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x38, 0x07,
  0x80, 0x07, 0x03, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1C, 0xF0,
  0x00, 0x0E, 0x1E, 0x00, 0x07, 0x83, 0x80, 0x03, 0xC0, 0x70, 0x01, 0xE0,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x0E, 0x0F,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1C, 0x3C,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x70, 0x0E, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xC0,
  0x38, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x00, 0x0F, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x0F,
  0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x38, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x23, 0xFF, 0x80, 0x03, 0x7C,
  0xFC, 0x00, 0x77, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x00, 0xEE, 0x00, 0x7C,
  0x1E, 0xC0, 0x03, 0xFF, 0xCC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x00,
};

const GFXglyph RobotoMono_Light53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 5, 38, 32, 13, -38 },
  { 25, 11, 12, 32, 10, -40 },
  { 42, 28, 38, 32, 2, -38 },
  { 175, 23, 48, 32, 5, -43 },
  { 313, 30, 39, 32, 1, -38 },
  { 460, 27, 39, 32, 4, -38 },
  { 592, 3, 12, 32, 13, -40 },
  { 597, 12, 54, 32, 10, -42 },
  { 678, 12, 54, 32, 9, -42 },
  { 759, 23, 23, 32, 5, -38 },
  { 826, 26, 27, 32, 3, -31 },
  { 914, 6, 13, 32, 10, -5 },
  { 924, 19, 2, 32, 6, -18 },
  { 929, 5, 5, 32, 14, -5 },
  { 933, 19, 41, 32, 7, -38 },
  { 1031, 24, 39, 32, 4, -38 },
  { 1148, 13, 38, 32, 6, -38 },
  { 1210, 24, 38, 32, 3, -38 },
  { 1324, 23, 39, 32, 3, -38 },
  { 1437, 27, 38, 32, 2, -38 },
  { 1566, 23, 39, 32, 5, -38 },
  { 1679, 23, 39, 32, 4, -38 },
  { 1792, 25, 38, 32, 3, -38 },
  { 1911, 24, 39, 32, 5, -38 },
  { 2028, 23, 38, 32, 4, -38 },
  { 2138, 6, 28, 32, 15, -28 },
  { 2159, 7, 36, 32, 14, -28 },
  { 2191, 22, 22, 32, 4, -28 },
  { 2252, 24, 14, 32, 4, -24 },
  { 2294, 22, 22, 32, 5, -28 },
  { 2355, 21, 38, 32, 6, -38 },
  { 2455, 29, 38, 32, 1, -38 },
  { 2593, 27, 38, 32, 3, -38 },
  { 2722, 24, 38, 32, 5, -38 },
  { 2836, 25, 39, 32, 3, -38 },
  { 2958, 24, 38, 32, 5, -38 },
  { 3072, 22, 38, 32, 5, -38 },
  { 3177, 23, 38, 32, 5, -38 },
  { 3287, 25, 39, 32, 3, -38 },
  { 3409, 24, 38, 32, 4, -38 },
  { 3523, 22, 38, 32, 5, -38 },
  { 3628, 24, 39, 32, 3, -38 },
  { 3745, 26, 38, 32, 5, -38 },
  { 3869, 22, 38, 32, 6, -38 },
  { 3974, 24, 38, 32, 4, -38 },
  { 4088, 24, 38, 32, 4, -38 },
  { 4202, 26, 39, 32, 3, -38 },
  { 4329, 23, 38, 32, 6, -38 },
  { 4439, 26, 45, 32, 3, -38 },
  { 4586, 24, 38, 32, 5, -38 },
  { 4700, 25, 39, 32, 4, -38 },
  { 4822, 28, 38, 32, 2, -38 },
  { 4955, 24, 39, 32, 4, -38 },
  { 5072, 27, 38, 32, 2, -38 },
  { 5201, 28, 38, 32, 2, -38 },
  { 5334, 27, 38, 32, 3, -38 },
  { 5463, 27, 38, 32, 2, -38 },
  { 5592, 24, 38, 32, 3, -38 },
  { 5706, 9, 51, 32, 12, -43 },
  { 5764, 18, 41, 32, 7, -38 },
  { 5857, 9, 51, 32, 11, -43 },
  { 5915, 19, 21, 32, 6, -38 },
  { 5965, 23, 3, 32, 4, 0 },
  { 5974, 8, 7, 32, 12, -39 },
  { 5981, 24, 30, 32, 4, -29 },
  { 6071, 23, 41, 32, 5, -40 },
  { 6189, 23, 30, 32, 4, -29 },
  { 6276, 23, 41, 32, 4, -40 },
  { 6394, 24, 30, 32, 4, -29 },
  { 6484, 24, 41, 32, 5, -41 },
  { 6607, 23, 40, 32, 4, -29 },
  { 6722, 22, 40, 32, 5, -40 },
  { 6832, 22, 38, 32, 6, -38 },
  { 6937, 17, 49, 32, 5, -38 },
  { 7042, 23, 40, 32, 6, -40 },
  { 7157, 22, 40, 32, 6, -40 },
  { 7267, 28, 29, 32, 2, -29 },
  { 7369, 22, 29, 32, 5, -29 },
  { 7449, 25, 30, 32, 3, -29 },
  { 7543, 23, 40, 32, 5, -29 },
  { 7658, 23, 40, 32, 4, -29 },
  { 7773, 19, 29, 32, 9, -29 },
  { 7842, 23, 30, 32, 5, -29 },
  { 7929, 23, 36, 32, 4, -35 },
  { 8033, 22, 29, 32, 5, -28 },
  { 8113, 26, 28, 32, 3, -28 },
  { 8204, 29, 28, 32, 2, -28 },
  { 8306, 26, 28, 32, 3, -28 },
  { 8397, 28, 39, 32, 2, -28 },
  { 8534, 24, 28, 32, 4, -28 },
  { 8618, 17, 51, 32, 9, -41 },
  { 8727, 2, 47, 32, 15, -38 },
  { 8739, 17, 51, 32, 9, -41 },
  { 8848, 28, 9, 32, 2, -20 },
};

const GFXfont RobotoMono_Light53pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light53pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light53pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOMONO_LIGHT53PT7B_H_
