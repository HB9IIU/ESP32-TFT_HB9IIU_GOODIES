#ifndef _ROBOTOMONO_LIGHT37PT7B_H_
#define _ROBOTOMONO_LIGHT37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light37pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x00, 0x03, 0xEC, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2, 0x00, 0xC0, 0xC0, 0x0C, 0x18,
  0x00, 0xC1, 0x80, 0x08, 0x18, 0x01, 0x81, 0x80, 0x18, 0x10, 0x01, 0x83,
  0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x30, 0x30, 0x03, 0x02, 0x00, 0x30,
  0x20, 0x03, 0x06, 0x00, 0x20, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x06,
  0x04, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x40, 0xC0, 0x0C, 0x0C, 0x00,
  0xC0, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x08, 0x18, 0x01, 0x81, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x3C, 0x00, 0xFF, 0x80, 0xF1,
  0xE0, 0xE0, 0x38, 0x60, 0x0E, 0x70, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1B, 0x00,
  0x0D, 0x80, 0x07, 0xE0, 0x03, 0x30, 0x01, 0x9C, 0x01, 0xC7, 0x01, 0xC1,
  0xFF, 0xC0, 0x7F, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x07, 0xE0, 0x00, 0x63, 0x00, 0x0C, 0x18, 0x00, 0xC1,
  0x83, 0x0C, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x18, 0x60, 0xC1, 0x8C, 0x0C,
  0x10, 0x80, 0x77, 0x18, 0x03, 0xE3, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x10, 0x00, 0xC7, 0xE0, 0x18, 0xC6, 0x01, 0x88,
  0x30, 0x31, 0x83, 0x02, 0x18, 0x10, 0x61, 0x81, 0x0C, 0x18, 0x10, 0xC1,
  0x83, 0x00, 0x0C, 0x30, 0x00, 0xE6, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0x00,
  0xFE, 0x00, 0x38, 0xE0, 0x0E, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0xC0, 0x18, 0x38, 0x01, 0x8E, 0x00, 0x33, 0x80, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0x70, 0x01, 0xC6, 0x03, 0x30,
  0x60, 0xEE, 0x0E, 0x19, 0x80, 0xE3, 0x30, 0x0C, 0x6E, 0x00, 0xDD, 0xC0,
  0x1F, 0x18, 0x01, 0xC3, 0x80, 0x3C, 0x38, 0x0F, 0x83, 0xFF, 0x98, 0x3F,
  0xC3, 0x80, 0xFF, 0xFF, 0x00, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60,
  0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x18, 0x0C,
  0x0C, 0x06, 0x06, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x04, 0x0C, 0x0B, 0x86, 0x1F, 0xF2, 0x7E, 0x1F, 0xF8, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0xD8, 0x00, 0xC6, 0x00, 0xE1, 0x80, 0xE0, 0xE0,
  0x60, 0x38, 0x10, 0x08, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x33,
  0x37, 0x76, 0x6C, 0xFF, 0xFF, 0xFF, 0xF0, 0xEF, 0xE0, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x1C,
  0x3C, 0x30, 0x0C, 0x70, 0x06, 0x60, 0x06, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x1B, 0xC0, 0x33, 0xC0, 0x63, 0xC1, 0xC3, 0xC3,
  0x83, 0xC7, 0x03, 0xCE, 0x03, 0xDC, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0x60, 0x03, 0x60, 0x06, 0x70, 0x0E, 0x38, 0x1C, 0x1F, 0xF8, 0x0F,
  0xF0, 0x01, 0x83, 0xCF, 0xFF, 0x3C, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x03, 0xC0, 0x0F, 0xF8, 0x0F,
  0x0F, 0x0E, 0x01, 0x86, 0x00, 0xE7, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x0F, 0xF8, 0x3C, 0x3C, 0x70,
  0x0E, 0x60, 0x06, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x78, 0x07, 0xE0, 0x07, 0xF8, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0x60, 0x06, 0x70, 0x0E, 0x3F, 0xFC, 0x0F, 0xF0, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xB0, 0x00, 0xEC, 0x00, 0x33,
  0x00, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0,
  0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x30, 0x60,
  0x0C, 0x30, 0x03, 0x0F, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x3F, 0xFE,
  0x3F, 0xFE, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x67, 0xC0, 0x7F, 0xF0, 0x78, 0xFC, 0x60, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0xC0, 0x07, 0xC0, 0x06, 0xE0, 0x0E, 0x60, 0x0E, 0x78, 0x3C, 0x3F, 0xF8,
  0x0F, 0xF0, 0x00, 0x08, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC7, 0xF0,
  0xDF, 0xF8, 0xF8, 0x1C, 0xE0, 0x0E, 0xE0, 0x06, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x60, 0x06,
  0x70, 0x0E, 0x38, 0x1C, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x07, 0xFC, 0x07,
  0x8F, 0x07, 0x01, 0xC7, 0x00, 0x73, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06,
  0x60, 0x03, 0x30, 0x01, 0x8C, 0x01, 0x87, 0x01, 0xC1, 0xF7, 0xC0, 0x3F,
  0x80, 0x7D, 0xF0, 0x70, 0x1C, 0x70, 0x07, 0x30, 0x01, 0xB8, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0D, 0x80, 0x0E, 0xE0, 0x06, 0x38, 0x0E,
  0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x3C, 0x38, 0x30,
  0x1C, 0x60, 0x0E, 0x60, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x07, 0x70, 0x0F, 0x38,
  0x1B, 0x1F, 0xF3, 0x0F, 0xE3, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x1F, 0xE0, 0x1F, 0x80, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x77, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x66, 0x66, 0x66, 0xCC, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x78, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x00, 0xE0, 0x00, 0x80, 0x00, 0x03, 0x00, 0x3F, 0xE0, 0xF1, 0xE3, 0x80,
  0xEE, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x01, 0xFE, 0x00, 0x78,
  0x78, 0x0E, 0x01, 0xC1, 0xC0, 0x0C, 0x18, 0x00, 0x63, 0x07, 0x82, 0x20,
  0xFE, 0x36, 0x18, 0x63, 0x63, 0x04, 0x34, 0x30, 0x43, 0xC2, 0x04, 0x1C,
  0x60, 0x41, 0xC6, 0x04, 0x1C, 0x60, 0xC3, 0xC6, 0x0C, 0x3C, 0x60, 0xC3,
  0xC6, 0x0C, 0x2C, 0x61, 0xC6, 0xC3, 0x34, 0x64, 0x3E, 0x7C, 0x60, 0x81,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x20, 0x0F, 0xDE, 0x00, 0x3F,
  0xC0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xD8, 0x00, 0x1B,
  0x00, 0x07, 0x60, 0x00, 0xCE, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xC3,
  0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0xC0, 0xE0, 0x18, 0x0C, 0x03, 0x01,
  0x80, 0xC0, 0x30, 0x18, 0x03, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x18, 0x00,
  0xC3, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x00,
  0xD8, 0x00, 0x1C, 0xFF, 0xE0, 0xFF, 0xF8, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0,
  0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0,
  0x1C, 0xFF, 0xF0, 0xFF, 0xF0, 0xC0, 0x78, 0xC0, 0x0E, 0xC0, 0x06, 0xC0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0,
  0x0E, 0xC0, 0x1C, 0xFF, 0xF8, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xFF, 0x00,
  0xF1, 0xE0, 0x70, 0x1C, 0x38, 0x03, 0x8C, 0x00, 0x66, 0x00, 0x19, 0x80,
  0x07, 0x60, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x03, 0x60, 0x01, 0xDC, 0x00, 0x63, 0x00, 0x18, 0xE0,
  0x0C, 0x1C, 0x07, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xE0, 0x7F, 0xF8,
  0x30, 0x0F, 0x18, 0x01, 0xCC, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x0D, 0x80,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x6C, 0x00, 0x76, 0x00, 0x33, 0x00, 0x31, 0x80, 0x70, 0xFF,
  0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x07, 0xFF, 0xCF, 0xFF, 0x98, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0F, 0xFF, 0xDF, 0xFF, 0xB0, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0x00, 0xF1,
  0xE0, 0x70, 0x1C, 0x38, 0x03, 0x8C, 0x00, 0x66, 0x00, 0x19, 0x80, 0x03,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x0D, 0x80, 0x03, 0x60, 0x00, 0xDC, 0x00, 0x33, 0x00, 0x0C, 0xE0, 0x07,
  0x1C, 0x03, 0x83, 0xFF, 0xC0, 0x3F, 0xC0, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xD8, 0x00, 0x6E, 0x00, 0x33,
  0x00, 0x39, 0xC0, 0x18, 0x70, 0x3C, 0x1F, 0xFC, 0x07, 0xF8, 0x00, 0xC0,
  0x07, 0xE0, 0x07, 0x30, 0x07, 0x18, 0x03, 0x0C, 0x03, 0x06, 0x03, 0x83,
  0x03, 0x81, 0x83, 0x80, 0xC3, 0x80, 0x63, 0x80, 0x31, 0x80, 0x19, 0xC0,
  0x0D, 0xF0, 0x07, 0xD8, 0x03, 0xCE, 0x01, 0xC3, 0x80, 0xC0, 0xC0, 0x60,
  0x70, 0x30, 0x1C, 0x18, 0x07, 0x0C, 0x01, 0x86, 0x00, 0xE3, 0x00, 0x39,
  0x80, 0x0E, 0xC0, 0x03, 0x60, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xBF, 0x80, 0xDE, 0xC0, 0x6F,
  0x60, 0x67, 0x98, 0x33, 0xCC, 0x31, 0xE6, 0x18, 0xF1, 0x8C, 0x78, 0xCC,
  0x7C, 0x66, 0x3E, 0x1F, 0x1F, 0x0F, 0x0F, 0x87, 0x87, 0xC1, 0x83, 0xE0,
  0xC1, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF8, 0x03, 0xD8, 0x03, 0xCC, 0x03, 0xCC, 0x03, 0xC6,
  0x03, 0xC6, 0x03, 0xC3, 0x03, 0xC3, 0x83, 0xC1, 0x83, 0xC1, 0xC3, 0xC0,
  0xC3, 0xC0, 0xE3, 0xC0, 0x63, 0xC0, 0x33, 0xC0, 0x33, 0xC0, 0x1B, 0xC0,
  0x1B, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0x01,
  0xE0, 0x01, 0xFE, 0x00, 0xF3, 0xE0, 0x70, 0x18, 0x38, 0x03, 0x0C, 0x00,
  0xE6, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x06, 0x60, 0x01, 0x9C, 0x00,
  0x63, 0x00, 0x30, 0xE0, 0x1C, 0x1C, 0x0E, 0x03, 0xFF, 0x00, 0x3F, 0x80,
  0xFF, 0xF0, 0x7F, 0xFE, 0x30, 0x03, 0x98, 0x00, 0xCC, 0x00, 0x36, 0x00,
  0x1B, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8,
  0x00, 0xCC, 0x01, 0xE7, 0xFF, 0xE3, 0xFF, 0xC1, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xFE,
  0x00, 0xF3, 0xE0, 0x60, 0x1C, 0x30, 0x03, 0x1C, 0x00, 0x66, 0x00, 0x19,
  0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x03, 0x60, 0x01, 0xD8, 0x00, 0x63, 0x00, 0x38,
  0xE0, 0x0C, 0x1C, 0x0E, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x02, 0xFF, 0xE0, 0xFF, 0xF8,
  0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x07,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x38, 0xFF, 0xF0,
  0xFF, 0xC0, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x38, 0xC0, 0x18,
  0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x03,
  0x00, 0xE0, 0x01, 0xFF, 0x01, 0xF1, 0xE0, 0xE0, 0x1C, 0x30, 0x03, 0x9C,
  0x00, 0x67, 0x00, 0x1D, 0x80, 0x03, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x03, 0x60, 0x00, 0xD8,
  0x00, 0x37, 0x00, 0x1C, 0xC0, 0x06, 0x3C, 0x03, 0x83, 0xFF, 0xC0, 0x7F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0x60, 0x07, 0x70,
  0x0E, 0x38, 0x1C, 0x1F, 0xF8, 0x0F, 0xF0, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x1D, 0x80, 0x06, 0x60, 0x01, 0x9C, 0x00, 0xE3, 0x00, 0x30, 0xC0,
  0x0C, 0x38, 0x07, 0x06, 0x01, 0x81, 0x80, 0x60, 0x70, 0x38, 0x0C, 0x0C,
  0x03, 0x03, 0x00, 0xE0, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00,
  0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x03,
  0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x83, 0x41, 0xB8, 0x6C, 0x33, 0x0D,
  0x86, 0x61, 0xB0, 0xCC, 0x26, 0x19, 0x8C, 0x43, 0x31, 0x8C, 0x66, 0x31,
  0x88, 0xC6, 0x33, 0x0C, 0xC6, 0x61, 0xB0, 0xCC, 0x36, 0x0D, 0x86, 0xC1,
  0xB0, 0xD8, 0x36, 0x1B, 0x06, 0xC3, 0x40, 0xF0, 0x38, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0xE0, 0x00, 0xEE, 0x00,
  0x30, 0xC0, 0x0E, 0x0C, 0x01, 0x81, 0xC0, 0x70, 0x18, 0x0C, 0x03, 0x83,
  0x00, 0x30, 0xE0, 0x03, 0x18, 0x00, 0x77, 0x00, 0x06, 0xC0, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x1D, 0x80, 0x03, 0x18,
  0x00, 0xE3, 0x80, 0x18, 0x30, 0x06, 0x07, 0x01, 0xC0, 0x60, 0x30, 0x06,
  0x0E, 0x00, 0xE3, 0x80, 0x0C, 0x60, 0x01, 0xDC, 0x00, 0x1C, 0xE0, 0x00,
  0xEE, 0x00, 0x18, 0xC0, 0x07, 0x1C, 0x00, 0xC1, 0x80, 0x18, 0x38, 0x06,
  0x03, 0x00, 0xC0, 0x70, 0x30, 0x06, 0x06, 0x00, 0xE1, 0x80, 0x0C, 0x30,
  0x01, 0xCC, 0x00, 0x19, 0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x70, 0xFF, 0xF0, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xFF,
  0x03, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0C, 0xC0, 0x33, 0x00, 0xC6,
  0x06, 0x18, 0x18, 0x70, 0xC0, 0xC3, 0x03, 0x18, 0x06, 0x60, 0x1B, 0x80,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xC3, 0x86, 0x0C, 0x07, 0xE0, 0x1F,
  0xF8, 0x38, 0x1C, 0x70, 0x0E, 0x60, 0x06, 0x60, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x0F, 0xFF, 0x3E, 0x07, 0x70, 0x07, 0x60, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0x70, 0x1B, 0x3F, 0xF3, 0x1F,
  0xE3, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC7, 0xC1, 0xBF, 0xE3, 0xE0, 0xE7, 0x00, 0xEC,
  0x00, 0xD8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x06, 0xE0, 0x1D,
  0xE0, 0x73, 0x7F, 0xC6, 0x7F, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x3C, 0x1C,
  0x30, 0x0E, 0x70, 0x07, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x03,
  0x60, 0x03, 0x70, 0x06, 0x38, 0x0E, 0x1F, 0x7C, 0x07, 0xF0, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x07, 0xC7, 0x1F, 0xF7, 0x3C, 0x3F, 0x30, 0x0F, 0x60, 0x07,
  0x60, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x0F,
  0x38, 0x1F, 0x1F, 0xFB, 0x0F, 0xE3, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0x07,
  0x06, 0x01, 0xC6, 0x00, 0x73, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0,
  0x03, 0x7F, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x03, 0x1C, 0x03, 0x87, 0xFF, 0x80, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x07, 0xC3, 0x1F, 0xF3, 0x3C, 0x3B, 0x30, 0x0F, 0x60, 0x07, 0x60,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x0F, 0x38,
  0x1F, 0x1F, 0xFF, 0x0F, 0xE7, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x20,
  0x0E, 0x70, 0x0C, 0x38, 0x3C, 0x1F, 0xF0, 0x03, 0xC0, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE1, 0xF0, 0xE7, 0xFC, 0xEC, 0x1E, 0xF8, 0x06, 0xF0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0x01, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x40, 0x1C, 0x03, 0x80, 0x20, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x03, 0x9F, 0xE3, 0xF0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x0E, 0xC0, 0x1C, 0xC0, 0x38, 0xC0, 0x70,
  0xC0, 0xE0, 0xC1, 0xC0, 0xC3, 0x80, 0xC7, 0x00, 0xCE, 0x00, 0xDE, 0x00,
  0xF7, 0x00, 0xE3, 0x80, 0xC1, 0xC0, 0xC0, 0xE0, 0xC0, 0x60, 0xC0, 0x70,
  0xC0, 0x38, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0x0F, 0x1F, 0xF3, 0xFB, 0x87, 0xC7, 0x60,
  0x70, 0x6C, 0x0C, 0x0F, 0x81, 0x80, 0xF0, 0x30, 0x1E, 0x06, 0x03, 0xC0,
  0xC0, 0x78, 0x18, 0x0F, 0x03, 0x01, 0xE0, 0x60, 0x3C, 0x0C, 0x07, 0x81,
  0x80, 0xF0, 0x30, 0x1E, 0x06, 0x03, 0xC0, 0xC0, 0x78, 0x18, 0x0F, 0x03,
  0x01, 0xE0, 0x60, 0x30, 0xE1, 0xF0, 0xE7, 0xFC, 0xEC, 0x1E, 0xF8, 0x06,
  0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x03, 0xF0, 0x03, 0xFF,
  0x01, 0xE0, 0xE0, 0xE0, 0x1C, 0x30, 0x03, 0x9C, 0x00, 0x66, 0x00, 0x19,
  0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0x60,
  0x01, 0xD8, 0x00, 0x66, 0x00, 0x19, 0xC0, 0x0E, 0x38, 0x03, 0x07, 0x03,
  0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0xC7, 0xC1, 0xBF, 0xE3, 0xE1, 0xE7, 0x00,
  0xEC, 0x00, 0xD8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x06, 0xE0,
  0x1D, 0xE0, 0x73, 0xFF, 0xC6, 0x7F, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x07, 0xC3,
  0x1F, 0xF3, 0x3C, 0x3B, 0x70, 0x0F, 0x60, 0x07, 0x60, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x07, 0x38, 0x1F, 0x1F, 0xFF,
  0x0F, 0xE7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xE0, 0xFF, 0x3F, 0xFB, 0xC3, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0xFC, 0x3C, 0x1E, 0x30, 0x07, 0x60,
  0x03, 0x60, 0x03, 0x60, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x03, 0x60, 0x03, 0x60,
  0x03, 0x70, 0x06, 0x1F, 0x7E, 0x0F, 0xF8, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x1E, 0xC0, 0x6C, 0xFF, 0x98, 0xFE, 0x30, 0xC0,
  0x00, 0xF8, 0x00, 0x76, 0x00, 0x19, 0x80, 0x06, 0x30, 0x03, 0x0C, 0x00,
  0xC3, 0x80, 0x70, 0x60, 0x18, 0x1C, 0x06, 0x03, 0x03, 0x00, 0xC0, 0xC0,
  0x18, 0x70, 0x06, 0x18, 0x01, 0xC6, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x00, 0xC0, 0x60, 0x3C, 0x06,
  0x03, 0x60, 0x70, 0x36, 0x07, 0x03, 0x60, 0xF0, 0x26, 0x0D, 0x06, 0x60,
  0xD8, 0x63, 0x09, 0x86, 0x31, 0x98, 0x63, 0x18, 0x8C, 0x31, 0x8C, 0xC1,
  0x10, 0xCC, 0x1B, 0x0C, 0xC1, 0xB0, 0x48, 0x1B, 0x05, 0x81, 0xA0, 0x78,
  0x0A, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x60, 0x01,
  0xDC, 0x00, 0x63, 0x80, 0x30, 0x70, 0x1C, 0x0C, 0x0E, 0x01, 0x87, 0x00,
  0x71, 0x80, 0x0E, 0xE0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0xC0, 0x03, 0xB0, 0x01, 0xC6, 0x00, 0x61, 0xC0, 0x30, 0x38, 0x1C, 0x07,
  0x0E, 0x00, 0xC3, 0x00, 0x1B, 0x80, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x06,
  0x70, 0x00, 0xE3, 0x00, 0x0C, 0x38, 0x00, 0xC1, 0x80, 0x1C, 0x1C, 0x01,
  0x80, 0xC0, 0x38, 0x0C, 0x03, 0x00, 0x60, 0x70, 0x06, 0x06, 0x00, 0x70,
  0x60, 0x03, 0x0C, 0x00, 0x38, 0xC0, 0x01, 0x9C, 0x00, 0x1D, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x30, 0x0F, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x1C, 0x0F, 0x80, 0xF0, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x1F, 0x00, 0xF0, 0x1C, 0x03, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x70, 0x0E, 0x00, 0x1F, 0x00, 0x37, 0xFC,
  0x03, 0x60, 0xE0, 0x3C, 0x07, 0x06, 0xC0, 0x3F, 0xEC, 0x00, 0xFC,
};

const GFXglyph RobotoMono_Light37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 3, 26, 22, 9, -26 },
  { 11, 8, 8, 22, 7, -28 },
  { 19, 20, 26, 22, 1, -26 },
  { 84, 17, 34, 22, 3, -30 },
  { 157, 20, 27, 22, 1, -27 },
  { 225, 19, 27, 22, 2, -27 },
  { 290, 2, 8, 22, 9, -28 },
  { 292, 9, 38, 22, 7, -30 },
  { 335, 9, 38, 22, 6, -30 },
  { 378, 17, 16, 22, 3, -26 },
  { 412, 18, 19, 22, 2, -22 },
  { 455, 4, 8, 22, 7, -3 },
  { 459, 14, 2, 22, 4, -13 },
  { 463, 4, 3, 22, 10, -3 },
  { 465, 13, 28, 22, 5, -26 },
  { 511, 16, 27, 22, 3, -27 },
  { 565, 9, 26, 22, 4, -26 },
  { 595, 17, 27, 22, 2, -27 },
  { 653, 16, 27, 22, 2, -27 },
  { 707, 18, 26, 22, 2, -26 },
  { 766, 16, 26, 22, 4, -26 },
  { 818, 16, 27, 22, 3, -27 },
  { 872, 18, 26, 22, 2, -26 },
  { 931, 17, 27, 22, 3, -27 },
  { 989, 16, 27, 22, 3, -27 },
  { 1043, 3, 19, 22, 11, -19 },
  { 1051, 4, 24, 22, 10, -19 },
  { 1063, 15, 16, 22, 3, -20 },
  { 1093, 16, 10, 22, 3, -17 },
  { 1113, 16, 16, 22, 3, -20 },
  { 1145, 15, 27, 22, 4, -27 },
  { 1196, 20, 26, 22, 1, -26 },
  { 1261, 19, 26, 22, 2, -26 },
  { 1323, 16, 26, 22, 4, -26 },
  { 1375, 18, 27, 22, 2, -27 },
  { 1436, 17, 26, 22, 3, -26 },
  { 1492, 15, 26, 22, 4, -26 },
  { 1541, 15, 26, 22, 4, -26 },
  { 1590, 18, 27, 22, 2, -27 },
  { 1651, 16, 26, 22, 3, -26 },
  { 1703, 16, 26, 22, 3, -26 },
  { 1755, 17, 26, 22, 2, -26 },
  { 1811, 17, 26, 22, 4, -26 },
  { 1867, 16, 26, 22, 4, -26 },
  { 1919, 17, 26, 22, 3, -26 },
  { 1975, 16, 26, 22, 3, -26 },
  { 2027, 18, 27, 22, 2, -27 },
  { 2088, 17, 26, 22, 4, -26 },
  { 2144, 18, 32, 22, 2, -27 },
  { 2216, 16, 26, 22, 4, -26 },
  { 2268, 18, 27, 22, 2, -27 },
  { 2329, 19, 26, 22, 2, -26 },
  { 2391, 16, 26, 22, 3, -26 },
  { 2443, 18, 26, 22, 2, -26 },
  { 2502, 19, 26, 22, 2, -26 },
  { 2564, 19, 26, 22, 2, -26 },
  { 2626, 19, 26, 22, 1, -26 },
  { 2688, 17, 26, 22, 2, -26 },
  { 2744, 6, 36, 22, 8, -30 },
  { 2771, 13, 28, 22, 5, -26 },
  { 2817, 6, 36, 22, 8, -30 },
  { 2844, 14, 14, 22, 4, -26 },
  { 2869, 16, 2, 22, 3, 0 },
  { 2873, 6, 5, 22, 8, -27 },
  { 2877, 16, 20, 22, 3, -20 },
  { 2917, 15, 28, 22, 4, -28 },
  { 2970, 16, 20, 22, 3, -20 },
  { 3010, 16, 28, 22, 3, -28 },
  { 3066, 17, 20, 22, 3, -20 },
  { 3109, 17, 28, 22, 3, -28 },
  { 3169, 16, 28, 22, 3, -20 },
  { 3225, 16, 28, 22, 3, -28 },
  { 3281, 16, 27, 22, 4, -27 },
  { 3335, 11, 35, 22, 4, -27 },
  { 3384, 16, 28, 22, 4, -28 },
  { 3440, 16, 28, 22, 4, -28 },
  { 3496, 19, 20, 22, 2, -20 },
  { 3544, 16, 20, 22, 3, -20 },
  { 3584, 18, 20, 22, 2, -20 },
  { 3629, 15, 28, 22, 4, -20 },
  { 3682, 16, 28, 22, 3, -20 },
  { 3738, 13, 20, 22, 6, -20 },
  { 3771, 16, 20, 22, 3, -20 },
  { 3811, 16, 25, 22, 3, -25 },
  { 3861, 15, 20, 22, 4, -20 },
  { 3899, 18, 20, 22, 2, -20 },
  { 3944, 20, 20, 22, 1, -20 },
  { 3994, 18, 20, 22, 2, -20 },
  { 4039, 20, 28, 22, 1, -20 },
  { 4109, 17, 20, 22, 3, -20 },
  { 4152, 12, 36, 22, 6, -29 },
  { 4206, 2, 32, 22, 10, -26 },
  { 4214, 12, 36, 22, 6, -29 },
  { 4268, 20, 6, 22, 1, -14 },
};

const GFXfont RobotoMono_Light37pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light37pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOMONO_LIGHT37PT7B_H_
