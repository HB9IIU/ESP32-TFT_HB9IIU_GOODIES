#ifndef _ROBOTOMONO_LIGHT40PT7B_H_
#define _ROBOTOMONO_LIGHT40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x00, 0x60, 0x60,
  0x01, 0x81, 0x80, 0x0C, 0x04, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03,
  0x03, 0x00, 0x0C, 0x0C, 0x00, 0x20, 0x30, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF0, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x0F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60,
  0x01, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x01,
  0xF0, 0x01, 0xFF, 0x81, 0xF1, 0xF0, 0x70, 0x1C, 0x38, 0x03, 0x8C, 0x00,
  0x63, 0x00, 0x1D, 0xC0, 0x07, 0x30, 0x00, 0xCC, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00,
  0x36, 0x00, 0x0D, 0x80, 0x03, 0x70, 0x01, 0xCE, 0x00, 0xE3, 0xC0, 0x78,
  0x7F, 0xFC, 0x07, 0xFC, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x01, 0xFC, 0x00, 0x06, 0x18, 0x00, 0x30, 0x60,
  0x00, 0xC0, 0xC0, 0xC3, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x30, 0xC0,
  0xC0, 0xC6, 0x03, 0x06, 0x18, 0x06, 0x18, 0xC0, 0x1F, 0xC3, 0x00, 0x1E,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x8F, 0xC0, 0x0C, 0x73, 0x80, 0x61, 0x87, 0x01, 0x8C, 0x0C,
  0x0C, 0x30, 0x30, 0x30, 0xC0, 0xC1, 0x83, 0x03, 0x0E, 0x0C, 0x0C, 0x10,
  0x30, 0x30, 0x00, 0x61, 0x80, 0x01, 0xCE, 0x00, 0x03, 0xF0, 0x01, 0xE0,
  0x00, 0xFF, 0x00, 0x1E, 0x38, 0x01, 0xC1, 0xC0, 0x38, 0x0C, 0x03, 0x80,
  0xC0, 0x38, 0x0C, 0x03, 0x81, 0xC0, 0x38, 0x18, 0x01, 0x83, 0x80, 0x1C,
  0x70, 0x00, 0xCE, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x01,
  0xD8, 0x00, 0x39, 0xC0, 0x67, 0x0E, 0x06, 0xE0, 0x70, 0x6E, 0x03, 0x86,
  0xC0, 0x18, 0xEC, 0x01, 0xCC, 0xC0, 0x0F, 0xCC, 0x00, 0x78, 0xE0, 0x03,
  0x8E, 0x00, 0x78, 0x70, 0x1F, 0xC3, 0xFF, 0xCE, 0x0F, 0xF0, 0x70, 0xFF,
  0xFF, 0xC0, 0x00, 0x40, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60,
  0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80,
  0xC0, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0E, 0x07,
  0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0,
  0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x81,
  0x81, 0x81, 0x80, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x06, 0x06, 0x0F, 0xE2, 0x3E, 0xFF, 0x7E, 0x07, 0xF0,
  0x00, 0xE0, 0x00, 0xD8, 0x00, 0xEE, 0x00, 0xE3, 0x80, 0x60, 0xE0, 0x70,
  0x30, 0x70, 0x1C, 0x10, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x77,
  0x77, 0x76, 0x6E, 0xC8, 0xFF, 0xFF, 0xFF, 0xF0, 0x4E, 0xFE, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0x01,
  0xE1, 0xE0, 0xE0, 0x1C, 0x30, 0x03, 0x1C, 0x00, 0xE6, 0x00, 0x19, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x73, 0xC0, 0x38,
  0xF0, 0x1C, 0x3C, 0x0E, 0x0F, 0x07, 0x03, 0xC3, 0x80, 0xF1, 0xC0, 0x3E,
  0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x76, 0x00, 0x19, 0x80,
  0x06, 0x70, 0x03, 0x8E, 0x01, 0xC1, 0xC0, 0xE0, 0x3F, 0xF0, 0x07, 0xF8,
  0x00, 0x00, 0xE0, 0x7C, 0x7F, 0xBE, 0x7F, 0x0F, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x03, 0xE0, 0x03, 0xFF, 0x01, 0xE3, 0xE0, 0xE0,
  0x1C, 0x70, 0x03, 0x18, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x06, 0xC0, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0x03, 0xF0,
  0x03, 0xFF, 0x01, 0xE1, 0xE0, 0xE0, 0x1C, 0x70, 0x03, 0x18, 0x00, 0xEE,
  0x00, 0x1B, 0x80, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x06, 0x60, 0x01, 0x9C, 0x00, 0xE3, 0x80, 0x70, 0x7F,
  0xF8, 0x07, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0x60, 0x00, 0x36, 0x00, 0x06, 0x60, 0x00, 0xE6, 0x00, 0x0C, 0x60,
  0x01, 0x86, 0x00, 0x38, 0x60, 0x03, 0x06, 0x00, 0x60, 0x60, 0x0E, 0x06,
  0x00, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0x60, 0x30, 0x06, 0x06, 0x00,
  0x60, 0xE0, 0x06, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x3F, 0xFF, 0x9F, 0xFF, 0xCC, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1D,
  0xFC, 0x0F, 0xFF, 0x87, 0x83, 0xE3, 0x80, 0x78, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0E, 0xC0, 0x0E, 0x70, 0x0F, 0x1E, 0x0F, 0x07, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x0E, 0x03, 0x9F, 0xF0, 0xCF, 0x3E, 0x36, 0x01, 0xCF, 0x00, 0x33,
  0x80, 0x0E, 0xE0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x6E, 0x00, 0x19, 0x80, 0x06, 0x70, 0x03, 0x8E, 0x01,
  0xC1, 0xC0, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x7C, 0x7C, 0x1E, 0x03,
  0xC3, 0x80, 0x38, 0x60, 0x03, 0x1C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01,
  0xCE, 0x00, 0x38, 0xC0, 0x06, 0x1C, 0x01, 0xC1, 0xC0, 0x70, 0x1F, 0xFC,
  0x00, 0xFE, 0x00, 0x7D, 0xF0, 0x3C, 0x07, 0x06, 0x00, 0x31, 0xC0, 0x07,
  0x30, 0x00, 0x6E, 0x00, 0x0D, 0xC0, 0x01, 0xF8, 0x00, 0x3B, 0x00, 0x06,
  0x70, 0x01, 0xCE, 0x00, 0x30, 0xF0, 0x1E, 0x0F, 0xFF, 0x80, 0x7F, 0xC0,
  0x03, 0xE0, 0x03, 0xFE, 0x01, 0xE1, 0xE0, 0xE0, 0x38, 0x70, 0x07, 0x18,
  0x00, 0xE6, 0x00, 0x3B, 0x80, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x3D, 0xC0, 0x0F,
  0x38, 0x0F, 0xC7, 0x9F, 0x60, 0xFF, 0x98, 0x06, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0F,
  0x80, 0x3F, 0xC0, 0x0F, 0x80, 0x00, 0x6F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0xFF, 0xE0, 0x10, 0xE3, 0xCE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x8E, 0x38, 0xC3, 0x0C, 0x63,
  0x84, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x03,
  0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0x80, 0x00,
  0x03, 0xE0, 0x1F, 0xF8, 0x3E, 0x3C, 0x70, 0x0E, 0x60, 0x06, 0x60, 0x07,
  0xE0, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x07, 0xFE, 0x00, 0x3C, 0x3C, 0x01, 0xC0, 0x18, 0x0C, 0x00, 0x30,
  0x60, 0x00, 0xC1, 0x81, 0xC1, 0x8C, 0x1F, 0x86, 0x20, 0xE3, 0x09, 0x86,
  0x0C, 0x26, 0x18, 0x30, 0xD0, 0x40, 0xC3, 0x43, 0x02, 0x0F, 0x0C, 0x08,
  0x3C, 0x30, 0x20, 0xF0, 0x80, 0x83, 0xC2, 0x06, 0x0B, 0x08, 0x18, 0x2C,
  0x30, 0x60, 0xB0, 0xC3, 0x86, 0x43, 0x1A, 0x11, 0x87, 0xCF, 0xC6, 0x1E,
  0x1E, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xE0, 0x10,
  0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0xEC, 0x00, 0x06, 0x70,
  0x00, 0x31, 0x80, 0x03, 0x8C, 0x00, 0x18, 0x70, 0x00, 0xC1, 0x80, 0x0E,
  0x0C, 0x00, 0x60, 0x70, 0x03, 0x01, 0x80, 0x38, 0x0C, 0x01, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0xE0, 0x0C, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0x80,
  0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x8E, 0x00, 0x0C, 0x60, 0x00, 0x63,
  0x00, 0x03, 0xB8, 0x00, 0x0D, 0xC0, 0x00, 0x70, 0xFF, 0xF0, 0x3F, 0xFF,
  0x0C, 0x00, 0xE3, 0x00, 0x1C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x3B,
  0x00, 0x0E, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x73, 0x00, 0x78, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0C, 0x03, 0xE3, 0x00, 0x1C, 0xC0, 0x03, 0xB0, 0x00,
  0x6C, 0x00, 0x1B, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x6C, 0x00, 0x1B,
  0x00, 0x0E, 0xC0, 0x07, 0x30, 0x07, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0x00,
  0xF8, 0x00, 0xFF, 0xC0, 0x3C, 0x3C, 0x0E, 0x01, 0xC1, 0x80, 0x1C, 0x70,
  0x01, 0x8C, 0x00, 0x3B, 0x80, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x06, 0xC0, 0x00, 0xDC, 0x00, 0x19, 0x80, 0x07, 0x38, 0x00, 0xC3, 0x80,
  0x38, 0x38, 0x0E, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0x80, 0x78, 0x70, 0x03, 0x8E, 0x00, 0x39, 0xC0, 0x03, 0x38, 0x00,
  0x77, 0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x6E, 0x00, 0x0D, 0xC0, 0x03,
  0xB8, 0x00, 0xE7, 0x00, 0x38, 0xE0, 0x0F, 0x1C, 0x07, 0xC3, 0xFF, 0xE0,
  0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xE7, 0xFF, 0xF3, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x3E, 0x3E, 0x0E, 0x01,
  0xC3, 0x80, 0x1C, 0x70, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x03, 0x60, 0x00,
  0x6C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x01,
  0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xDC, 0x00, 0x19, 0x80, 0x03,
  0x38, 0x00, 0x63, 0x80, 0x0C, 0x38, 0x07, 0x83, 0xFF, 0xC0, 0x1F, 0xE0,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x76, 0x00, 0x19, 0xC0, 0x0E, 0x30, 0x03, 0x0F, 0x03, 0xC1, 0xFF, 0xE0,
  0x1F, 0xE0, 0xC0, 0x01, 0xD8, 0x00, 0x73, 0x00, 0x1C, 0x60, 0x07, 0x0C,
  0x01, 0xC1, 0x80, 0x70, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0xE0, 0x18,
  0x38, 0x03, 0x0E, 0x00, 0x63, 0x80, 0x0C, 0xF0, 0x01, 0xBF, 0x00, 0x3E,
  0xE0, 0x07, 0x8E, 0x00, 0xF0, 0xE0, 0x1C, 0x0C, 0x03, 0x01, 0xC0, 0x60,
  0x1C, 0x0C, 0x01, 0xC1, 0x80, 0x38, 0x30, 0x03, 0x86, 0x00, 0x38, 0xC0,
  0x03, 0x98, 0x00, 0x73, 0x00, 0x07, 0x60, 0x00, 0x70, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x60, 0x0F, 0xD8, 0x06, 0xF6, 0x01, 0xBC, 0xC0,
  0xEF, 0x30, 0x33, 0xCC, 0x0C, 0xF1, 0x87, 0x3C, 0x61, 0x8F, 0x9C, 0x63,
  0xE3, 0x30, 0xF8, 0xCC, 0x3E, 0x3F, 0x0F, 0x87, 0x83, 0xE1, 0xE0, 0xF8,
  0x30, 0x3E, 0x0C, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xD8, 0x00, 0xF7,
  0x00, 0x3C, 0xC0, 0x0F, 0x38, 0x03, 0xC6, 0x00, 0xF1, 0xC0, 0x3C, 0x30,
  0x0F, 0x06, 0x03, 0xC1, 0xC0, 0xF0, 0x30, 0x3C, 0x0E, 0x0F, 0x01, 0x83,
  0xC0, 0x70, 0xF0, 0x0C, 0x3C, 0x03, 0x8F, 0x00, 0x63, 0xC0, 0x1C, 0xF0,
  0x03, 0x3C, 0x00, 0x6F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0x9F, 0x01, 0xC0,
  0x38, 0x18, 0x01, 0x83, 0x80, 0x1C, 0x30, 0x00, 0xC7, 0x00, 0x0E, 0x60,
  0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x70, 0x00,
  0xE3, 0x00, 0x0C, 0x38, 0x01, 0xC1, 0xC0, 0x38, 0x0E, 0x07, 0x00, 0x7F,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8E, 0x00, 0x73, 0x80,
  0x0E, 0xE0, 0x01, 0xB8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x06, 0xE0, 0x03, 0xB8, 0x03, 0xCF,
  0xFF, 0xE3, 0xFF, 0xE0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE0,
  0x0F, 0x9F, 0x01, 0xC0, 0x38, 0x38, 0x01, 0xC3, 0x00, 0x0C, 0x70, 0x00,
  0xE6, 0x00, 0x06, 0x60, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0x60, 0x00, 0x76,
  0x00, 0x06, 0x70, 0x00, 0x63, 0x00, 0x0E, 0x38, 0x01, 0xC1, 0xC0, 0x18,
  0x1E, 0x07, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x02, 0xFF, 0xF0, 0x3F, 0xFF,
  0x0C, 0x00, 0xE3, 0x00, 0x1C, 0xC0, 0x03, 0x30, 0x00, 0xEC, 0x00, 0x1B,
  0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x3B, 0x00, 0x0C, 0xC0,
  0x07, 0x30, 0x07, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xC0, 0x30, 0x30, 0x0E,
  0x0C, 0x01, 0x83, 0x00, 0x70, 0xC0, 0x0C, 0x30, 0x03, 0x8C, 0x00, 0x63,
  0x00, 0x1C, 0xC0, 0x03, 0x30, 0x00, 0xEC, 0x00, 0x1B, 0x00, 0x07, 0x01,
  0xF0, 0x01, 0xFF, 0x80, 0x7C, 0x7C, 0x1C, 0x01, 0xC7, 0x00, 0x18, 0xC0,
  0x03, 0x98, 0x00, 0x33, 0x00, 0x07, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0x60, 0x00, 0xCE, 0x00,
  0x38, 0xF0, 0x1E, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x76, 0x00, 0x19, 0xC0, 0x0E,
  0x38, 0x07, 0x0F, 0x03, 0xC1, 0xFF, 0xC0, 0x1F, 0xE0, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0x60, 0x00, 0x66, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x00, 0x0C,
  0x30, 0x01, 0xC3, 0x80, 0x1C, 0x18, 0x01, 0x81, 0x80, 0x18, 0x1C, 0x03,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x70, 0x06, 0x06, 0x00, 0x60,
  0x60, 0x06, 0x0E, 0x00, 0x70, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0xC0, 0x03,
  0x98, 0x00, 0x19, 0x80, 0x01, 0xB8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0xC0, 0x70, 0x1E, 0x03, 0x80,
  0xF0, 0x1C, 0x0F, 0x80, 0xE0, 0x6E, 0x0F, 0x03, 0x70, 0x6C, 0x19, 0x83,
  0x60, 0xCC, 0x1B, 0x06, 0x60, 0xD8, 0x33, 0x0C, 0xC3, 0x98, 0x66, 0x18,
  0xE3, 0x18, 0xC7, 0x18, 0xC6, 0x18, 0xC6, 0x30, 0xC6, 0x31, 0x86, 0x61,
  0x8C, 0x33, 0x06, 0x61, 0x98, 0x36, 0x0C, 0xC1, 0xB0, 0x76, 0x0D, 0x81,
  0xE0, 0x6C, 0x0F, 0x03, 0x60, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03,
  0xC0, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xF0, 0x00, 0x71,
  0x80, 0x07, 0x0E, 0x00, 0x30, 0x30, 0x03, 0x81, 0xC0, 0x18, 0x07, 0x01,
  0xC0, 0x18, 0x1C, 0x00, 0xE0, 0xC0, 0x03, 0x0E, 0x00, 0x1C, 0x60, 0x00,
  0x77, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x01, 0xD8, 0x00, 0x0C, 0x60, 0x00, 0xE3, 0x80, 0x0E,
  0x0C, 0x00, 0x60, 0x70, 0x07, 0x01, 0xC0, 0x70, 0x06, 0x03, 0x80, 0x38,
  0x38, 0x00, 0xC1, 0x80, 0x07, 0x1C, 0x00, 0x1D, 0xC0, 0x00, 0x70, 0xF0,
  0x00, 0x3B, 0x80, 0x03, 0x8E, 0x00, 0x18, 0x70, 0x01, 0xC1, 0xC0, 0x0C,
  0x06, 0x00, 0xE0, 0x38, 0x06, 0x00, 0xC0, 0x70, 0x07, 0x03, 0x00, 0x18,
  0x38, 0x00, 0xE1, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0x6E, 0x00,
  0x03, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x1F, 0xFF, 0x80, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0xFF, 0xFF, 0xF8, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x7F, 0xFF, 0x80, 0x03, 0x00, 0x1E, 0x00, 0x78,
  0x01, 0xF0, 0x0C, 0xC0, 0x33, 0x01, 0x8E, 0x06, 0x18, 0x38, 0x70, 0xC0,
  0xC3, 0x03, 0x18, 0x06, 0x60, 0x1B, 0x80, 0x7C, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE1, 0xC3, 0x86, 0x0C, 0x00, 0x40, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xE0, 0x1C, 0x70, 0x03, 0x98, 0x00, 0xE6, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x7F, 0xF8, 0x7F, 0xFE, 0x38, 0x01,
  0x9C, 0x00, 0x66, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0xE6,
  0x00, 0x79, 0xE0, 0x76, 0x3F, 0xF9, 0x87, 0xFC, 0x70, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x80, 0x63, 0xFC, 0x37, 0xFF, 0x1F, 0x03, 0xCF, 0x00,
  0x67, 0x00, 0x3B, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x06,
  0xC0, 0x03, 0x70, 0x03, 0xBC, 0x03, 0x9F, 0x03, 0xCD, 0xFF, 0xC6, 0x3F,
  0x80, 0x00, 0x40, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x70, 0x1C, 0x38, 0x03,
  0x9C, 0x00, 0x66, 0x00, 0x19, 0x80, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x07, 0x60, 0x01, 0x9C, 0x00, 0x63, 0x80, 0x38, 0x70, 0x1C, 0x0F, 0xFE,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x81, 0x83, 0xF8,
  0xC7, 0xFF, 0x67, 0x81, 0xF3, 0x00, 0x7B, 0x80, 0x1D, 0x80, 0x06, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB8, 0x01, 0xCE, 0x01,
  0xE7, 0x81, 0xF1, 0xFF, 0xD8, 0x3F, 0x8C, 0x00, 0x40, 0x01, 0xFF, 0x00,
  0xFB, 0xE0, 0x70, 0x1C, 0x38, 0x03, 0x9C, 0x00, 0x66, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x23,
  0x80, 0x1C, 0x70, 0x0E, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x06, 0x00,
  0x1F, 0xF0, 0x1F, 0x9C, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x80, 0x03, 0xF8, 0xC7,
  0xFF, 0x67, 0x81, 0xF3, 0x00, 0x7B, 0x80, 0x1D, 0x80, 0x06, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB8, 0x01, 0xCE, 0x01, 0xE7,
  0x81, 0xF1, 0xFF, 0xD8, 0x3F, 0x8C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x90, 0x01, 0x9C, 0x01, 0xC7, 0x01, 0xC1, 0xFF, 0xC0, 0x3F, 0xC0, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x40, 0x63, 0xFC, 0x33, 0xFF, 0x9B, 0x01,
  0xCF, 0x00, 0x77, 0x00, 0x1B, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x20, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xCF, 0xFC, 0xFF,
  0x03, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xB8, 0x01,
  0xCE, 0x00, 0xE3, 0x80, 0x70, 0xE0, 0x38, 0x38, 0x1C, 0x0E, 0x0E, 0x03,
  0x87, 0x00, 0xE7, 0x80, 0x3B, 0xC0, 0x0F, 0xF0, 0x03, 0xEE, 0x00, 0xF1,
  0xC0, 0x38, 0x70, 0x0E, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x38, 0x07,
  0x0E, 0x00, 0xE3, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x00, 0xF0, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x02, 0x01, 0x0D, 0xFC, 0xFE, 0xFF, 0xDF, 0xEE, 0x0F, 0x07,
  0xC0, 0x70, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60,
  0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06,
  0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0,
  0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0x00, 0x40, 0xC7,
  0xF8, 0xCF, 0xFE, 0xD8, 0x0E, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0xE0,
  0xF0, 0x3C, 0x70, 0x03, 0x9C, 0x00, 0xEE, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xDC, 0x00, 0xE3, 0x00, 0x30,
  0xF0, 0x3C, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x80, 0x63, 0xF8, 0x37,
  0xFF, 0x1F, 0x03, 0xCE, 0x00, 0xE7, 0x00, 0x3B, 0x00, 0x0D, 0x80, 0x06,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x06, 0xC0, 0x03, 0x70, 0x03, 0xB8, 0x03, 0x9F,
  0x03, 0xCD, 0xFF, 0xC6, 0x3F, 0x83, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x07, 0xFC, 0xC7, 0xFF, 0x67, 0x81, 0xF3, 0x80, 0x3B, 0x80, 0x1D,
  0x80, 0x06, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB8,
  0x01, 0xCE, 0x00, 0xE7, 0x81, 0xF1, 0xFF, 0xD8, 0x3F, 0x8C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x33, 0x0F, 0xFC, 0x7F, 0xF7, 0x80, 0xD8, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x80, 0x07, 0xFC, 0x0F, 0xDF,
  0x8E, 0x01, 0xE6, 0x00, 0x77, 0x00, 0x1F, 0x80, 0x0E, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0C, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xCE, 0x00,
  0xE3, 0xFF, 0xE0, 0x7F, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0x60, 0x0F, 0x70, 0x1B, 0x3F, 0xFB, 0x1F, 0xE3, 0xE0, 0x00, 0x76,
  0x00, 0x06, 0x70, 0x00, 0xE3, 0x00, 0x0C, 0x30, 0x01, 0xC3, 0x80, 0x18,
  0x18, 0x01, 0x81, 0xC0, 0x38, 0x0C, 0x03, 0x00, 0xE0, 0x70, 0x06, 0x06,
  0x00, 0x60, 0x60, 0x07, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x9C, 0x00, 0x19,
  0x80, 0x01, 0x98, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x60, 0x00, 0xE0, 0x30, 0x0D, 0x80, 0xC0, 0x36, 0x03, 0x81, 0x98, 0x1E,
  0x06, 0x60, 0x78, 0x19, 0xC1, 0xA0, 0x63, 0x06, 0xC1, 0x8C, 0x33, 0x0C,
  0x30, 0xCC, 0x30, 0xC3, 0x30, 0xC1, 0x88, 0x63, 0x06, 0x61, 0x88, 0x19,
  0x86, 0x60, 0x66, 0x09, 0x81, 0x90, 0x36, 0x03, 0xC0, 0xD8, 0x0F, 0x03,
  0x40, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x70, 0x06, 0x01, 0x80,
  0xE0, 0x01, 0xEE, 0x00, 0x70, 0xE0, 0x0E, 0x0C, 0x03, 0x81, 0xC0, 0xE0,
  0x1C, 0x38, 0x01, 0xC6, 0x00, 0x19, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0xF8, 0x00, 0x3B, 0x00, 0x0E, 0x70, 0x01, 0x87, 0x00,
  0x70, 0x70, 0x1C, 0x06, 0x07, 0x00, 0xE1, 0xC0, 0x0E, 0x30, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x01, 0xCC, 0x00, 0x0C, 0x70, 0x00,
  0xE1, 0x80, 0x06, 0x0E, 0x00, 0x70, 0x30, 0x03, 0x01, 0xC0, 0x18, 0x0E,
  0x01, 0xC0, 0x38, 0x0C, 0x01, 0xC0, 0xE0, 0x06, 0x06, 0x00, 0x38, 0x70,
  0x00, 0xC3, 0x00, 0x07, 0x18, 0x00, 0x19, 0x80, 0x00, 0xEC, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xBF,
  0xFF, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x3F, 0x01, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x60, 0x03,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x3E, 0x00, 0x70, 0x0F, 0x80, 0xE0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x03, 0xC0, 0x78, 0x01,
  0x00, 0x00, 0x1F, 0x80, 0x0C, 0xFF, 0x80, 0x36, 0x0F, 0x01, 0xD8, 0x0E,
  0x06, 0xC0, 0x1E, 0x7B, 0x00, 0x3F, 0xC0, 0x00, 0x3C, 0x00,
};

const GFXglyph RobotoMono_Light40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 3, 28, 24, 10, -28 },
  { 12, 8, 9, 24, 8, -30 },
  { 21, 22, 28, 24, 1, -28 },
  { 98, 18, 37, 24, 3, -33 },
  { 182, 22, 29, 24, 1, -29 },
  { 262, 20, 29, 24, 3, -29 },
  { 335, 2, 9, 24, 10, -30 },
  { 338, 10, 41, 24, 7, -32 },
  { 390, 9, 41, 24, 7, -32 },
  { 437, 17, 17, 24, 4, -28 },
  { 474, 20, 21, 24, 2, -24 },
  { 527, 4, 10, 24, 8, -4 },
  { 532, 14, 2, 24, 5, -14 },
  { 536, 4, 4, 24, 11, -4 },
  { 538, 15, 30, 24, 5, -28 },
  { 595, 18, 29, 24, 3, -29 },
  { 661, 11, 28, 24, 4, -28 },
  { 700, 18, 29, 24, 2, -29 },
  { 766, 18, 29, 24, 2, -29 },
  { 832, 20, 28, 24, 2, -28 },
  { 902, 17, 28, 24, 4, -28 },
  { 962, 18, 29, 24, 3, -29 },
  { 1028, 19, 28, 24, 2, -28 },
  { 1095, 19, 29, 24, 3, -29 },
  { 1164, 18, 29, 24, 3, -29 },
  { 1230, 4, 21, 24, 12, -21 },
  { 1241, 6, 27, 24, 10, -21 },
  { 1262, 17, 17, 24, 3, -21 },
  { 1299, 18, 10, 24, 3, -18 },
  { 1322, 17, 16, 24, 4, -21 },
  { 1356, 16, 29, 24, 4, -29 },
  { 1414, 22, 29, 24, 1, -29 },
  { 1494, 21, 28, 24, 2, -28 },
  { 1568, 18, 28, 24, 4, -28 },
  { 1631, 19, 29, 24, 2, -29 },
  { 1700, 19, 28, 24, 3, -28 },
  { 1767, 17, 28, 24, 4, -28 },
  { 1827, 17, 28, 24, 4, -28 },
  { 1887, 19, 29, 24, 2, -29 },
  { 1956, 18, 28, 24, 3, -28 },
  { 2019, 16, 28, 24, 4, -28 },
  { 2075, 18, 28, 24, 2, -28 },
  { 2138, 19, 28, 24, 4, -28 },
  { 2205, 17, 28, 24, 4, -28 },
  { 2265, 18, 28, 24, 3, -28 },
  { 2328, 18, 28, 24, 3, -28 },
  { 2391, 20, 29, 24, 2, -29 },
  { 2464, 18, 28, 24, 4, -28 },
  { 2527, 20, 34, 24, 2, -29 },
  { 2612, 18, 28, 24, 4, -28 },
  { 2675, 19, 29, 24, 3, -29 },
  { 2744, 20, 28, 24, 2, -28 },
  { 2814, 18, 28, 24, 3, -28 },
  { 2877, 20, 28, 24, 2, -28 },
  { 2947, 21, 28, 24, 2, -28 },
  { 3021, 21, 28, 24, 2, -28 },
  { 3095, 21, 28, 24, 1, -28 },
  { 3169, 18, 28, 24, 3, -28 },
  { 3232, 7, 39, 24, 9, -33 },
  { 3267, 14, 30, 24, 5, -28 },
  { 3320, 7, 39, 24, 8, -33 },
  { 3355, 14, 15, 24, 5, -28 },
  { 3382, 18, 2, 24, 3, 0 },
  { 3387, 6, 5, 24, 9, -29 },
  { 3391, 18, 22, 24, 3, -22 },
  { 3441, 17, 30, 24, 4, -30 },
  { 3505, 18, 22, 24, 3, -22 },
  { 3555, 17, 30, 24, 3, -30 },
  { 3619, 18, 22, 24, 3, -22 },
  { 3669, 18, 31, 24, 4, -31 },
  { 3739, 17, 30, 24, 3, -22 },
  { 3803, 17, 30, 24, 4, -30 },
  { 3867, 17, 29, 24, 4, -29 },
  { 3929, 12, 38, 24, 4, -29 },
  { 3986, 18, 30, 24, 4, -30 },
  { 4054, 17, 30, 24, 4, -30 },
  { 4118, 20, 22, 24, 2, -22 },
  { 4173, 16, 22, 24, 4, -22 },
  { 4217, 18, 22, 24, 3, -22 },
  { 4267, 17, 30, 24, 4, -22 },
  { 4331, 17, 30, 24, 3, -22 },
  { 4395, 14, 22, 24, 7, -22 },
  { 4434, 17, 22, 24, 4, -22 },
  { 4481, 17, 27, 24, 3, -27 },
  { 4539, 16, 21, 24, 4, -21 },
  { 4581, 20, 21, 24, 2, -21 },
  { 4634, 22, 21, 24, 1, -21 },
  { 4692, 19, 21, 24, 3, -21 },
  { 4742, 21, 30, 24, 1, -21 },
  { 4821, 18, 21, 24, 3, -21 },
  { 4869, 13, 39, 24, 6, -31 },
  { 4933, 2, 35, 24, 11, -28 },
  { 4942, 13, 39, 24, 6, -31 },
  { 5006, 22, 7, 24, 1, -15 },
};

const GFXfont RobotoMono_Light40pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light40pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOMONO_LIGHT40PT7B_H_
