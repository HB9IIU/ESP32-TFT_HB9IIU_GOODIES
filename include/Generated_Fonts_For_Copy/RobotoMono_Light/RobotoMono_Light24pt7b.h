#ifndef _ROBOTOMONO_LIGHT24PT7B_H_
#define _ROBOTOMONO_LIGHT24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x9C, 0xE5, 0x29, 0x00, 0x04, 0x20,
  0x21, 0x01, 0x18, 0x18, 0x80, 0x84, 0x3F, 0xFC, 0x21, 0x01, 0x18, 0x18,
  0x80, 0x84, 0x04, 0x21, 0xFF, 0xE1, 0x18, 0x18, 0x80, 0x84, 0x04, 0x20,
  0x21, 0x00, 0x04, 0x00, 0x80, 0x10, 0x0F, 0xC3, 0x1C, 0xC1, 0x90, 0x12,
  0x03, 0x40, 0x0C, 0x00, 0xE0, 0x07, 0x80, 0x38, 0x01, 0x80, 0x1E, 0x03,
  0xC0, 0x68, 0x09, 0x83, 0x1F, 0xC0, 0x40, 0x08, 0x00, 0x70, 0x04, 0x40,
  0x22, 0x11, 0x11, 0x88, 0x88, 0x44, 0x83, 0xE4, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x01, 0x3C, 0x12, 0x31, 0x90, 0x88, 0x84, 0xC4, 0x20, 0x33, 0x00,
  0xF0, 0x3E, 0x02, 0x30, 0x61, 0x06, 0x10, 0x63, 0x02, 0x20, 0x3C, 0x01,
  0x80, 0x38, 0x06, 0xC2, 0xC6, 0x28, 0x32, 0x81, 0x68, 0x1C, 0x80, 0xCC,
  0x1E, 0x3E, 0x30, 0xF8, 0x04, 0x21, 0x84, 0x20, 0x86, 0x10, 0x41, 0x04,
  0x30, 0xC3, 0x04, 0x10, 0x41, 0x86, 0x08, 0x30, 0x40, 0x83, 0x04, 0x81,
  0x02, 0x0C, 0x10, 0x41, 0x82, 0x08, 0x20, 0xC3, 0x0C, 0x30, 0xC2, 0x08,
  0x21, 0x84, 0x30, 0x86, 0x30, 0x80, 0x04, 0x00, 0x80, 0x10, 0x62, 0x37,
  0xDE, 0x1C, 0x02, 0x80, 0xD8, 0x31, 0x84, 0x18, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x5F, 0x80, 0xFF, 0xFC, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x20,
  0x30, 0x10, 0x18, 0x08, 0x04, 0x06, 0x02, 0x01, 0x01, 0x80, 0x80, 0xC0,
  0x40, 0x60, 0x00, 0x3F, 0x0C, 0x31, 0x03, 0x60, 0x28, 0x05, 0x01, 0xE0,
  0x5C, 0x13, 0x8C, 0x73, 0x0E, 0xC1, 0xF0, 0x3C, 0x05, 0x80, 0x90, 0x33,
  0x0C, 0x1F, 0x00, 0x0C, 0xFE, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0x0C, 0x31, 0x03, 0x60, 0x2C, 0x04, 0x00,
  0x80, 0x30, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x08,
  0x03, 0x00, 0x7F, 0xE0, 0x1F, 0x8C, 0x19, 0x01, 0x60, 0x20, 0x06, 0x00,
  0x80, 0x30, 0x1C, 0x0F, 0x00, 0x18, 0x01, 0x00, 0x3C, 0x07, 0x80, 0xD0,
  0x13, 0x06, 0x1F, 0x80, 0x00, 0x80, 0x18, 0x03, 0x80, 0x28, 0x04, 0x80,
  0xC8, 0x08, 0x81, 0x08, 0x30, 0x82, 0x08, 0x40, 0x8F, 0xFF, 0xFF, 0xF0,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x3F, 0xC4, 0x00, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x1F, 0xC3, 0xFC, 0x20, 0xC0, 0x08, 0x01, 0x80, 0x38, 0x06,
  0x80, 0xD8, 0x31, 0x8E, 0x1F, 0x00, 0x0F, 0x07, 0x03, 0x01, 0x80, 0x40,
  0x30, 0x09, 0xF2, 0x86, 0xC0, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x70, 0x14,
  0x0D, 0x86, 0x1F, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x18, 0x00, 0x3F, 0x0C, 0x19, 0x01, 0x20, 0x24,
  0x06, 0x80, 0x98, 0x31, 0xDC, 0x1F, 0x0C, 0x19, 0x01, 0x60, 0x3C, 0x03,
  0x80, 0xF0, 0x1B, 0x06, 0x3F, 0x80, 0x3F, 0x18, 0x64, 0x0F, 0x03, 0x80,
  0x60, 0x18, 0x07, 0x01, 0xC0, 0xD8, 0x73, 0xF4, 0x01, 0x00, 0xC0, 0x20,
  0x18, 0x1C, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x6C, 0x00, 0x00, 0x01, 0xB6,
  0xB0, 0x00, 0x40, 0x70, 0x70, 0x70, 0xF0, 0x30, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x30, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x80,
  0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x30, 0x38, 0x78, 0x70, 0x30, 0x00,
  0x7E, 0x61, 0xA0, 0x70, 0x10, 0x08, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x02,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x0F, 0xC0, 0xC3, 0x08,
  0x0C, 0x82, 0x24, 0x79, 0x44, 0x46, 0x62, 0x32, 0x11, 0x90, 0x8C, 0x84,
  0x64, 0x65, 0x23, 0x28, 0xEE, 0x60, 0x01, 0x00, 0x06, 0x08, 0x1F, 0x80,
  0x02, 0x00, 0x38, 0x01, 0x40, 0x0A, 0x00, 0xD8, 0x04, 0xC0, 0x22, 0x03,
  0x10, 0x10, 0xC0, 0x82, 0x0C, 0x10, 0x7F, 0xC2, 0x02, 0x30, 0x11, 0x00,
  0xC8, 0x02, 0xC0, 0x18, 0xFF, 0x18, 0x33, 0x03, 0x60, 0x2C, 0x05, 0x80,
  0xB0, 0x36, 0x1C, 0xFF, 0x98, 0x1B, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x16, 0x0E, 0xFF, 0x00, 0x1F, 0x83, 0x0C, 0x20, 0x66, 0x03, 0x40, 0x34,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x36,
  0x02, 0x20, 0x63, 0x0C, 0x0F, 0x80, 0xFE, 0x18, 0x73, 0x03, 0x60, 0x2C,
  0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07,
  0x80, 0xB0, 0x26, 0x1C, 0xFE, 0x00, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xFF, 0xB0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xFF, 0x98, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x00, 0x1F, 0x83, 0x0C, 0x20, 0x26, 0x03, 0x40, 0x34,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x3F, 0xC0, 0x14, 0x01, 0x40, 0x16,
  0x01, 0x20, 0x13, 0x86, 0x0F, 0xC0, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0xFF, 0xC0, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x1C, 0x02, 0x80, 0xD8,
  0x11, 0x86, 0x1F, 0x00, 0xC0, 0x6C, 0x0C, 0xC1, 0x8C, 0x10, 0xC2, 0x0C,
  0x60, 0xCC, 0x0D, 0x80, 0xFC, 0x0E, 0x40, 0xC6, 0x0C, 0x30, 0xC1, 0x8C,
  0x08, 0xC0, 0xCC, 0x06, 0xC0, 0x30, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0xFF, 0xC0, 0xC0, 0x78, 0x1F, 0x83, 0xD0, 0x7A, 0x17, 0x62,
  0xE4, 0xDC, 0x93, 0x8A, 0x71, 0xCE, 0x31, 0xC2, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x60, 0xC0, 0x78, 0x0F, 0x81, 0xD0, 0x3B, 0x07, 0x20,
  0xE6, 0x1C, 0x43, 0x8C, 0x70, 0xCE, 0x09, 0xC1, 0xB8, 0x17, 0x03, 0xE0,
  0x3C, 0x07, 0x80, 0x60, 0x1F, 0x83, 0x0C, 0x20, 0x66, 0x02, 0x40, 0x34,
  0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x34, 0x03, 0x40, 0x36,
  0x02, 0x20, 0x63, 0x0C, 0x0F, 0x80, 0xFE, 0x20, 0x68, 0x0E, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x03, 0x83, 0xBF, 0x88, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x00, 0x1F, 0x83, 0x0C, 0x60, 0x66, 0x02, 0x40, 0x3C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x40, 0x36,
  0x02, 0x20, 0x63, 0x0C, 0x1F, 0x80, 0x06, 0x00, 0x30, 0x01, 0xFF, 0x18,
  0x33, 0x03, 0x60, 0x2C, 0x07, 0x80, 0xF0, 0x16, 0x06, 0xC3, 0x9F, 0xC3,
  0x0C, 0x60, 0x8C, 0x19, 0x81, 0x30, 0x36, 0x02, 0xC0, 0x60, 0x3F, 0x0C,
  0x1B, 0x01, 0x60, 0x3C, 0x07, 0x80, 0x18, 0x01, 0xC0, 0x0F, 0x00, 0x30,
  0x01, 0x00, 0x38, 0x03, 0x00, 0x70, 0x1B, 0x06, 0x3F, 0x80, 0xFF, 0xF0,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x05, 0x80, 0x90, 0x33, 0x0C, 0x1F, 0x00,
  0xC0, 0x14, 0x03, 0x40, 0x26, 0x02, 0x60, 0x62, 0x06, 0x30, 0x43, 0x0C,
  0x10, 0xC1, 0x88, 0x19, 0x80, 0x98, 0x09, 0x00, 0xD0, 0x07, 0x00, 0x60,
  0x06, 0x00, 0x82, 0x1E, 0x30, 0xF1, 0xC5, 0x8A, 0x24, 0x51, 0x22, 0x89,
  0x14, 0x49, 0xA6, 0x69, 0xB3, 0x45, 0x1A, 0x28, 0x51, 0x43, 0x8A, 0x18,
  0x70, 0xC1, 0x86, 0x0C, 0x30, 0x40, 0xC0, 0x33, 0x01, 0x0C, 0x18, 0x20,
  0x81, 0x8C, 0x04, 0xC0, 0x34, 0x00, 0xE0, 0x06, 0x00, 0x38, 0x03, 0x60,
  0x11, 0x01, 0x8C, 0x18, 0x20, 0x81, 0x8C, 0x06, 0xC0, 0x18, 0xC0, 0x34,
  0x02, 0x60, 0x62, 0x04, 0x30, 0xC1, 0x08, 0x19, 0x80, 0x90, 0x0F, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xFF, 0xC0, 0x30, 0x08, 0x06, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x06,
  0x01, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x02, 0x00, 0xFF, 0xC0, 0xFF, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF, 0xC0, 0x40,
  0x40, 0x60, 0x20, 0x20, 0x10, 0x10, 0x18, 0x08, 0x08, 0x0C, 0x04, 0x06,
  0x02, 0x02, 0x03, 0x01, 0xFF, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0xFF, 0x18, 0x0C, 0x07, 0x06, 0x82, 0x63, 0x11, 0x08,
  0x86, 0xC1, 0x80, 0xFF, 0xC0, 0xC6, 0x21, 0x1F, 0x1C, 0x64, 0x0F, 0x01,
  0x00, 0x40, 0x13, 0xFD, 0x81, 0xC0, 0x60, 0x1C, 0x0D, 0x85, 0x3E, 0x40,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x9E, 0x3C, 0xE7, 0x06, 0xC0,
  0x58, 0x0B, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xB0, 0x16, 0x06, 0xE1, 0x9B,
  0xE0, 0x1F, 0x0E, 0x66, 0x0F, 0x01, 0xC0, 0x60, 0x08, 0x02, 0x00, 0x80,
  0x30, 0x14, 0x05, 0x86, 0x1F, 0x00, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x47, 0x93, 0x35, 0x83, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C,
  0x05, 0x03, 0x61, 0xCF, 0xD0, 0x1F, 0x06, 0x71, 0x83, 0x60, 0x28, 0x07,
  0x00, 0xFF, 0xFC, 0x00, 0x80, 0x18, 0x01, 0x01, 0x38, 0x61, 0xF8, 0x07,
  0xE1, 0x80, 0x20, 0x04, 0x00, 0x81, 0xFF, 0x82, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x1E, 0x4C, 0xD6, 0x0F, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70,
  0x14, 0x0D, 0x87, 0x3F, 0x40, 0x10, 0x0D, 0x02, 0x61, 0x87, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x33, 0xCD, 0x9B, 0x83, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x10, 0x0C, 0x03,
  0x00, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0xFF, 0xC0, 0x03, 0x03, 0x00, 0x00,
  0x3F, 0x3F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x02, 0x02, 0x06, 0x0C, 0xF8, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x68, 0x32, 0x18, 0x8C, 0x26, 0x0B, 0x03, 0xC0, 0xC8, 0x23, 0x08,
  0x62, 0x0C, 0x81, 0xA0, 0x30, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x3F, 0xF0, 0xBC, 0xEA, 0x73, 0xC6, 0x18, 0x21, 0x82, 0x18,
  0x21, 0x82, 0x18, 0x21, 0x82, 0x18, 0x21, 0x82, 0x18, 0x21, 0x82, 0x10,
  0xCF, 0x36, 0x6E, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x40, 0x1E, 0x0E, 0x71, 0x03, 0x60, 0x28, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0B, 0x03, 0x30, 0xC3, 0xF0, 0xCF,
  0x1E, 0x73, 0x03, 0x60, 0x6C, 0x05, 0x80, 0xB0, 0x1E, 0x02, 0xC0, 0x58,
  0x0B, 0x03, 0x70, 0xCD, 0xF1, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00,
  0x1E, 0x5C, 0xD6, 0x0F, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70,
  0x14, 0x0D, 0x87, 0x3F, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0xCF,
  0xEE, 0xB8, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x00, 0x1F, 0x06, 0x31, 0x03, 0x20, 0x24, 0x00, 0xE0, 0x07, 0xC0,
  0x0E, 0x00, 0x58, 0x0F, 0x01, 0x30, 0x63, 0xF8, 0x08, 0x02, 0x00, 0x83,
  0xFF, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0xC0, 0x1F, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x14, 0x0D, 0x85, 0x3E, 0x40, 0xC0, 0x14, 0x03,
  0x60, 0x22, 0x06, 0x20, 0x43, 0x04, 0x10, 0xC1, 0x88, 0x09, 0x80, 0x90,
  0x05, 0x00, 0x60, 0x06, 0x00, 0x82, 0x0C, 0x30, 0xE1, 0x85, 0x8E, 0x24,
  0x51, 0x26, 0x89, 0x24, 0x8D, 0x34, 0x28, 0xA1, 0xC5, 0x0C, 0x38, 0x61,
  0x83, 0x04, 0x00, 0xC0, 0x68, 0x19, 0x82, 0x18, 0x81, 0xB0, 0x1C, 0x03,
  0x00, 0x70, 0x1B, 0x06, 0x21, 0x82, 0x20, 0x6C, 0x06, 0xC0, 0x1C, 0x03,
  0x40, 0x36, 0x02, 0x20, 0x63, 0x04, 0x10, 0xC1, 0x88, 0x09, 0x80, 0xD0,
  0x05, 0x00, 0x70, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0xFF, 0xDF, 0xF8, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10,
  0x06, 0x01, 0x80, 0x60, 0x0F, 0xFE, 0x03, 0x06, 0x08, 0x08, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x10, 0x30, 0xE0, 0xE0, 0x30, 0x10, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x08, 0x0C, 0x06, 0x01, 0xFF, 0xFF, 0xF8, 0x80, 0x60, 0x30,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x18, 0x08, 0x07, 0x07, 0x08, 0x18,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x30, 0x60, 0x80, 0x78, 0x0E, 0x30,
  0xE0, 0xCD, 0x03, 0xC0,
};

const GFXglyph RobotoMono_Light24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 2, 17, 14, 6, -17 },
  { 6, 5, 5, 14, 5, -18 },
  { 10, 13, 17, 14, 1, -17 },
  { 38, 11, 22, 14, 2, -20 },
  { 69, 13, 17, 14, 1, -17 },
  { 97, 12, 17, 14, 2, -17 },
  { 123, 1, 5, 14, 6, -18 },
  { 124, 6, 25, 14, 4, -19 },
  { 143, 6, 25, 14, 4, -19 },
  { 162, 11, 10, 14, 2, -17 },
  { 176, 12, 12, 14, 1, -14 },
  { 194, 2, 5, 14, 5, -2 },
  { 196, 8, 1, 14, 3, -8 },
  { 197, 3, 2, 14, 6, -2 },
  { 198, 9, 18, 14, 3, -17 },
  { 219, 11, 17, 14, 2, -17 },
  { 243, 6, 17, 14, 3, -17 },
  { 256, 11, 17, 14, 1, -17 },
  { 280, 11, 17, 14, 1, -17 },
  { 304, 12, 17, 14, 1, -17 },
  { 330, 11, 17, 14, 2, -17 },
  { 354, 10, 17, 14, 2, -17 },
  { 376, 12, 17, 14, 1, -17 },
  { 402, 11, 17, 14, 2, -17 },
  { 426, 10, 17, 14, 2, -17 },
  { 448, 2, 12, 14, 7, -12 },
  { 451, 3, 15, 14, 6, -12 },
  { 457, 10, 10, 14, 2, -13 },
  { 470, 11, 6, 14, 2, -11 },
  { 479, 10, 10, 14, 2, -13 },
  { 492, 9, 17, 14, 3, -17 },
  { 512, 13, 17, 14, 1, -17 },
  { 540, 13, 17, 14, 1, -17 },
  { 568, 11, 17, 14, 2, -17 },
  { 592, 12, 17, 14, 1, -17 },
  { 618, 11, 17, 14, 2, -17 },
  { 642, 10, 17, 14, 2, -17 },
  { 664, 11, 17, 14, 2, -17 },
  { 688, 12, 17, 14, 1, -17 },
  { 714, 11, 17, 14, 2, -17 },
  { 738, 10, 17, 14, 2, -17 },
  { 760, 11, 17, 14, 1, -17 },
  { 784, 12, 17, 14, 2, -17 },
  { 810, 10, 17, 14, 3, -17 },
  { 832, 11, 17, 14, 2, -17 },
  { 856, 11, 17, 14, 2, -17 },
  { 880, 12, 17, 14, 1, -17 },
  { 906, 10, 17, 14, 3, -17 },
  { 928, 12, 20, 14, 1, -17 },
  { 958, 11, 17, 14, 2, -17 },
  { 982, 11, 17, 14, 2, -17 },
  { 1006, 12, 17, 14, 1, -17 },
  { 1032, 11, 17, 14, 2, -17 },
  { 1056, 12, 17, 14, 1, -17 },
  { 1082, 13, 17, 14, 1, -17 },
  { 1110, 13, 17, 14, 1, -17 },
  { 1138, 12, 17, 14, 1, -17 },
  { 1164, 10, 17, 14, 2, -17 },
  { 1186, 4, 24, 14, 5, -20 },
  { 1198, 8, 18, 14, 3, -17 },
  { 1216, 4, 24, 14, 5, -20 },
  { 1228, 9, 9, 14, 3, -17 },
  { 1239, 10, 1, 14, 2, 0 },
  { 1241, 4, 4, 14, 5, -18 },
  { 1243, 10, 13, 14, 2, -13 },
  { 1260, 11, 18, 14, 2, -18 },
  { 1285, 10, 13, 14, 2, -13 },
  { 1302, 10, 18, 14, 2, -18 },
  { 1325, 11, 13, 14, 2, -13 },
  { 1343, 11, 18, 14, 2, -18 },
  { 1368, 10, 18, 14, 2, -13 },
  { 1391, 10, 18, 14, 2, -18 },
  { 1414, 10, 17, 14, 3, -17 },
  { 1436, 8, 22, 14, 2, -17 },
  { 1458, 10, 18, 14, 3, -18 },
  { 1481, 10, 18, 14, 3, -18 },
  { 1504, 12, 13, 14, 1, -13 },
  { 1524, 10, 13, 14, 2, -13 },
  { 1541, 11, 13, 14, 2, -13 },
  { 1559, 11, 18, 14, 2, -13 },
  { 1584, 10, 18, 14, 2, -13 },
  { 1607, 9, 13, 14, 4, -13 },
  { 1622, 11, 13, 14, 2, -13 },
  { 1640, 10, 16, 14, 2, -16 },
  { 1660, 10, 13, 14, 2, -13 },
  { 1677, 12, 13, 14, 1, -13 },
  { 1697, 13, 13, 14, 1, -13 },
  { 1719, 11, 13, 14, 2, -13 },
  { 1737, 12, 18, 14, 1, -13 },
  { 1764, 11, 13, 14, 2, -13 },
  { 1782, 8, 24, 14, 4, -19 },
  { 1806, 1, 21, 14, 7, -17 },
  { 1809, 8, 24, 14, 4, -19 },
  { 1833, 13, 4, 14, 1, -9 },
};

const GFXfont RobotoMono_Light24pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light24pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOMONO_LIGHT24PT7B_H_
