#ifndef _ROBOTOMONO_LIGHT48PT7B_H_
#define _ROBOTOMONO_LIGHT48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light48pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x00, 0x00, 0x00, 0x6F, 0xFF, 0x60, 0xD8, 0x36, 0x0D, 0x83, 0x60,
  0xD8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x60, 0x18, 0x00, 0x0C, 0x07, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x70,
  0x18, 0x00, 0x0E, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF0,
  0x06, 0x03, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x06, 0x01,
  0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0xE0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x1C, 0x00, 0x0E, 0x03, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xE0, 0x7C, 0x1C,
  0x00, 0xE1, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x60, 0x00, 0x77, 0x00, 0x03,
  0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xE7, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDE, 0x00, 0x1C, 0x78, 0x01,
  0xE1, 0xF0, 0x3E, 0x07, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x38, 0x70, 0x00, 0x0E,
  0x06, 0x00, 0x01, 0xC0, 0xE0, 0x30, 0x30, 0x0C, 0x06, 0x06, 0x01, 0x81,
  0x80, 0xC0, 0x30, 0x70, 0x18, 0x06, 0x0C, 0x03, 0x00, 0xC3, 0x80, 0x70,
  0x38, 0x60, 0x06, 0x06, 0x1C, 0x00, 0xF3, 0xC3, 0x00, 0x0F, 0xF0, 0xE0,
  0x00, 0x78, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x83, 0xE0, 0x00, 0x70, 0xFF,
  0x00, 0x0C, 0x38, 0xE0, 0x03, 0x8E, 0x0E, 0x00, 0x61, 0x80, 0xC0, 0x1C,
  0x30, 0x1C, 0x03, 0x06, 0x03, 0x80, 0xC0, 0xC0, 0x70, 0x38, 0x18, 0x0E,
  0x06, 0x03, 0x01, 0xC0, 0xC0, 0x60, 0x30, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xE0, 0xF0,
  0x00, 0xE0, 0x38, 0x00, 0x70, 0x0C, 0x00, 0x70, 0x06, 0x00, 0x38, 0x03,
  0x00, 0x1C, 0x01, 0x80, 0x0E, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x01, 0xC0,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xCF, 0x00, 0x03, 0xC3, 0x80, 0x71, 0xC0, 0xE0, 0x39, 0xC0, 0x38, 0x18,
  0xE0, 0x1E, 0x0C, 0xE0, 0x07, 0x0E, 0x70, 0x01, 0xC7, 0x38, 0x00, 0x77,
  0x1C, 0x00, 0x3F, 0x8E, 0x00, 0x0F, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x03,
  0xE0, 0x70, 0x03, 0xF8, 0x3E, 0x07, 0xDE, 0x07, 0xFF, 0x87, 0x81, 0xFF,
  0x81, 0xE0, 0xFF, 0xFF, 0xFE, 0xD8, 0x00, 0x60, 0x1C, 0x07, 0x01, 0xC0,
  0x30, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x20, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0,
  0x38, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x00, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x04, 0x03, 0x00, 0x9E, 0x0C, 0x1E, 0xFF, 0x31, 0xFC, 0x7F,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0x30,
  0x00, 0x1C, 0xE0, 0x00, 0xE1, 0xC0, 0x07, 0x03, 0x80, 0x3C, 0x0F, 0x01,
  0xE0, 0x1E, 0x03, 0x00, 0x30, 0x04, 0x00, 0x80, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x39, 0xCE, 0x73, 0x9C,
  0xEE, 0x77, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF7, 0xFD, 0xE0, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3C, 0x07, 0x83,
  0xC0, 0x1E, 0x1C, 0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00,
  0x37, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xDF, 0x80, 0x1C, 0xFC, 0x01, 0xC7, 0xE0, 0x1C, 0x3F, 0x03, 0xC1,
  0xF8, 0x3C, 0x0F, 0xC3, 0xC0, 0x7E, 0x38, 0x03, 0xF3, 0x80, 0x1F, 0xB8,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0E,
  0xC0, 0x00, 0x67, 0x00, 0x07, 0x38, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x80,
  0x3C, 0x1E, 0x07, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x30, 0x0F,
  0x03, 0xF1, 0xFF, 0x7E, 0x3F, 0x83, 0xC0, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0x80, 0xF8, 0x3C,
  0x00, 0xE0, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x60, 0x00,
  0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0x78,
  0x3C, 0x00, 0xF0, 0xE0, 0x01, 0xC7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70,
  0x00, 0x39, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE3,
  0x80, 0x07, 0x8F, 0x00, 0x3C, 0x1F, 0x01, 0xE0, 0x3F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x07,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x1C,
  0x00, 0xE0, 0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x1F, 0x80, 0x3B, 0xFF, 0x81, 0xFF, 0xFE, 0x0F,
  0x81, 0xF8, 0x70, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x01, 0xE7, 0x00, 0x0F,
  0x3C, 0x00, 0xF0, 0xF0, 0x0F, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x1F, 0xE0,
  0x73, 0xFF, 0xC3, 0x3C, 0x1F, 0x1B, 0x80, 0x3C, 0xF0, 0x00, 0xE7, 0x00,
  0x03, 0xB8, 0x00, 0x1D, 0x80, 0x00, 0xEC, 0x00, 0x03, 0x60, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xB8, 0x00,
  0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x0F, 0x1C, 0x00, 0x70, 0xF0, 0x07, 0x03,
  0xE0, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x3C, 0x00, 0xF0, 0xE0, 0x01, 0xC3, 0x80,
  0x07, 0x1C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03,
  0x9C, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xE0, 0x01, 0xC1, 0xC0, 0x0E, 0x03,
  0x80, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0x80,
  0x78, 0x3C, 0x00, 0xF1, 0xE0, 0x01, 0xE7, 0x00, 0x03, 0xB8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1D, 0xC0, 0x00, 0xE7, 0x80, 0x07, 0x8F, 0x00, 0x3C, 0x1F, 0x03,
  0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0xC0, 0x3C, 0x0F, 0x03, 0xC0, 0x1C, 0x3C, 0x00, 0x71, 0xC0,
  0x03, 0x9C, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7B, 0x80, 0x03, 0xDC, 0x00, 0x3E, 0x70, 0x03, 0xF3,
  0xC0, 0x7B, 0x8F, 0xFF, 0x98, 0x1F, 0xF8, 0xC0, 0x3E, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x03, 0xF8, 0x00, 0xF7, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0x70, 0x3C, 0x7C, 0xF9, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x38, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x38,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0x03, 0xC7, 0x80, 0x3C, 0xE0, 0x03, 0x98, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x1E, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xE0, 0xC0, 0x00, 0x18, 0x60, 0x3F, 0x06, 0x38, 0x1F, 0xE0, 0xCC, 0x0E,
  0x18, 0x33, 0x07, 0x06, 0x0D, 0xC1, 0x81, 0x83, 0x60, 0xC0, 0x60, 0xD8,
  0x30, 0x18, 0x36, 0x0C, 0x06, 0x0D, 0x86, 0x01, 0x83, 0x61, 0x80, 0x60,
  0xF8, 0x60, 0x10, 0x3C, 0x18, 0x0C, 0x0F, 0x06, 0x03, 0x03, 0xE1, 0x80,
  0xC0, 0xD8, 0x60, 0x30, 0x26, 0x18, 0x1C, 0x19, 0x83, 0x0F, 0x06, 0x60,
  0xEE, 0x63, 0x1C, 0x3F, 0x9F, 0x83, 0x03, 0x83, 0xC0, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x01, 0x00, 0x1E, 0x01,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x1C,
  0x00, 0x0E, 0x06, 0x00, 0x06, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x80,
  0x60, 0x01, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x03, 0x80, 0x70, 0x01, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x1C,
  0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E,
  0x70, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x30, 0x0F, 0xE1, 0x80, 0x07, 0x8C, 0x00, 0x1E, 0x60, 0x00, 0x73, 0x00,
  0x01, 0x98, 0x00, 0x0E, 0xC0, 0x00, 0x76, 0x00, 0x03, 0xB0, 0x00, 0x1D,
  0x80, 0x01, 0xCC, 0x00, 0x0E, 0x60, 0x00, 0xE3, 0x00, 0x1E, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x30, 0x00, 0xF1, 0x80, 0x01, 0xCC,
  0x00, 0x07, 0x60, 0x00, 0x3B, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xEC, 0x00, 0x07, 0x60,
  0x00, 0x73, 0x00, 0x0F, 0x98, 0x03, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x78, 0x0F,
  0x01, 0xE0, 0x07, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x18, 0x00, 0x0E,
  0x70, 0x00, 0x1C, 0xE0, 0x00, 0x19, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x33, 0x80, 0x00, 0xE3, 0x80, 0x01,
  0xC7, 0x00, 0x07, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x38, 0x0F, 0x81, 0xE0,
  0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0E,
  0x03, 0xF0, 0x38, 0x01, 0xF0, 0xE0, 0x01, 0xE3, 0x80, 0x03, 0x8E, 0x00,
  0x07, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x1C, 0xE0,
  0x00, 0xE3, 0x80, 0x07, 0x8E, 0x00, 0x7C, 0x38, 0x1F, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x7C, 0x0F, 0x81, 0xE0, 0x07, 0x07, 0x80, 0x07, 0x0E,
  0x00, 0x0F, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xC7, 0x00, 0x03, 0x87,
  0x00, 0x1E, 0x0F, 0x80, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x70, 0xE0, 0x07, 0x83,
  0xC0, 0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xE0, 0x00, 0x3D, 0xC0,
  0x00, 0xE3, 0x80, 0x03, 0xC7, 0x00, 0x0F, 0x0E, 0x00, 0x3C, 0x1C, 0x00,
  0xF0, 0x38, 0x01, 0xC0, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x78,
  0x03, 0x81, 0xE0, 0x07, 0x07, 0x80, 0x0E, 0x1E, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0xEF, 0xC0, 0x01, 0xFF, 0xC0, 0x03,
  0xF3, 0x80, 0x07, 0xC3, 0x80, 0x0F, 0x07, 0x80, 0x1C, 0x07, 0x80, 0x38,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0F, 0x01, 0xC0, 0x0F, 0x03, 0x80,
  0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x3C, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFD, 0x80, 0x0F,
  0xFE, 0x00, 0x6F, 0xF0, 0x07, 0x7D, 0x80, 0x33, 0xEE, 0x03, 0x9F, 0x70,
  0x1C, 0xF9, 0x80, 0xC7, 0xCE, 0x0E, 0x3E, 0x70, 0x71, 0xF1, 0x83, 0x0F,
  0x8E, 0x38, 0x7C, 0x71, 0x83, 0xE1, 0x9C, 0x1F, 0x0E, 0xE0, 0xF8, 0x36,
  0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x38, 0x0F, 0x81, 0xC0, 0x7C,
  0x0C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFD,
  0xC0, 0x07, 0xEE, 0x00, 0x3F, 0x38, 0x01, 0xF9, 0xC0, 0x0F, 0xC7, 0x00,
  0x7E, 0x1C, 0x03, 0xF0, 0xE0, 0x1F, 0x83, 0x80, 0xFC, 0x1C, 0x07, 0xE0,
  0x70, 0x3F, 0x03, 0x81, 0xF8, 0x0E, 0x0F, 0xC0, 0x70, 0x7E, 0x01, 0xC3,
  0xF0, 0x0E, 0x1F, 0x80, 0x38, 0xFC, 0x00, 0xE7, 0xE0, 0x07, 0x3F, 0x00,
  0x1D, 0xF8, 0x00, 0xEF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7C, 0x1F, 0x01, 0xE0,
  0x0F, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0x70, 0x00,
  0x1C, 0xE0, 0x00, 0x39, 0x80, 0x00, 0x77, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0C, 0xC0,
  0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE3, 0x80, 0x03, 0x87, 0x00,
  0x07, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x70, 0x0F, 0x83, 0xE0, 0x0F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0E, 0x00, 0x7C,
  0x38, 0x00, 0x78, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xEE, 0x00, 0x03, 0xB8,
  0x00, 0x0E, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x3C,
  0xE0, 0x01, 0xE3, 0x80, 0x7F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x78,
  0x1F, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x0F, 0x0E, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x33, 0x80, 0x00, 0xE7, 0x00,
  0x01, 0xC7, 0x00, 0x07, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x78, 0x0F, 0x83,
  0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x04,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x38, 0x07, 0xE1, 0xC0, 0x07, 0x8E, 0x00,
  0x1E, 0x70, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77,
  0x00, 0x01, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00,
  0x3B, 0x80, 0x03, 0x9C, 0x00, 0x3C, 0xE0, 0x07, 0xC7, 0xFF, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0xF8, 0x0E, 0x01, 0xC0, 0x70, 0x07, 0x03, 0x80, 0x38,
  0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x87, 0x00, 0x1C, 0x38, 0x00, 0x71, 0xC0,
  0x03, 0x8E, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0x0E,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x7C, 0x0F, 0x81, 0xE0, 0x07, 0x87, 0x00, 0x07, 0x8E,
  0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x77, 0x00, 0x00, 0xEF, 0x00, 0x03, 0xCE, 0x00, 0x07, 0x0F,
  0x00, 0x1C, 0x0F, 0x81, 0xF8, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0xC0, 0x00, 0xE7,
  0x00, 0x07, 0x3C, 0x00, 0x70, 0xF0, 0x07, 0x83, 0xE0, 0xF8, 0x0F, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x03, 0x9C, 0x00,
  0x01, 0xCE, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x30, 0x30, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0C, 0x07,
  0x00, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x70,
  0x00, 0xE0, 0x38, 0x00, 0x70, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x06, 0x00, 0x01, 0x87, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71,
  0x80, 0x00, 0x19, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x01, 0xF8, 0x07, 0x00, 0x6E, 0x01, 0xE0,
  0x1B, 0x80, 0x78, 0x06, 0x60, 0x1E, 0x03, 0x98, 0x07, 0x80, 0xE7, 0x03,
  0xE0, 0x39, 0xC0, 0xFC, 0x0E, 0x70, 0x37, 0x03, 0x1C, 0x0C, 0xC0, 0xC7,
  0x03, 0x30, 0x30, 0xC1, 0xCC, 0x1C, 0x30, 0x73, 0x07, 0x0C, 0x18, 0xE1,
  0xC3, 0x86, 0x38, 0x70, 0xE1, 0x86, 0x18, 0x38, 0xE1, 0x86, 0x0E, 0x38,
  0x61, 0x81, 0x8C, 0x1C, 0xE0, 0x63, 0x07, 0x38, 0x18, 0xC0, 0xCE, 0x07,
  0x30, 0x33, 0x81, 0xDC, 0x0C, 0xC0, 0x77, 0x03, 0xB0, 0x1D, 0x80, 0xEC,
  0x03, 0x60, 0x3B, 0x00, 0xD8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x1E,
  0x78, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x70,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x03, 0x81, 0xC0,
  0x03, 0x83, 0x80, 0x01, 0xC7, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xC7, 0x00,
  0x01, 0xC3, 0x80, 0x03, 0x83, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0x38,
  0x38, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1E,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x70,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x81, 0xC0,
  0x03, 0x81, 0xC0, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xE3, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x76, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0xFF, 0xFF, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x76, 0x00, 0x3B, 0x80, 0x19, 0xC0, 0x1C, 0x70,
  0x0C, 0x38, 0x0E, 0x0C, 0x07, 0x07, 0x03, 0x01, 0x83, 0x80, 0xE1, 0x80,
  0x71, 0xC0, 0x1C, 0xE0, 0x0E, 0x60, 0x03, 0x70, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0xE0, 0xC1, 0xC1, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x78, 0x07, 0xC3, 0x80, 0x0E, 0x38,
  0x00, 0x39, 0xC0, 0x01, 0xCC, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xF0, 0x38, 0xF0,
  0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D,
  0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x78, 0x00, 0xF9, 0xC0, 0x0F, 0xCF, 0x81,
  0xEE, 0x3F, 0xFE, 0x38, 0x7F, 0xC1, 0xC0, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0xF8, 0x0C, 0x7F,
  0xE0, 0xCF, 0xFF, 0x0D, 0xC0, 0x78, 0xF8, 0x03, 0xCF, 0x00, 0x1E, 0xE0,
  0x00, 0xEE, 0x00, 0x0E, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x00,
  0xEF, 0x00, 0x1C, 0xF8, 0x03, 0xCD, 0xE0, 0xF8, 0xCF, 0xFF, 0x0C, 0x3F,
  0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3C, 0x03, 0xC3,
  0xC0, 0x0E, 0x1C, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x07, 0x1C, 0x00, 0x38, 0xF0,
  0x03, 0x83, 0xE0, 0x78, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x01,
  0xF0, 0x70, 0x7F, 0xE7, 0x0F, 0xFF, 0x71, 0xE0, 0x3F, 0x38, 0x01, 0xF7,
  0x80, 0x0F, 0x70, 0x00, 0x77, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x77, 0x00,
  0x07, 0x70, 0x00, 0x73, 0x80, 0x0F, 0x3C, 0x01, 0xF1, 0xE0, 0x7F, 0x0F,
  0xFF, 0x70, 0x3F, 0xC7, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0,
  0x3C, 0x07, 0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0x39, 0xC0, 0x01, 0xCC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x18, 0x70, 0x01, 0xE3, 0xE0, 0x3C, 0x07, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xE3,
  0x0F, 0xFF, 0x71, 0xE0, 0x3F, 0x38, 0x01, 0xF7, 0x80, 0x0F, 0x70, 0x00,
  0x77, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x73,
  0x80, 0x0F, 0x3C, 0x01, 0xF1, 0xF0, 0x7F, 0x0F, 0xFF, 0x70, 0x3F, 0xC7,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x20, 0x00,
  0xE7, 0x00, 0x1E, 0x3C, 0x03, 0xC1, 0xF0, 0xF8, 0x0F, 0xFF, 0x00, 0x3F,
  0xC0, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0xFC, 0x0C, 0x3F, 0xF0, 0xC7, 0xFF, 0x8C, 0xE0, 0x3C,
  0xD8, 0x01, 0xEF, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x06, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x71, 0x07, 0xE3, 0xFF, 0x07, 0xFC, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x05, 0xC0, 0x03, 0xCE, 0x00, 0x3C, 0x70, 0x03,
  0xC3, 0x80, 0x3C, 0x1C, 0x03, 0xC0, 0xE0, 0x3C, 0x07, 0x03, 0xC0, 0x38,
  0x38, 0x01, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0x77, 0xC0, 0x03, 0xFF, 0x00,
  0x1F, 0xB8, 0x00, 0xF8, 0xE0, 0x07, 0x87, 0x80, 0x38, 0x1E, 0x01, 0xC0,
  0x78, 0x0E, 0x01, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x70,
  0xE0, 0x03, 0xC7, 0x00, 0x0F, 0x38, 0x00, 0x3D, 0xC0, 0x00, 0xF0, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0,
  0x78, 0x77, 0xF8, 0xFF, 0x3F, 0xFE, 0xFF, 0xDF, 0x07, 0xC0, 0xEF, 0x01,
  0xE0, 0x37, 0x00, 0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x38, 0x07, 0xE0,
  0x1C, 0x03, 0xF0, 0x0E, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03, 0x80, 0x7E,
  0x01, 0xC0, 0x3F, 0x00, 0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x38, 0x07,
  0xE0, 0x1C, 0x03, 0xF0, 0x0E, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03, 0x80,
  0x7E, 0x01, 0xC0, 0x3F, 0x00, 0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x38,
  0x07, 0xE0, 0x1C, 0x03, 0xF0, 0x0E, 0x01, 0xC0, 0x00, 0x78, 0x0C, 0x3F,
  0xF0, 0xC7, 0xFF, 0x8C, 0xE0, 0x3C, 0xD8, 0x01, 0xEF, 0x00, 0x0E, 0xE0,
  0x00, 0xEE, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xF8, 0x0F,
  0x01, 0xC0, 0x07, 0x07, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x70, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0C, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE3, 0x80,
  0x03, 0x87, 0x80, 0x0F, 0x07, 0x80, 0x3C, 0x07, 0x81, 0xF0, 0x07, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x01, 0xF8, 0x0C, 0x7F, 0xE0, 0xCF, 0xFF, 0x0D,
  0xC0, 0x78, 0xF0, 0x03, 0xCF, 0x00, 0x1C, 0xE0, 0x00, 0xEC, 0x00, 0x0E,
  0xC0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xEC, 0x00, 0x0E, 0xE0, 0x00, 0xEF, 0x00, 0x1C, 0xF8,
  0x03, 0xCD, 0xC0, 0xF8, 0xCF, 0xFF, 0x0C, 0x3F, 0xC0, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x7F, 0xE7, 0x0F, 0xFF, 0x71, 0xE0, 0x3F, 0x3C, 0x01, 0xF7, 0x80,
  0x0F, 0x70, 0x00, 0x77, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x77, 0x00, 0x07,
  0x70, 0x00, 0x73, 0x80, 0x0F, 0x3C, 0x01, 0xF1, 0xE0, 0x7F, 0x0F, 0xFF,
  0x70, 0x3F, 0xC7, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x3F, 0x70, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0,
  0x0E, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3C, 0x03, 0xC3, 0x80,
  0x0F, 0x18, 0x00, 0x39, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1C, 0xE0, 0x01,
  0xC3, 0xC0, 0x3C, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x77, 0x00, 0x1E, 0xE0, 0x06, 0xCF, 0x03, 0xD8,
  0xFF, 0xE3, 0x0F, 0xF8, 0x60, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x39, 0xC0,
  0x00, 0x73, 0x80, 0x00, 0xE3, 0x00, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00,
  0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x30, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0xE0,
  0x01, 0xC1, 0xC0, 0x01, 0x87, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x18, 0x00,
  0x07, 0x70, 0x00, 0x0E, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0xEC, 0x01, 0xC0, 0x19,
  0xC0, 0x38, 0x03, 0x38, 0x07, 0x80, 0xE3, 0x01, 0xB0, 0x1C, 0x60, 0x36,
  0x03, 0x0C, 0x06, 0xC0, 0x61, 0xC0, 0xDC, 0x1C, 0x38, 0x3B, 0x83, 0x83,
  0x06, 0x30, 0x60, 0x60, 0xC6, 0x0C, 0x0E, 0x18, 0xE1, 0x81, 0xC7, 0x0C,
  0x70, 0x18, 0xC1, 0x8E, 0x03, 0x18, 0x31, 0x80, 0x63, 0x07, 0x30, 0x0E,
  0xE0, 0x66, 0x01, 0xD8, 0x0D, 0xC0, 0x1B, 0x01, 0xB0, 0x03, 0x60, 0x36,
  0x00, 0x7C, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0xE0, 0x0F, 0x00, 0x1C,
  0x01, 0xC0, 0x03, 0x80, 0x18, 0x00, 0xF0, 0x00, 0x1E, 0x70, 0x00, 0x70,
  0x70, 0x01, 0xE0, 0xF0, 0x03, 0x80, 0xF0, 0x0E, 0x00, 0xE0, 0x38, 0x00,
  0xE0, 0xF0, 0x00, 0xE1, 0xC0, 0x01, 0xE7, 0x00, 0x01, 0xDC, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3B,
  0x80, 0x00, 0xF3, 0x80, 0x01, 0xC7, 0x80, 0x07, 0x07, 0x00, 0x1C, 0x07,
  0x00, 0x78, 0x07, 0x00, 0xE0, 0x0F, 0x03, 0x80, 0x0F, 0x0E, 0x00, 0x0E,
  0x3C, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xE0, 0x00,
  0xE0, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x00,
  0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x1C,
  0x07, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE1, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0xC0, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x01,
  0xE0, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xCF, 0xFE, 0x00,
  0x33, 0x87, 0xC0, 0x0D, 0xC0, 0x78, 0x07, 0x60, 0x0F, 0x03, 0x98, 0x01,
  0xFB, 0xEE, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF0,
};

const GFXglyph RobotoMono_Light48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 4, 34, 29, 12, -34 },
  { 18, 10, 10, 29, 9, -36 },
  { 31, 27, 34, 29, 1, -34 },
  { 146, 21, 44, 29, 4, -39 },
  { 262, 27, 36, 29, 1, -35 },
  { 384, 25, 35, 29, 3, -35 },
  { 494, 3, 10, 29, 12, -36 },
  { 498, 11, 49, 29, 9, -38 },
  { 566, 11, 49, 29, 8, -38 },
  { 634, 22, 21, 29, 4, -34 },
  { 692, 23, 25, 29, 3, -28 },
  { 764, 5, 11, 29, 9, -4 },
  { 771, 17, 2, 29, 6, -16 },
  { 776, 5, 4, 29, 13, -4 },
  { 779, 16, 37, 29, 7, -34 },
  { 853, 21, 35, 29, 4, -35 },
  { 945, 12, 34, 29, 5, -34 },
  { 996, 22, 35, 29, 2, -35 },
  { 1093, 22, 35, 29, 2, -35 },
  { 1190, 24, 34, 29, 2, -34 },
  { 1292, 21, 34, 29, 5, -34 },
  { 1382, 21, 34, 29, 4, -34 },
  { 1472, 22, 34, 29, 3, -34 },
  { 1566, 22, 35, 29, 4, -35 },
  { 1663, 21, 35, 29, 4, -35 },
  { 1755, 5, 25, 29, 14, -25 },
  { 1771, 7, 32, 29, 12, -25 },
  { 1799, 20, 20, 29, 4, -25 },
  { 1849, 21, 13, 29, 4, -22 },
  { 1884, 21, 20, 29, 4, -25 },
  { 1937, 19, 35, 29, 5, -35 },
  { 2021, 26, 34, 29, 1, -34 },
  { 2132, 25, 34, 29, 2, -34 },
  { 2239, 21, 34, 29, 5, -34 },
  { 2329, 23, 35, 29, 3, -35 },
  { 2430, 22, 34, 29, 4, -34 },
  { 2524, 20, 34, 29, 5, -34 },
  { 2609, 20, 34, 29, 5, -34 },
  { 2694, 23, 35, 29, 3, -35 },
  { 2795, 21, 34, 29, 4, -34 },
  { 2885, 19, 34, 29, 5, -34 },
  { 2966, 21, 34, 29, 3, -34 },
  { 3056, 23, 34, 29, 5, -34 },
  { 3154, 20, 34, 29, 5, -34 },
  { 3239, 21, 34, 29, 4, -34 },
  { 3329, 21, 34, 29, 4, -34 },
  { 3419, 23, 35, 29, 3, -35 },
  { 3520, 22, 34, 29, 5, -34 },
  { 3614, 23, 41, 29, 3, -35 },
  { 3732, 21, 34, 29, 5, -34 },
  { 3822, 23, 35, 29, 3, -35 },
  { 3923, 25, 34, 29, 2, -34 },
  { 4030, 21, 34, 29, 4, -34 },
  { 4120, 25, 34, 29, 2, -34 },
  { 4227, 26, 34, 29, 2, -34 },
  { 4338, 24, 34, 29, 3, -34 },
  { 4440, 24, 34, 29, 2, -34 },
  { 4542, 22, 34, 29, 3, -34 },
  { 4636, 8, 46, 29, 11, -39 },
  { 4682, 17, 37, 29, 6, -34 },
  { 4761, 8, 46, 29, 10, -39 },
  { 4807, 17, 18, 29, 6, -34 },
  { 4846, 21, 2, 29, 4, 0 },
  { 4852, 7, 6, 29, 11, -35 },
  { 4858, 21, 26, 29, 4, -26 },
  { 4927, 20, 36, 29, 5, -36 },
  { 5017, 21, 26, 29, 4, -26 },
  { 5086, 20, 36, 29, 4, -36 },
  { 5176, 21, 26, 29, 4, -26 },
  { 5245, 22, 37, 29, 4, -37 },
  { 5347, 20, 36, 29, 4, -26 },
  { 5437, 20, 36, 29, 5, -36 },
  { 5527, 21, 34, 29, 5, -34 },
  { 5617, 15, 44, 29, 5, -34 },
  { 5700, 21, 36, 29, 5, -36 },
  { 5795, 21, 36, 29, 5, -36 },
  { 5890, 25, 26, 29, 2, -26 },
  { 5972, 20, 26, 29, 5, -26 },
  { 6037, 23, 26, 29, 3, -26 },
  { 6112, 20, 36, 29, 5, -26 },
  { 6202, 20, 36, 29, 4, -26 },
  { 6292, 17, 26, 29, 8, -26 },
  { 6348, 21, 26, 29, 4, -26 },
  { 6417, 20, 32, 29, 4, -32 },
  { 6497, 19, 25, 29, 5, -25 },
  { 6557, 23, 25, 29, 3, -25 },
  { 6629, 27, 25, 29, 1, -25 },
  { 6714, 23, 25, 29, 3, -25 },
  { 6786, 25, 35, 29, 2, -25 },
  { 6896, 23, 25, 29, 3, -25 },
  { 6968, 15, 46, 29, 8, -37 },
  { 7055, 3, 42, 29, 13, -34 },
  { 7071, 15, 46, 29, 8, -37 },
  { 7158, 26, 8, 29, 1, -18 },
};

const GFXfont RobotoMono_Light48pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light48pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _ROBOTOMONO_LIGHT48PT7B_H_
