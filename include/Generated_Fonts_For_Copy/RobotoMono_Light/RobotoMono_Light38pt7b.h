#ifndef _ROBOTOMONO_LIGHT38PT7B_H_
#define _ROBOTOMONO_LIGHT38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light38pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x00, 0x00, 0xDF, 0x00,
  0x43, 0x43, 0x43, 0x43, 0x43, 0xC3, 0xC3, 0xC3, 0xC3, 0x00, 0xC0, 0xC0,
  0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x00, 0x0C, 0x18, 0x00, 0xC0,
  0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x3F, 0xFF, 0xF8, 0x0C, 0x18, 0x00,
  0x40, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x00, 0x0C, 0x18,
  0x00, 0x40, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x3F, 0xFF, 0xF8, 0x0C,
  0x08, 0x00, 0x60, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80,
  0x0C, 0x08, 0x00, 0x60, 0xC0, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x7F, 0x80, 0xFF, 0xE0, 0x70, 0x38, 0x70,
  0x0E, 0x30, 0x03, 0x38, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x37, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xB0, 0x00, 0xD8, 0x00, 0xEE, 0x00, 0x63, 0x80, 0xF0, 0xFF, 0xF0,
  0x1F, 0xE0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x3E,
  0x00, 0x03, 0x18, 0x00, 0x30, 0x60, 0x01, 0x83, 0x03, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x18, 0x18, 0x30, 0xC0, 0xC1, 0x8C, 0x03, 0x18,
  0x60, 0x1F, 0xC6, 0x00, 0x38, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x38, 0x00, 0xC7, 0xE0, 0x0C, 0x61, 0x80, 0x63,
  0x06, 0x06, 0x10, 0x30, 0x31, 0x81, 0x83, 0x0C, 0x0C, 0x30, 0x20, 0x60,
  0x81, 0x83, 0x00, 0x0C, 0x30, 0x00, 0x33, 0x80, 0x00, 0xF8, 0x07, 0xE0,
  0x03, 0xFE, 0x00, 0x60, 0xE0, 0x1C, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x06, 0x01, 0x81, 0xC0, 0x38, 0x70, 0x03, 0x1C, 0x00, 0x77, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0E, 0xE0, 0x03, 0x8E, 0x06,
  0x60, 0xE0, 0xDC, 0x0C, 0x1B, 0x00, 0xC7, 0x60, 0x1C, 0xCC, 0x01, 0xD9,
  0x80, 0x1E, 0x30, 0x01, 0xC7, 0x00, 0x78, 0x70, 0x1F, 0x87, 0xFF, 0x38,
  0x7F, 0x83, 0x80, 0xFF, 0xFA, 0x80, 0x01, 0x81, 0xC1, 0xC0, 0xC0, 0xC0,
  0xC0, 0x60, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x02, 0x40, 0x70, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38,
  0x18, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x07, 0x07, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x03, 0x06, 0x0F, 0xE3,
  0x1E, 0x7F, 0xFE, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x66, 0x00,
  0x61, 0x80, 0x70, 0xE0, 0x70, 0x38, 0x30, 0x0C, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x33, 0x33, 0x33, 0x76, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xFE,
  0x0E, 0x03, 0x86, 0x00, 0xC6, 0x00, 0x73, 0x00, 0x1B, 0x80, 0x0D, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x06, 0xF0, 0x06, 0x78, 0x0E, 0x3C, 0x0E, 0x1E,
  0x0E, 0x0F, 0x0E, 0x07, 0x8E, 0x03, 0xCE, 0x01, 0xEC, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x33, 0x00, 0x19, 0x80, 0x1C, 0x60, 0x0C, 0x38,
  0x0E, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xC0, 0xF1, 0xFD, 0xF3, 0xF0,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x0F, 0xF0, 0x0F, 0xFE, 0x0E, 0x07, 0x8E, 0x00,
  0xCE, 0x00, 0x76, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xF0, 0x0F, 0xFE, 0x0E, 0x03, 0x8E, 0x00, 0xC6, 0x00,
  0x37, 0x00, 0x1B, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x0C, 0xE0, 0x0E, 0x38, 0x0E, 0x0F, 0xFE, 0x03, 0xFE, 0x00,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x06, 0xE0,
  0x01, 0xDC, 0x00, 0x33, 0x80, 0x0C, 0x70, 0x03, 0x8E, 0x00, 0x61, 0xC0,
  0x18, 0x38, 0x07, 0x07, 0x00, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x81,
  0x80, 0x70, 0x60, 0x0E, 0x1C, 0x01, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x6F, 0xF0, 0x7F, 0xF8, 0x70, 0x3C, 0x20, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0x70, 0x0E, 0x38, 0x3C, 0x1F, 0xFC, 0x0F, 0xF0, 0x00,
  0xF8, 0x01, 0xFC, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0xF0, 0x33, 0xFE, 0x1B, 0x87,
  0x8F, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x37, 0x00, 0x19, 0x80, 0x1C,
  0xE0, 0x0C, 0x38, 0x0E, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x07, 0xF8,
  0x0F, 0xFE, 0x0E, 0x03, 0x86, 0x00, 0xE7, 0x00, 0x33, 0x80, 0x1D, 0x80,
  0x06, 0xC0, 0x03, 0x60, 0x03, 0xB8, 0x01, 0x8E, 0x01, 0xC3, 0x81, 0xC0,
  0xFF, 0xC0, 0x3F, 0xC0, 0x70, 0x78, 0x70, 0x0E, 0x70, 0x03, 0xB0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0D, 0x80, 0x06, 0xE0,
  0x07, 0x38, 0x07, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xFC,
  0x0E, 0x07, 0x0E, 0x01, 0xC6, 0x00, 0x67, 0x00, 0x1B, 0x00, 0x0D, 0x80,
  0x06, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3B,
  0x00, 0x3D, 0xC0, 0x3E, 0x70, 0x3E, 0x1F, 0xFB, 0x03, 0xF1, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x70, 0x00,
  0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x7B, 0xDC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x73, 0x9C, 0xE6, 0x33, 0x98, 0x00, 0x01, 0x00, 0x0F, 0x00,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0x80, 0x01, 0x00, 0x00, 0x0F,
  0xF0, 0x7F, 0xF1, 0xC0, 0x73, 0x00, 0x6E, 0x00, 0xFC, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xC0, 0x70, 0x18, 0x00,
  0xC1, 0x80, 0x06, 0x18, 0x08, 0x18, 0xC1, 0xF0, 0xCC, 0x18, 0xC2, 0x61,
  0x86, 0x12, 0x18, 0x30, 0xD0, 0xC1, 0x87, 0x86, 0x0C, 0x3C, 0x20, 0x61,
  0xE3, 0x02, 0x0F, 0x18, 0x10, 0x58, 0xC0, 0x82, 0xC6, 0x0C, 0x16, 0x30,
  0x61, 0xB0, 0xC7, 0x08, 0x87, 0x6C, 0xC6, 0x1E, 0x3C, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x02, 0x00, 0x7E, 0xF8, 0x00, 0xFF,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1B,
  0x00, 0x03, 0x60, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x61,
  0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0x60, 0x18, 0x0C, 0x03, 0x01,
  0x80, 0x60, 0x18, 0x18, 0x03, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x1C, 0x00,
  0xC3, 0x00, 0x18, 0x60, 0x03, 0x9C, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00,
  0xFC, 0x00, 0x0F, 0x00, 0x01, 0x80, 0xFF, 0xC0, 0x7F, 0xFC, 0x30, 0x0F,
  0x18, 0x01, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x1D, 0x80, 0x0E, 0xC0,
  0x06, 0x60, 0x03, 0x30, 0x03, 0x18, 0x07, 0x8F, 0xFF, 0x07, 0xFF, 0xC3,
  0x00, 0x71, 0x80, 0x0C, 0xC0, 0x07, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00,
  0x7C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x1D, 0x80, 0x1C, 0xC0, 0x1E, 0x7F,
  0xFC, 0x3F, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x81, 0xC0, 0x70, 0xE0,
  0x0E, 0x30, 0x01, 0x9C, 0x00, 0x76, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x03, 0x60, 0x00, 0xDC, 0x00, 0x73, 0x00, 0x18, 0xE0, 0x0E, 0x1C, 0x07,
  0x03, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xC0, 0x3F, 0xFC, 0x0E, 0x03, 0xC3,
  0x80, 0x38, 0xE0, 0x07, 0x38, 0x00, 0xCE, 0x00, 0x3B, 0x80, 0x06, 0xE0,
  0x01, 0xB8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1B,
  0x80, 0x06, 0xE0, 0x03, 0xB8, 0x00, 0xCE, 0x00, 0x73, 0x80, 0x38, 0xE0,
  0x3C, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xFF, 0xFC, 0xFF, 0xFC, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x81, 0xC0,
  0x70, 0xE0, 0x0E, 0x30, 0x01, 0x9C, 0x00, 0x76, 0x00, 0x0D, 0x80, 0x03,
  0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x36, 0x00,
  0x0D, 0x80, 0x03, 0x60, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0x60, 0x03,
  0x1E, 0x03, 0xC3, 0xFF, 0xC0, 0x3F, 0xE0, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1D, 0x80, 0x0C, 0xE0, 0x0E, 0x38,
  0x0E, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0xC0, 0x03, 0xB0, 0x01, 0xCC, 0x00,
  0xE3, 0x00, 0x70, 0xC0, 0x18, 0x30, 0x0C, 0x0C, 0x07, 0x03, 0x03, 0x80,
  0xC1, 0xC0, 0x30, 0xE0, 0x0C, 0x70, 0x03, 0x38, 0x00, 0xCE, 0x00, 0x37,
  0xC0, 0x0F, 0xB8, 0x03, 0xC7, 0x00, 0xE0, 0xC0, 0x30, 0x38, 0x0C, 0x07,
  0x03, 0x00, 0xC0, 0xC0, 0x38, 0x30, 0x07, 0x0C, 0x00, 0xE3, 0x00, 0x18,
  0xC0, 0x07, 0x30, 0x00, 0xEC, 0x00, 0x1C, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFE,
  0xC0, 0x6F, 0x60, 0x37, 0x98, 0x33, 0xCC, 0x19, 0xE6, 0x0C, 0xF1, 0x8C,
  0x78, 0xC6, 0x3C, 0x67, 0x1E, 0x1B, 0x0F, 0x0D, 0x87, 0x87, 0x83, 0xC1,
  0xC1, 0xE0, 0xE0, 0xF0, 0x20, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x60, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1E, 0xC0, 0x0F,
  0x70, 0x07, 0x98, 0x03, 0xC6, 0x01, 0xE3, 0x00, 0xF0, 0xC0, 0x78, 0x70,
  0x3C, 0x18, 0x1E, 0x0E, 0x0F, 0x03, 0x07, 0x81, 0xC3, 0xC0, 0x61, 0xE0,
  0x38, 0xF0, 0x0C, 0x78, 0x03, 0x3C, 0x01, 0x9E, 0x00, 0x6F, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xE0, 0x03, 0xF8, 0x03,
  0xFF, 0x81, 0xC0, 0xF0, 0x60, 0x0C, 0x30, 0x03, 0x9C, 0x00, 0x66, 0x00,
  0x1D, 0x80, 0x03, 0x60, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x01, 0xCC, 0x00, 0x63, 0x00,
  0x38, 0x60, 0x0C, 0x1C, 0x0F, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0xFF, 0xF0,
  0x7F, 0xFE, 0x30, 0x07, 0x98, 0x00, 0xEC, 0x00, 0x36, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x6C,
  0x00, 0x76, 0x00, 0xF3, 0xFF, 0xF1, 0xFF, 0xC0, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x70, 0x1C, 0x1C, 0x01, 0xC3, 0x00, 0x18, 0xE0, 0x03, 0x98, 0x00,
  0x33, 0x00, 0x06, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x03, 0xB0, 0x00, 0x66, 0x00, 0x0C, 0xE0, 0x03,
  0x8C, 0x00, 0x61, 0xC0, 0x1C, 0x1C, 0x07, 0x01, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x02,
  0xFF, 0xE0, 0x7F, 0xFC, 0x30, 0x0F, 0x18, 0x01, 0xCC, 0x00, 0x66, 0x00,
  0x3B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x01, 0xD8,
  0x00, 0xCC, 0x00, 0xE6, 0x03, 0xE3, 0xFF, 0xC1, 0xFF, 0xC0, 0xC0, 0x60,
  0x60, 0x18, 0x30, 0x0E, 0x18, 0x03, 0x0C, 0x01, 0xC6, 0x00, 0x63, 0x00,
  0x39, 0x80, 0x0C, 0xC0, 0x07, 0x60, 0x01, 0xB0, 0x00, 0xE0, 0x07, 0xF8,
  0x07, 0xFF, 0x83, 0x80, 0xF1, 0xC0, 0x0C, 0x60, 0x03, 0xB8, 0x00, 0x6E,
  0x00, 0x1B, 0x80, 0x01, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1B, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x19, 0xC0, 0x0E, 0x38, 0x07, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3F, 0x00, 0x19, 0x80, 0x0C, 0xE0, 0x0C, 0x38, 0x0E, 0x0F, 0xFE, 0x01,
  0xFC, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x03, 0x30, 0x00, 0x66,
  0x00, 0x1C, 0xE0, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x1C, 0x38, 0x03, 0x03,
  0x00, 0x60, 0x60, 0x1C, 0x0E, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x1C, 0x03,
  0x83, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x01,
  0x8C, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x60, 0x3C, 0x0E, 0x03,
  0xC0, 0xE0, 0x7C, 0x0E, 0x06, 0xC0, 0xF0, 0x6C, 0x0F, 0x06, 0xE0, 0xB0,
  0x66, 0x1B, 0x06, 0x61, 0xB0, 0x66, 0x19, 0x8E, 0x61, 0x98, 0xC6, 0x11,
  0x8C, 0x63, 0x18, 0xC7, 0x31, 0x8C, 0x33, 0x08, 0xC3, 0x30, 0xCC, 0x33,
  0x0C, 0xC3, 0x60, 0xD8, 0x36, 0x0D, 0x83, 0x60, 0xD8, 0x36, 0x07, 0x81,
  0xE0, 0x78, 0x1C, 0x07, 0x81, 0xC0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x30,
  0x1C, 0x03, 0x00, 0xE0, 0x00, 0xEE, 0x00, 0x18, 0xC0, 0x07, 0x1C, 0x01,
  0xC1, 0xC0, 0x30, 0x18, 0x0E, 0x03, 0x81, 0x80, 0x30, 0x70, 0x07, 0x1C,
  0x00, 0x73, 0x00, 0x06, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x0D, 0x80, 0x03, 0x98, 0x00, 0x63, 0x80, 0x1C, 0x30,
  0x03, 0x07, 0x00, 0xC0, 0x60, 0x38, 0x06, 0x06, 0x00, 0xE1, 0xC0, 0x0C,
  0x30, 0x01, 0xCE, 0x00, 0x1B, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x77, 0x00,
  0x06, 0x30, 0x00, 0xE3, 0x80, 0x0C, 0x18, 0x01, 0xC1, 0xC0, 0x18, 0x0C,
  0x03, 0x80, 0xE0, 0x30, 0x06, 0x07, 0x00, 0x70, 0x60, 0x03, 0x0C, 0x00,
  0x38, 0xC0, 0x01, 0x98, 0x00, 0x1D, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0xFF, 0xE0, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xFC, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x1B,
  0x00, 0xD8, 0x0C, 0xE0, 0x63, 0x07, 0x18, 0x30, 0x61, 0x83, 0x18, 0x1C,
  0xC0, 0x6E, 0x03, 0x60, 0x0F, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE1, 0xC3, 0x86, 0x0C, 0x0F, 0xF8, 0x0F, 0xBE, 0x0E, 0x03, 0x8E, 0x00,
  0xE6, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0xFF, 0x0F,
  0xFF, 0x8F, 0x00, 0xCE, 0x00, 0x66, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D,
  0xC0, 0x0E, 0xE0, 0x0F, 0x38, 0x0F, 0x8F, 0xFE, 0xC3, 0xFC, 0x70, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xCF, 0xF0, 0xDF, 0xF8, 0xF0, 0x1C, 0xE0,
  0x0C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xC0,
  0x0E, 0xE0, 0x0C, 0xF0, 0x1C, 0xDF, 0xF8, 0xCF, 0xF0, 0x07, 0xF8, 0x0F,
  0xBE, 0x0E, 0x03, 0x86, 0x00, 0xE6, 0x00, 0x33, 0x00, 0x1B, 0x80, 0x0F,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x0E, 0xC0, 0x06, 0x30, 0x07, 0x1C, 0x07, 0x07,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x0F, 0xF3,
  0x1F, 0xFB, 0x38, 0x0F, 0x70, 0x07, 0x60, 0x07, 0x60, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x70, 0x07, 0x38, 0x0F, 0x1F, 0xFB,
  0x0F, 0xF3, 0x07, 0xF8, 0x0F, 0xBE, 0x0E, 0x03, 0x86, 0x00, 0xE6, 0x00,
  0x33, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x03, 0x9E, 0x03, 0x83, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x3F, 0xF0, 0x1E, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0xF3, 0x1F, 0xFB, 0x38, 0x0F, 0x70, 0x07, 0x60,
  0x07, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x70,
  0x07, 0x38, 0x0F, 0x1F, 0xFB, 0x0F, 0xF3, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x20, 0x06, 0x70, 0x0E, 0x38, 0x1C, 0x1F, 0xF8, 0x07, 0xE0, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC7, 0xF8, 0xCF, 0xFC, 0xD8, 0x1C, 0xF0,
  0x0E, 0xE0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x3F, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x0E, 0x03,
  0x9F, 0xE3, 0xF8, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x60,
  0x07, 0x30, 0x07, 0x18, 0x07, 0x0C, 0x07, 0x06, 0x07, 0x03, 0x07, 0x01,
  0x87, 0x00, 0xC7, 0x00, 0x67, 0x00, 0x37, 0xC0, 0x1E, 0x70, 0x0E, 0x38,
  0x06, 0x0E, 0x03, 0x03, 0x81, 0x80, 0xE0, 0xC0, 0x38, 0x60, 0x0E, 0x30,
  0x03, 0x18, 0x01, 0xCC, 0x00, 0x78, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x8F, 0xDF, 0xFB, 0xFB, 0x83, 0x83, 0xE0,
  0x70, 0x3C, 0x0C, 0x07, 0x81, 0x80, 0xF0, 0x30, 0x1E, 0x06, 0x03, 0xC0,
  0xC0, 0x78, 0x18, 0x0F, 0x03, 0x01, 0xE0, 0x60, 0x3C, 0x0C, 0x07, 0x81,
  0x80, 0xF0, 0x30, 0x1E, 0x06, 0x03, 0xC0, 0xC0, 0x78, 0x18, 0x0F, 0x03,
  0x01, 0xE0, 0x60, 0x30, 0xC7, 0xF1, 0x9F, 0xFB, 0x60, 0x77, 0x00, 0x7E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x30, 0x07, 0xF8, 0x03, 0xEF, 0x81, 0xC0,
  0x70, 0xE0, 0x0E, 0x30, 0x01, 0x9C, 0x00, 0x76, 0x00, 0x0D, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0x60, 0x00, 0xD8,
  0x00, 0x37, 0x00, 0x1C, 0xC0, 0x06, 0x38, 0x03, 0x87, 0x01, 0xC0, 0xFF,
  0xE0, 0x0F, 0xE0, 0xCF, 0xF0, 0xDF, 0xF8, 0xF0, 0x1C, 0xE0, 0x0C, 0xC0,
  0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xE0,
  0x0C, 0xF0, 0x1C, 0xDF, 0xF8, 0xCF, 0xE0, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x0F,
  0xF3, 0x1F, 0x7B, 0x38, 0x0F, 0x70, 0x07, 0x60, 0x03, 0x60, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x70, 0x07, 0x38, 0x0F, 0x1F,
  0xFB, 0x0F, 0xF3, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xC7, 0xFE, 0x7F, 0xF7, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x1F, 0xF0, 0x3E, 0xFC, 0x70, 0x0E, 0xE0, 0x06,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x06, 0x70, 0x0E, 0x3F, 0xFC, 0x1F, 0xF0, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x7C, 0xFF, 0xD8, 0xFE, 0x30,
  0xE0, 0x00, 0xEC, 0x00, 0x19, 0x80, 0x07, 0x38, 0x00, 0xC3, 0x00, 0x18,
  0x70, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x38, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x38, 0x30, 0x03, 0x06, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0xCE, 0x00,
  0x0D, 0x80, 0x01, 0xB0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0xC0, 0x20, 0x1B, 0x03, 0x80, 0xD8, 0x1C, 0x0C, 0xC0, 0xA0, 0x66, 0x05,
  0x03, 0x30, 0x6C, 0x18, 0xC3, 0x60, 0x86, 0x1B, 0x0C, 0x30, 0x88, 0x61,
  0x8C, 0x63, 0x0C, 0x63, 0x18, 0x33, 0x19, 0x81, 0x90, 0x4C, 0x0D, 0x83,
  0x60, 0x6C, 0x1B, 0x01, 0x60, 0xD0, 0x0E, 0x02, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0xE0, 0x1C, 0x07, 0x00, 0x70, 0x01, 0xE7, 0x00, 0x30, 0x60, 0x0E,
  0x0E, 0x03, 0x80, 0xE0, 0xE0, 0x0E, 0x18, 0x00, 0xC6, 0x00, 0x0D, 0xC0,
  0x01, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x3B, 0x80,
  0x0E, 0x38, 0x01, 0x83, 0x80, 0x70, 0x30, 0x1C, 0x07, 0x07, 0x00, 0x70,
  0xC0, 0x07, 0x70, 0x00, 0x70, 0xE0, 0x00, 0x37, 0x00, 0x07, 0x30, 0x00,
  0x63, 0x80, 0x0E, 0x18, 0x00, 0xC1, 0x80, 0x1C, 0x1C, 0x01, 0x80, 0xC0,
  0x18, 0x0E, 0x03, 0x80, 0x60, 0x30, 0x07, 0x07, 0x00, 0x30, 0x60, 0x03,
  0x8E, 0x00, 0x18, 0xC0, 0x01, 0xCC, 0x00, 0x0D, 0x80, 0x00, 0xD8, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x3F, 0x00,
  0x03, 0xC0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x10,
  0x07, 0x00, 0xE0, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x01,
  0xC0, 0xF0, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x00, 0xF0, 0x0F, 0x01, 0xC0, 0x30,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0xE0, 0x00, 0x04,
  0x00, 0x01, 0xFC, 0x00, 0xDE, 0xF0, 0x06, 0xC1, 0xE0, 0x6C, 0x03, 0x87,
  0x60, 0x0F, 0xF0, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoMono_Light38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 3, 27, 23, 10, -27 },
  { 12, 8, 9, 23, 7, -29 },
  { 21, 21, 27, 23, 1, -27 },
  { 92, 17, 35, 23, 3, -31 },
  { 167, 21, 27, 23, 1, -27 },
  { 238, 19, 27, 23, 3, -27 },
  { 303, 2, 9, 23, 10, -29 },
  { 306, 9, 39, 23, 7, -30 },
  { 350, 9, 39, 23, 6, -30 },
  { 394, 17, 16, 23, 3, -27 },
  { 428, 19, 19, 23, 2, -22 },
  { 474, 4, 9, 23, 7, -4 },
  { 479, 14, 2, 23, 4, -13 },
  { 483, 4, 3, 23, 10, -3 },
  { 485, 14, 29, 23, 5, -27 },
  { 536, 17, 27, 23, 3, -27 },
  { 594, 10, 27, 23, 4, -27 },
  { 628, 17, 27, 23, 2, -27 },
  { 686, 17, 27, 23, 2, -27 },
  { 744, 19, 27, 23, 2, -27 },
  { 809, 16, 27, 23, 4, -27 },
  { 863, 17, 27, 23, 3, -27 },
  { 921, 18, 27, 23, 2, -27 },
  { 982, 17, 27, 23, 3, -27 },
  { 1040, 17, 27, 23, 3, -27 },
  { 1098, 4, 19, 23, 11, -19 },
  { 1108, 5, 24, 23, 10, -19 },
  { 1123, 16, 16, 23, 3, -20 },
  { 1155, 17, 10, 23, 3, -17 },
  { 1177, 17, 16, 23, 3, -20 },
  { 1211, 15, 27, 23, 4, -27 },
  { 1262, 21, 27, 23, 1, -27 },
  { 1333, 19, 27, 23, 2, -27 },
  { 1398, 17, 27, 23, 4, -27 },
  { 1456, 18, 27, 23, 2, -27 },
  { 1517, 18, 27, 23, 3, -27 },
  { 1578, 16, 27, 23, 4, -27 },
  { 1632, 16, 27, 23, 4, -27 },
  { 1686, 18, 27, 23, 2, -27 },
  { 1747, 17, 27, 23, 3, -27 },
  { 1805, 15, 27, 23, 4, -27 },
  { 1856, 17, 27, 23, 2, -27 },
  { 1914, 18, 27, 23, 4, -27 },
  { 1975, 16, 27, 23, 4, -27 },
  { 2029, 17, 27, 23, 3, -27 },
  { 2087, 17, 27, 23, 3, -27 },
  { 2145, 18, 27, 23, 2, -27 },
  { 2206, 17, 27, 23, 4, -27 },
  { 2264, 19, 32, 23, 2, -27 },
  { 2340, 17, 27, 23, 4, -27 },
  { 2398, 18, 27, 23, 3, -27 },
  { 2459, 19, 27, 23, 2, -27 },
  { 2524, 17, 27, 23, 3, -27 },
  { 2582, 19, 27, 23, 2, -27 },
  { 2647, 20, 27, 23, 2, -27 },
  { 2715, 19, 27, 23, 2, -27 },
  { 2780, 20, 27, 23, 1, -27 },
  { 2848, 18, 27, 23, 2, -27 },
  { 2909, 7, 37, 23, 8, -31 },
  { 2942, 13, 29, 23, 5, -27 },
  { 2990, 6, 37, 23, 8, -31 },
  { 3018, 13, 15, 23, 5, -27 },
  { 3043, 17, 2, 23, 3, 0 },
  { 3048, 6, 5, 23, 8, -28 },
  { 3052, 17, 20, 23, 3, -20 },
  { 3095, 16, 29, 23, 4, -29 },
  { 3153, 17, 20, 23, 3, -20 },
  { 3196, 16, 29, 23, 3, -29 },
  { 3254, 17, 20, 23, 3, -20 },
  { 3297, 18, 29, 23, 3, -29 },
  { 3363, 16, 28, 23, 3, -20 },
  { 3419, 16, 29, 23, 4, -29 },
  { 3477, 16, 27, 23, 4, -27 },
  { 3531, 11, 35, 23, 4, -27 },
  { 3580, 17, 29, 23, 4, -29 },
  { 3642, 16, 29, 23, 4, -29 },
  { 3700, 19, 20, 23, 2, -20 },
  { 3748, 15, 20, 23, 4, -20 },
  { 3786, 18, 20, 23, 2, -20 },
  { 3831, 16, 28, 23, 4, -20 },
  { 3887, 16, 28, 23, 3, -20 },
  { 3943, 13, 20, 23, 7, -20 },
  { 3976, 16, 20, 23, 4, -20 },
  { 4016, 16, 25, 23, 3, -25 },
  { 4066, 15, 20, 23, 4, -20 },
  { 4104, 19, 20, 23, 2, -20 },
  { 4152, 21, 20, 23, 1, -20 },
  { 4205, 19, 20, 23, 2, -20 },
  { 4253, 20, 28, 23, 1, -20 },
  { 4323, 17, 20, 23, 3, -20 },
  { 4366, 12, 37, 23, 6, -30 },
  { 4422, 2, 33, 23, 10, -27 },
  { 4431, 12, 37, 23, 6, -30 },
  { 4487, 21, 7, 23, 1, -15 },
};

const GFXfont RobotoMono_Light38pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light38pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOMONO_LIGHT38PT7B_H_
