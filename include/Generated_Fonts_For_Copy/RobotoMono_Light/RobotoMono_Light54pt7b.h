#ifndef _ROBOTOMONO_LIGHT54PT7B_H_
#define _ROBOTOMONO_LIGHT54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light54pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xE0, 0x00, 0x00, 0x00, 0xEF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x30,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x1C, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x38,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xE0, 0x1C,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38,
  0x07, 0x00, 0x01, 0x80, 0x30, 0x07, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38,
  0x07, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x1C,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0x81, 0xF0, 0x1E, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1F, 0xC7, 0xF8, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x03, 0x80, 0x60, 0x08, 0x0E, 0x01, 0x80, 0x70, 0x38, 0x07,
  0x01, 0x80, 0xE0, 0x1C, 0x0E, 0x03, 0x80, 0x70, 0x30, 0x0E, 0x01, 0xC1,
  0xC0, 0x38, 0x06, 0x0E, 0x00, 0x60, 0x38, 0x38, 0x01, 0xC0, 0xE1, 0xC0,
  0x07, 0x87, 0x07, 0x00, 0x0F, 0xF8, 0x38, 0x00, 0x1F, 0xC0, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03,
  0x83, 0xF8, 0x00, 0x1C, 0x1E, 0xF0, 0x00, 0x70, 0xE0, 0xE0, 0x03, 0x87,
  0x01, 0xC0, 0x0C, 0x1C, 0x07, 0x00, 0x70, 0x60, 0x1C, 0x01, 0x81, 0x80,
  0x30, 0x0E, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x03, 0x01, 0xC0, 0x60, 0x0C,
  0x0E, 0x01, 0xC0, 0x70, 0x08, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x80,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x07, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x1E, 0x0E,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x3C, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x73, 0xC0, 0xF0, 0x0E, 0x70,
  0x0F, 0x01, 0xDE, 0x00, 0xF0, 0x3B, 0x80, 0x0E, 0x0E, 0x70, 0x01, 0xE1,
  0xCE, 0x00, 0x1E, 0x39, 0xC0, 0x01, 0xEF, 0x38, 0x00, 0x1F, 0xC7, 0x00,
  0x01, 0xF8, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC1, 0xE0, 0x01, 0xFC,
  0x3E, 0x00, 0x7B, 0x83, 0xF0, 0x7E, 0x78, 0x1F, 0xFF, 0x87, 0x81, 0xFF,
  0xC0, 0x78, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xB6, 0xDB, 0x60, 0x00, 0x10,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x40, 0x40, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x60, 0x18, 0x06, 0xFC, 0x18,
  0x3F, 0xFF, 0x98, 0xFF, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xC3,
  0x80, 0x03, 0x83, 0xC0, 0x07, 0x81, 0xE0, 0x0F, 0x00, 0xF0, 0x1E, 0x00,
  0x70, 0x0E, 0x00, 0x78, 0x04, 0x00, 0x20, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCE, 0x39, 0xE7, 0x38, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x79, 0xEF, 0xFF, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F,
  0x80, 0xF8, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x38,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x77, 0xE0,
  0x01, 0xE7, 0xE0, 0x03, 0xC7, 0xE0, 0x07, 0x87, 0xE0, 0x0F, 0x07, 0xE0,
  0x1E, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x70, 0x07, 0xE0, 0xE0, 0x07, 0xE1,
  0xC0, 0x07, 0xE7, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0x78, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x78,
  0x00, 0x0E, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x0F,
  0x00, 0x78, 0x0F, 0xC1, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x01, 0xF0, 0x3F, 0xC3, 0xFF, 0x7F, 0x3F, 0xF0,
  0xFF, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x07,
  0x83, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x1C, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x07, 0x9C, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0x01, 0xF0, 0x3C,
  0x00, 0x78, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0xF0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xF0,
  0x00, 0x0E, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x1F,
  0x83, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x1C, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x38,
  0x0E, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x07, 0x00,
  0x1E, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x0E,
  0x00, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x0F, 0x00,
  0x1C, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xF8, 0x07, 0xE1,
  0xC0, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xB8, 0x00,
  0x0F, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x78, 0xF8, 0x01, 0xF0, 0xFC, 0x0F,
  0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x7F, 0x80, 0x71, 0xFF,
  0xE0, 0xE7, 0xFF, 0xF0, 0xEF, 0x00, 0xF8, 0xFC, 0x00, 0x3C, 0xF8, 0x00,
  0x3C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x1F, 0x00,
  0x78, 0x0F, 0xC1, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x1C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x1F, 0x01, 0xF8, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x78,
  0x00, 0x1C, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x38,
  0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x0F, 0x81, 0xF0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0x00, 0xF8, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0x78,
  0x00, 0x1C, 0x3E, 0x00, 0x7C, 0x1F, 0x83, 0xF8, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x0F, 0x81, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x38,
  0x00, 0x1C, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0,
  0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0x78, 0x00, 0x1F, 0x38, 0x00, 0x1F, 0x3C, 0x00, 0x77, 0x1E,
  0x00, 0xF7, 0x0F, 0xC7, 0xE7, 0x07, 0xFF, 0xCE, 0x01, 0xFF, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0xE0, 0x1C, 0x7C, 0xF9, 0xF3,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x87, 0x0E, 0x1C,
  0x70, 0xE3, 0x82, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xF0, 0x7C, 0x07, 0xC7, 0x80, 0x0F, 0x38, 0x00, 0x3B,
  0xC0, 0x01, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x0E, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x06, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0xC0,
  0x30, 0x70, 0x1F, 0xC0, 0xE1, 0x80, 0xFF, 0xC1, 0x8E, 0x07, 0x07, 0x06,
  0x30, 0x38, 0x1C, 0x18, 0xC0, 0xC0, 0x70, 0x73, 0x07, 0x01, 0x81, 0xDC,
  0x1C, 0x06, 0x07, 0x60, 0x60, 0x18, 0x0D, 0x81, 0x80, 0x60, 0x36, 0x0E,
  0x01, 0x80, 0xD8, 0x38, 0x06, 0x03, 0x60, 0xC0, 0x18, 0x1D, 0x83, 0x00,
  0x60, 0x66, 0x0C, 0x01, 0x81, 0x98, 0x30, 0x0E, 0x06, 0x60, 0xC0, 0x38,
  0x19, 0x83, 0x81, 0xE0, 0xE6, 0x0E, 0x07, 0x83, 0x18, 0x18, 0x36, 0x1C,
  0x70, 0x7B, 0x9C, 0xE0, 0xC0, 0xFE, 0x3F, 0x03, 0x01, 0xE0, 0x78, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x01, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x0E, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E,
  0x0E, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80,
  0x01, 0xC0, 0x70, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x70, 0x00, 0x70, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xE0, 0x1F, 0xF0,
  0xE0, 0x00, 0xF8, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0xF0, 0xE0, 0x07, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x01, 0xF0, 0x0F, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1E, 0x38,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x38, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC0,
  0xF0, 0x00, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x38, 0x0F, 0xF0, 0x1C, 0x00, 0x7C, 0x0E, 0x00, 0x0F, 0x07, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0x70,
  0x00, 0x07, 0x38, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0E, 0xE0, 0x00,
  0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x78, 0x70, 0x00, 0xF8, 0x38, 0x01, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x8E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xC1, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0x9E, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07,
  0x70, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xF0, 0x00,
  0x07, 0x1C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x1E,
  0x00, 0x3E, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x10, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x3C,
  0x1E, 0x00, 0xF8, 0x0F, 0xC3, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x10, 0x00, 0xE0, 0x00, 0x0F, 0xB8, 0x00, 0x03, 0xCE, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x0E, 0x00,
  0x1E, 0x03, 0x80, 0x0F, 0x00, 0xE0, 0x07, 0xC0, 0x38, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x03, 0x80, 0x78, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x1E, 0x00,
  0x0E, 0x0F, 0x00, 0x03, 0x87, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0xF8,
  0x00, 0x0E, 0x7F, 0x00, 0x03, 0xBD, 0xE0, 0x00, 0xFE, 0x78, 0x00, 0x3F,
  0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x01,
  0xE0, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0xE0,
  0x00, 0x3C, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3C,
  0xE0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0x70, 0x01, 0xDF, 0xB8, 0x00, 0xEF, 0xDC, 0x00, 0xE7, 0xE7, 0x00,
  0x73, 0xF3, 0x80, 0x39, 0xF9, 0xC0, 0x38, 0xFC, 0x70, 0x1C, 0x7E, 0x38,
  0x0E, 0x3F, 0x1C, 0x0E, 0x1F, 0x87, 0x07, 0x0F, 0xC3, 0x87, 0x07, 0xE0,
  0xE3, 0x83, 0xF0, 0x71, 0xC1, 0xF8, 0x39, 0xC0, 0xFC, 0x0E, 0xE0, 0x7E,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x80, 0xF8, 0x1F, 0xC0, 0x78, 0x0F,
  0xE0, 0x3C, 0x07, 0xF0, 0x0E, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xEE, 0x00, 0x07, 0xEF, 0x00, 0x07, 0xE7, 0x00, 0x07, 0xE7,
  0x80, 0x07, 0xE3, 0x80, 0x07, 0xE1, 0xC0, 0x07, 0xE1, 0xC0, 0x07, 0xE0,
  0xE0, 0x07, 0xE0, 0xF0, 0x07, 0xE0, 0x70, 0x07, 0xE0, 0x78, 0x07, 0xE0,
  0x38, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1E, 0x07, 0xE0,
  0x0E, 0x07, 0xE0, 0x07, 0x07, 0xE0, 0x07, 0x07, 0xE0, 0x03, 0x87, 0xE0,
  0x03, 0xC7, 0xE0, 0x01, 0xC7, 0xE0, 0x01, 0xE7, 0xE0, 0x00, 0xE7, 0xE0,
  0x00, 0xF7, 0xE0, 0x00, 0x77, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x1C, 0x1C, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0x80, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0xE1, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x18, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xE0, 0x03, 0xF0, 0xE0, 0x00, 0xF8,
  0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0xF0, 0x03, 0xE0, 0x3C,
  0x00, 0x1C, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x07, 0x78, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x03, 0x80, 0x01,
  0xE0, 0x78, 0x00, 0x78, 0x07, 0xC0, 0x1E, 0x00, 0x7E, 0x1F, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x31, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x38, 0x01, 0xFC, 0x1C, 0x00, 0x1F, 0x0E, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00,
  0x07, 0x38, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0x70,
  0x00, 0x3C, 0x38, 0x00, 0x7C, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0xC0,
  0x70, 0x00, 0xE0, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0F,
  0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x3C, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x01, 0xF0, 0x1F, 0x81, 0xE0, 0x03, 0xE1, 0xE0, 0x00, 0xF1,
  0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xC3, 0xE0, 0x07, 0xC0, 0xFE, 0x1F,
  0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x3C,
  0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x1F, 0x00, 0x78, 0x0F, 0xC3, 0xF0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1E, 0x38, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x38,
  0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x70, 0x0F, 0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03,
  0xC0, 0x1C, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x07, 0x00,
  0x3F, 0x00, 0x38, 0x01, 0xDC, 0x01, 0xE0, 0x0E, 0xE0, 0x0F, 0x00, 0x77,
  0x00, 0xF8, 0x07, 0x38, 0x07, 0xC0, 0x39, 0xC0, 0x3E, 0x01, 0xCE, 0x01,
  0xB8, 0x0E, 0x70, 0x0D, 0xC0, 0x71, 0xC0, 0xEE, 0x03, 0x8E, 0x07, 0x70,
  0x1C, 0x70, 0x39, 0x80, 0xC3, 0x81, 0xCC, 0x0E, 0x1C, 0x0C, 0x70, 0x70,
  0xE0, 0xE3, 0x83, 0x87, 0x07, 0x1C, 0x1C, 0x1C, 0x38, 0x60, 0xE0, 0xE1,
  0xC3, 0x07, 0x07, 0x0C, 0x1C, 0x30, 0x38, 0x60, 0xE3, 0x81, 0xC7, 0x07,
  0x1C, 0x0E, 0x38, 0x38, 0xE0, 0x71, 0xC0, 0xC7, 0x01, 0x8C, 0x07, 0x38,
  0x0E, 0x60, 0x39, 0xC0, 0x77, 0x01, 0xCC, 0x03, 0xB8, 0x0E, 0xE0, 0x1D,
  0xC0, 0x37, 0x00, 0xEE, 0x01, 0xB8, 0x07, 0x60, 0x0F, 0xC0, 0x1B, 0x00,
  0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1C, 0x03,
  0xC0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0x78, 0x0F,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xE0,
  0x3C, 0x00, 0x38, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x03, 0xC0, 0x07, 0x80,
  0x70, 0x00, 0x70, 0x1E, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x0E, 0x3C, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x3C, 0x3C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xF0, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF, 0xF0,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1D, 0xC0, 0x03, 0x9C, 0x00, 0x38, 0xE0, 0x07, 0x0E, 0x00, 0x70,
  0xE0, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x03, 0x81, 0xC0, 0x38, 0x1C,
  0x03, 0xC1, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x70, 0x00, 0xEF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0,
  0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1C,
  0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x17, 0xFE, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0x80, 0x0E, 0x3C, 0x00, 0x0E, 0x78, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0E,
  0x70, 0x00, 0x1E, 0x70, 0x00, 0x3E, 0x78, 0x00, 0x7E, 0x3C, 0x00, 0xEE,
  0x3F, 0x8F, 0xCF, 0x1F, 0xFF, 0x8F, 0x07, 0xFE, 0x07, 0x00, 0x40, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x0F,
  0xF0, 0x1C, 0x7F, 0xF8, 0x39, 0xFF, 0xF8, 0x77, 0x80, 0xF8, 0xFC, 0x00,
  0xF9, 0xF0, 0x00, 0xF3, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0xEE, 0x00, 0x01,
  0xDC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3B, 0xC0, 0x00, 0xF7, 0xC0, 0x01, 0xCF, 0xC0, 0x07, 0x9F, 0xC0,
  0x1E, 0x3B, 0xF1, 0xF8, 0x71, 0xFF, 0xE0, 0xE1, 0xFF, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0x80,
  0x78, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x78, 0x00,
  0x0E, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x78, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x3C, 0x00,
  0x0E, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x3C, 0x07, 0xC1, 0xF8, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x0F, 0xE0, 0xE0, 0x7F, 0xF1, 0xC1,
  0xFF, 0xF3, 0x87, 0xC0, 0x77, 0x1E, 0x00, 0x7E, 0x78, 0x00, 0x7C, 0xE0,
  0x00, 0x7B, 0xC0, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x39,
  0xE0, 0x00, 0xF1, 0xC0, 0x03, 0xE3, 0xE0, 0x0F, 0xC3, 0xF0, 0xFB, 0x83,
  0xFF, 0xE7, 0x01, 0xFF, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0x80, 0xF8, 0x1E, 0x00, 0x3C, 0x1C,
  0x00, 0x1E, 0x38, 0x00, 0x0E, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x06, 0x1E, 0x00, 0x0F, 0x0F,
  0x00, 0x1E, 0x07, 0xE0, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xF3, 0xC0,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x0E, 0x07, 0xFF, 0x1C, 0x1F, 0xFF, 0x38, 0x7C, 0x07, 0x71, 0xE0,
  0x07, 0xE7, 0x80, 0x07, 0xCE, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x70, 0x00,
  0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEF,
  0x00, 0x01, 0xCE, 0x00, 0x03, 0x9E, 0x00, 0x0F, 0x1C, 0x00, 0x3E, 0x3E,
  0x00, 0xFC, 0x3F, 0x0F, 0xB8, 0x3F, 0xFE, 0x70, 0x1F, 0xF0, 0xE0, 0x06,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x40, 0x00, 0xF1, 0xE0, 0x03, 0xC1, 0xE0, 0x0F, 0x81, 0xF8, 0xFE,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x03, 0xF8, 0x1C, 0x3F, 0xFC, 0x38, 0xFF,
  0xFC, 0x73, 0xC0, 0x7C, 0xEE, 0x00, 0x79, 0xD8, 0x00, 0x7B, 0xE0, 0x00,
  0x77, 0x80, 0x00, 0xEF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0xF1, 0x03, 0xF8, 0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xDC,
  0x00, 0x0F, 0x38, 0x00, 0x3C, 0x70, 0x00, 0xF0, 0xE0, 0x07, 0xC1, 0xC0,
  0x1F, 0x03, 0x80, 0x7C, 0x07, 0x01, 0xE0, 0x0E, 0x07, 0x80, 0x1C, 0x1E,
  0x00, 0x38, 0x78, 0x00, 0x71, 0xE0, 0x00, 0xE7, 0x80, 0x01, 0xDF, 0x80,
  0x03, 0xFF, 0x80, 0x07, 0xE7, 0x80, 0x0F, 0x87, 0x80, 0x1E, 0x0F, 0x00,
  0x38, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0F, 0x01, 0xC0, 0x0F, 0x03,
  0x80, 0x0F, 0x07, 0x00, 0x1F, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x38,
  0x00, 0x1E, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE1, 0xF0, 0x1F, 0x8E, 0x7F, 0xC7,
  0xFC, 0xEF, 0xFE, 0xFF, 0xEF, 0xC1, 0xFC, 0x0E, 0xF8, 0x0F, 0x80, 0xFF,
  0x00, 0xF0, 0x07, 0xF0, 0x07, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07,
  0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07, 0x00, 0x7E, 0x00, 0x70, 0x07,
  0xE0, 0x07, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07, 0x00, 0x7E, 0x00,
  0x70, 0x07, 0xE0, 0x07, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07, 0x00,
  0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0,
  0x07, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07, 0x00, 0x7E, 0x00, 0x70,
  0x07, 0xE0, 0x07, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07, 0x00, 0x70,
  0xE0, 0x7F, 0x81, 0xC3, 0xFF, 0xC3, 0x8F, 0xFF, 0xC7, 0x3C, 0x07, 0xCE,
  0xE0, 0x07, 0x9F, 0x80, 0x07, 0xBE, 0x00, 0x07, 0x78, 0x00, 0x0E, 0xF0,
  0x00, 0x1D, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0xE0,
  0x00, 0x1E, 0x78, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x0F,
  0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0xFE, 0x01, 0xC7, 0xFF, 0x83, 0x9F, 0xFF, 0x87, 0x78,
  0x0F, 0x8F, 0xC0, 0x0F, 0x9F, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x78, 0x00,
  0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xDC, 0x00, 0x03, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1C, 0xF8,
  0x00, 0x79, 0xF8, 0x01, 0xE3, 0xBE, 0x0F, 0x87, 0x3F, 0xFE, 0x0E, 0x1F,
  0xF8, 0x1C, 0x02, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFE, 0x0E,
  0x07, 0xFF, 0x1C, 0x1F, 0xFF, 0xB8, 0x78, 0x07, 0xF1, 0xE0, 0x07, 0xE7,
  0x80, 0x07, 0xCE, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0,
  0x00, 0x1D, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEF, 0x00, 0x01,
  0xCE, 0x00, 0x03, 0x9E, 0x00, 0x0F, 0x1C, 0x00, 0x3E, 0x3E, 0x00, 0xFC,
  0x3F, 0x07, 0xB8, 0x3F, 0xFE, 0x70, 0x1F, 0xF0, 0xE0, 0x06, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF9,
  0xF0, 0x1F, 0x70, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xF0, 0x07,
  0xC3, 0xC0, 0x03, 0xCF, 0x00, 0x03, 0x9C, 0x00, 0x07, 0xB8, 0x00, 0x07,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x78, 0x00,
  0x1C, 0x78, 0x00, 0x78, 0x7E, 0x07, 0xE0, 0x7F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x0C, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x04, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1D, 0xC0, 0x00, 0x77, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x78, 0x00, 0x7C,
  0xF0, 0x07, 0xF1, 0xF0, 0xFD, 0xC3, 0xFF, 0xE7, 0x07, 0xFE, 0x1C, 0x01,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x80, 0xE0,
  0x01, 0xC0, 0x3C, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x07, 0x80, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x38,
  0x00, 0x1E, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C,
  0x70, 0x00, 0x07, 0x38, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F,
  0xC0, 0x1E, 0x00, 0x66, 0x00, 0xF8, 0x07, 0x38, 0x07, 0xC0, 0x39, 0xC0,
  0x36, 0x01, 0xCE, 0x03, 0xB0, 0x0E, 0x70, 0x1D, 0xC0, 0x61, 0x80, 0xEE,
  0x07, 0x0E, 0x06, 0x70, 0x38, 0x70, 0x71, 0x81, 0xC3, 0x83, 0x8E, 0x0C,
  0x0C, 0x18, 0x70, 0x60, 0x60, 0xC3, 0x87, 0x03, 0x8E, 0x0C, 0x38, 0x1C,
  0x70, 0x71, 0xC0, 0xE3, 0x03, 0x8C, 0x03, 0x18, 0x1C, 0x60, 0x1D, 0xC0,
  0x67, 0x00, 0xEE, 0x03, 0xB8, 0x07, 0x60, 0x1D, 0x80, 0x1B, 0x00, 0x6C,
  0x00, 0xD8, 0x03, 0x60, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x80, 0xF0, 0x01, 0xE0, 0x0E, 0x00, 0x78, 0x00, 0xE0, 0x0E, 0x00, 0x1E,
  0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x78, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x80,
  0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x0F, 0x00, 0x1E, 0x03,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xCF, 0x80, 0x00,
  0x3E, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1C, 0x1C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x70,
  0x07, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0, 0x38,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x02, 0x7E,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x08, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xCF, 0xFE, 0x00, 0x0E, 0xF0,
  0xFC, 0x00, 0x7F, 0x01, 0xF0, 0x07, 0x70, 0x03, 0xC0, 0x3B, 0x00, 0x0F,
  0x87, 0x98, 0x00, 0x3F, 0xFC, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF8,
  0x00,
};

const GFXglyph RobotoMono_Light54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 4, 38, 32, 14, -38 },
  { 20, 10, 12, 32, 11, -41 },
  { 35, 29, 38, 32, 2, -38 },
  { 173, 24, 49, 32, 5, -44 },
  { 320, 30, 40, 32, 1, -39 },
  { 470, 27, 40, 32, 4, -39 },
  { 605, 3, 12, 32, 14, -41 },
  { 610, 13, 55, 32, 10, -43 },
  { 700, 13, 55, 32, 9, -43 },
  { 790, 24, 23, 32, 5, -38 },
  { 859, 26, 28, 32, 3, -32 },
  { 950, 6, 13, 32, 10, -5 },
  { 960, 20, 3, 32, 6, -19 },
  { 968, 6, 5, 32, 14, -5 },
  { 972, 19, 41, 32, 7, -38 },
  { 1070, 24, 40, 32, 4, -39 },
  { 1190, 14, 38, 32, 6, -38 },
  { 1257, 25, 39, 32, 3, -39 },
  { 1379, 24, 40, 32, 3, -39 },
  { 1499, 27, 38, 32, 2, -38 },
  { 1628, 23, 39, 32, 6, -38 },
  { 1741, 24, 40, 32, 4, -39 },
  { 1861, 26, 38, 32, 3, -38 },
  { 1985, 24, 40, 32, 5, -39 },
  { 2105, 24, 39, 32, 4, -39 },
  { 2222, 5, 28, 32, 16, -28 },
  { 2240, 7, 36, 32, 14, -28 },
  { 2272, 23, 23, 32, 4, -29 },
  { 2339, 23, 13, 32, 5, -24 },
  { 2377, 23, 23, 32, 5, -29 },
  { 2444, 21, 39, 32, 6, -39 },
  { 2547, 30, 39, 32, 1, -39 },
  { 2694, 27, 38, 32, 3, -38 },
  { 2823, 24, 38, 32, 5, -38 },
  { 2937, 26, 40, 32, 3, -39 },
  { 3067, 25, 38, 32, 5, -38 },
  { 3186, 23, 38, 32, 5, -38 },
  { 3296, 22, 38, 32, 6, -38 },
  { 3401, 26, 40, 32, 3, -39 },
  { 3531, 24, 38, 32, 4, -38 },
  { 3645, 22, 38, 32, 5, -38 },
  { 3750, 24, 39, 32, 3, -38 },
  { 3867, 26, 38, 32, 5, -38 },
  { 3991, 23, 38, 32, 6, -38 },
  { 4101, 25, 38, 32, 4, -38 },
  { 4220, 24, 38, 32, 4, -38 },
  { 4334, 26, 40, 32, 3, -39 },
  { 4464, 24, 38, 32, 6, -38 },
  { 4578, 27, 46, 32, 3, -39 },
  { 4734, 25, 38, 32, 5, -38 },
  { 4853, 25, 40, 32, 4, -39 },
  { 4978, 28, 38, 32, 2, -38 },
  { 5111, 24, 39, 32, 4, -38 },
  { 5228, 28, 38, 32, 2, -38 },
  { 5361, 29, 38, 32, 2, -38 },
  { 5499, 27, 38, 32, 3, -38 },
  { 5628, 28, 38, 32, 2, -38 },
  { 5761, 25, 38, 32, 3, -38 },
  { 5880, 9, 52, 32, 12, -44 },
  { 5939, 19, 41, 32, 7, -38 },
  { 6037, 9, 52, 32, 11, -44 },
  { 6096, 20, 20, 32, 6, -38 },
  { 6146, 23, 3, 32, 5, 0 },
  { 6155, 8, 7, 32, 12, -40 },
  { 6162, 24, 30, 32, 4, -29 },
  { 6252, 23, 42, 32, 5, -41 },
  { 6373, 24, 30, 32, 4, -29 },
  { 6463, 23, 42, 32, 4, -41 },
  { 6584, 24, 30, 32, 4, -29 },
  { 6674, 25, 41, 32, 5, -41 },
  { 6803, 23, 40, 32, 4, -29 },
  { 6918, 23, 41, 32, 5, -41 },
  { 7036, 23, 39, 32, 6, -39 },
  { 7149, 17, 51, 32, 5, -39 },
  { 7258, 23, 41, 32, 6, -41 },
  { 7376, 23, 41, 32, 6, -41 },
  { 7494, 28, 29, 32, 2, -29 },
  { 7596, 23, 29, 32, 5, -29 },
  { 7680, 26, 30, 32, 3, -29 },
  { 7778, 23, 40, 32, 5, -29 },
  { 7893, 23, 40, 32, 4, -29 },
  { 8008, 19, 29, 32, 9, -29 },
  { 8077, 23, 30, 32, 5, -29 },
  { 8164, 23, 37, 32, 4, -36 },
  { 8271, 22, 30, 32, 5, -29 },
  { 8354, 26, 29, 32, 3, -29 },
  { 8449, 29, 29, 32, 2, -29 },
  { 8555, 27, 29, 32, 3, -29 },
  { 8653, 28, 41, 32, 2, -29 },
  { 8797, 25, 29, 32, 4, -29 },
  { 8888, 17, 53, 32, 9, -42 },
  { 9001, 3, 47, 32, 15, -38 },
  { 9019, 17, 53, 32, 9, -42 },
  { 9132, 29, 10, 32, 2, -21 },
};

const GFXfont RobotoMono_Light54pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light54pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light54pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOMONO_LIGHT54PT7B_H_
