#ifndef _ROBOTOMONO_LIGHT31PT7B_H_
#define _ROBOTOMONO_LIGHT31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0xC7, 0x1C, 0x71, 0xC7, 0x18,
  0x40, 0x01, 0x06, 0x01, 0x82, 0x00, 0xC1, 0x00, 0x61, 0x80, 0x20, 0xC0,
  0x10, 0x41, 0xFF, 0xFE, 0xFF, 0xFF, 0x06, 0x18, 0x02, 0x0C, 0x01, 0x06,
  0x00, 0x82, 0x00, 0xC1, 0x00, 0x61, 0x83, 0xFF, 0xFD, 0xFF, 0xFE, 0x08,
  0x20, 0x0C, 0x10, 0x06, 0x08, 0x03, 0x0C, 0x01, 0x06, 0x00, 0x82, 0x00,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x3F, 0x83, 0x8F, 0x30, 0x19, 0x80, 0x68,
  0x03, 0xC0, 0x1A, 0x00, 0x18, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x80, 0x1C, 0x01, 0xE0, 0x0D,
  0x80, 0xE7, 0x1E, 0x1F, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x7C, 0x00,
  0x63, 0x00, 0x20, 0x82, 0x10, 0x41, 0x08, 0x21, 0x84, 0x10, 0x82, 0x08,
  0xC1, 0x8C, 0xC0, 0x7C, 0x40, 0x08, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0xC0, 0x19, 0xF8, 0x08, 0x84, 0x0C, 0xC3, 0x04, 0x61, 0x86, 0x30,
  0xC6, 0x18, 0x61, 0x0C, 0x30, 0x03, 0x30, 0x00, 0xF0, 0x0F, 0xC0, 0x1C,
  0xE0, 0x30, 0x60, 0x30, 0x60, 0x30, 0x60, 0x30, 0x60, 0x30, 0xC0, 0x19,
  0xC0, 0x1B, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x33, 0x02, 0x61,
  0x86, 0xC0, 0xC6, 0xC0, 0x66, 0xC0, 0x74, 0xC0, 0x3C, 0xC0, 0x18, 0x60,
  0x3C, 0x38, 0xE6, 0x1F, 0xC7, 0xFA, 0xA8, 0x02, 0x0C, 0x30, 0xC1, 0x06,
  0x08, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x10, 0x30, 0x60, 0x40, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x83, 0x03, 0x06, 0x04, 0x0C, 0x18, 0x30, 0x60, 0xC0,
  0x81, 0x02, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x20, 0xC3,
  0x04, 0x18, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xC3, 0x0B,
  0xC9, 0xF1, 0xFE, 0x00, 0xC0, 0x05, 0x80, 0x33, 0x01, 0x8C, 0x0C, 0x18,
  0x30, 0x30, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x6D, 0xB6, 0xB0, 0xFF,
  0xFF, 0xFC, 0x7F, 0x80, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x0F, 0xE0, 0x71, 0xC3, 0x01, 0x98, 0x06, 0x60, 0x0D, 0x80, 0x34,
  0x01, 0xF0, 0x0F, 0xC0, 0x6F, 0x03, 0x3C, 0x18, 0xF0, 0xC3, 0xC6, 0x0F,
  0x30, 0x3F, 0x80, 0xDC, 0x03, 0x60, 0x0D, 0x80, 0x36, 0x01, 0x8C, 0x06,
  0x1C, 0x70, 0x3F, 0x80, 0x01, 0x0F, 0x3F, 0xF3, 0x83, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x0F, 0xE0, 0x78, 0xE0, 0xC0, 0x63, 0x00, 0xC6, 0x00, 0xC8,
  0x01, 0xA0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x07, 0xFF, 0xEF, 0xFF, 0xC0, 0x0F, 0xE0, 0x71, 0xC3,
  0x01, 0x98, 0x03, 0x60, 0x0D, 0x80, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x7E, 0x01, 0xFC, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0xC0, 0x0D, 0x80, 0x36, 0x00, 0xCC, 0x06, 0x3C, 0x70, 0x3F, 0x80, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0xD0, 0x01, 0x90, 0x01, 0x90, 0x03,
  0x10, 0x06, 0x10, 0x06, 0x10, 0x0C, 0x10, 0x08, 0x10, 0x18, 0x10, 0x30,
  0x10, 0x20, 0x10, 0x60, 0x10, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x3F, 0xF9, 0xFF, 0xC8, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x6F, 0xC3, 0xFF, 0x18,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xC0, 0x1E, 0x00,
  0xD8, 0x0E, 0xE0, 0xE3, 0xFF, 0x07, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x4F, 0xE3, 0x61,
  0xCF, 0x01, 0xB8, 0x06, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x40,
  0x0D, 0x80, 0x36, 0x01, 0x8C, 0x0E, 0x1C, 0x70, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x1F, 0xC0, 0xE3, 0xC6, 0x03, 0x18, 0x06, 0xC0, 0x1B, 0x00, 0x6C,
  0x01, 0x90, 0x06, 0x60, 0x30, 0xE1, 0x80, 0xFC, 0x0F, 0x78, 0x60, 0x33,
  0x00, 0x6C, 0x00, 0xB0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0x98, 0x0E,
  0x78, 0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0x71, 0xC3, 0x03, 0x18, 0x06, 0x60,
  0x09, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x00, 0x36, 0x00, 0xD8,
  0x07, 0x38, 0x3C, 0x7F, 0xB0, 0x78, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x38, 0x1F, 0xC0, 0x7C, 0x00, 0x5F, 0x80, 0x00, 0x00, 0x00,
  0xBF, 0x27, 0x70, 0x00, 0x00, 0x00, 0x00, 0x06, 0x66, 0x66, 0x6C, 0x00,
  0x30, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x0E, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0xE0, 0x3C, 0x07, 0x81, 0xF0,
  0x3C, 0x01, 0x80, 0x08, 0x00, 0x00, 0x1F, 0xC1, 0xC7, 0x18, 0x0C, 0xC0,
  0x6C, 0x01, 0x00, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x03, 0x00, 0x03, 0xF0, 0x07, 0x0E, 0x06, 0x01,
  0x86, 0x00, 0x42, 0x0C, 0x33, 0x0F, 0x89, 0x08, 0x44, 0x8C, 0x23, 0xC4,
  0x11, 0xC2, 0x08, 0xE3, 0x0C, 0x71, 0x86, 0x38, 0xC2, 0x14, 0x61, 0x0A,
  0x31, 0x85, 0x88, 0xE4, 0xC7, 0x9E, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xC3, 0x80, 0x3F, 0x80, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x16,
  0x00, 0x6C, 0x00, 0xD8, 0x01, 0x10, 0x06, 0x30, 0x0C, 0x60, 0x10, 0x40,
  0x60, 0xC0, 0xC1, 0x81, 0x01, 0x06, 0x03, 0x0F, 0xFE, 0x1F, 0xFC, 0x60,
  0x0C, 0xC0, 0x19, 0x00, 0x16, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xC0, 0xFF,
  0x83, 0xFF, 0x8C, 0x07, 0x30, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB0,
  0x06, 0xC0, 0x33, 0x03, 0x8F, 0xF8, 0x30, 0x3C, 0xC0, 0x3B, 0x00, 0x6C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xB0, 0x0E, 0xFF, 0xE3,
  0xFF, 0x00, 0x0F, 0xE0, 0x38, 0xE0, 0xC0, 0x63, 0x00, 0x66, 0x00, 0xD8,
  0x00, 0xB0, 0x01, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x03, 0xC0, 0x04, 0xC0, 0x19,
  0x80, 0x31, 0x80, 0xC1, 0xC7, 0x01, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0x0C,
  0x06, 0x30, 0x0C, 0xC0, 0x1B, 0x00, 0x6C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x02,
  0xC0, 0x1B, 0x00, 0x6C, 0x03, 0x30, 0x18, 0xFF, 0xC3, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x3F, 0xFD, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x3F, 0xFD, 0xFF, 0xEC, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x0F,
  0xE0, 0x38, 0xE0, 0xC0, 0x63, 0x00, 0x66, 0x00, 0xD8, 0x00, 0xF0, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x0F, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x06, 0xC0, 0x0D, 0x80, 0x19, 0x80,
  0x71, 0xE3, 0x81, 0xFE, 0x00, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xC1,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0xC0, 0x0B, 0x00, 0x6C, 0x01, 0x98, 0x0C, 0x38, 0xE0, 0x7F, 0x00, 0xC0,
  0x0D, 0x80, 0x33, 0x00, 0xC6, 0x03, 0x0C, 0x0C, 0x18, 0x38, 0x30, 0xE0,
  0x61, 0x80, 0xC6, 0x01, 0x98, 0x03, 0x78, 0x07, 0xB0, 0x0E, 0x30, 0x18,
  0x70, 0x30, 0x60, 0x60, 0x60, 0xC0, 0x61, 0x80, 0xE3, 0x00, 0xC6, 0x00,
  0xCC, 0x00, 0xD8, 0x01, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0xC0, 0x1E, 0x01, 0xF8, 0x0F, 0xC0, 0x5B,
  0x06, 0xD8, 0x36, 0xC1, 0x33, 0x19, 0x98, 0x8C, 0x4C, 0x63, 0x63, 0x1A,
  0x18, 0x70, 0xC3, 0x86, 0x18, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03,
  0xD8, 0x0F, 0x60, 0x3C, 0xC0, 0xF3, 0x03, 0xC6, 0x0F, 0x08, 0x3C, 0x30,
  0xF0, 0x63, 0xC1, 0x8F, 0x03, 0x3C, 0x0C, 0xF0, 0x1B, 0xC0, 0x6F, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x30, 0x0F, 0xE0, 0x39, 0xE0,
  0xC0, 0xE3, 0x00, 0xC6, 0x00, 0xD8, 0x01, 0xB0, 0x01, 0x60, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x02, 0xC0, 0x0C, 0xC0, 0x19, 0x80, 0x61, 0x81, 0xC1, 0xEF, 0x01,
  0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0xCC, 0x03, 0xB0, 0x07, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x6C, 0x03, 0xBF, 0xFC, 0xFF,
  0xC3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x0F, 0xE0, 0x39, 0xE0, 0xC0, 0x63, 0x00,
  0x66, 0x00, 0xD8, 0x00, 0xB0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x04, 0xC0, 0x19, 0x80, 0x31, 0x80, 0xC1, 0xEF, 0x01, 0xFE, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x08, 0xFF, 0x83, 0xFF, 0x8C, 0x03, 0x30,
  0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x00, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0xEC,
  0x07, 0x3F, 0xF8, 0xFF, 0x83, 0x03, 0x0C, 0x0C, 0x30, 0x18, 0xC0, 0x63,
  0x00, 0xCC, 0x03, 0x30, 0x06, 0xC0, 0x1B, 0x00, 0x30, 0x0F, 0xE0, 0x78,
  0xF0, 0xC0, 0x73, 0x00, 0x66, 0x00, 0xEC, 0x00, 0xD8, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x0D, 0x80, 0x3B, 0x80, 0x63, 0xC7,
  0x81, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x40, 0x0D, 0x80, 0x36, 0x01, 0x8C, 0x0E, 0x1C, 0xF0,
  0x3F, 0x80, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x06, 0x60, 0x06, 0x30, 0x06,
  0x30, 0x04, 0x30, 0x0C, 0x18, 0x0C, 0x18, 0x08, 0x18, 0x18, 0x0C, 0x18,
  0x0C, 0x10, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x60, 0x02, 0x60,
  0x03, 0x60, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x81,
  0xE0, 0xE0, 0xD0, 0x70, 0x48, 0x38, 0x26, 0x14, 0x13, 0x0A, 0x19, 0x85,
  0x8C, 0xC6, 0xC6, 0x63, 0x63, 0x11, 0x91, 0x08, 0x88, 0x86, 0x46, 0x43,
  0x63, 0x61, 0xB1, 0xB0, 0xD8, 0x58, 0x68, 0x2C, 0x14, 0x14, 0x0E, 0x0E,
  0x07, 0x07, 0x03, 0x83, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0xC0, 0x06, 0xC0,
  0x19, 0xC0, 0x31, 0x80, 0xC1, 0x83, 0x03, 0x06, 0x03, 0x18, 0x06, 0x30,
  0x06, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x6C, 0x00, 0xD8, 0x03,
  0x18, 0x06, 0x30, 0x18, 0x30, 0x60, 0x30, 0xC0, 0x63, 0x00, 0x66, 0x00,
  0xF8, 0x00, 0xC0, 0xE0, 0x03, 0x60, 0x06, 0x70, 0x06, 0x30, 0x0C, 0x30,
  0x0C, 0x18, 0x18, 0x08, 0x18, 0x0C, 0x30, 0x04, 0x30, 0x06, 0x60, 0x02,
  0x60, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xFC, 0xC0, 0x18, 0x01,
  0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30,
  0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3F,
  0xFC, 0x0C, 0x01, 0xC0, 0x38, 0x0D, 0x01, 0x30, 0x62, 0x0C, 0x61, 0x0C,
  0x60, 0xC8, 0x1B, 0x01, 0x60, 0x30, 0xFF, 0xFF, 0xFF, 0xC0, 0xC3, 0x0C,
  0x70, 0x07, 0x01, 0xFF, 0x1C, 0x1D, 0x80, 0x6C, 0x01, 0x00, 0x0C, 0x00,
  0x60, 0x7F, 0x3F, 0xFB, 0x80, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xE0, 0x1F,
  0x01, 0xEE, 0x3B, 0x3F, 0x98, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x1C, 0x1B, 0xF8, 0xF0, 0x67, 0x01, 0xB0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x6E, 0x03, 0x7C, 0x73, 0x3F, 0x00, 0x03, 0x80, 0x3F, 0xC3, 0x83,
  0x8C, 0x06, 0x60, 0x0D, 0x80, 0x34, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x0D, 0x80, 0x33, 0x01, 0x87, 0x1C, 0x0F,
  0xE0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x70, 0xC7, 0xF3, 0x38, 0x3C, 0xC0, 0x76, 0x00, 0xD8, 0x03, 0x40, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x80, 0x36, 0x00, 0xD8, 0x07,
  0x30, 0x1C, 0x71, 0xB0, 0xFC, 0xC0, 0x03, 0x80, 0x3F, 0x81, 0x83, 0x8C,
  0x06, 0x60, 0x0D, 0x80, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0xC7, 0x0E, 0x0F, 0xF0,
  0x00, 0x78, 0x0F, 0xF0, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0xFF, 0xF8, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x7F, 0xB3, 0x83, 0xCC,
  0x07, 0x60, 0x1D, 0x80, 0x34, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xD8, 0x03, 0x60, 0x0D, 0x80, 0x73, 0x01, 0xC7, 0x1B, 0x0F, 0xCC,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x60, 0x18, 0xE1, 0xC1, 0xFE, 0x00, 0x40,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x0C, 0x19,
  0xFC, 0xD8, 0x77, 0x01, 0xB0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0xE0, 0x73, 0xF8, 0x78, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xB0, 0x0C, 0xC0, 0x63, 0x03, 0x0C,
  0x38, 0x31, 0xC0, 0xCE, 0x03, 0x70, 0x0F, 0xE0, 0x3D, 0x80, 0xC3, 0x03,
  0x06, 0x0C, 0x0C, 0x30, 0x38, 0xC0, 0x73, 0x00, 0xEC, 0x01, 0xC0, 0xFF,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x18, 0xDF, 0x3E, 0xE1, 0xC3, 0xC1, 0x83,
  0xC1, 0x81, 0xC1, 0x81, 0xC1, 0x81, 0xC1, 0x81, 0xC1, 0x81, 0xC1, 0x81,
  0xC1, 0x81, 0xC1, 0x81, 0xC1, 0x81, 0xC1, 0x81, 0xC1, 0x81, 0xC1, 0x81,
  0xC1, 0x81, 0x03, 0x06, 0x7F, 0x36, 0x1D, 0xC0, 0x6C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x18, 0x03, 0x80, 0x3F, 0xC0, 0xE0, 0xC3,
  0x80, 0xC6, 0x00, 0xD8, 0x01, 0xB0, 0x01, 0x60, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x8C, 0x06, 0x0E, 0x38,
  0x0F, 0xE0, 0x07, 0x06, 0xFE, 0x3C, 0x19, 0xC0, 0x6C, 0x03, 0x60, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1B, 0x81, 0xDF, 0x1C, 0xCF, 0xC6, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x07, 0x00, 0x7F, 0xB3, 0x83, 0xCC, 0x07, 0x60,
  0x0D, 0x80, 0x34, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xD8,
  0x03, 0x60, 0x0D, 0x80, 0x73, 0x01, 0xC7, 0x1B, 0x0F, 0xCC, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0xF9, 0xFF,
  0x70, 0x78, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x07, 0x01, 0xFF,
  0x1C, 0x1C, 0xC0, 0x3C, 0x01, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1F, 0x80,
  0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x01, 0xE0, 0x0D, 0x80, 0x6F, 0x0E, 0x1F,
  0xE0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x7F, 0xF8, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x10, 0x3F, 0x80,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xB0, 0x3D, 0xE7,
  0x63, 0xF3, 0xC0, 0x07, 0x80, 0x19, 0x80, 0x33, 0x00, 0xC3, 0x01, 0x86,
  0x02, 0x04, 0x0C, 0x0C, 0x18, 0x18, 0x60, 0x18, 0xC0, 0x31, 0x00, 0x26,
  0x00, 0x68, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0x80, 0xC0, 0x81, 0xE0, 0xE0,
  0x90, 0x70, 0x48, 0x28, 0x66, 0x14, 0x33, 0x1B, 0x19, 0x89, 0x88, 0x44,
  0x44, 0x22, 0x26, 0x1B, 0x1B, 0x0D, 0x0D, 0x02, 0x82, 0x81, 0x41, 0x40,
  0xE0, 0xE0, 0x60, 0x70, 0x30, 0x10, 0xE0, 0x0E, 0x60, 0x30, 0xE0, 0xE0,
  0xC1, 0x80, 0xC6, 0x00, 0xD8, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0D,
  0x80, 0x31, 0x80, 0xE3, 0x01, 0x83, 0x06, 0x03, 0x18, 0x03, 0x70, 0x07,
  0xE0, 0x03, 0x60, 0x03, 0x70, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x18, 0x0C,
  0x18, 0x18, 0x0C, 0x18, 0x0C, 0x10, 0x06, 0x30, 0x06, 0x30, 0x03, 0x60,
  0x03, 0x60, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0x20, 0x00, 0x7F, 0xFC,
  0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0xE0, 0x60, 0x18, 0x04, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x0F, 0x03, 0xC0,
  0x18, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x1C,
  0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x04, 0x01, 0x80, 0x3C, 0x0F, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0xE0, 0x70, 0x30, 0x00,
  0x3C, 0x00, 0x3F, 0x80, 0xF0, 0x60, 0x58, 0x1C, 0x68, 0x07, 0xE0, 0x00,
  0x40,
};

const GFXglyph RobotoMono_Light31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 2, 22, 19, 8, -22 },
  { 7, 6, 7, 19, 6, -23 },
  { 13, 17, 22, 19, 1, -22 },
  { 60, 13, 28, 19, 3, -25 },
  { 106, 17, 22, 19, 1, -22 },
  { 153, 16, 22, 19, 2, -22 },
  { 197, 2, 7, 19, 8, -23 },
  { 199, 7, 32, 19, 6, -25 },
  { 227, 7, 32, 19, 5, -25 },
  { 255, 14, 13, 19, 3, -22 },
  { 278, 15, 16, 19, 2, -18 },
  { 308, 3, 7, 19, 6, -3 },
  { 311, 11, 2, 19, 4, -11 },
  { 314, 3, 3, 19, 8, -3 },
  { 316, 11, 24, 19, 4, -22 },
  { 349, 14, 22, 19, 2, -22 },
  { 388, 8, 22, 19, 3, -22 },
  { 410, 15, 22, 19, 1, -22 },
  { 452, 14, 22, 19, 1, -22 },
  { 491, 16, 22, 19, 1, -22 },
  { 535, 13, 22, 19, 3, -22 },
  { 571, 14, 22, 19, 2, -22 },
  { 610, 14, 22, 19, 2, -22 },
  { 649, 14, 22, 19, 3, -22 },
  { 688, 14, 22, 19, 2, -22 },
  { 727, 3, 16, 19, 9, -16 },
  { 733, 4, 20, 19, 8, -16 },
  { 743, 12, 13, 19, 3, -16 },
  { 763, 13, 8, 19, 3, -14 },
  { 776, 13, 13, 19, 3, -16 },
  { 798, 13, 22, 19, 3, -22 },
  { 834, 17, 22, 19, 1, -22 },
  { 881, 15, 22, 19, 2, -22 },
  { 923, 14, 22, 19, 3, -22 },
  { 962, 15, 22, 19, 2, -22 },
  { 1004, 14, 22, 19, 3, -22 },
  { 1043, 13, 22, 19, 3, -22 },
  { 1079, 13, 22, 19, 3, -22 },
  { 1115, 15, 22, 19, 2, -22 },
  { 1157, 14, 22, 19, 2, -22 },
  { 1196, 13, 22, 19, 3, -22 },
  { 1232, 14, 22, 19, 2, -22 },
  { 1271, 15, 22, 19, 3, -22 },
  { 1313, 13, 22, 19, 3, -22 },
  { 1349, 13, 22, 19, 3, -22 },
  { 1385, 14, 22, 19, 2, -22 },
  { 1424, 15, 22, 19, 2, -22 },
  { 1466, 14, 22, 19, 3, -22 },
  { 1505, 15, 26, 19, 2, -22 },
  { 1554, 14, 22, 19, 3, -22 },
  { 1593, 15, 22, 19, 2, -22 },
  { 1635, 16, 22, 19, 1, -22 },
  { 1679, 14, 22, 19, 2, -22 },
  { 1718, 16, 22, 19, 1, -22 },
  { 1762, 17, 22, 19, 1, -22 },
  { 1809, 15, 22, 19, 2, -22 },
  { 1851, 16, 22, 19, 1, -22 },
  { 1895, 14, 22, 19, 2, -22 },
  { 1934, 5, 30, 19, 7, -25 },
  { 1953, 11, 24, 19, 4, -22 },
  { 1986, 5, 30, 19, 7, -25 },
  { 2005, 11, 12, 19, 4, -22 },
  { 2022, 13, 2, 19, 3, 0 },
  { 2026, 5, 4, 19, 7, -23 },
  { 2029, 13, 17, 19, 3, -17 },
  { 2057, 13, 23, 19, 3, -23 },
  { 2095, 14, 17, 19, 2, -17 },
  { 2125, 14, 23, 19, 2, -23 },
  { 2166, 14, 17, 19, 2, -17 },
  { 2196, 14, 24, 19, 3, -24 },
  { 2238, 14, 24, 19, 2, -17 },
  { 2280, 13, 23, 19, 3, -23 },
  { 2318, 14, 22, 19, 3, -22 },
  { 2357, 10, 29, 19, 3, -22 },
  { 2394, 14, 23, 19, 3, -23 },
  { 2435, 14, 23, 19, 3, -23 },
  { 2476, 16, 17, 19, 1, -17 },
  { 2510, 13, 17, 19, 3, -17 },
  { 2538, 15, 17, 19, 2, -17 },
  { 2570, 13, 23, 19, 3, -17 },
  { 2608, 14, 23, 19, 2, -17 },
  { 2649, 11, 17, 19, 5, -17 },
  { 2673, 13, 17, 19, 3, -17 },
  { 2701, 13, 21, 19, 3, -21 },
  { 2736, 13, 16, 19, 3, -16 },
  { 2762, 15, 16, 19, 2, -16 },
  { 2792, 17, 16, 19, 1, -16 },
  { 2826, 15, 16, 19, 2, -16 },
  { 2856, 16, 23, 19, 1, -16 },
  { 2902, 15, 16, 19, 2, -16 },
  { 2932, 10, 30, 19, 5, -24 },
  { 2970, 1, 27, 19, 9, -22 },
  { 2974, 10, 30, 19, 5, -24 },
  { 3012, 17, 6, 19, 1, -12 },
};

const GFXfont RobotoMono_Light31pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light31pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOMONO_LIGHT31PT7B_H_
