#ifndef _ROBOTOMONO_LIGHT67PT7B_H_
#define _ROBOTOMONO_LIGHT67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light67pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xBC, 0x0E, 0xE0, 0x3B, 0x80,
  0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x80, 0x1C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x80, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x00,
  0x3E, 0x0F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xF1,
  0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x78, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0xF0, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x00,
  0x38, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0xE0,
  0x01, 0xC0, 0x0E, 0x07, 0x80, 0x07, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x01,
  0xC0, 0xF0, 0x00, 0x78, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x78, 0x1C, 0x00,
  0x01, 0xFF, 0xE0, 0x70, 0x00, 0x03, 0xFF, 0x03, 0x80, 0x00, 0x07, 0xF0,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0xC0,
  0x00, 0x01, 0xC0, 0x7F, 0xC0, 0x00, 0x07, 0x03, 0xFF, 0x80, 0x00, 0x38,
  0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x38,
  0x00, 0x3C, 0x1E, 0x00, 0xE0, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x07, 0x81,
  0xC0, 0x0F, 0x00, 0x1C, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x70, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x3C, 0x03, 0x80, 0x1E, 0x00, 0xE0, 0x02, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x07, 0xC1, 0xF0, 0x01, 0xC1, 0xF0, 0x1E, 0x00, 0x78, 0x7C,
  0x03, 0xE0, 0x0F, 0x0F, 0x00, 0x3E, 0x01, 0xE3, 0xE0, 0x03, 0xE0, 0x3C,
  0x78, 0x00, 0x3E, 0x07, 0x8F, 0x00, 0x03, 0xC1, 0xE1, 0xE0, 0x00, 0x7C,
  0x3C, 0x78, 0x00, 0x07, 0xC7, 0x8F, 0x00, 0x00, 0x7D, 0xE0, 0xE0, 0x00,
  0x07, 0xFC, 0x1E, 0x00, 0x00, 0x7F, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x78,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x0F, 0xF0,
  0x0F, 0x80, 0x03, 0xFF, 0x00, 0xFC, 0x01, 0xF9, 0xF0, 0x0F, 0xFF, 0xFE,
  0x1F, 0x00, 0xFF, 0xFF, 0x01, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x40, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x01, 0x80, 0x0E, 0x00, 0x67, 0x80, 0x38, 0x07, 0xBF,
  0xC0, 0xE0, 0xFF, 0xFF, 0xE3, 0x8F, 0xFC, 0xFF, 0xEF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80,
  0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x01,
  0xC0, 0x00, 0xF0, 0x03, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C,
  0x79, 0xF3, 0xC7, 0x9E, 0x38, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01,
  0xF7, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1E, 0xFF, 0x00, 0x01, 0xF3, 0xFC, 0x00, 0x0F, 0x8F, 0xF0,
  0x00, 0x7C, 0x3F, 0xC0, 0x03, 0xE0, 0xFF, 0x00, 0x1F, 0x03, 0xFC, 0x00,
  0xF0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x3C, 0x00, 0xFF, 0x01, 0xE0,
  0x03, 0xFC, 0x1F, 0x00, 0x0F, 0xF0, 0xF8, 0x00, 0x3F, 0xC7, 0xC0, 0x00,
  0xFF, 0x3E, 0x00, 0x03, 0xFD, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x7F,
  0xFC, 0xFF, 0x9F, 0xFE, 0x0F, 0xFC, 0x07, 0xF8, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xF8, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0xF8, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF9, 0xE0, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x10, 0x00, 0x0F, 0x1F, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xF1, 0xFF, 0xC0,
  0xFC, 0x01, 0xFE, 0x07, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x07, 0xCF, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3F,
  0x0F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0x80, 0x1C, 0x1F, 0xFF, 0x80, 0xE3,
  0xFF, 0xFE, 0x0F, 0x3F, 0x03, 0xF8, 0x7B, 0xE0, 0x07, 0xE3, 0xFC, 0x00,
  0x0F, 0x9F, 0xC0, 0x00, 0x3C, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0x80, 0x0F,
  0xC0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x7C,
  0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x0F,
  0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0xF8, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFC, 0x1F,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x3F, 0x3C, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x07, 0xF1,
  0xF0, 0x00, 0x7B, 0x83, 0xE0, 0x03, 0xCE, 0x07, 0xE0, 0x7F, 0x38, 0x0F,
  0xFF, 0xF1, 0xE0, 0x1F, 0xFF, 0x87, 0x80, 0x1F, 0xF8, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7B, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0x0F, 0xCF, 0xE7, 0xF1, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x3C,
  0x1E, 0x1E, 0x02, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xF0, 0x7F, 0x01, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x1F, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x7E, 0x00, 0xE1, 0xE0, 0x1F,
  0xF8, 0x0E, 0x1C, 0x03, 0xFF, 0xC0, 0xE3, 0xC0, 0x7C, 0x1C, 0x06, 0x38,
  0x07, 0x01, 0xC0, 0x73, 0x80, 0xE0, 0x1C, 0x07, 0x70, 0x1E, 0x01, 0xC0,
  0x77, 0x01, 0xC0, 0x1C, 0x07, 0x70, 0x1C, 0x01, 0xC0, 0x77, 0x03, 0x80,
  0x1C, 0x07, 0x60, 0x38, 0x01, 0xC0, 0x7E, 0x03, 0x80, 0x18, 0x07, 0xE0,
  0x38, 0x01, 0x80, 0x7E, 0x07, 0x00, 0x18, 0x07, 0xE0, 0x70, 0x01, 0x80,
  0x7E, 0x07, 0x00, 0x38, 0x07, 0xE0, 0x70, 0x03, 0x80, 0x7E, 0x07, 0x00,
  0x38, 0x07, 0xE0, 0x70, 0x03, 0x80, 0x6E, 0x07, 0x00, 0x38, 0x06, 0xE0,
  0x70, 0x07, 0x80, 0xEE, 0x07, 0x00, 0x78, 0x0E, 0xE0, 0x38, 0x0F, 0x80,
  0xC7, 0x03, 0x81, 0xF8, 0x1C, 0x70, 0x3C, 0x39, 0xC3, 0x87, 0x01, 0xFF,
  0x1F, 0xF8, 0x70, 0x0F, 0xE0, 0xFF, 0x03, 0x80, 0x7C, 0x07, 0xC0, 0x38,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x02, 0x00, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x3F, 0x83, 0xC0, 0x00, 0x3F,
  0x0F, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x3E, 0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x83, 0xC0, 0x03, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x00, 0x7F, 0x0F, 0x00, 0x00, 0x7E, 0x3C, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x00, 0xFB, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3F, 0x3C, 0x00, 0x03, 0xF8, 0xF0,
  0x00, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xC0,
  0x01, 0xF8, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x0F,
  0xE0, 0x1E, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x7C, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1F,
  0x83, 0xC0, 0x00, 0x7E, 0x07, 0x80, 0x03, 0xF8, 0x0F, 0x00, 0x7F, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x8E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F,
  0x7C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x00,
  0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00,
  0xF3, 0xF8, 0x00, 0x00, 0xF7, 0xFC, 0x00, 0x00, 0xF7, 0xFE, 0x00, 0x00,
  0xFF, 0xBE, 0x00, 0x00, 0xFF, 0x1F, 0x00, 0x00, 0xFE, 0x0F, 0x80, 0x00,
  0xFC, 0x07, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF0, 0x03, 0xE0, 0x00,
  0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x77, 0xF7, 0x00, 0x03, 0xDF, 0xDE, 0x00, 0x0F, 0x7F, 0x78, 0x00,
  0x79, 0xFC, 0xF0, 0x01, 0xE7, 0xF3, 0xC0, 0x07, 0x1F, 0xC7, 0x00, 0x3C,
  0x7F, 0x1E, 0x00, 0xF1, 0xFC, 0x78, 0x03, 0x87, 0xF0, 0xE0, 0x1E, 0x1F,
  0xC3, 0xC0, 0x70, 0x7F, 0x0F, 0x03, 0xC1, 0xFC, 0x1C, 0x0F, 0x07, 0xF0,
  0x78, 0x38, 0x1F, 0xC1, 0xE1, 0xE0, 0x7F, 0x03, 0x87, 0x81, 0xFC, 0x0F,
  0x1C, 0x07, 0xF0, 0x3C, 0xF0, 0x1F, 0xC0, 0x7B, 0x80, 0x7F, 0x01, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00,
  0x7F, 0x00, 0x7C, 0x01, 0xFC, 0x01, 0xE0, 0x07, 0xF0, 0x07, 0x80, 0x1F,
  0xC0, 0x0C, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xF7, 0x80, 0x00, 0x3F, 0xDE, 0x00, 0x00, 0xFF, 0x3C, 0x00,
  0x03, 0xFC, 0xF0, 0x00, 0x0F, 0xF1, 0xE0, 0x00, 0x3F, 0xC7, 0x80, 0x00,
  0xFF, 0x0F, 0x00, 0x03, 0xFC, 0x3C, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x3F,
  0xC1, 0xF0, 0x00, 0xFF, 0x03, 0xC0, 0x03, 0xFC, 0x07, 0x80, 0x0F, 0xF0,
  0x1E, 0x00, 0x3F, 0xC0, 0x3C, 0x00, 0xFF, 0x00, 0xF0, 0x03, 0xFC, 0x01,
  0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x0F, 0x00, 0xFF, 0x00, 0x3C,
  0x03, 0xFC, 0x00, 0x78, 0x0F, 0xF0, 0x01, 0xF0, 0x3F, 0xC0, 0x03, 0xC0,
  0xFF, 0x00, 0x07, 0x83, 0xFC, 0x00, 0x1E, 0x0F, 0xF0, 0x00, 0x3C, 0x3F,
  0xC0, 0x00, 0xF0, 0xFF, 0x00, 0x01, 0xE3, 0xFC, 0x00, 0x07, 0x8F, 0xF0,
  0x00, 0x0F, 0x3F, 0xC0, 0x00, 0x3C, 0xFF, 0x00, 0x00, 0x7B, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0E,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xF0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x1F, 0xC3, 0xC0, 0x00, 0x1F, 0x8F, 0x00,
  0x00, 0x1F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x1F, 0xC3, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x1F, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x0F, 0x0F, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0C, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0xF0, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x7C,
  0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x7C,
  0x3C, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0,
  0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFC,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x7C, 0x00,
  0x00, 0x0F, 0x3E, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x1E, 0x1F, 0x80,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1E, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0x00, 0x0E, 0xF0, 0x00, 0xF0, 0x00, 0xEF, 0x00, 0x1F, 0x00, 0x1E,
  0xF0, 0x01, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0x00, 0x1E, 0x70, 0x01, 0xF8,
  0x01, 0xE7, 0x00, 0x1F, 0x80, 0x1E, 0x78, 0x03, 0xF8, 0x01, 0xC7, 0x80,
  0x3F, 0x80, 0x1C, 0x78, 0x03, 0xB8, 0x01, 0xC7, 0x80, 0x3B, 0xC0, 0x3C,
  0x78, 0x03, 0xBC, 0x03, 0xC3, 0x80, 0x79, 0xC0, 0x3C, 0x38, 0x07, 0x9C,
  0x03, 0xC3, 0xC0, 0x71, 0xC0, 0x38, 0x3C, 0x07, 0x1C, 0x03, 0x83, 0xC0,
  0x71, 0xE0, 0x38, 0x3C, 0x07, 0x0E, 0x07, 0x83, 0xC0, 0xF0, 0xE0, 0x78,
  0x1C, 0x0F, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0xE0, 0x78, 0x1C, 0x0E, 0x0F,
  0x07, 0x01, 0xE0, 0xE0, 0xF0, 0x70, 0x1E, 0x1E, 0x07, 0x07, 0x01, 0xE1,
  0xE0, 0x70, 0xF0, 0x1E, 0x1C, 0x07, 0x0F, 0x00, 0xE1, 0xC0, 0x78, 0xF0,
  0x0E, 0x1C, 0x07, 0x8F, 0x00, 0xE3, 0xC0, 0x38, 0xE0, 0x0F, 0x3C, 0x03,
  0x8E, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0x0F, 0x38, 0x03, 0x8E, 0x00, 0xF3,
  0x80, 0x3D, 0xE0, 0x07, 0x38, 0x03, 0xDE, 0x00, 0x77, 0x80, 0x1D, 0xE0,
  0x07, 0x78, 0x01, 0xDC, 0x00, 0x7F, 0x00, 0x1D, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE3, 0x80, 0x03, 0xC3, 0xC0, 0x03,
  0xC3, 0xC0, 0x03, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0xE0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E,
  0x00, 0x38, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x1F, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x01, 0xF8, 0x00,
  0xF8, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x83, 0xFF, 0xC0, 0x3C, 0x7F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x3F, 0x78, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x3F, 0xCF,
  0x80, 0x03, 0xDE, 0x3F, 0x00, 0xFC, 0xF1, 0xFF, 0xFF, 0xC7, 0x83, 0xFF,
  0xFC, 0x3E, 0x07, 0xFF, 0x81, 0xF0, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x3F, 0xC0, 0x0E, 0x0F, 0xFF, 0x00, 0xE3, 0xFF, 0xFC, 0x0E, 0x7F, 0x1F,
  0xE0, 0xEF, 0x80, 0x3F, 0x0F, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3E, 0xE0, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0x8F,
  0xE0, 0x01, 0xF0, 0xEF, 0x80, 0x7F, 0x0E, 0x7F, 0xFF, 0xE0, 0xE1, 0xFF,
  0xF8, 0x0E, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0x0F, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0x01, 0xE0, 0x1F,
  0xFE, 0x0F, 0x03, 0xFF, 0xFC, 0x78, 0x3F, 0xE7, 0xF3, 0xC3, 0xF0, 0x03,
  0xDE, 0x1F, 0x00, 0x0F, 0xF1, 0xF0, 0x00, 0x3F, 0x9F, 0x00, 0x00, 0xFC,
  0xF0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x3F, 0x87,
  0xC0, 0x03, 0xFC, 0x1F, 0x80, 0x7D, 0xE0, 0x7F, 0xFF, 0xCF, 0x01, 0xFF,
  0xFC, 0x78, 0x03, 0xFF, 0x83, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x10, 0x7C, 0x00,
  0x00, 0xC0, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x60, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFF, 0xC3, 0xC0, 0xFF, 0xFF, 0x1E, 0x0F, 0xF9, 0xFC,
  0xF0, 0xFC, 0x00, 0xF7, 0x87, 0xC0, 0x03, 0xFC, 0x7C, 0x00, 0x0F, 0xE7,
  0xC0, 0x00, 0x3F, 0x3C, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xFC, 0x7C,
  0x00, 0x0F, 0xE1, 0xF0, 0x00, 0xFF, 0x07, 0xE0, 0x1F, 0x78, 0x1F, 0xFF,
  0xF3, 0xC0, 0x7F, 0xFF, 0x1E, 0x00, 0xFF, 0xE0, 0xF0, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x82, 0x00, 0x00, 0x78, 0x38, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xC0, 0x3F, 0xC1, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x07, 0xF0, 0x0F, 0x03, 0xFF, 0xE0, 0xF0, 0xFF, 0xFF, 0x0F,
  0x1F, 0xC7, 0xF8, 0xF3, 0xE0, 0x0F, 0xCF, 0x78, 0x00, 0x3E, 0xF7, 0x00,
  0x01, 0xEF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x20, 0x0F, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x5E, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00,
  0xFC, 0x3C, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0xF0,
  0x0F, 0x80, 0x07, 0x80, 0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0xF8,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x78, 0xF8, 0x00, 0x03, 0xCF, 0xE0, 0x00,
  0x1E, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF9, 0xF0, 0x00, 0x3F,
  0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0xF8,
  0x07, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3E, 0x0F,
  0x00, 0x00, 0xF8, 0x78, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1F, 0x1E, 0x00,
  0x00, 0x7C, 0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07, 0xC0, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFE, 0x01, 0xFC, 0x38, 0xFF, 0xC1, 0xFF, 0x8F, 0x7F, 0xF8, 0xFF,
  0xF3, 0xFE, 0x7F, 0x7C, 0x7E, 0xFC, 0x03, 0xFC, 0x07, 0xBE, 0x00, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01,
  0xE0, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x1F, 0xC0,
  0x07, 0x80, 0x07, 0xF0, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x7F,
  0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x07, 0x80, 0x07, 0xF0, 0x01, 0xE0, 0x01,
  0xFC, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x07, 0x80,
  0x07, 0xF0, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x1E,
  0x00, 0x1F, 0xC0, 0x07, 0x80, 0x07, 0xF0, 0x01, 0xE0, 0x01, 0xFC, 0x00,
  0x78, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x07, 0x80, 0x07, 0xF0,
  0x01, 0xE0, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x1F,
  0xC0, 0x07, 0x80, 0x07, 0xF0, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0x78, 0x00,
  0x7F, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0xF0,
  0x0F, 0x03, 0xFF, 0xE0, 0xF0, 0xFF, 0xFF, 0x0F, 0x1F, 0xC7, 0xF8, 0xF3,
  0xE0, 0x0F, 0xCF, 0x78, 0x00, 0x3E, 0xF7, 0x00, 0x01, 0xEF, 0xE0, 0x00,
  0x1E, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x78, 0x3E,
  0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x03,
  0xF0, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0x83,
  0xFF, 0xC0, 0x3C, 0x7F, 0xFF, 0x81, 0xE7, 0xF3, 0xFE, 0x0F, 0x78, 0x01,
  0xF8, 0x7F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x7C,
  0xF8, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0x1E, 0x7E, 0x00, 0x01, 0xF3, 0xF8, 0x00, 0x1F, 0x1F,
  0xE0, 0x01, 0xF0, 0xF7, 0xC0, 0x3F, 0x07, 0x9F, 0xFF, 0xF8, 0x3C, 0x7F,
  0xFF, 0x01, 0xE0, 0xFF, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFF, 0xC3, 0xC0, 0xFF, 0xFF, 0x1E, 0x0F, 0xF1, 0xFC, 0xF0,
  0xFC, 0x00, 0xF7, 0x87, 0xC0, 0x03, 0xFC, 0x7C, 0x00, 0x0F, 0xE7, 0xC0,
  0x00, 0x3F, 0x3C, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x0F, 0xE1, 0xF0, 0x00, 0xFF, 0x07, 0xE0, 0x1F, 0x78, 0x1F, 0xFF, 0xF3,
  0xC0, 0x7F, 0xFF, 0x1E, 0x00, 0xFF, 0xE0, 0xF0, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F,
  0x00, 0x1E, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0x01, 0xF8, 0x00,
  0xFC, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x03, 0xC7,
  0xE0, 0x00, 0x7C, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x1F, 0x3C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7F, 0x1F, 0x00, 0x0E,
  0xF1, 0xF8, 0x03, 0xEF, 0x0F, 0xFF, 0xFC, 0xF0, 0x7F, 0xFF, 0x0F, 0x01,
  0xFF, 0xE0, 0xF0, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x7F, 0x80, 0x07, 0x80, 0x03, 0x9C, 0x00, 0x3C, 0x00,
  0x3C, 0xE0, 0x01, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x80, 0x0F, 0x3C, 0x00,
  0xFC, 0x00, 0x70, 0xE0, 0x07, 0x60, 0x03, 0x87, 0x00, 0x3B, 0x80, 0x3C,
  0x3C, 0x01, 0xDC, 0x01, 0xE1, 0xE0, 0x1C, 0xE0, 0x0E, 0x0F, 0x00, 0xE7,
  0x00, 0x70, 0x38, 0x07, 0x3C, 0x03, 0x81, 0xC0, 0x38, 0xE0, 0x3C, 0x0F,
  0x03, 0xC7, 0x01, 0xE0, 0x78, 0x1C, 0x38, 0x0E, 0x01, 0xC0, 0xE0, 0xE0,
  0x70, 0x0E, 0x07, 0x07, 0x03, 0x80, 0x70, 0x78, 0x38, 0x3C, 0x03, 0xC3,
  0x81, 0xC1, 0xC0, 0x1E, 0x1C, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x38, 0x70,
  0x03, 0x8F, 0x01, 0xC3, 0x80, 0x1C, 0x70, 0x0E, 0x3C, 0x00, 0xF3, 0x80,
  0x39, 0xC0, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x0E, 0x70, 0x00,
  0xEE, 0x00, 0x73, 0x80, 0x07, 0x70, 0x01, 0xF8, 0x00, 0x3B, 0x80, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01,
  0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0x7C,
  0x1E, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE0,
  0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x06, 0x1F, 0xFF, 0x00, 0x00, 0x73, 0xFF, 0xFC, 0x00,
  0x07, 0x3C, 0x07, 0xE0, 0x00, 0xF7, 0x80, 0x3F, 0x00, 0x0F, 0x70, 0x00,
  0xF8, 0x01, 0xEF, 0x00, 0x07, 0xE0, 0x3E, 0xE0, 0x00, 0x3F, 0x8F, 0xCE,
  0x00, 0x01, 0xFF, 0xF8, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0,
};

const GFXglyph RobotoMono_Light67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 5, 48, 40, 17, -48 },
  { 31, 14, 14, 40, 13, -50 },
  { 56, 37, 48, 40, 2, -48 },
  { 278, 29, 62, 40, 6, -55 },
  { 503, 38, 49, 40, 1, -48 },
  { 736, 35, 49, 40, 4, -48 },
  { 951, 4, 14, 40, 17, -50 },
  { 958, 16, 68, 40, 12, -53 },
  { 1094, 16, 68, 40, 11, -53 },
  { 1230, 30, 29, 40, 6, -48 },
  { 1339, 33, 34, 40, 4, -39 },
  { 1480, 7, 16, 40, 13, -6 },
  { 1494, 24, 3, 40, 8, -23 },
  { 1503, 6, 6, 40, 18, -6 },
  { 1508, 24, 52, 40, 9, -48 },
  { 1664, 30, 49, 40, 5, -48 },
  { 1848, 17, 48, 40, 7, -48 },
  { 1950, 31, 48, 40, 3, -48 },
  { 2136, 30, 49, 40, 3, -48 },
  { 2320, 34, 48, 40, 3, -48 },
  { 2524, 29, 49, 40, 7, -48 },
  { 2702, 29, 49, 40, 5, -48 },
  { 2880, 31, 48, 40, 4, -48 },
  { 3066, 30, 49, 40, 6, -48 },
  { 3250, 30, 48, 40, 5, -48 },
  { 3430, 6, 35, 40, 20, -35 },
  { 3457, 9, 45, 40, 17, -35 },
  { 3508, 28, 28, 40, 5, -35 },
  { 3606, 29, 17, 40, 6, -30 },
  { 3668, 29, 28, 40, 6, -36 },
  { 3770, 27, 48, 40, 7, -48 },
  { 3932, 36, 48, 40, 2, -48 },
  { 4148, 35, 48, 40, 3, -48 },
  { 4358, 30, 48, 40, 6, -48 },
  { 4538, 32, 49, 40, 4, -48 },
  { 4734, 31, 48, 40, 6, -48 },
  { 4920, 28, 48, 40, 7, -48 },
  { 5088, 28, 48, 40, 7, -48 },
  { 5256, 32, 49, 40, 4, -48 },
  { 5452, 30, 48, 40, 5, -48 },
  { 5632, 28, 48, 40, 6, -48 },
  { 5800, 30, 49, 40, 4, -48 },
  { 5984, 32, 48, 40, 7, -48 },
  { 6176, 28, 48, 40, 7, -48 },
  { 6344, 30, 48, 40, 5, -48 },
  { 6524, 30, 48, 40, 5, -48 },
  { 6704, 32, 49, 40, 4, -48 },
  { 6900, 30, 48, 40, 7, -48 },
  { 7080, 34, 56, 40, 3, -48 },
  { 7318, 30, 48, 40, 7, -48 },
  { 7498, 32, 49, 40, 4, -48 },
  { 7694, 34, 48, 40, 3, -48 },
  { 7898, 30, 49, 40, 5, -48 },
  { 8082, 34, 48, 40, 3, -48 },
  { 8286, 36, 48, 40, 3, -48 },
  { 8502, 34, 48, 40, 4, -48 },
  { 8706, 35, 48, 40, 2, -48 },
  { 8916, 31, 48, 40, 4, -48 },
  { 9102, 11, 64, 40, 15, -54 },
  { 9190, 24, 52, 40, 8, -48 },
  { 9346, 11, 64, 40, 14, -54 },
  { 9434, 24, 26, 40, 8, -48 },
  { 9512, 29, 3, 40, 6, 0 },
  { 9523, 10, 9, 40, 15, -49 },
  { 9535, 29, 37, 40, 6, -36 },
  { 9670, 28, 51, 40, 7, -50 },
  { 9849, 30, 37, 40, 5, -36 },
  { 9988, 29, 51, 40, 5, -50 },
  { 10173, 30, 37, 40, 5, -36 },
  { 10312, 31, 51, 40, 6, -51 },
  { 10510, 29, 50, 40, 5, -36 },
  { 10692, 28, 50, 40, 6, -50 },
  { 10867, 29, 48, 40, 7, -48 },
  { 11041, 21, 62, 40, 6, -48 },
  { 11204, 29, 50, 40, 7, -50 },
  { 11386, 29, 50, 40, 7, -50 },
  { 11568, 34, 36, 40, 3, -36 },
  { 11721, 28, 36, 40, 6, -36 },
  { 11847, 32, 37, 40, 4, -36 },
  { 11995, 29, 50, 40, 6, -36 },
  { 12177, 29, 50, 40, 5, -36 },
  { 12359, 23, 36, 40, 12, -36 },
  { 12463, 29, 37, 40, 6, -36 },
  { 12598, 28, 45, 40, 6, -44 },
  { 12756, 28, 36, 40, 6, -35 },
  { 12882, 34, 35, 40, 3, -35 },
  { 13031, 37, 35, 40, 2, -35 },
  { 13193, 33, 35, 40, 4, -35 },
  { 13338, 36, 49, 40, 2, -35 },
  { 13559, 31, 35, 40, 5, -35 },
  { 13695, 22, 65, 40, 11, -52 },
  { 13874, 4, 59, 40, 18, -48 },
  { 13904, 22, 65, 40, 11, -52 },
  { 14083, 36, 12, 40, 2, -26 },
};

const GFXfont RobotoMono_Light67pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light67pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light67pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _ROBOTOMONO_LIGHT67PT7B_H_
