#ifndef _ROBOTOMONO_LIGHT33PT7B_H_
#define _ROBOTOMONO_LIGHT33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light33pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x00, 0x05, 0xF8, 0x46, 0x8D,
  0x1A, 0x34, 0x68, 0xD1, 0x80, 0x01, 0x83, 0x00, 0x60, 0x80, 0x10, 0x60,
  0x04, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0x02,
  0x0C, 0x01, 0x83, 0x00, 0x60, 0x80, 0x18, 0x20, 0x04, 0x18, 0x01, 0x06,
  0x00, 0xC1, 0x83, 0xFF, 0xFE, 0x0C, 0x10, 0x02, 0x04, 0x00, 0x83, 0x00,
  0x20, 0xC0, 0x18, 0x30, 0x06, 0x08, 0x01, 0x86, 0x00, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x01, 0xF0, 0x1F, 0xF0, 0xE0, 0xE7, 0x01, 0x98, 0x03, 0x60,
  0x0D, 0x80, 0x36, 0x00, 0x18, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xD8, 0x03, 0x70, 0x18, 0xFB, 0xE1, 0xFE, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x0C, 0x20, 0x02, 0x0C, 0x10, 0x83,
  0x0C, 0x20, 0xC2, 0x08, 0x31, 0x82, 0x0C, 0x40, 0xC2, 0x30, 0x1F, 0x88,
  0x03, 0x86, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0xF0,
  0x0C, 0x66, 0x02, 0x30, 0xC1, 0x88, 0x30, 0x42, 0x0C, 0x30, 0x83, 0x08,
  0x20, 0xC0, 0x0C, 0x30, 0x01, 0x98, 0x00, 0x3C, 0x03, 0x80, 0x07, 0xF0,
  0x07, 0x1C, 0x03, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x30,
  0xC0, 0x18, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x01,
  0xDC, 0x09, 0xC7, 0x0C, 0xC1, 0x86, 0xC0, 0x63, 0x60, 0x19, 0xB0, 0x0F,
  0x98, 0x03, 0xC6, 0x00, 0xC3, 0x80, 0xF0, 0xF3, 0xCC, 0x3F, 0x87, 0xFF,
  0xFC, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x10, 0x30, 0x30, 0x60, 0x60, 0x60,
  0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60,
  0x60, 0x60, 0x20, 0x30, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x81,
  0x81, 0x81, 0x83, 0x03, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x20, 0xC1,
  0x06, 0x18, 0x60, 0x81, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x0C, 0x10, 0xDF, 0x27, 0xC7, 0xFC, 0x01, 0xC0, 0x07, 0x80, 0x09, 0x80,
  0x31, 0x80, 0xC1, 0x83, 0x03, 0x82, 0x02, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x33, 0x33, 0x66, 0xC4, 0xFF, 0xF0,
  0xFF, 0x80, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x7F, 0x83, 0x07, 0x18, 0x06, 0x40,
  0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xBC, 0x0C, 0xF0,
  0x63, 0xC3, 0x0F, 0x18, 0x3D, 0xC0, 0xFE, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x60, 0x19, 0xC0, 0xE3, 0xCF, 0x07, 0xF0, 0x07, 0x1F,
  0xFB, 0xE3, 0x83, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x00, 0x3F,
  0xC1, 0xC1, 0xC3, 0x00, 0xCC, 0x01, 0x98, 0x01, 0xB0, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x7F, 0x87, 0x03, 0x18,
  0x06, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x07, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x80, 0x63, 0xCF, 0x07, 0xF8,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0D, 0x80, 0x0C,
  0xC0, 0x06, 0x60, 0x06, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x03, 0x06, 0x03,
  0x03, 0x01, 0x81, 0x81, 0x80, 0xC1, 0x80, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x3F, 0xFC, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x67, 0xC0, 0xFF, 0xE1, 0xC1, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0D, 0x80, 0x19, 0x80,
  0x33, 0x00, 0xE3, 0x03, 0x83, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x30, 0x07,
  0xE0, 0x1E, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xCF, 0xE1, 0x71, 0xE3, 0x80, 0xEE, 0x00, 0xDC, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x63, 0x00,
  0xC7, 0x03, 0x07, 0x9E, 0x03, 0xF0, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x3F, 0xE0, 0xE0, 0xE3, 0x00, 0xC6, 0x00, 0xC8,
  0x01, 0xB0, 0x03, 0x20, 0x06, 0x60, 0x0C, 0xC0, 0x30, 0xE0, 0xE0, 0xFF,
  0x01, 0xFE, 0x06, 0x07, 0x18, 0x03, 0x60, 0x06, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0xCE, 0x03, 0x8F, 0x3E, 0x0F, 0xF0, 0x07,
  0x80, 0x7F, 0x83, 0x07, 0x18, 0x0E, 0xC0, 0x1B, 0x00, 0x6C, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x1D, 0x80, 0xF3,
  0x9E, 0xC7, 0xF3, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x70,
  0x03, 0x81, 0xF8, 0x07, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x31, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x31, 0x8C,
  0xC6, 0x60, 0x00, 0x18, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x03,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x78, 0x07, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0x03, 0x00, 0x00, 0x0F, 0x01, 0xFE, 0x1C, 0x19, 0x80, 0x6C,
  0x03, 0x60, 0x08, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xFF,
  0x00, 0xE0, 0x60, 0x60, 0x0C, 0x30, 0x01, 0x8C, 0x18, 0x66, 0x1F, 0x89,
  0x0C, 0x23, 0x42, 0x18, 0xF1, 0x86, 0x3C, 0x41, 0x8F, 0x10, 0x43, 0x84,
  0x10, 0xE1, 0x04, 0x38, 0x41, 0x0B, 0x10, 0xC2, 0xC4, 0x31, 0xB1, 0xB6,
  0x44, 0x38, 0xE1, 0x80, 0x00, 0x20, 0x00, 0x0E, 0x00, 0x01, 0xE1, 0xC0,
  0x1F, 0xC0, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x26,
  0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03,
  0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0xC0, 0x30, 0x7F, 0xF8,
  0x30, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x4C, 0x00, 0x36, 0x00,
  0x1B, 0x00, 0x0E, 0xFF, 0xE1, 0x81, 0xE3, 0x00, 0x66, 0x00, 0xEC, 0x00,
  0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x19, 0x80, 0xE3, 0xFF, 0x87,
  0xFF, 0x8C, 0x01, 0x98, 0x01, 0xB0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x6C, 0x01, 0x9F, 0xFE, 0x3F, 0xF0, 0x00, 0x03,
  0xC0, 0x0F, 0xF0, 0x1C, 0x1C, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x60,
  0x06, 0x60, 0x06, 0x30, 0x0E, 0x38, 0x0C, 0x1E, 0x78, 0x07, 0xF0, 0xFF,
  0xC1, 0x81, 0xC3, 0x00, 0xC6, 0x00, 0xCC, 0x00, 0xD8, 0x01, 0xB0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x76, 0x01,
  0xCC, 0x07, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0F, 0xFF, 0xBF, 0xFE, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x1C, 0x1C, 0x30,
  0x0C, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x30, 0x03, 0x38,
  0x06, 0x1F, 0x3C, 0x07, 0xF0, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0xFF, 0xFC,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x0D, 0x80,
  0x1B, 0x00, 0x33, 0x00, 0xE7, 0x03, 0x87, 0x9E, 0x07, 0xF8, 0x00, 0xC0,
  0x0E, 0xC0, 0x1C, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0xC0, 0xC1,
  0x80, 0xC3, 0x80, 0xC7, 0x00, 0xCE, 0x00, 0xCE, 0x00, 0xDF, 0x00, 0xF3,
  0x00, 0xE1, 0x80, 0xC1, 0xC0, 0xC0, 0xE0, 0xC0, 0x60, 0xC0, 0x30, 0xC0,
  0x38, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x07, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xEC, 0x0D, 0xB0, 0x37, 0x40, 0x9D, 0x86, 0x76,
  0x19, 0xC8, 0x47, 0x33, 0x1C, 0xCC, 0x71, 0x61, 0xC7, 0x87, 0x1C, 0x1C,
  0x30, 0x70, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x40, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x60, 0x3D, 0x80, 0xF3, 0x03, 0xCC, 0x0F, 0x18, 0x3C, 0x70, 0xF0,
  0xC3, 0xC1, 0x8F, 0x06, 0x3C, 0x0C, 0xF0, 0x33, 0xC0, 0x6F, 0x01, 0xBC,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xC0, 0x03, 0x80, 0x0F,
  0xF0, 0x1C, 0x38, 0x30, 0x0C, 0x60, 0x0C, 0x60, 0x06, 0x60, 0x06, 0xC0,
  0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x30, 0x0C, 0x38, 0x1C, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xF1, 0x80,
  0xF3, 0x00, 0x36, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x76, 0x03, 0xCF, 0xFF, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x1C, 0x38, 0x30,
  0x0C, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x70, 0x0C, 0x38,
  0x1C, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x02, 0xFF, 0xE1, 0x80, 0xE3, 0x00, 0x66, 0x00, 0x6C, 0x00, 0xD8, 0x01,
  0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x3B, 0x00, 0xE6, 0x0F, 0x8F,
  0xFC, 0x18, 0x18, 0x30, 0x18, 0x60, 0x30, 0xC0, 0x31, 0x80, 0x63, 0x00,
  0x66, 0x00, 0xCC, 0x00, 0xD8, 0x01, 0xB0, 0x01, 0x80, 0x03, 0xC0, 0x0F,
  0xF8, 0x3C, 0x1C, 0x30, 0x0E, 0x60, 0x06, 0x60, 0x07, 0x60, 0x03, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60,
  0x03, 0x60, 0x06, 0x30, 0x0E, 0x1F, 0x7C, 0x0F, 0xF0, 0xFF, 0xFF, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xD8, 0x06, 0x70, 0x38, 0xF3, 0xC1, 0xFC, 0x00,
  0xE0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80,
  0x30, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01,
  0x83, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x18, 0x40, 0x04, 0x60, 0x03, 0x30,
  0x01, 0x98, 0x00, 0xD8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0xC0, 0xC0, 0xD0, 0x30, 0x36, 0x0E, 0x0D, 0x83, 0x82, 0x61, 0xE0,
  0x98, 0x68, 0x66, 0x1A, 0x19, 0x84, 0xC6, 0x21, 0x31, 0x8C, 0xCC, 0x63,
  0x33, 0x10, 0xCC, 0x44, 0x33, 0x13, 0x0C, 0x86, 0xC3, 0x21, 0xB0, 0x58,
  0x6C, 0x16, 0x0B, 0x07, 0x82, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x80, 0xC0, 0x60, 0xE0, 0x07, 0x30, 0x03, 0x0C, 0x03, 0x87,
  0x01, 0x81, 0x81, 0x80, 0x60, 0xC0, 0x30, 0xC0, 0x0C, 0xE0, 0x07, 0x60,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x19,
  0x80, 0x18, 0x60, 0x0C, 0x38, 0x0C, 0x0C, 0x0E, 0x03, 0x06, 0x01, 0x86,
  0x00, 0x63, 0x00, 0x3B, 0x00, 0x0E, 0xE0, 0x03, 0xB0, 0x01, 0x8C, 0x01,
  0xC6, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x30, 0x06,
  0x18, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x6C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0xFF, 0xFE, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0F, 0xFF, 0xC0, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x06, 0x00, 0x30, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x3F, 0xFF, 0x06, 0x00, 0xE0, 0x0F, 0x00, 0xB0, 0x19,
  0x81, 0x98, 0x30, 0xC3, 0x0C, 0x60, 0xC6, 0x06, 0x60, 0x6C, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE1, 0x8C, 0x30, 0x07, 0x80, 0xFF, 0x87, 0x03, 0x18,
  0x06, 0xC0, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x1F, 0xFC, 0xF0, 0x36,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0x79, 0xEC,
  0xFE, 0x30, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x31, 0xE0, 0xCF, 0xE3, 0xE1, 0xCE, 0x01, 0xB8, 0x06, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x6F, 0x03, 0xB7, 0x3C, 0xCF, 0xE0, 0x07, 0x80,
  0x7F, 0x83, 0x83, 0x98, 0x06, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x36, 0x00,
  0xDC, 0x06, 0x3C, 0xF0, 0x3F, 0x80, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC1, 0xC3, 0x1F, 0xCC, 0xE1, 0xB6,
  0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x80, 0x77, 0x03, 0xCF, 0x3B,
  0x1F, 0xCC, 0x03, 0xC0, 0x1F, 0xE0, 0x70, 0x61, 0x80, 0x67, 0x00, 0x6C,
  0x00, 0xD8, 0x01, 0xA0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x01, 0x1C, 0x07, 0x1E, 0x3C, 0x0F, 0xE0,
  0x00, 0xFE, 0x07, 0xCC, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0xFF, 0xFC, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x7F, 0x33, 0x86, 0xD8, 0x0F, 0xE0, 0x1F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x36,
  0x01, 0xDC, 0x0F, 0x3C, 0xEC, 0x7F, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x19,
  0x00, 0x67, 0x07, 0x0F, 0xF8, 0x0F, 0x80, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0xE0, 0xCF, 0xF3, 0x60,
  0xEF, 0x01, 0xB8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0C, 0x02, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x80, 0x70,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x03, 0xBF, 0xCF, 0xC0,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x02, 0xC0, 0x19, 0x80, 0xE3, 0x03, 0x86, 0x0E, 0x0C, 0x38,
  0x18, 0xE0, 0x33, 0x80, 0x6F, 0x00, 0xFF, 0x01, 0xC7, 0x03, 0x06, 0x06,
  0x06, 0x0C, 0x06, 0x18, 0x0E, 0x30, 0x0E, 0x60, 0x0E, 0xC0, 0x0E, 0xFF,
  0x03, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0x0E, 0x6F, 0xDF, 0xBC,
  0x78, 0x7C, 0x18, 0x3C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x81, 0x81,
  0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06,
  0x07, 0x03, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x40, 0x03, 0x83,
  0x3F, 0xCD, 0x83, 0xBC, 0x06, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0F, 0xF0, 0x38, 0x38,
  0x30, 0x0C, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xE0, 0x06, 0x60, 0x06, 0x70, 0x0C,
  0x38, 0x1C, 0x1C, 0x78, 0x0F, 0xE0, 0x07, 0x83, 0x7F, 0x8F, 0x87, 0x38,
  0x0E, 0xC0, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7E, 0x01, 0xB8, 0x0E, 0xDC, 0xF3,
  0x3F, 0x8C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x7F, 0x33, 0x06, 0xD8, 0x07, 0xE0, 0x1F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x36, 0x01, 0xDC, 0x0F, 0x3C, 0xEC, 0x7F, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x03, 0xF9,
  0xFF, 0x70, 0x78, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x07,
  0x80, 0x7F, 0xC3, 0x03, 0x98, 0x07, 0x60, 0x0D, 0x80, 0x06, 0x00, 0x0E,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0xD8, 0x07, 0x3C, 0x78, 0x7F, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x03, 0xFF, 0xE0, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x8C, 0x07, 0xF0, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x80, 0x76, 0x03,
  0xCF, 0x7B, 0x1F, 0xCC, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0C,
  0x30, 0x0C, 0x30, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x0C, 0x30,
  0x0C, 0x20, 0x06, 0x60, 0x06, 0x60, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x01, 0x80, 0xC0, 0xC0, 0xF0, 0x30, 0x34, 0x0C, 0x09, 0x87, 0x86, 0x61,
  0xE1, 0x98, 0x48, 0x62, 0x12, 0x10, 0x8C, 0xC4, 0x33, 0x33, 0x0C, 0x84,
  0xC3, 0x21, 0x30, 0x58, 0x68, 0x16, 0x1A, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x30, 0x30, 0x0C, 0x0C, 0x00, 0xE0, 0x07, 0x30, 0x0C, 0x18, 0x1C, 0x1C,
  0x38, 0x0C, 0x30, 0x06, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x06, 0x60, 0x0E, 0x30, 0x0C, 0x38, 0x18, 0x18, 0x30, 0x0C, 0x70,
  0x06, 0xE0, 0x07, 0xE0, 0x01, 0xD8, 0x00, 0xE3, 0x00, 0x30, 0xC0, 0x0C,
  0x38, 0x06, 0x06, 0x01, 0x81, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x01,
  0x86, 0x00, 0x61, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x1C, 0x06, 0x01,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x03, 0xC0, 0xE0, 0x07, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x07, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x40, 0x1E, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0F, 0x00, 0xE0,
  0x78, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x07, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x1F, 0xC0, 0x36, 0x38, 0x0F, 0x03, 0x86, 0xC0, 0x7F, 0xA0, 0x07, 0xC0,
};

const GFXglyph RobotoMono_Light33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 3, 23, 20, 8, -23 },
  { 10, 7, 7, 20, 6, -25 },
  { 17, 18, 23, 20, 1, -23 },
  { 69, 14, 30, 20, 3, -27 },
  { 122, 18, 24, 20, 1, -24 },
  { 176, 17, 24, 20, 2, -24 },
  { 227, 2, 7, 20, 8, -25 },
  { 229, 8, 34, 20, 6, -26 },
  { 263, 7, 34, 20, 6, -26 },
  { 293, 15, 14, 20, 3, -23 },
  { 320, 16, 17, 20, 2, -19 },
  { 354, 4, 8, 20, 6, -3 },
  { 358, 12, 1, 20, 4, -11 },
  { 360, 3, 3, 20, 9, -3 },
  { 362, 12, 25, 20, 4, -23 },
  { 400, 14, 24, 20, 3, -24 },
  { 442, 8, 23, 20, 4, -23 },
  { 465, 15, 24, 20, 2, -24 },
  { 510, 14, 24, 20, 2, -24 },
  { 552, 17, 23, 20, 1, -23 },
  { 601, 15, 23, 20, 3, -23 },
  { 645, 15, 24, 20, 2, -24 },
  { 690, 15, 23, 20, 2, -23 },
  { 734, 15, 24, 20, 3, -24 },
  { 779, 14, 24, 20, 3, -24 },
  { 821, 3, 17, 20, 10, -17 },
  { 828, 5, 22, 20, 8, -17 },
  { 842, 13, 13, 20, 3, -17 },
  { 864, 14, 9, 20, 3, -15 },
  { 880, 14, 14, 20, 3, -18 },
  { 905, 13, 24, 20, 4, -24 },
  { 944, 18, 24, 20, 1, -24 },
  { 998, 17, 23, 20, 2, -23 },
  { 1047, 15, 23, 20, 3, -23 },
  { 1091, 16, 24, 20, 2, -24 },
  { 1139, 15, 23, 20, 3, -23 },
  { 1183, 14, 23, 20, 3, -23 },
  { 1224, 14, 23, 20, 3, -23 },
  { 1265, 16, 24, 20, 2, -24 },
  { 1313, 14, 23, 20, 3, -23 },
  { 1354, 14, 23, 20, 3, -23 },
  { 1395, 15, 23, 20, 2, -23 },
  { 1439, 16, 23, 20, 3, -23 },
  { 1485, 13, 23, 20, 4, -23 },
  { 1523, 14, 23, 20, 3, -23 },
  { 1564, 14, 23, 20, 3, -23 },
  { 1605, 16, 24, 20, 2, -24 },
  { 1653, 15, 23, 20, 3, -23 },
  { 1697, 16, 28, 20, 2, -24 },
  { 1753, 15, 23, 20, 3, -23 },
  { 1797, 16, 24, 20, 2, -24 },
  { 1845, 16, 23, 20, 2, -23 },
  { 1891, 14, 23, 20, 3, -23 },
  { 1932, 17, 23, 20, 1, -23 },
  { 1981, 18, 23, 20, 1, -23 },
  { 2033, 17, 23, 20, 2, -23 },
  { 2082, 17, 23, 20, 1, -23 },
  { 2131, 15, 23, 20, 2, -23 },
  { 2175, 6, 32, 20, 7, -27 },
  { 2199, 12, 25, 20, 4, -23 },
  { 2237, 6, 32, 20, 7, -27 },
  { 2261, 12, 12, 20, 4, -23 },
  { 2279, 14, 2, 20, 3, 0 },
  { 2283, 5, 4, 20, 7, -24 },
  { 2286, 14, 18, 20, 3, -18 },
  { 2318, 14, 25, 20, 3, -25 },
  { 2362, 14, 18, 20, 3, -18 },
  { 2394, 14, 25, 20, 3, -25 },
  { 2438, 15, 18, 20, 2, -18 },
  { 2472, 15, 25, 20, 3, -25 },
  { 2519, 14, 25, 20, 3, -18 },
  { 2563, 14, 25, 20, 3, -25 },
  { 2607, 14, 24, 20, 4, -24 },
  { 2649, 10, 31, 20, 3, -24 },
  { 2688, 15, 25, 20, 3, -25 },
  { 2735, 14, 25, 20, 4, -25 },
  { 2779, 17, 18, 20, 1, -18 },
  { 2818, 14, 18, 20, 3, -18 },
  { 2850, 16, 18, 20, 2, -18 },
  { 2886, 14, 25, 20, 3, -18 },
  { 2930, 14, 25, 20, 3, -18 },
  { 2974, 11, 18, 20, 6, -18 },
  { 2999, 14, 18, 20, 3, -18 },
  { 3031, 14, 22, 20, 3, -22 },
  { 3070, 14, 17, 20, 3, -17 },
  { 3100, 16, 17, 20, 2, -17 },
  { 3134, 18, 17, 20, 1, -17 },
  { 3173, 16, 17, 20, 2, -17 },
  { 3207, 18, 24, 20, 1, -17 },
  { 3261, 16, 17, 20, 2, -17 },
  { 3295, 11, 33, 20, 5, -26 },
  { 3341, 2, 28, 20, 9, -23 },
  { 3348, 11, 33, 20, 5, -26 },
  { 3394, 18, 6, 20, 1, -13 },
};

const GFXfont RobotoMono_Light33pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light33pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _ROBOTOMONO_LIGHT33PT7B_H_
