#ifndef _ROBOTOMONO_LIGHT39PT7B_H_
#define _ROBOTOMONO_LIGHT39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light39pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x00, 0x1F, 0xF0,
  0xC3, 0xC2, 0xC2, 0xC2, 0xC2, 0xC6, 0x86, 0x86, 0x00, 0x60, 0x60, 0x02,
  0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60,
  0x02, 0x06, 0x00, 0x30, 0x30, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x60,
  0x60, 0x03, 0x02, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00,
  0x60, 0x60, 0x03, 0x02, 0x00, 0x10, 0x30, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xE0, 0x60, 0x60, 0x03, 0x03, 0x00, 0x10, 0x30, 0x01, 0x81, 0x80, 0x0C,
  0x0C, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81,
  0xE0, 0xF0, 0xE0, 0x1C, 0x30, 0x03, 0x8C, 0x00, 0x67, 0x00, 0x19, 0xC0,
  0x06, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x06, 0xE0, 0x01, 0xF8, 0x00, 0x76, 0x00, 0x19, 0xC0,
  0x06, 0x70, 0x03, 0x8F, 0x01, 0xC1, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00,
  0x06, 0x18, 0x00, 0x30, 0x60, 0x40, 0xC0, 0x81, 0x83, 0x03, 0x0C, 0x0C,
  0x0C, 0x30, 0x30, 0x21, 0x80, 0xC1, 0x86, 0x03, 0x06, 0x30, 0x07, 0x30,
  0xC0, 0x0F, 0xC6, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC3, 0xE0, 0x03, 0x1F, 0xC0, 0x18, 0xE1, 0x80,
  0x63, 0x06, 0x03, 0x0C, 0x08, 0x0C, 0x30, 0x30, 0x60, 0xC0, 0xC3, 0x83,
  0x02, 0x04, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0x73, 0x00, 0x00, 0xF8,
  0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1C, 0x38, 0x01, 0x81, 0x80, 0x38, 0x1C,
  0x03, 0x01, 0xC0, 0x30, 0x18, 0x03, 0x81, 0x80, 0x38, 0x38, 0x01, 0x87,
  0x00, 0x1C, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x80, 0x03, 0x9C, 0x00, 0x70, 0xC0, 0x66, 0x06, 0x0E, 0xE0, 0x70, 0xCC,
  0x03, 0x8C, 0xC0, 0x1C, 0xCC, 0x00, 0xD8, 0xC0, 0x0F, 0x8C, 0x00, 0x70,
  0xE0, 0x07, 0x87, 0x01, 0xDC, 0x3F, 0xF8, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF,
  0x00, 0x80, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x30, 0x38, 0x18, 0x0C,
  0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x70,
  0x18, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x03, 0x80, 0xC0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x06,
  0x06, 0x03, 0x03, 0x03, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x10, 0x30, 0x27, 0x0C, 0x3F, 0xFB, 0x3F,
  0x0F, 0xFE, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0E, 0xC0, 0x03, 0x38, 0x01,
  0x87, 0x00, 0xE0, 0xE0, 0x70, 0x1C, 0x08, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x33, 0x33, 0x33,
  0x76, 0xE4, 0xFF, 0xFF, 0xFF, 0xF0, 0x27, 0xF7, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x00, 0x07, 0xF0, 0x07, 0xFE, 0x07, 0x03, 0x87, 0x00, 0xE7, 0x00, 0x33,
  0x00, 0x1D, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x03,
  0x78, 0x07, 0x3C, 0x07, 0x1E, 0x07, 0x0F, 0x07, 0x07, 0x87, 0x03, 0xC7,
  0x01, 0xE7, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1B, 0x00, 0x0D,
  0x80, 0x0E, 0xE0, 0x06, 0x30, 0x07, 0x1C, 0x07, 0x07, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x40, 0x70, 0xFC, 0xFB, 0xF8, 0xF0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x07, 0xF0, 0x07, 0xFF, 0x03, 0x81, 0xE1, 0xC0, 0x18, 0x60, 0x07, 0x38,
  0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0x03, 0x8E, 0x00, 0xE6,
  0x00, 0x33, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x07, 0x70, 0x03, 0x1C, 0x07, 0x87, 0xFF,
  0x81, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1B,
  0x00, 0x03, 0x60, 0x00, 0xCC, 0x00, 0x39, 0x80, 0x06, 0x30, 0x01, 0x86,
  0x00, 0x70, 0xC0, 0x0C, 0x18, 0x03, 0x03, 0x00, 0xE0, 0x60, 0x18, 0x0C,
  0x06, 0x01, 0x81, 0xC0, 0x30, 0x30, 0x06, 0x0C, 0x00, 0xC3, 0x80, 0x18,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x3F, 0xFF,
  0x1F, 0xFF, 0x8C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x78, 0x0D, 0xFF, 0x07,
  0xFF, 0xC3, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1C, 0xC0,
  0x0E, 0x70, 0x0F, 0x1E, 0x0F, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x78,
  0x00, 0xFC, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0xFC, 0x19, 0xFF, 0x8D,
  0xC0, 0xE7, 0x80, 0x3B, 0x80, 0x0D, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1D, 0x80, 0x0C, 0xE0,
  0x06, 0x30, 0x07, 0x1E, 0x07, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xC0, 0xF0,
  0xE0, 0x1C, 0x30, 0x03, 0x9C, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x60,
  0x01, 0x9C, 0x00, 0x63, 0x00, 0x38, 0x60, 0x1C, 0x0E, 0x1E, 0x01, 0xFE,
  0x00, 0xFF, 0xC0, 0x70, 0x3C, 0x30, 0x03, 0x9C, 0x00, 0x66, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x36, 0x00, 0x1D, 0x80, 0x07, 0x70,
  0x03, 0x8E, 0x01, 0xC1, 0xFF, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x0F, 0xFC,
  0x0F, 0x07, 0x06, 0x01, 0xC7, 0x00, 0x73, 0x00, 0x1B, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1B,
  0x00, 0x1D, 0xC0, 0x1E, 0x70, 0x1F, 0x3C, 0x1D, 0x87, 0xFC, 0xC1, 0xF8,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x7C, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0x27, 0xF7, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x7F, 0x70, 0x13, 0xDE, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x8C, 0x63, 0x19, 0xCE, 0x66, 0x10,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x70, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0x80, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xE0, 0x01, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x1F,
  0xF8, 0x38, 0x1C, 0x70, 0x0E, 0x60, 0x06, 0xE0, 0x06, 0xC0, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xE0,
  0x70, 0x1C, 0x00, 0xC1, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0xF0, 0x46,
  0x1F, 0xC3, 0x60, 0xC2, 0x1B, 0x0C, 0x10, 0xD0, 0xC0, 0x82, 0x86, 0x04,
  0x1C, 0x30, 0x60, 0xE1, 0x03, 0x07, 0x08, 0x18, 0x38, 0x40, 0xC3, 0xC6,
  0x06, 0x1E, 0x10, 0x30, 0xF0, 0x83, 0x85, 0x86, 0x3C, 0x64, 0x3F, 0x76,
  0x30, 0xF1, 0xE1, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x08, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x19, 0x80, 0x01, 0x98,
  0x00, 0x19, 0x80, 0x03, 0x1C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x60,
  0xE0, 0x06, 0x06, 0x00, 0x60, 0x60, 0x0E, 0x07, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x01, 0xC0, 0x38, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x38, 0x01, 0xC3,
  0x00, 0x0C, 0x30, 0x00, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0x66, 0x00, 0x06,
  0xE0, 0x00, 0x6C, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x30, 0x1F, 0x18,
  0x01, 0xCC, 0x00, 0x66, 0x00, 0x3B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03,
  0x60, 0x03, 0xB0, 0x01, 0x98, 0x01, 0xCC, 0x07, 0x87, 0xFF, 0x83, 0xFF,
  0xF1, 0x80, 0x1C, 0xC0, 0x07, 0x60, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x06, 0xC0, 0x07, 0x60, 0x0F,
  0x3F, 0xFF, 0x1F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x38, 0x1C,
  0x0E, 0x01, 0xC3, 0x80, 0x1C, 0x60, 0x01, 0x9C, 0x00, 0x33, 0x00, 0x07,
  0x60, 0x00, 0x6C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0E, 0xE0, 0x01, 0xCC, 0x00, 0x31,
  0xC0, 0x0E, 0x18, 0x01, 0x83, 0xC0, 0xE0, 0x3F, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xFC, 0x0E, 0x07, 0xC3, 0x80, 0x38, 0xE0, 0x07, 0x38,
  0x00, 0xCE, 0x00, 0x3B, 0x80, 0x06, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x6E, 0x00, 0x3B, 0x80, 0x1C, 0xE0, 0x0E, 0x38, 0x0F, 0x0F, 0xFF,
  0x83, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0,
  0x38, 0x1C, 0x0E, 0x01, 0xC3, 0x80, 0x1C, 0x60, 0x01, 0x9C, 0x00, 0x3B,
  0x00, 0x07, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xE0, 0x00, 0xCC,
  0x00, 0x19, 0xC0, 0x03, 0x1C, 0x00, 0xE1, 0xC0, 0x38, 0x1F, 0xFE, 0x01,
  0xFF, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x01, 0xB8, 0x00, 0x66,
  0x00, 0x19, 0x80, 0x0E, 0x70, 0x07, 0x0E, 0x03, 0x81, 0xFF, 0xC0, 0x1F,
  0xE0, 0xC0, 0x01, 0xD8, 0x00, 0x73, 0x00, 0x1C, 0x60, 0x07, 0x0C, 0x01,
  0xC1, 0x80, 0x70, 0x30, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0xE0, 0x18, 0x38,
  0x03, 0x0E, 0x00, 0x63, 0x80, 0x0C, 0xE0, 0x01, 0xBE, 0x00, 0x36, 0xE0,
  0x07, 0xCC, 0x00, 0xF1, 0xC0, 0x1C, 0x1C, 0x03, 0x01, 0xC0, 0x60, 0x38,
  0x0C, 0x03, 0x81, 0x80, 0x38, 0x30, 0x03, 0x86, 0x00, 0x70, 0xC0, 0x07,
  0x18, 0x00, 0x73, 0x00, 0x06, 0x60, 0x00, 0xF0, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x06, 0xF6, 0x01, 0xBD, 0x80, 0xCF,
  0x30, 0x33, 0xCC, 0x0C, 0xF3, 0x06, 0x7C, 0x61, 0x9F, 0x18, 0xE7, 0xC6,
  0x31, 0xF0, 0xCC, 0x7C, 0x36, 0x1F, 0x0F, 0x87, 0xC1, 0xE1, 0xF0, 0x70,
  0x7C, 0x0C, 0x1F, 0x02, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1E, 0xC0, 0x0F,
  0x70, 0x07, 0x98, 0x03, 0xCE, 0x01, 0xE3, 0x00, 0xF0, 0xC0, 0x78, 0x70,
  0x3C, 0x18, 0x1E, 0x0E, 0x0F, 0x03, 0x07, 0x81, 0xC3, 0xC0, 0x61, 0xE0,
  0x38, 0xF0, 0x0C, 0x78, 0x07, 0x3C, 0x01, 0x9E, 0x00, 0x6F, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x30, 0x01,
  0xF8, 0x00, 0xFF, 0xC0, 0x38, 0x3C, 0x0E, 0x01, 0xC3, 0x80, 0x18, 0x60,
  0x03, 0x9C, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xEC, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x76, 0x00,
  0x0C, 0xE0, 0x01, 0x8C, 0x00, 0x71, 0xC0, 0x0C, 0x18, 0x03, 0x83, 0xC0,
  0xE0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x0C, 0x03,
  0xE3, 0x00, 0x1C, 0xC0, 0x03, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03, 0xB0,
  0x01, 0xCC, 0x07, 0xE3, 0xFF, 0xE0, 0xFF, 0xC0, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0xC0, 0x38, 0x3C, 0x0E, 0x01, 0xC3, 0x80, 0x18, 0x60, 0x01, 0x98,
  0x00, 0x33, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x36, 0x00, 0x06, 0xC0,
  0x01, 0xDC, 0x00, 0x31, 0x80, 0x0E, 0x18, 0x03, 0x83, 0xC0, 0xE0, 0x3F,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x40, 0xFF, 0xC0, 0x7F, 0xFC, 0x30, 0x1F, 0x18, 0x01,
  0xCC, 0x00, 0x76, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xB0, 0x00, 0xD8, 0x00, 0xEC, 0x00, 0x66, 0x00, 0xF3, 0xFF, 0xF1,
  0xFF, 0xE0, 0xC0, 0x60, 0x60, 0x18, 0x30, 0x0E, 0x18, 0x03, 0x0C, 0x01,
  0xC6, 0x00, 0x63, 0x00, 0x39, 0x80, 0x0C, 0xC0, 0x07, 0x60, 0x01, 0xB0,
  0x00, 0xF8, 0x00, 0x30, 0x03, 0xF8, 0x03, 0xFF, 0x83, 0xC0, 0xF1, 0xC0,
  0x0E, 0x70, 0x03, 0x98, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0x60, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0x70, 0x01,
  0x8E, 0x01, 0xE1, 0xFF, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x0D, 0x80, 0x0E, 0xE0, 0x06, 0x30, 0x07, 0x1E, 0x07,
  0x07, 0xFF, 0x00, 0xFF, 0x00, 0xC0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00,
  0xE6, 0x00, 0x0E, 0x60, 0x00, 0xC7, 0x00, 0x0C, 0x30, 0x01, 0xC3, 0x00,
  0x18, 0x38, 0x01, 0x81, 0x80, 0x38, 0x18, 0x03, 0x01, 0xC0, 0x30, 0x0C,
  0x07, 0x00, 0xC0, 0x60, 0x0E, 0x06, 0x00, 0x60, 0xE0, 0x06, 0x0C, 0x00,
  0x60, 0xC0, 0x03, 0x1C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x39, 0x80,
  0x01, 0xB0, 0x00, 0x1B, 0x00, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF0, 0x76, 0x0D, 0x06, 0x61,
  0x98, 0x66, 0x19, 0x86, 0x61, 0x98, 0x66, 0x19, 0x86, 0x61, 0x98, 0x67,
  0x10, 0xC6, 0x33, 0x0C, 0xC3, 0x30, 0xCC, 0x33, 0x0C, 0xC3, 0x30, 0xCC,
  0x33, 0x04, 0xC3, 0x60, 0x6C, 0x3E, 0x06, 0xC1, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x81, 0xC0,
  0x38, 0xE0, 0x00, 0x77, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x80, 0x1C, 0x1C,
  0x03, 0x80, 0xC0, 0x38, 0x0E, 0x07, 0x00, 0x60, 0x60, 0x07, 0x0E, 0x00,
  0x30, 0xC0, 0x01, 0x98, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x39, 0xC0, 0x03, 0x0C,
  0x00, 0x70, 0xE0, 0x06, 0x06, 0x00, 0xE0, 0x70, 0x1C, 0x03, 0x81, 0x80,
  0x18, 0x38, 0x01, 0xC3, 0x00, 0x0C, 0x70, 0x00, 0xEE, 0x00, 0x07, 0xE0,
  0x00, 0x37, 0x00, 0x07, 0x30, 0x00, 0x63, 0x80, 0x0E, 0x18, 0x00, 0xC1,
  0xC0, 0x1C, 0x0C, 0x01, 0x80, 0xE0, 0x38, 0x06, 0x03, 0x00, 0x70, 0x70,
  0x03, 0x06, 0x00, 0x38, 0xE0, 0x01, 0x8C, 0x00, 0x1D, 0xC0, 0x00, 0xD8,
  0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xFF, 0xF0, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0xFF, 0xFC,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xE0, 0x0D, 0x80, 0x33, 0x01, 0x8C, 0x06, 0x38, 0x38, 0x60,
  0xC1, 0x83, 0x03, 0x18, 0x0C, 0x60, 0x3B, 0x80, 0x6C, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x03, 0xF0, 0x0F,
  0xFE, 0x0F, 0x03, 0x86, 0x00, 0xE6, 0x00, 0x33, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x81, 0xFF, 0xC7, 0xFF, 0xE7, 0x00, 0x77, 0x00,
  0x3B, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xB0, 0x03, 0xDC,
  0x07, 0xE7, 0xFF, 0x31, 0xFE, 0x18, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC7, 0xE0,
  0xCF, 0xF8, 0xD8, 0x3C, 0xF0, 0x0E, 0xE0, 0x06, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xF8, 0x1C,
  0xDF, 0xF8, 0xC7, 0xF0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x03, 0x87, 0x00,
  0xE7, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x03, 0x70, 0x03, 0x98, 0x01, 0x87, 0x01, 0xC1, 0xFF, 0xC0, 0x7F,
  0x80, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x07, 0xE3, 0x87, 0xFD, 0xC7, 0x07,
  0xE7, 0x00, 0xF7, 0x00, 0x3B, 0x00, 0x1D, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0E, 0xC0, 0x07, 0x70, 0x03, 0x98, 0x03, 0xCE, 0x03, 0xE3, 0xFF,
  0x70, 0x7F, 0x38, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xE0, 0xE0, 0xE0, 0x1C,
  0x70, 0x03, 0x18, 0x00, 0x66, 0x00, 0x1B, 0x80, 0x06, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x61, 0xC0, 0x70, 0x3F, 0xF8,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0x04, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x3F,
  0xFF, 0xEF, 0xFF, 0xF8, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0xE3, 0x87, 0xFD, 0xC7, 0x07, 0xE7, 0x00, 0xF7, 0x00, 0x7B, 0x00, 0x1D,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0E, 0xC0, 0x07, 0x70, 0x03, 0x98,
  0x03, 0xCF, 0x03, 0xE3, 0xFF, 0x70, 0x7F, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x20, 0x07, 0x38, 0x03, 0x0E, 0x07, 0x83, 0xFF, 0x80, 0x7F,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC3, 0xF0, 0xCF, 0xFC, 0xDC, 0x1E, 0xD0,
  0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x60, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x3F,
  0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x1C, 0xFF, 0x8F, 0xE0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x07,
  0x60, 0x07, 0x30, 0x07, 0x18, 0x07, 0x0C, 0x07, 0x06, 0x07, 0x03, 0x07,
  0x01, 0x87, 0x00, 0xCF, 0x00, 0x6F, 0x00, 0x3F, 0xC0, 0x1E, 0x70, 0x0E,
  0x1C, 0x06, 0x07, 0x03, 0x01, 0xC1, 0x80, 0xE0, 0xC0, 0x38, 0x60, 0x0E,
  0x30, 0x03, 0x98, 0x00, 0xEC, 0x00, 0x38, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xCF, 0x87, 0x8D,
  0xFD, 0xFE, 0xF1, 0xD8, 0xEE, 0x0E, 0x07, 0xC0, 0x60, 0x7C, 0x06, 0x03,
  0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60,
  0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06,
  0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0,
  0x60, 0x30, 0xC3, 0xF0, 0xCF, 0xFC, 0xDC, 0x1E, 0xF0, 0x0E, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x03, 0xF0, 0x03, 0xFF,
  0x03, 0xC1, 0xE0, 0xE0, 0x1C, 0x70, 0x03, 0x38, 0x00, 0xEE, 0x00, 0x1B,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1B, 0x80, 0x06, 0x60, 0x03, 0x9C, 0x01,
  0xC3, 0x80, 0xE0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0xC7, 0xE0, 0xCF, 0xF8,
  0xD8, 0x3C, 0xF0, 0x0E, 0xE0, 0x0E, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xE0, 0x0E, 0xF0, 0x1C, 0xDF, 0xF8,
  0xCF, 0xF0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0xE3, 0x87, 0xFD, 0xC7, 0x07,
  0xE7, 0x00, 0xF7, 0x00, 0x3B, 0x00, 0x1D, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0E, 0xC0, 0x07, 0x70, 0x03, 0x98, 0x03, 0xCE, 0x03, 0xE3, 0xFF,
  0x70, 0x7F, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0xC1, 0xFE, 0x3F, 0xF3,
  0xC3, 0xB0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xFC, 0x38,
  0x1E, 0x70, 0x06, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x70, 0x0E, 0x3F, 0xFC, 0x0F,
  0xF8, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x07,
  0xFF, 0xFB, 0xFF, 0xFC, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0x60, 0x0F, 0x70, 0x1B, 0x3F,
  0xF3, 0x1F, 0xE3, 0xC0, 0x00, 0x7C, 0x00, 0x1D, 0x80, 0x03, 0x38, 0x00,
  0x63, 0x00, 0x1C, 0x70, 0x03, 0x06, 0x00, 0xE0, 0xC0, 0x18, 0x1C, 0x03,
  0x01, 0x80, 0xC0, 0x38, 0x18, 0x03, 0x07, 0x00, 0x60, 0xC0, 0x06, 0x18,
  0x00, 0xC6, 0x00, 0x1C, 0xC0, 0x01, 0xB8, 0x00, 0x36, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x06, 0x00, 0xC0, 0x30, 0x1F, 0x01, 0x80, 0xD8, 0x1C,
  0x06, 0xC0, 0xE0, 0x36, 0x07, 0x81, 0xB0, 0x2C, 0x18, 0xC3, 0x60, 0xC6,
  0x19, 0x06, 0x30, 0xCC, 0x31, 0x86, 0x61, 0x0C, 0x63, 0x18, 0x33, 0x08,
  0xC1, 0x98, 0x66, 0x0C, 0xC3, 0x30, 0x6C, 0x19, 0x01, 0x60, 0x58, 0x0F,
  0x03, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x18,
  0x00, 0x70, 0x00, 0xE6, 0x00, 0x38, 0xE0, 0x06, 0x0E, 0x01, 0xC0, 0xE0,
  0x70, 0x0C, 0x1C, 0x00, 0xC3, 0x00, 0x1C, 0xE0, 0x01, 0xF8, 0x00, 0x1E,
  0x00, 0x01, 0x80, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x07, 0x38, 0x00, 0xC3,
  0x00, 0x30, 0x70, 0x0E, 0x07, 0x03, 0x80, 0x70, 0xE0, 0x06, 0x18, 0x00,
  0xEF, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x01, 0x9C, 0x00, 0x1C, 0x60,
  0x00, 0xC3, 0x80, 0x06, 0x0C, 0x00, 0x70, 0x70, 0x03, 0x01, 0x80, 0x38,
  0x0E, 0x01, 0x80, 0x30, 0x1C, 0x01, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x38,
  0x60, 0x01, 0xC3, 0x00, 0x06, 0x38, 0x00, 0x39, 0x80, 0x00, 0xDC, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x07, 0x80,
  0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x03,
  0xE0, 0x3C, 0x01, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x80, 0x1E, 0x01, 0xF0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x20, 0x00, 0x1F, 0x00, 0x01,
  0xFE, 0x00, 0xDC, 0x78, 0x06, 0xC0, 0xE0, 0x3C, 0x03, 0xC7, 0x60, 0x07,
  0xF0, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoMono_Light39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 3, 28, 23, 10, -28 },
  { 12, 8, 8, 23, 8, -29 },
  { 20, 21, 28, 23, 1, -28 },
  { 94, 18, 36, 23, 3, -32 },
  { 175, 22, 28, 23, 1, -28 },
  { 252, 20, 28, 23, 3, -28 },
  { 322, 2, 8, 23, 10, -29 },
  { 324, 9, 40, 23, 7, -31 },
  { 369, 9, 40, 23, 7, -31 },
  { 414, 18, 17, 23, 3, -28 },
  { 453, 19, 20, 23, 2, -23 },
  { 501, 4, 10, 23, 7, -4 },
  { 506, 14, 2, 23, 5, -13 },
  { 510, 4, 4, 23, 10, -4 },
  { 512, 14, 30, 23, 5, -28 },
  { 565, 17, 28, 23, 3, -28 },
  { 625, 10, 28, 23, 4, -28 },
  { 660, 18, 28, 23, 2, -28 },
  { 723, 17, 28, 23, 2, -28 },
  { 783, 19, 28, 23, 2, -28 },
  { 850, 17, 28, 23, 4, -28 },
  { 910, 17, 28, 23, 3, -28 },
  { 970, 19, 28, 23, 2, -28 },
  { 1037, 18, 28, 23, 3, -28 },
  { 1100, 17, 28, 23, 3, -28 },
  { 1160, 4, 21, 23, 11, -21 },
  { 1171, 5, 27, 23, 10, -21 },
  { 1188, 16, 17, 23, 3, -21 },
  { 1222, 17, 10, 23, 3, -18 },
  { 1244, 17, 17, 23, 3, -21 },
  { 1281, 16, 28, 23, 4, -28 },
  { 1337, 21, 28, 23, 1, -28 },
  { 1411, 20, 28, 23, 2, -28 },
  { 1481, 17, 28, 23, 4, -28 },
  { 1541, 19, 28, 23, 2, -28 },
  { 1608, 18, 28, 23, 3, -28 },
  { 1671, 16, 28, 23, 4, -28 },
  { 1727, 16, 28, 23, 4, -28 },
  { 1783, 19, 28, 23, 2, -28 },
  { 1850, 17, 28, 23, 3, -28 },
  { 1910, 16, 28, 23, 4, -28 },
  { 1966, 18, 28, 23, 2, -28 },
  { 2029, 19, 28, 23, 4, -28 },
  { 2096, 17, 28, 23, 4, -28 },
  { 2156, 18, 28, 23, 3, -28 },
  { 2219, 17, 28, 23, 3, -28 },
  { 2279, 19, 28, 23, 2, -28 },
  { 2346, 18, 28, 23, 4, -28 },
  { 2409, 19, 33, 23, 2, -28 },
  { 2488, 17, 28, 23, 4, -28 },
  { 2548, 18, 28, 23, 3, -28 },
  { 2611, 20, 28, 23, 2, -28 },
  { 2681, 17, 28, 23, 3, -28 },
  { 2741, 20, 28, 23, 2, -28 },
  { 2811, 20, 28, 23, 2, -28 },
  { 2881, 20, 28, 23, 2, -28 },
  { 2951, 20, 28, 23, 1, -28 },
  { 3021, 18, 28, 23, 2, -28 },
  { 3084, 6, 38, 23, 9, -32 },
  { 3113, 14, 30, 23, 5, -28 },
  { 3166, 7, 38, 23, 8, -32 },
  { 3200, 14, 15, 23, 5, -28 },
  { 3227, 17, 2, 23, 3, 0 },
  { 3232, 6, 6, 23, 9, -29 },
  { 3237, 17, 21, 23, 3, -21 },
  { 3282, 16, 29, 23, 4, -29 },
  { 3340, 17, 21, 23, 3, -21 },
  { 3385, 17, 29, 23, 3, -29 },
  { 3447, 18, 21, 23, 3, -21 },
  { 3495, 18, 30, 23, 3, -30 },
  { 3563, 17, 29, 23, 3, -21 },
  { 3625, 16, 29, 23, 4, -29 },
  { 3683, 17, 28, 23, 4, -28 },
  { 3743, 12, 36, 23, 4, -28 },
  { 3797, 17, 29, 23, 4, -29 },
  { 3859, 17, 29, 23, 4, -29 },
  { 3921, 20, 21, 23, 2, -21 },
  { 3974, 16, 21, 23, 4, -21 },
  { 4016, 18, 21, 23, 3, -21 },
  { 4064, 16, 29, 23, 4, -21 },
  { 4122, 17, 29, 23, 3, -21 },
  { 4184, 13, 21, 23, 7, -21 },
  { 4219, 16, 21, 23, 4, -21 },
  { 4261, 17, 26, 23, 3, -26 },
  { 4317, 16, 21, 23, 4, -21 },
  { 4359, 19, 21, 23, 2, -21 },
  { 4409, 21, 21, 23, 1, -21 },
  { 4465, 19, 21, 23, 2, -21 },
  { 4515, 21, 29, 23, 1, -21 },
  { 4592, 18, 21, 23, 3, -21 },
  { 4640, 13, 38, 23, 6, -30 },
  { 4702, 2, 34, 23, 11, -28 },
  { 4711, 13, 38, 23, 6, -30 },
  { 4773, 21, 7, 23, 1, -15 },
};

const GFXfont RobotoMono_Light39pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light39pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _ROBOTOMONO_LIGHT39PT7B_H_
