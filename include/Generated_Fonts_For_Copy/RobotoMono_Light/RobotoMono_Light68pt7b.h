#ifndef _ROBOTOMONO_LIGHT68PT7B_H_
#define _ROBOTOMONO_LIGHT68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light68pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF,
  0xDE, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0x70, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F,
  0x80, 0xFE, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x70, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0x7C, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x70, 0x03, 0x80,
  0x1C, 0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x38, 0x03, 0x80, 0x3C,
  0x00, 0xE0, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x0E, 0x03,
  0x80, 0x07, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x00, 0xE0, 0x70, 0x00, 0x78,
  0x07, 0x83, 0xC0, 0x00, 0xF0, 0x3C, 0x0E, 0x00, 0x03, 0xE1, 0xE0, 0x78,
  0x00, 0x07, 0xFF, 0x81, 0xC0, 0x00, 0x0F, 0xF8, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x3F,
  0x80, 0x00, 0x07, 0x81, 0xFF, 0x80, 0x00, 0x1C, 0x0F, 0xFF, 0x00, 0x00,
  0xF0, 0x78, 0x3E, 0x00, 0x03, 0x83, 0xC0, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0xF0, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x1E,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x78, 0x01,
  0xC0, 0x0E, 0x01, 0xE0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x1C, 0x01, 0xC0,
  0x1E, 0x00, 0x70, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x08, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x3C, 0x3E,
  0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00,
  0x7C, 0x1E, 0x00, 0x1E, 0x1E, 0x07, 0xC0, 0x07, 0x8F, 0x80, 0xF8, 0x01,
  0xE7, 0xC0, 0x1F, 0x00, 0x79, 0xE0, 0x03, 0xE0, 0x1C, 0xF8, 0x00, 0x78,
  0x0F, 0x3C, 0x00, 0x1F, 0x03, 0xCF, 0x00, 0x03, 0xE0, 0xF3, 0xC0, 0x00,
  0x7C, 0x3C, 0xE0, 0x00, 0x0F, 0x1E, 0x38, 0x00, 0x03, 0xE7, 0x8F, 0x00,
  0x00, 0x7F, 0xC3, 0xC0, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xF0,
  0x3E, 0x00, 0x0F, 0xFE, 0x07, 0xE0, 0x0F, 0xC7, 0xC0, 0xFF, 0xFF, 0xE0,
  0xF0, 0x1F, 0xFF, 0xF0, 0x3E, 0x01, 0xFF, 0xF0, 0x07, 0xC0, 0x07, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0xE0, 0x00, 0x02,
  0x00, 0x0E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x06, 0x00, 0x02, 0x40, 0x00, 0x70, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x40, 0x03, 0x80,
  0x04, 0xE0, 0x07, 0x00, 0x79, 0xF8, 0x0E, 0x03, 0xF7, 0xFC, 0x1C, 0x3F,
  0xE7, 0xFF, 0x39, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x80, 0x03,
  0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x3C,
  0x00, 0x1E, 0x00, 0x10, 0x00, 0x10, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x3C, 0x78, 0xF3, 0xC7, 0x9E, 0x38, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7D, 0xFB, 0xFF, 0xFF,
  0xEF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0xF8, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1F,
  0x38, 0x00, 0x00, 0x7E, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3E, 0x7F, 0x80, 0x00, 0xF8, 0xFF, 0x00, 0x03, 0xE1, 0xFE,
  0x00, 0x0F, 0x83, 0xFC, 0x00, 0x3E, 0x07, 0xF8, 0x00, 0xF8, 0x0F, 0xF0,
  0x03, 0xC0, 0x1F, 0xE0, 0x0F, 0x00, 0x3F, 0xC0, 0x3C, 0x00, 0x7F, 0x81,
  0xF0, 0x00, 0xFF, 0x07, 0xC0, 0x01, 0xFE, 0x1F, 0x00, 0x03, 0xFC, 0x7C,
  0x00, 0x07, 0xF9, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3D, 0xF8, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x03, 0xFC, 0x03,
  0xFF, 0x07, 0xFF, 0xC7, 0xFC, 0xF7, 0xFC, 0x3F, 0xF8, 0x0F, 0xF8, 0x03,
  0xF8, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xBE,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xF8,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0x81, 0xF8,
  0x00, 0x3F, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x01,
  0xE0, 0x0F, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE0, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0xFF, 0x00, 0x0F, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xF8, 0x00, 0xFF, 0x03, 0x80, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x80,
  0x3F, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x07, 0x83, 0xFF, 0xC0, 0x1E, 0x3F, 0xFF, 0xC0, 0x71,
  0xFF, 0xFF, 0x83, 0xCF, 0x80, 0x7F, 0x0F, 0x78, 0x00, 0x7E, 0x3F, 0xC0,
  0x00, 0xF8, 0xFE, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9F, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0xC0, 0x7F,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x7C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0x3F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1F,
  0x3C, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0x1F, 0xC7,
  0xC0, 0x01, 0xEF, 0x0F, 0xC0, 0x0F, 0xBC, 0x1F, 0xE1, 0xFC, 0xF0, 0x3F,
  0xFF, 0xC3, 0xC0, 0x3F, 0xFE, 0x0E, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x79, 0xFB,
  0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x3F, 0x7F, 0xFF, 0xF9, 0xF0, 0x1E, 0x1F, 0x8F, 0xC7, 0xF3, 0xF0, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0,
  0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x1C, 0x04, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x81,
  0xF8, 0x03, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x1E, 0x78, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x06, 0x00, 0x38, 0x1C,
  0x01, 0xFF, 0x01, 0xC1, 0xC0, 0x1F, 0xFC, 0x07, 0x0E, 0x01, 0xFB, 0xF0,
  0x38, 0xE0, 0x1E, 0x03, 0x81, 0xC7, 0x01, 0xE0, 0x18, 0x0E, 0x38, 0x0E,
  0x00, 0xC0, 0x33, 0x80, 0xF0, 0x06, 0x01, 0x9C, 0x07, 0x00, 0x30, 0x0E,
  0xE0, 0x38, 0x03, 0x80, 0x77, 0x03, 0x80, 0x1C, 0x03, 0xB0, 0x1C, 0x00,
  0xE0, 0x1F, 0x80, 0xE0, 0x07, 0x00, 0xFC, 0x07, 0x00, 0x38, 0x07, 0xE0,
  0x38, 0x01, 0xC0, 0x3F, 0x03, 0x80, 0x0E, 0x01, 0xF8, 0x1C, 0x00, 0x60,
  0x0D, 0xC0, 0xE0, 0x03, 0x00, 0x6E, 0x07, 0x00, 0x18, 0x07, 0x70, 0x38,
  0x01, 0xC0, 0x3B, 0x81, 0xC0, 0x0E, 0x01, 0xDC, 0x07, 0x00, 0xF0, 0x0C,
  0xE0, 0x38, 0x07, 0x80, 0xE7, 0x01, 0xC0, 0x7C, 0x07, 0x1C, 0x0F, 0x07,
  0x70, 0x70, 0xE0, 0x3C, 0x73, 0x87, 0x87, 0x01, 0xFF, 0x9F, 0xF8, 0x3C,
  0x07, 0xF8, 0x7F, 0x80, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x02, 0x00,
  0x01, 0xFC, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x1C, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x07, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0x80, 0x03, 0xFC, 0x0F, 0x00, 0x00, 0xFC, 0x1E, 0x00, 0x00, 0x7C,
  0x3C, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF9,
  0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x81, 0xE0, 0x00, 0x1F, 0xC3, 0xC0, 0x00, 0x0F, 0xC7, 0x80, 0x00,
  0x07, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x0F, 0xC7,
  0x80, 0x00, 0x3F, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xC7, 0xFC, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x01, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x0F,
  0xF0, 0x0F, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01,
  0xF0, 0x78, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x1F, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7E, 0x07, 0x80, 0x03, 0xF8,
  0x0F, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x80,
  0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0x78, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x07, 0x3E, 0x00,
  0x00, 0x07, 0x1E, 0x00, 0x00, 0x07, 0x1F, 0x00, 0x00, 0x07, 0x0F, 0x80,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0xF0, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x00,
  0xF0, 0x07, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x00,
  0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x00, 0xF1, 0xF8, 0x00, 0x00, 0xF3, 0xFC, 0x00, 0x00,
  0xF7, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0x00, 0x00,
  0xFF, 0x0F, 0x80, 0x00, 0xFE, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFB, 0x80, 0x00, 0xFF, 0xEF, 0x00, 0x07, 0xBF, 0xBC, 0x00, 0x1E, 0xFE,
  0x78, 0x00, 0x73, 0xF9, 0xE0, 0x03, 0xCF, 0xE3, 0x80, 0x0F, 0x3F, 0x8F,
  0x00, 0x78, 0xFE, 0x3C, 0x01, 0xE3, 0xF8, 0x70, 0x07, 0x0F, 0xE1, 0xE0,
  0x3C, 0x3F, 0x87, 0x80, 0xF0, 0xFE, 0x0E, 0x03, 0x83, 0xF8, 0x3C, 0x1E,
  0x0F, 0xE0, 0xF0, 0x78, 0x3F, 0x81, 0xC3, 0xC0, 0xFE, 0x07, 0x8F, 0x03,
  0xF8, 0x1E, 0x38, 0x0F, 0xE0, 0x3D, 0xE0, 0x3F, 0x80, 0xF7, 0x80, 0xFE,
  0x01, 0xDC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x3E, 0x00, 0xFE, 0x00, 0xF8, 0x03, 0xF8, 0x03, 0xC0, 0x0F, 0xE0, 0x07,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xF7, 0x80, 0x00, 0x1F, 0xE7, 0x80, 0x00,
  0x3F, 0xCF, 0x00, 0x00, 0x7F, 0x8F, 0x00, 0x00, 0xFF, 0x1E, 0x00, 0x01,
  0xFE, 0x1E, 0x00, 0x03, 0xFC, 0x3C, 0x00, 0x07, 0xF8, 0x3C, 0x00, 0x0F,
  0xF0, 0x7C, 0x00, 0x1F, 0xE0, 0x78, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x7F,
  0x80, 0xF0, 0x00, 0xFF, 0x00, 0xF0, 0x01, 0xFE, 0x01, 0xE0, 0x03, 0xFC,
  0x01, 0xE0, 0x07, 0xF8, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x1F, 0xE0,
  0x07, 0x80, 0x3F, 0xC0, 0x07, 0x80, 0x7F, 0x80, 0x0F, 0x80, 0xFF, 0x00,
  0x0F, 0x01, 0xFE, 0x00, 0x1F, 0x03, 0xFC, 0x00, 0x1E, 0x07, 0xF8, 0x00,
  0x1E, 0x0F, 0xF0, 0x00, 0x3C, 0x1F, 0xE0, 0x00, 0x3C, 0x3F, 0xC0, 0x00,
  0x78, 0x7F, 0x80, 0x00, 0x78, 0xFF, 0x00, 0x00, 0xF1, 0xFE, 0x00, 0x00,
  0xF3, 0xFC, 0x00, 0x01, 0xF7, 0xF8, 0x00, 0x01, 0xEF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0x80, 0x00, 0xFE, 0x0F, 0x00,
  0x00, 0x7E, 0x1E, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3E, 0x78, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xFC,
  0x78, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x1E, 0x00,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07, 0x8F, 0x80,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x1F, 0xC0,
  0xF0, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3E, 0x3C,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x0F, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xFC, 0x3C,
  0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x01,
  0xE0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x1F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0x7E, 0x00,
  0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xEF, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x01, 0xF8,
  0x00, 0xE7, 0x00, 0x1F, 0x80, 0x0E, 0x78, 0x01, 0xF8, 0x01, 0xE7, 0x80,
  0x1F, 0x80, 0x1E, 0x78, 0x01, 0xF8, 0x01, 0xE7, 0x80, 0x3F, 0xC0, 0x1E,
  0x78, 0x03, 0xFC, 0x01, 0xE7, 0x80, 0x39, 0xC0, 0x1C, 0x38, 0x03, 0x9C,
  0x01, 0xC3, 0x80, 0x39, 0xC0, 0x1C, 0x3C, 0x07, 0x9E, 0x03, 0xC3, 0xC0,
  0x79, 0xE0, 0x3C, 0x3C, 0x07, 0x0E, 0x03, 0xC3, 0xC0, 0x70, 0xE0, 0x3C,
  0x3C, 0x07, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0xE0, 0x38, 0x1C, 0x0F, 0x0F,
  0x03, 0x81, 0xE0, 0xF0, 0xF0, 0x78, 0x1E, 0x0E, 0x07, 0x07, 0x81, 0xE0,
  0xE0, 0x70, 0x78, 0x1E, 0x0E, 0x07, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0x70,
  0x0E, 0x1E, 0x07, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0F, 0x1C, 0x03,
  0x87, 0x00, 0xF1, 0xC0, 0x38, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x3C, 0xF0, 0x0F, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0,
  0x07, 0x38, 0x01, 0xCE, 0x00, 0x77, 0x80, 0x1C, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0x3D, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x3C, 0x00,
  0x00, 0x0F, 0x1F, 0x00, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xB8, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0xF1, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x1E, 0x00,
  0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x0F,
  0x80, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3C, 0x78, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x3F, 0xF0, 0x01, 0xE3, 0xF8, 0x00, 0x0F, 0x3F, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1F, 0x78, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x01,
  0xFE, 0x7C, 0x00, 0x1F, 0xF1, 0xF8, 0x07, 0xF7, 0xC7, 0xFF, 0xFE, 0x1E,
  0x1F, 0xFF, 0xE0, 0xF0, 0x3F, 0xFC, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x0C, 0x00, 0x1E, 0x0F, 0xFE, 0x00, 0xF1, 0xFF, 0xFC,
  0x07, 0x9F, 0xFF, 0xF0, 0x3D, 0xF0, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x9E, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xF0,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xE3, 0xBC, 0x00,
  0x7E, 0x1D, 0xF8, 0x0F, 0xE0, 0xE3, 0xFF, 0xFE, 0x07, 0x0F, 0xFF, 0xE0,
  0x38, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x3E, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x08,
  0x01, 0xE0, 0x0F, 0xFE, 0x0F, 0x01, 0xFF, 0xFC, 0x78, 0x1F, 0xFF, 0xF3,
  0xC1, 0xFC, 0x07, 0xDE, 0x1F, 0x80, 0x0F, 0xF1, 0xF0, 0x00, 0x3F, 0x8F,
  0x80, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xE0, 0xFC, 0x03,
  0xEF, 0x03, 0xFF, 0xFE, 0x78, 0x0F, 0xFF, 0xE3, 0xC0, 0x1F, 0xFC, 0x1E,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x1E,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x02,
  0x07, 0xC0, 0x00, 0x0E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFB, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF,
  0x83, 0xC0, 0x7F, 0xFF, 0x1E, 0x07, 0xFF, 0xFC, 0xF0, 0x7F, 0x01, 0xF7,
  0x87, 0xE0, 0x03, 0xFC, 0x7C, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x3F, 0x3E,
  0x00, 0x00, 0xF9, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF8, 0x3F, 0x00, 0xFB, 0xC0, 0xFF, 0xFF,
  0x9E, 0x03, 0xFF, 0xF8, 0xF0, 0x07, 0xFF, 0x07, 0x80, 0x03, 0x80, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x10, 0x00, 0x03, 0xE1, 0xC0, 0x00,
  0x1E, 0x1F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x01, 0xFC, 0x07, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x03, 0xFF, 0x80, 0xF0, 0x7F, 0xFF,
  0x07, 0x87, 0xFF, 0xFC, 0x3C, 0x7C, 0x03, 0xF1, 0xE7, 0x80, 0x0F, 0xCF,
  0x78, 0x00, 0x1E, 0x7B, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xDF, 0x80,
  0x00, 0x1E, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x3F, 0x0F, 0x00, 0x01, 0xF8, 0x3C, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x00, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF0, 0xFC, 0x00, 0x03, 0xC7,
  0xE0, 0x00, 0x0F, 0x3F, 0x00, 0x00, 0x3D, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFE, 0xF8, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xF0, 0x0F,
  0x00, 0x07, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x07, 0xEF, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x30, 0x1E, 0x3F, 0xE0, 0x7F, 0xC3,
  0xCF, 0xFE, 0x1F, 0xFC, 0x7B, 0xFF, 0xE7, 0xFF, 0xCF, 0xE0, 0x7D, 0xE0,
  0x7D, 0xF8, 0x07, 0xF0, 0x07, 0xBE, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0x0F,
  0x80, 0x0F, 0xF0, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0x3F, 0xC0,
  0x07, 0x80, 0x07, 0xF8, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x1F,
  0xE0, 0x03, 0xC0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0x7F, 0x80, 0x0F, 0x00,
  0x0F, 0xF0, 0x01, 0xE0, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x07,
  0x80, 0x07, 0xF8, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x1F, 0xE0,
  0x03, 0xC0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0x7F, 0x80, 0x0F, 0x00, 0x0F,
  0xF0, 0x00, 0xE0, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0x3F, 0xC0, 0x03, 0x80,
  0x07, 0xF8, 0x00, 0x70, 0x00, 0xFF, 0x00, 0x0E, 0x00, 0x1F, 0xE0, 0x01,
  0xC0, 0x03, 0xFC, 0x00, 0x38, 0x00, 0x7F, 0x80, 0x07, 0x00, 0x0F, 0xF0,
  0x00, 0xE0, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0x3F, 0xC0, 0x03, 0x80, 0x07,
  0xF8, 0x00, 0x70, 0x00, 0xFF, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x07, 0x80, 0xFF, 0xE0, 0x3C, 0x1F, 0xFF, 0xC1, 0xE1, 0xFF, 0xFF, 0x0F,
  0x1F, 0x00, 0xFC, 0x79, 0xE0, 0x03, 0xF3, 0xDC, 0x00, 0x07, 0x9E, 0xC0,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0xF7, 0xE0, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x3C,
  0x1F, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x0E,
  0x07, 0xFF, 0x00, 0xE1, 0xFF, 0xFC, 0x0E, 0x3F, 0xFF, 0xE0, 0xE7, 0xC0,
  0x7F, 0x0E, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C,
  0xF8, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF8,
  0xFE, 0x00, 0x1F, 0x8F, 0xF8, 0x07, 0xF0, 0xF7, 0xFF, 0xFE, 0x0F, 0x1F,
  0xFF, 0xC0, 0xF0, 0x7F, 0xF0, 0x0F, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0xFF, 0x83, 0xC0, 0x7F, 0xFF, 0x1E, 0x07, 0xFF, 0xFC, 0xF0, 0x7F, 0x01,
  0xF7, 0x87, 0xE0, 0x03, 0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x3F,
  0x3E, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF8, 0x3F, 0x00, 0xFF, 0xC0, 0xFF,
  0xFF, 0xDE, 0x03, 0xFF, 0xF8, 0xF0, 0x07, 0xFF, 0x07, 0x80, 0x03, 0x80,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFE, 0xF0, 0xFF, 0xFE,
  0xF1, 0xFE, 0x0E, 0xF3, 0xE0, 0x00, 0xF7, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1F, 0x3F,
  0x00, 0x01, 0xF0, 0xFE, 0x00, 0x7F, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0xF0, 0x00,
  0x0F, 0xDF, 0x00, 0x03, 0xB9, 0xF0, 0x00, 0xF7, 0x3F, 0x00, 0x7C, 0xE3,
  0xFF, 0xFF, 0x1C, 0x1F, 0xFF, 0xC3, 0x81, 0xFF, 0xE0, 0x70, 0x03, 0xA0,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0E, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x7F, 0x80,
  0x03, 0x80, 0x03, 0xDC, 0x00, 0x1E, 0x00, 0x1E, 0xE0, 0x01, 0xF0, 0x00,
  0xE7, 0x80, 0x0F, 0x80, 0x07, 0x3C, 0x00, 0x7C, 0x00, 0x79, 0xE0, 0x03,
  0x70, 0x03, 0xC7, 0x00, 0x3B, 0x80, 0x1E, 0x3C, 0x01, 0xDC, 0x00, 0xE1,
  0xE0, 0x0E, 0xE0, 0x07, 0x0F, 0x00, 0x77, 0x80, 0x78, 0x38, 0x07, 0x9C,
  0x03, 0xC1, 0xC0, 0x38, 0xE0, 0x1C, 0x0F, 0x01, 0xC7, 0x00, 0xE0, 0x78,
  0x0E, 0x3C, 0x07, 0x03, 0xC0, 0xF0, 0xE0, 0x78, 0x0E, 0x07, 0x07, 0x03,
  0xC0, 0x70, 0x38, 0x38, 0x1C, 0x03, 0xC1, 0xC1, 0xE0, 0xE0, 0x1E, 0x1C,
  0x07, 0x07, 0x00, 0x70, 0xE0, 0x38, 0x78, 0x03, 0x87, 0x01, 0xC3, 0x80,
  0x1C, 0x38, 0x0F, 0x1C, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0x07, 0x9C, 0x01,
  0xC7, 0x00, 0x1C, 0xE0, 0x0E, 0x78, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x07,
  0x70, 0x01, 0xDC, 0x00, 0x3F, 0x80, 0x0E, 0xE0, 0x00, 0xFC, 0x00, 0x77,
  0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00,
  0xF9, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7B, 0xE0, 0x00,
  0x00, 0x78, 0xF8, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x0F, 0x1F, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x0F, 0x3E,
  0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xC7, 0xFF, 0xE0, 0x00, 0x1E, 0x7F, 0x7F, 0x80, 0x00, 0xF7,
  0xC0, 0x7F, 0x00, 0x07, 0x3C, 0x00, 0xFC, 0x00, 0x79, 0xC0, 0x03, 0xF0,
  0x03, 0xDE, 0x00, 0x0F, 0xE0, 0x7C, 0xE0, 0x00, 0x1F, 0xFF, 0xC7, 0x00,
  0x00, 0x7F, 0xFE, 0x38, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00,
};

const GFXglyph RobotoMono_Light68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 6, 48, 41, 17, -48 },
  { 37, 14, 15, 41, 13, -51 },
  { 64, 37, 48, 41, 2, -48 },
  { 286, 30, 63, 41, 6, -56 },
  { 523, 38, 50, 41, 1, -49 },
  { 761, 34, 50, 41, 5, -49 },
  { 974, 4, 15, 41, 17, -51 },
  { 982, 16, 70, 41, 13, -54 },
  { 1122, 16, 70, 41, 11, -54 },
  { 1262, 31, 29, 41, 6, -48 },
  { 1375, 33, 35, 41, 4, -40 },
  { 1520, 7, 16, 41, 13, -6 },
  { 1534, 25, 3, 41, 8, -23 },
  { 1544, 7, 6, 41, 18, -6 },
  { 1550, 24, 52, 41, 9, -48 },
  { 1706, 31, 50, 41, 5, -49 },
  { 1900, 18, 48, 41, 7, -48 },
  { 2008, 32, 49, 41, 3, -49 },
  { 2204, 31, 50, 41, 3, -49 },
  { 2398, 34, 48, 41, 3, -48 },
  { 2602, 29, 49, 41, 7, -48 },
  { 2780, 30, 50, 41, 5, -49 },
  { 2968, 32, 48, 41, 4, -48 },
  { 3160, 31, 50, 41, 6, -49 },
  { 3354, 30, 49, 41, 5, -49 },
  { 3538, 7, 35, 41, 20, -35 },
  { 3569, 9, 45, 41, 18, -35 },
  { 3620, 28, 28, 41, 6, -36 },
  { 3718, 29, 18, 41, 6, -31 },
  { 3784, 29, 28, 41, 6, -36 },
  { 3886, 27, 49, 41, 7, -49 },
  { 4052, 37, 49, 41, 2, -49 },
  { 4279, 35, 48, 41, 3, -48 },
  { 4489, 31, 48, 41, 6, -48 },
  { 4675, 33, 50, 41, 4, -49 },
  { 4882, 31, 48, 41, 6, -48 },
  { 5068, 28, 48, 41, 7, -48 },
  { 5236, 29, 48, 41, 7, -48 },
  { 5410, 32, 50, 41, 4, -49 },
  { 5610, 31, 48, 41, 5, -48 },
  { 5796, 28, 48, 41, 6, -48 },
  { 5964, 30, 49, 41, 4, -48 },
  { 6148, 32, 48, 41, 7, -48 },
  { 6340, 29, 48, 41, 7, -48 },
  { 6514, 30, 48, 41, 6, -48 },
  { 6694, 31, 48, 41, 5, -48 },
  { 6880, 33, 50, 41, 4, -49 },
  { 7087, 31, 48, 41, 7, -48 },
  { 7273, 33, 57, 41, 4, -49 },
  { 7509, 30, 48, 41, 7, -48 },
  { 7689, 32, 50, 41, 5, -49 },
  { 7889, 35, 48, 41, 3, -48 },
  { 8099, 31, 49, 41, 5, -48 },
  { 8289, 35, 48, 41, 3, -48 },
  { 8499, 36, 48, 41, 3, -48 },
  { 8715, 34, 48, 41, 4, -48 },
  { 8919, 34, 48, 41, 3, -48 },
  { 9123, 31, 48, 41, 4, -48 },
  { 9309, 12, 65, 41, 15, -55 },
  { 9407, 23, 52, 41, 9, -48 },
  { 9557, 12, 65, 41, 14, -55 },
  { 9655, 25, 26, 41, 8, -48 },
  { 9737, 29, 3, 41, 6, 0 },
  { 9748, 11, 9, 41, 15, -50 },
  { 9761, 29, 38, 41, 6, -37 },
  { 9899, 29, 52, 41, 7, -51 },
  { 10088, 30, 38, 41, 5, -37 },
  { 10231, 29, 52, 41, 5, -51 },
  { 10420, 31, 38, 41, 5, -37 },
  { 10568, 31, 52, 41, 6, -52 },
  { 10770, 29, 51, 41, 5, -37 },
  { 10955, 29, 51, 41, 6, -51 },
  { 11140, 29, 49, 41, 7, -49 },
  { 11318, 22, 64, 41, 6, -49 },
  { 11494, 30, 51, 41, 7, -51 },
  { 11686, 29, 51, 41, 7, -51 },
  { 11871, 35, 37, 41, 3, -37 },
  { 12033, 29, 37, 41, 6, -37 },
  { 12168, 32, 38, 41, 4, -37 },
  { 12320, 28, 51, 41, 7, -37 },
  { 12499, 29, 51, 41, 5, -37 },
  { 12684, 24, 37, 41, 12, -37 },
  { 12795, 29, 38, 41, 6, -37 },
  { 12933, 29, 46, 41, 6, -45 },
  { 13100, 27, 37, 41, 7, -36 },
  { 13225, 33, 36, 41, 4, -36 },
  { 13374, 37, 36, 41, 2, -36 },
  { 13541, 33, 36, 41, 4, -36 },
  { 13690, 35, 51, 41, 3, -36 },
  { 13914, 31, 36, 41, 5, -36 },
  { 14054, 22, 66, 41, 11, -53 },
  { 14236, 3, 59, 41, 19, -48 },
  { 14259, 22, 66, 41, 11, -53 },
  { 14441, 37, 12, 41, 2, -26 },
};

const GFXfont RobotoMono_Light68pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light68pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light68pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _ROBOTOMONO_LIGHT68PT7B_H_
