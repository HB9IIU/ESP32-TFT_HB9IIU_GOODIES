#ifndef _ROBOTOMONO_LIGHT72PT7B_H_
#define _ROBOTOMONO_LIGHT72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light72pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x47,
  0xBF, 0xFF, 0xF7, 0x80, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0x78, 0x0E, 0xF0, 0x1D, 0xE0, 0x3B, 0xC0,
  0x77, 0x80, 0xEF, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x03, 0x80, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x03, 0x80, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x0F,
  0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1E,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1F, 0x3C,
  0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x7C,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x07,
  0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x08, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x78, 0x00,
  0xE0, 0x03, 0x80, 0x78, 0x00, 0xE0, 0x03, 0x80, 0xF0, 0x00, 0xE0, 0x03,
  0x80, 0xE0, 0x00, 0xF0, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x07, 0x81, 0xC0,
  0x00, 0x78, 0x0F, 0x03, 0xC0, 0x00, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x3F,
  0xFE, 0x07, 0x80, 0x00, 0x1F, 0xFC, 0x07, 0x00, 0x00, 0x07, 0xF0, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x1F, 0xE0, 0x00, 0x01, 0xE0, 0x7F, 0xF0, 0x00,
  0x01, 0xC0, 0xFF, 0xF8, 0x00, 0x03, 0xC1, 0xF0, 0x7C, 0x00, 0x07, 0x81,
  0xE0, 0x1C, 0x00, 0x07, 0x83, 0xC0, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x0E,
  0x00, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0x00, 0x38, 0x03, 0x80,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x0F, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x60, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x1E, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x03, 0xC3, 0xF0, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0xF0, 0x7C, 0x07, 0xC0, 0x07, 0x87, 0xC0, 0x3E, 0x00, 0x3C,
  0x3C, 0x00, 0xF8, 0x01, 0xE3, 0xE0, 0x03, 0xE0, 0x0F, 0x1E, 0x00, 0x0F,
  0x80, 0xF9, 0xF0, 0x00, 0x3E, 0x07, 0x8F, 0x00, 0x01, 0xF0, 0x3C, 0x78,
  0x00, 0x07, 0xC1, 0xE3, 0xC0, 0x00, 0x1F, 0x1E, 0x1E, 0x00, 0x00, 0x7C,
  0xF0, 0xF0, 0x00, 0x01, 0xFF, 0x07, 0x80, 0x00, 0x0F, 0xF8, 0x3C, 0x00,
  0x00, 0x3F, 0x81, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0x80, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xE0, 0x00,
  0xFD, 0xF0, 0x1F, 0xE0, 0x1F, 0xC7, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0x00,
  0xFF, 0xFF, 0x80, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x40, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x10, 0x00, 0xE0, 0x01, 0x1E, 0x00, 0x70, 0x03, 0xCF,
  0xE0, 0x38, 0x0F, 0xE7, 0xFE, 0x1C, 0x1F, 0xFD, 0xFF, 0xCE, 0x7F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xF0, 0x7C,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x3E,
  0x7C, 0xF1, 0xE7, 0xCF, 0x3E, 0x78, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x10, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x1E,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xDF, 0xF0, 0x00, 0x0F, 0x9F, 0xF0, 0x00, 0x1F, 0x1F, 0xF0,
  0x00, 0x3E, 0x0F, 0xF0, 0x00, 0x7C, 0x0F, 0xF0, 0x00, 0xF8, 0x0F, 0xF0,
  0x01, 0xE0, 0x0F, 0xF0, 0x07, 0xC0, 0x0F, 0xF0, 0x0F, 0x80, 0x0F, 0xF0,
  0x1F, 0x00, 0x0F, 0xF0, 0x3E, 0x00, 0x0F, 0xF0, 0x7C, 0x00, 0x0F, 0xF0,
  0xF8, 0x00, 0x0F, 0xF1, 0xF0, 0x00, 0x0F, 0xF3, 0xE0, 0x00, 0x0F, 0xF7,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1E, 0xFC,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xFF,
  0x03, 0xFF, 0xC3, 0xFE, 0xF7, 0xFE, 0x3F, 0xFE, 0x0F, 0xFC, 0x03, 0xFC,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x01, 0xE3, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07,
  0x8F, 0x80, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xE1, 0xF8, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xF8, 0x07,
  0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x1F, 0xC0, 0x00, 0xF3, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x7F,
  0xF8, 0x1F, 0xC0, 0x0F, 0xF8, 0x3E, 0x00, 0x07, 0xF0, 0x08, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x78, 0x1F,
  0xFE, 0x00, 0x78, 0x7F, 0xFF, 0x80, 0x78, 0xFF, 0xFF, 0xC0, 0x79, 0xF8,
  0x0F, 0xE0, 0x7B, 0xE0, 0x03, 0xF0, 0x7F, 0x80, 0x01, 0xF8, 0xFF, 0x00,
  0x00, 0x7C, 0xFE, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xC0,
  0x00, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x0F, 0x9E,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xF0, 0x07,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00,
  0x00, 0xF8, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x0F, 0x7C, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x1F, 0x3C, 0x00,
  0x00, 0x3F, 0x3E, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7F, 0x1F, 0x00,
  0x00, 0xFF, 0x0F, 0xC0, 0x01, 0xEF, 0x07, 0xE0, 0x07, 0xCF, 0x03, 0xFE,
  0x7F, 0x8F, 0x01, 0xFF, 0xFF, 0x0F, 0x00, 0xFF, 0xFC, 0x1E, 0x00, 0x1F,
  0xF0, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x18, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x04, 0x0F, 0x8F, 0xE7,
  0xF3, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3E, 0x1E, 0x0F, 0x0F, 0x87, 0x87, 0xC3,
  0xC0, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x00, 0xFC, 0x3E,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x7E, 0x00, 0xE0, 0x70, 0x03,
  0xFE, 0x01, 0xE1, 0xE0, 0x0F, 0xFF, 0x01, 0xC3, 0x80, 0x3F, 0x3E, 0x03,
  0x87, 0x00, 0xF0, 0x1C, 0x07, 0x1C, 0x03, 0xC0, 0x38, 0x06, 0x38, 0x07,
  0x00, 0x70, 0x0E, 0x70, 0x1E, 0x00, 0xE0, 0x1D, 0xC0, 0x38, 0x01, 0xC0,
  0x3B, 0x80, 0x70, 0x03, 0x80, 0x77, 0x01, 0xC0, 0x07, 0x00, 0xEE, 0x03,
  0x80, 0x0E, 0x01, 0xDC, 0x07, 0x00, 0x1C, 0x03, 0xF8, 0x0E, 0x00, 0x30,
  0x07, 0xE0, 0x3C, 0x00, 0xE0, 0x0F, 0xC0, 0x70, 0x01, 0xC0, 0x1F, 0x80,
  0xE0, 0x03, 0x80, 0x3F, 0x01, 0xC0, 0x07, 0x00, 0x7E, 0x03, 0x80, 0x0E,
  0x00, 0xDC, 0x07, 0x00, 0x1C, 0x01, 0xB8, 0x0E, 0x00, 0x38, 0x07, 0x70,
  0x1C, 0x00, 0xF0, 0x0E, 0xE0, 0x38, 0x01, 0xE0, 0x1D, 0xE0, 0x78, 0x07,
  0xC0, 0x71, 0xC0, 0x70, 0x0F, 0x80, 0xE3, 0x80, 0xE0, 0x3F, 0x03, 0x87,
  0x01, 0xE1, 0xEF, 0x0F, 0x0E, 0x01, 0xFF, 0x8F, 0xFC, 0x1E, 0x03, 0xFE,
  0x1F, 0xF0, 0x1C, 0x03, 0xF8, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x06, 0x00, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F,
  0xC0, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x7F, 0xE0, 0xF0, 0x00, 0x03,
  0xF0, 0xF0, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xFC, 0xF0, 0x00, 0x01,
  0xF8, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x07, 0x9F, 0x00,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1E, 0x00, 0x7F, 0xE0, 0x0F, 0x00, 0x03, 0xFC, 0x07, 0x80, 0x00,
  0x3F, 0x03, 0xC0, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x03, 0xF0, 0xF0, 0x00,
  0x00, 0xF8, 0x78, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x0F, 0x9E, 0x00,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3E, 0x1E, 0x00,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3F, 0x07, 0x80, 0x00, 0x7F, 0x03, 0xC0,
  0x00, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x01,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x9E, 0x00, 0x00, 0x07, 0xE3,
  0xC0, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00,
  0x3F, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x01, 0xF0, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x1F, 0x80,
  0x00, 0xF0, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0xFC, 0x00, 0x00, 0x3C, 0x3F, 0x00, 0x00, 0x07, 0x8F, 0xE0, 0x00, 0x00,
  0xF1, 0xFE, 0x00, 0x00, 0x1E, 0x7F, 0xE0, 0x00, 0x03, 0xDF, 0x7E, 0x00,
  0x00, 0x7F, 0xC7, 0xC0, 0x00, 0x0F, 0xF0, 0x7C, 0x00, 0x01, 0xFC, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF8, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x1E, 0x00, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0xFC,
  0x3C, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00,
  0x0F, 0x9E, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xEF, 0xF7,
  0x80, 0x01, 0xEF, 0xF7, 0x80, 0x01, 0xCF, 0xF3, 0x80, 0x03, 0xCF, 0xF3,
  0xC0, 0x03, 0xCF, 0xF3, 0xC0, 0x07, 0x8F, 0xF1, 0xE0, 0x07, 0x8F, 0xF1,
  0xE0, 0x07, 0x8F, 0xF1, 0xE0, 0x0F, 0x0F, 0xF0, 0xF0, 0x0F, 0x0F, 0xF0,
  0xF0, 0x1E, 0x0F, 0xF0, 0xF0, 0x1E, 0x0F, 0xF0, 0x78, 0x1E, 0x0F, 0xF0,
  0x78, 0x3C, 0x0F, 0xF0, 0x78, 0x3C, 0x0F, 0xF0, 0x3C, 0x3C, 0x0F, 0xF0,
  0x3C, 0x78, 0x0F, 0xF0, 0x1C, 0x78, 0x0F, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0,
  0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xC0, 0x0F, 0xF0, 0x07, 0xC0, 0x0F, 0xF0,
  0x07, 0xC0, 0x0F, 0xF0, 0x03, 0x80, 0x0F, 0xF0, 0x03, 0x80, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xF7,
  0x80, 0x00, 0x1F, 0xF7, 0xC0, 0x00, 0x1F, 0xF3, 0xC0, 0x00, 0x1F, 0xF3,
  0xE0, 0x00, 0x1F, 0xF1, 0xE0, 0x00, 0x1F, 0xF1, 0xF0, 0x00, 0x1F, 0xF0,
  0xF0, 0x00, 0x1F, 0xF0, 0x78, 0x00, 0x1F, 0xF0, 0x7C, 0x00, 0x1F, 0xF0,
  0x3C, 0x00, 0x1F, 0xF0, 0x3E, 0x00, 0x1F, 0xF0, 0x1E, 0x00, 0x1F, 0xF0,
  0x1F, 0x00, 0x1F, 0xF0, 0x0F, 0x00, 0x1F, 0xF0, 0x0F, 0x80, 0x1F, 0xF0,
  0x07, 0x80, 0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x03, 0xC0, 0x1F, 0xF0,
  0x01, 0xE0, 0x1F, 0xF0, 0x01, 0xF0, 0x1F, 0xF0, 0x00, 0xF0, 0x1F, 0xF0,
  0x00, 0xF8, 0x1F, 0xF0, 0x00, 0x78, 0x1F, 0xF0, 0x00, 0x7C, 0x1F, 0xF0,
  0x00, 0x3C, 0x1F, 0xF0, 0x00, 0x3E, 0x1F, 0xF0, 0x00, 0x1E, 0x1F, 0xF0,
  0x00, 0x1F, 0x1F, 0xF0, 0x00, 0x0F, 0x1F, 0xF0, 0x00, 0x07, 0x9F, 0xF0,
  0x00, 0x07, 0xDF, 0xF0, 0x00, 0x03, 0xDF, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x01, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xF0, 0x00, 0xFF, 0xE0, 0xF0, 0x00, 0x07, 0xF0, 0xF0,
  0x00, 0x01, 0xF8, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0xF8, 0xF0, 0x00, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x07,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x03, 0xC7, 0xC0,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1E, 0x00, 0x3F, 0xF8, 0x0F, 0x00, 0x00, 0xFE, 0x07, 0x80,
  0x00, 0x1F, 0x83, 0xC0, 0x00, 0x07, 0xE1, 0xE0, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x0F,
  0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x3C, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x1E,
  0x7C, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78, 0x3E,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0xF8,
  0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0x78, 0x00,
  0x7C, 0x00, 0x3D, 0xE0, 0x03, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0xC0, 0x03,
  0x9E, 0x00, 0x3F, 0x80, 0x1E, 0x78, 0x00, 0xFE, 0x00, 0x79, 0xE0, 0x03,
  0xF8, 0x01, 0xE7, 0x80, 0x1E, 0xE0, 0x07, 0x8F, 0x00, 0x7B, 0x80, 0x1E,
  0x3C, 0x01, 0xEE, 0x00, 0x78, 0xF0, 0x07, 0x3C, 0x01, 0xC3, 0xC0, 0x1C,
  0xF0, 0x07, 0x0F, 0x00, 0xF1, 0xC0, 0x3C, 0x3C, 0x03, 0xC7, 0x00, 0xF0,
  0xF0, 0x0F, 0x1C, 0x03, 0xC1, 0xE0, 0x38, 0x78, 0x0F, 0x07, 0x80, 0xE1,
  0xE0, 0x3C, 0x1E, 0x07, 0x87, 0x80, 0xF0, 0x78, 0x1E, 0x0E, 0x03, 0x81,
  0xE0, 0x78, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x1E, 0x07, 0x03,
  0xC1, 0xE0, 0x38, 0x1C, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x1C, 0x1E, 0x03,
  0xC3, 0xC0, 0x70, 0x78, 0x0F, 0x0F, 0x01, 0xC1, 0xC0, 0x3C, 0x38, 0x07,
  0x8F, 0x00, 0xF0, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x07,
  0x1E, 0x00, 0xE3, 0xC0, 0x1E, 0x78, 0x03, 0x8F, 0x00, 0x79, 0xC0, 0x0F,
  0x3C, 0x01, 0xE7, 0x00, 0x3C, 0xE0, 0x07, 0xBC, 0x00, 0xF3, 0x80, 0x1E,
  0xF0, 0x01, 0xDE, 0x00, 0x7B, 0xC0, 0x07, 0x78, 0x00, 0xEF, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x7C, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x00, 0x7E, 0xF8, 0x00, 0x00, 0x01, 0xFB, 0xC0, 0x00, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0xC1, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00,
  0xF0, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xF1, 0xE0,
  0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E,
  0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xC3, 0xF8, 0x00, 0x07, 0x8F, 0xC0,
  0x00, 0x0F, 0x3E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3D, 0xF0, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x7E, 0x78, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x3E,
  0xF9, 0xFE, 0x03, 0xF9, 0xF1, 0xFF, 0xFF, 0xE3, 0xE0, 0xFF, 0xFF, 0x03,
  0xC0, 0x7F, 0xF8, 0x07, 0x80, 0x1E, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x3F,
  0xFC, 0x01, 0xE1, 0xFF, 0xFC, 0x03, 0xC7, 0xFF, 0xFE, 0x07, 0x9F, 0x01,
  0xFE, 0x0F, 0x78, 0x00, 0x7E, 0x1F, 0xE0, 0x00, 0x7C, 0x3F, 0x80, 0x00,
  0x7C, 0x7E, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x07, 0x9F, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x3C, 0x7F, 0x00,
  0x00, 0xF8, 0xFF, 0x00, 0x03, 0xE1, 0xFF, 0x00, 0x1F, 0xC3, 0xDF, 0x80,
  0xFF, 0x07, 0x9F, 0xFF, 0xFC, 0x0F, 0x0F, 0xFF, 0xE0, 0x1E, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1E, 0x1F, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x00, 0x7F, 0xF8, 0x3C, 0x07, 0xFF, 0xF0,
  0xF0, 0x3F, 0xFF, 0xF3, 0xC1, 0xFC, 0x07, 0xEF, 0x0F, 0xC0, 0x07, 0xFC,
  0x7C, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x0F, 0x7C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x1F,
  0xF0, 0x7F, 0x01, 0xFB, 0xC0, 0xFF, 0xFF, 0xCF, 0x01, 0xFF, 0xFE, 0x3C,
  0x01, 0xFF, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x03,
  0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x0F, 0x0F, 0x80, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x08, 0x0F, 0x80, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x0F, 0x81, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0xF0,
  0x1F, 0xFF, 0xC3, 0xC0, 0xFF, 0xFF, 0xCF, 0x07, 0xF0, 0x1F, 0xBC, 0x3F,
  0x00, 0x1F, 0xF1, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x7F, 0xC1, 0xFC, 0x07, 0xEF, 0x03, 0xFF, 0xFF, 0x3C, 0x07,
  0xFF, 0xF8, 0xF0, 0x07, 0xFF, 0x83, 0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x20, 0x00, 0x03, 0xE1, 0x80, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x3F, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0xFC, 0x00, 0xF0, 0x1F, 0xFE, 0x03, 0xC1, 0xFF, 0xFE, 0x0F, 0x0F,
  0xFF, 0xFC, 0x3C, 0x7C, 0x03, 0xF8, 0xF3, 0xC0, 0x03, 0xF3, 0xDE, 0x00,
  0x07, 0xCF, 0x60, 0x00, 0x0F, 0xBF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x7B, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x38, 0x1F,
  0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF9, 0xE0, 0x00, 0x07, 0xE3, 0xC0, 0x00, 0x1F, 0x87,
  0x80, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x3C,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x0F, 0xC0, 0x03, 0xC0, 0x3F, 0x00, 0x07, 0x80, 0xFC, 0x00, 0x0F, 0x03,
  0xF0, 0x00, 0x1E, 0x0F, 0xC0, 0x00, 0x3C, 0x3F, 0x00, 0x00, 0x78, 0xFC,
  0x00, 0x00, 0xF3, 0xF8, 0x00, 0x01, 0xEF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xF9, 0xF0, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x78, 0x03, 0xF0, 0x00, 0xF0, 0x03, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x80, 0x03, 0xE0,
  0x0F, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x07, 0xE0,
  0x78, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0x0F, 0xDE,
  0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x07, 0x8F, 0xFC, 0x07, 0xFC,
  0x3C, 0xFF, 0xF0, 0xFF, 0xF9, 0xEF, 0xFF, 0xCF, 0xFF, 0xCF, 0xF0, 0x3F,
  0xF8, 0x3F, 0x7E, 0x00, 0xFF, 0x00, 0x7B, 0xF0, 0x03, 0xF0, 0x03, 0xFF,
  0x00, 0x1F, 0x00, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xC0,
  0x03, 0xFC, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0x80, 0x07, 0xF8, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x7F, 0x80, 0x03,
  0xC0, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0x80, 0x07, 0xF8, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x01, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x7F, 0x80,
  0x03, 0xC0, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0x80, 0x07, 0xF8, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x01,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x7F,
  0x80, 0x03, 0xC0, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x00, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0x80, 0x07, 0xF8, 0x00, 0x3C, 0x00, 0x3F, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xC0, 0x7F, 0xF8, 0x0F,
  0x07, 0xFF, 0xF8, 0x3C, 0x3F, 0xFF, 0xF0, 0xF1, 0xF0, 0x0F, 0xE3, 0xCF,
  0x00, 0x0F, 0xCF, 0x78, 0x00, 0x1F, 0x3F, 0x80, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x00, 0xF9, 0xE0, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x0F, 0x1F, 0x00,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x7F, 0xF8, 0x03, 0xC3, 0xFF, 0xF8, 0x07, 0x9F, 0xFF, 0xFC,
  0x0F, 0x7E, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xF8,
  0x7E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x01, 0xF1, 0xFC, 0x00, 0x07, 0xC3, 0xFE, 0x00, 0x3F,
  0x07, 0xBF, 0x01, 0xFE, 0x0F, 0x3F, 0xFF, 0xF8, 0x1E, 0x1F, 0xFF, 0xC0,
  0x3C, 0x1F, 0xFF, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0xF0, 0x1F,
  0xFF, 0xE3, 0xC0, 0xFF, 0xFF, 0xCF, 0x0F, 0xF0, 0x1F, 0xBC, 0x3F, 0x00,
  0x1F, 0xF1, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x3F, 0xC1, 0xFC, 0x07, 0xEF, 0x03, 0xFF, 0xFF, 0x3C, 0x07, 0xFF,
  0xF8, 0xF0, 0x07, 0xFF, 0x83, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFC, 0x78, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xEF, 0x1F, 0xF8, 0xF7, 0x9F, 0x80, 0x03, 0xDF, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x03,
  0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7E, 0x1E, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x7C,
  0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFF, 0x00, 0x7F, 0x80,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0xDF, 0x00, 0x00,
  0x7F, 0x3E, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x3D, 0xF1, 0xFC, 0x07, 0xF7,
  0xC3, 0xFF, 0xFF, 0x1F, 0x07, 0xFF, 0xF8, 0x7C, 0x07, 0xFF, 0x80, 0xF0,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7D, 0xE0, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x3E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x1E, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0xE0, 0x00, 0x78, 0x00,
  0x3D, 0xE0, 0x00, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xE0, 0x00, 0xF7, 0x80,
  0x07, 0xE0, 0x01, 0xCF, 0x00, 0x0F, 0xC0, 0x03, 0x8E, 0x00, 0x1F, 0x80,
  0x0F, 0x1E, 0x00, 0x7F, 0x00, 0x1E, 0x3C, 0x00, 0xEF, 0x00, 0x3C, 0x78,
  0x01, 0xDE, 0x00, 0x70, 0x70, 0x03, 0x9C, 0x01, 0xE0, 0xE0, 0x0F, 0x38,
  0x03, 0xC1, 0xE0, 0x1E, 0x78, 0x07, 0x83, 0xC0, 0x38, 0xF0, 0x0E, 0x07,
  0x80, 0x70, 0xE0, 0x1C, 0x07, 0x01, 0xE1, 0xC0, 0x78, 0x0F, 0x03, 0xC3,
  0xC0, 0xF0, 0x1E, 0x07, 0x07, 0x81, 0xE0, 0x3C, 0x0E, 0x07, 0x03, 0x80,
  0x38, 0x3C, 0x0E, 0x07, 0x00, 0x70, 0x78, 0x1E, 0x1E, 0x00, 0xF0, 0xE0,
  0x3C, 0x3C, 0x01, 0xE1, 0xC0, 0x38, 0x78, 0x03, 0xC7, 0x80, 0x70, 0xE0,
  0x03, 0x8E, 0x00, 0xF1, 0xC0, 0x07, 0x1C, 0x01, 0xE7, 0x80, 0x0F, 0x38,
  0x01, 0xCF, 0x00, 0x1E, 0x70, 0x03, 0x9C, 0x00, 0x1D, 0xC0, 0x07, 0x38,
  0x00, 0x3B, 0x80, 0x0F, 0x70, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x00, 0xEE,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xDF, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x3C, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x9F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x10, 0x3F, 0xFE, 0x00,
  0x00, 0x38, 0xFF, 0xFF, 0x00, 0x00, 0xF3, 0xF0, 0x7F, 0x00, 0x01, 0xE7,
  0x80, 0x3F, 0x00, 0x03, 0xDE, 0x00, 0x3F, 0x00, 0x0F, 0x38, 0x00, 0x1F,
  0x80, 0x3E, 0xF0, 0x00, 0x1F, 0x80, 0xF9, 0xE0, 0x00, 0x1F, 0xFF, 0xF3,
  0xC0, 0x00, 0x1F, 0xFF, 0xC7, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00,
};

const GFXglyph RobotoMono_Light72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 6, 51, 43, 18, -51 },
  { 40, 15, 16, 43, 14, -54 },
  { 70, 39, 51, 43, 2, -51 },
  { 319, 32, 66, 43, 6, -59 },
  { 583, 40, 53, 43, 2, -52 },
  { 848, 37, 53, 43, 5, -52 },
  { 1094, 4, 16, 43, 18, -54 },
  { 1102, 17, 74, 43, 13, -57 },
  { 1260, 17, 74, 43, 12, -57 },
  { 1418, 33, 31, 43, 6, -51 },
  { 1546, 35, 37, 43, 4, -42 },
  { 1708, 7, 17, 43, 14, -7 },
  { 1723, 26, 4, 43, 8, -25 },
  { 1736, 7, 7, 43, 19, -7 },
  { 1743, 25, 55, 43, 10, -51 },
  { 1915, 32, 53, 43, 6, -52 },
  { 2127, 18, 51, 43, 8, -51 },
  { 2242, 34, 52, 43, 3, -52 },
  { 2463, 33, 53, 43, 3, -52 },
  { 2682, 36, 51, 43, 3, -51 },
  { 2912, 31, 52, 43, 7, -51 },
  { 3114, 32, 53, 43, 5, -52 },
  { 3326, 34, 51, 43, 4, -51 },
  { 3543, 33, 53, 43, 6, -52 },
  { 3762, 32, 52, 43, 5, -52 },
  { 3970, 7, 38, 43, 21, -38 },
  { 4004, 9, 48, 43, 19, -38 },
  { 4058, 30, 30, 43, 6, -38 },
  { 4171, 31, 18, 43, 6, -32 },
  { 4241, 31, 30, 43, 6, -38 },
  { 4358, 28, 52, 43, 8, -52 },
  { 4540, 39, 51, 43, 2, -51 },
  { 4789, 37, 51, 43, 4, -51 },
  { 5025, 32, 51, 43, 7, -51 },
  { 5229, 35, 53, 43, 4, -52 },
  { 5461, 33, 51, 43, 6, -51 },
  { 5672, 30, 51, 43, 7, -51 },
  { 5864, 31, 51, 43, 7, -51 },
  { 6062, 35, 53, 43, 4, -52 },
  { 6294, 32, 51, 43, 6, -51 },
  { 6498, 29, 51, 43, 7, -51 },
  { 6683, 32, 52, 43, 4, -51 },
  { 6891, 35, 51, 43, 7, -51 },
  { 7115, 30, 51, 43, 8, -51 },
  { 7307, 32, 51, 43, 6, -51 },
  { 7511, 32, 51, 43, 6, -51 },
  { 7715, 35, 53, 43, 4, -52 },
  { 7947, 32, 51, 43, 8, -51 },
  { 8151, 36, 61, 43, 4, -52 },
  { 8426, 33, 51, 43, 7, -51 },
  { 8637, 34, 53, 43, 5, -52 },
  { 8863, 37, 51, 43, 3, -51 },
  { 9099, 32, 52, 43, 6, -51 },
  { 9307, 37, 51, 43, 3, -51 },
  { 9543, 38, 51, 43, 3, -51 },
  { 9786, 37, 51, 43, 4, -51 },
  { 10022, 37, 51, 43, 3, -51 },
  { 10258, 32, 51, 43, 5, -51 },
  { 10462, 12, 70, 43, 16, -59 },
  { 10567, 25, 55, 43, 9, -51 },
  { 10739, 12, 70, 43, 15, -59 },
  { 10844, 26, 28, 43, 9, -51 },
  { 10935, 31, 4, 43, 6, 0 },
  { 10951, 11, 10, 43, 16, -53 },
  { 10965, 31, 40, 43, 6, -39 },
  { 11120, 31, 55, 43, 7, -54 },
  { 11334, 31, 40, 43, 6, -39 },
  { 11489, 30, 55, 43, 6, -54 },
  { 11696, 33, 40, 43, 5, -39 },
  { 11861, 33, 55, 43, 6, -55 },
  { 12088, 30, 54, 43, 6, -39 },
  { 12291, 30, 54, 43, 7, -54 },
  { 12494, 30, 52, 43, 8, -52 },
  { 12689, 22, 67, 43, 7, -52 },
  { 12874, 31, 54, 43, 8, -54 },
  { 13084, 30, 54, 43, 8, -54 },
  { 13287, 37, 39, 43, 3, -39 },
  { 13468, 30, 39, 43, 7, -39 },
  { 13615, 34, 40, 43, 5, -39 },
  { 13785, 31, 54, 43, 7, -39 },
  { 13995, 30, 54, 43, 6, -39 },
  { 14198, 25, 39, 43, 13, -39 },
  { 14320, 31, 40, 43, 7, -39 },
  { 14475, 31, 49, 43, 6, -48 },
  { 14665, 30, 39, 43, 7, -38 },
  { 14812, 35, 38, 43, 4, -38 },
  { 14979, 39, 38, 43, 2, -38 },
  { 15165, 34, 38, 43, 5, -38 },
  { 15327, 37, 53, 43, 3, -38 },
  { 15573, 34, 38, 43, 5, -38 },
  { 15735, 23, 70, 43, 12, -56 },
  { 15937, 3, 63, 43, 20, -51 },
  { 15961, 23, 70, 43, 12, -56 },
  { 16163, 39, 13, 43, 2, -28 },
};

const GFXfont RobotoMono_Light72pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light72pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light72pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _ROBOTOMONO_LIGHT72PT7B_H_
