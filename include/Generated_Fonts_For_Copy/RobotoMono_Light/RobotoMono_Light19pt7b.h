#ifndef _ROBOTOMONO_LIGHT19PT7B_H_
#define _ROBOTOMONO_LIGHT19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xC4, 0x99, 0x9A, 0x08, 0x82, 0x41, 0x10, 0x44, 0xFF, 0xC4,
  0x41, 0x20, 0x88, 0x22, 0x3F, 0xE2, 0x20, 0x90, 0x44, 0x11, 0x00, 0x08,
  0x08, 0x18, 0x66, 0xC3, 0x81, 0x80, 0x40, 0x70, 0x1C, 0x02, 0x01, 0x81,
  0x81, 0xC3, 0x7E, 0x08, 0x08, 0x30, 0x09, 0x02, 0x22, 0x44, 0x88, 0x90,
  0xF4, 0x00, 0x80, 0x20, 0x05, 0xC1, 0x44, 0x48, 0x89, 0x11, 0x22, 0x03,
  0x80, 0x1C, 0x0D, 0x82, 0x21, 0x88, 0x26, 0x0B, 0x01, 0x00, 0xA0, 0x4C,
  0xF1, 0x28, 0x2B, 0x06, 0x43, 0x8F, 0xB0, 0xF0, 0x12, 0x44, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x84, 0x42, 0x10, 0x82, 0x08, 0x41, 0x08, 0x43, 0x18,
  0x42, 0x31, 0x08, 0x44, 0x22, 0x30, 0x18, 0x18, 0x10, 0xD3, 0x7E, 0x18,
  0x24, 0x66, 0x42, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x00, 0xFA, 0x80, 0xFE, 0xF0, 0x04, 0x10, 0x82, 0x08, 0x41,
  0x04, 0x20, 0x84, 0x10, 0x42, 0x08, 0x00, 0x1C, 0x11, 0x90, 0x48, 0x14,
  0x1E, 0x17, 0x13, 0x91, 0xD0, 0xB0, 0x50, 0x28, 0x36, 0x11, 0xF0, 0x09,
  0xF3, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x18, 0x33, 0x30, 0xD0,
  0x20, 0x10, 0x08, 0x08, 0x08, 0x0C, 0x0C, 0x04, 0x04, 0x04, 0x07, 0xFC,
  0x1C, 0x66, 0xC1, 0x81, 0x01, 0x01, 0x06, 0x1E, 0x01, 0x01, 0x81, 0x81,
  0x43, 0x3E, 0x02, 0x03, 0x01, 0x81, 0x41, 0xA0, 0x90, 0x88, 0xC4, 0x42,
  0x41, 0x3F, 0xE0, 0x40, 0x20, 0x10, 0x7F, 0x7F, 0x40, 0x40, 0x40, 0x58,
  0xEE, 0x03, 0x01, 0x01, 0x81, 0x83, 0x42, 0x3C, 0x02, 0x0E, 0x08, 0x0C,
  0x04, 0x02, 0xF3, 0x8D, 0x82, 0xC0, 0xE0, 0x50, 0x28, 0x26, 0x11, 0xF0,
  0xFF, 0xFF, 0xC0, 0x40, 0x20, 0x30, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02,
  0x02, 0x01, 0x01, 0x00, 0x18, 0x66, 0xC3, 0x81, 0x81, 0xC2, 0x66, 0x7E,
  0x83, 0x81, 0x81, 0x81, 0xC3, 0x7E, 0x1C, 0x11, 0x10, 0x48, 0x3C, 0x0E,
  0x05, 0x02, 0x83, 0x36, 0x84, 0xC0, 0x40, 0x20, 0x61, 0xE0, 0xC0, 0xC0,
  0x70, 0x00, 0x56, 0x80, 0x02, 0x1C, 0xC6, 0x0C, 0x07, 0x03, 0x81, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x1C, 0x03, 0x06, 0x18, 0xE0, 0x80,
  0x38, 0x66, 0x82, 0x83, 0x02, 0x02, 0x04, 0x08, 0x18, 0x10, 0x00, 0x00,
  0x00, 0x10, 0x0C, 0x0C, 0xC4, 0x09, 0x32, 0x92, 0x64, 0x9A, 0x26, 0x89,
  0xA2, 0x69, 0xA9, 0xBA, 0x00, 0x40, 0x0F, 0x80, 0x08, 0x03, 0x00, 0xC0,
  0x50, 0x12, 0x04, 0x82, 0x20, 0x84, 0x21, 0x1F, 0xC4, 0x19, 0x02, 0xC0,
  0xA0, 0x30, 0xF0, 0x8E, 0x82, 0x81, 0x81, 0x82, 0x8C, 0xFE, 0x81, 0x81,
  0x81, 0x81, 0x82, 0xFC, 0x1C, 0x19, 0x90, 0x68, 0x18, 0x0C, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x30, 0x28, 0x16, 0x11, 0xF0, 0xE0, 0x9C, 0x82, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x86, 0xF8, 0xFF, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF,
  0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x1C, 0x19, 0x90, 0x68, 0x18, 0x04, 0x02, 0x01, 0x00, 0x87,
  0xC0, 0x70, 0x28, 0x16, 0x08, 0xF8, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x04, 0xFF, 0xFF,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0,
  0x50, 0x24, 0x31, 0xF0, 0x81, 0xC1, 0xA1, 0x90, 0x88, 0x84, 0x82, 0x81,
  0xE0, 0xC8, 0x46, 0x21, 0x10, 0x48, 0x14, 0x0C, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x81, 0x83,
  0xC3, 0xC5, 0xC5, 0xA5, 0xA9, 0xA9, 0x99, 0x91, 0x81, 0x81, 0x81, 0x81,
  0xC0, 0xE0, 0x78, 0x3C, 0x1D, 0x0E, 0x87, 0x23, 0x91, 0xC4, 0xE3, 0x70,
  0xB8, 0x7C, 0x1E, 0x04, 0x1C, 0x19, 0x90, 0x48, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x50, 0x28, 0x36, 0x11, 0xF0, 0xF0, 0x43, 0x20, 0x50,
  0x28, 0x1C, 0x0A, 0x05, 0xFC, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00,
  0x1C, 0x19, 0x90, 0x48, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x28, 0x16, 0x11, 0xF0, 0x04, 0x01, 0xF0, 0x8E, 0x83, 0x81, 0x81, 0x81,
  0x82, 0xFC, 0x8C, 0x84, 0x86, 0x82, 0x83, 0x81, 0x0C, 0x19, 0x90, 0x68,
  0x14, 0x03, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x60, 0x28, 0x16, 0x19, 0xF8,
  0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x50, 0x28, 0x36, 0x11, 0xF0, 0x80, 0xE0,
  0x2C, 0x09, 0x06, 0x41, 0x18, 0x42, 0x30, 0x88, 0x22, 0x04, 0x81, 0x40,
  0x50, 0x0C, 0x02, 0x00, 0x88, 0x63, 0x18, 0xC6, 0x32, 0x8C, 0xB5, 0x25,
  0x29, 0x4A, 0x52, 0x94, 0xA6, 0x29, 0x8C, 0x61, 0x08, 0x40, 0x80, 0xD0,
  0x26, 0x10, 0x8C, 0x12, 0x05, 0x80, 0xC0, 0x30, 0x1C, 0x04, 0x82, 0x30,
  0x84, 0x40, 0xB0, 0x30, 0x80, 0xC0, 0x50, 0x48, 0x22, 0x21, 0x10, 0x50,
  0x28, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0xFF, 0x80, 0x80, 0x40,
  0x40, 0x60, 0x20, 0x20, 0x10, 0x10, 0x18, 0x08, 0x08, 0x04, 0x07, 0xFC,
  0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0x9C, 0x80, 0x81, 0x01, 0x02, 0x04,
  0x04, 0x08, 0x18, 0x10, 0x20, 0x20, 0x40, 0x80, 0x80, 0xE4, 0x92, 0x49,
  0x24, 0x92, 0x49, 0x3C, 0x10, 0x30, 0xA1, 0x42, 0x48, 0x90, 0xC1, 0xFF,
  0xC8, 0x80, 0x7C, 0x82, 0x83, 0x03, 0x3F, 0xC3, 0x83, 0x83, 0x87, 0x79,
  0x80, 0x80, 0x80, 0x80, 0xBC, 0xC2, 0x83, 0x81, 0x81, 0x81, 0x81, 0x83,
  0xC2, 0xBC, 0x3E, 0x30, 0x90, 0x28, 0x0C, 0x02, 0x01, 0x00, 0x81, 0x61,
  0x0F, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x33, 0xFB, 0x0D, 0x06, 0x83, 0xC1,
  0xE0, 0xD0, 0x68, 0x36, 0x19, 0xFC, 0x1E, 0x30, 0x90, 0x28, 0x1F, 0xFE,
  0x01, 0x00, 0x80, 0x61, 0x8F, 0x80, 0x02, 0x1D, 0x10, 0x30, 0x30, 0xFF,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3E, 0xB0, 0xD0,
  0x68, 0x3C, 0x1E, 0x0D, 0x06, 0x83, 0x61, 0x9F, 0xC0, 0x60, 0x26, 0x30,
  0xF0, 0x80, 0x80, 0x80, 0x80, 0xBE, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x08, 0x18, 0x00, 0x00, 0xF8, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0xFF, 0x08, 0x30, 0x00, 0x7C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC2, 0x1B, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x83,
  0x84, 0x88, 0x90, 0xB0, 0xD0, 0x88, 0x84, 0x82, 0x83, 0xF8, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0xFF,
  0xA3, 0x28, 0x86, 0x21, 0x88, 0x62, 0x18, 0x86, 0x21, 0x88, 0x62, 0x10,
  0xBE, 0xC2, 0x83, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x3E, 0x30,
  0x90, 0x38, 0x18, 0x0C, 0x07, 0x02, 0x81, 0x61, 0x1F, 0x00, 0xBC, 0xC2,
  0x83, 0x81, 0x81, 0x81, 0x81, 0x83, 0xC2, 0xBC, 0x80, 0x80, 0x80, 0x80,
  0x3F, 0xB0, 0xD0, 0x68, 0x3C, 0x1E, 0x0D, 0x06, 0x83, 0x61, 0x9F, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x9F, 0x43, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x00, 0x7E, 0xC3, 0x81, 0xC0, 0x70, 0x0E, 0x03, 0x81, 0xC3, 0x7E, 0x30,
  0x30, 0x30, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x10, 0x1F,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC3, 0x7D, 0x80, 0xA0,
  0x50, 0x4C, 0x22, 0x21, 0x10, 0x48, 0x28, 0x0C, 0x04, 0x00, 0x88, 0x63,
  0x18, 0xCA, 0x52, 0x54, 0x94, 0xA5, 0x29, 0x8C, 0x63, 0x08, 0x40, 0xC0,
  0x90, 0x8C, 0x82, 0xC0, 0xC0, 0x60, 0x58, 0x44, 0x61, 0x60, 0x40, 0x80,
  0xF0, 0x24, 0x19, 0x84, 0x23, 0x08, 0x81, 0x20, 0x50, 0x0C, 0x02, 0x00,
  0x80, 0x60, 0x10, 0x38, 0x00, 0x7F, 0x80, 0x80, 0x80, 0x80, 0xC0, 0xC0,
  0x40, 0x40, 0x40, 0x7F, 0xC0, 0x04, 0x21, 0x04, 0x10, 0x41, 0x04, 0x23,
  0x02, 0x04, 0x10, 0x41, 0x04, 0x10, 0x20, 0x40, 0xFF, 0xFF, 0x80, 0x81,
  0x82, 0x0C, 0x10, 0x41, 0x04, 0x18, 0x11, 0x84, 0x10, 0x41, 0x0C, 0x21,
  0x88, 0x00, 0xF0, 0x63, 0x38, 0x78,
};

const GFXglyph RobotoMono_Light19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 1, 14, 11, 5, -14 },
  { 3, 4, 4, 11, 4, -14 },
  { 5, 10, 14, 11, 1, -14 },
  { 23, 8, 18, 11, 2, -16 },
  { 41, 11, 14, 11, 0, -14 },
  { 61, 10, 14, 11, 1, -14 },
  { 79, 1, 4, 11, 5, -14 },
  { 80, 4, 19, 11, 4, -15 },
  { 90, 5, 19, 11, 3, -15 },
  { 102, 8, 9, 11, 2, -14 },
  { 111, 9, 10, 11, 1, -11 },
  { 123, 2, 5, 11, 4, -2 },
  { 125, 7, 1, 11, 2, -7 },
  { 126, 2, 2, 11, 5, -2 },
  { 127, 6, 15, 11, 3, -14 },
  { 139, 9, 14, 11, 1, -14 },
  { 155, 5, 14, 11, 2, -14 },
  { 164, 9, 14, 11, 1, -14 },
  { 180, 8, 14, 11, 1, -14 },
  { 194, 9, 14, 11, 1, -14 },
  { 210, 8, 14, 11, 2, -14 },
  { 224, 9, 14, 11, 1, -14 },
  { 240, 9, 14, 11, 1, -14 },
  { 256, 8, 14, 11, 2, -14 },
  { 270, 9, 14, 11, 1, -14 },
  { 286, 1, 10, 11, 6, -10 },
  { 288, 2, 13, 11, 5, -10 },
  { 292, 7, 8, 11, 2, -10 },
  { 299, 8, 5, 11, 2, -9 },
  { 304, 8, 8, 11, 2, -10 },
  { 312, 8, 14, 11, 2, -14 },
  { 326, 10, 14, 11, 1, -14 },
  { 344, 10, 14, 11, 1, -14 },
  { 362, 8, 14, 11, 2, -14 },
  { 376, 9, 14, 11, 1, -14 },
  { 392, 8, 14, 11, 2, -14 },
  { 406, 8, 14, 11, 2, -14 },
  { 420, 8, 14, 11, 2, -14 },
  { 434, 9, 14, 11, 1, -14 },
  { 450, 9, 14, 11, 1, -14 },
  { 466, 8, 14, 11, 2, -14 },
  { 480, 9, 14, 11, 1, -14 },
  { 496, 9, 14, 11, 2, -14 },
  { 512, 8, 14, 11, 2, -14 },
  { 526, 8, 14, 11, 2, -14 },
  { 540, 9, 14, 11, 1, -14 },
  { 556, 9, 14, 11, 1, -14 },
  { 572, 9, 14, 11, 2, -14 },
  { 588, 9, 16, 11, 1, -14 },
  { 606, 8, 14, 11, 2, -14 },
  { 620, 9, 14, 11, 1, -14 },
  { 636, 10, 14, 11, 1, -14 },
  { 654, 9, 14, 11, 1, -14 },
  { 670, 10, 14, 11, 1, -14 },
  { 688, 10, 14, 11, 1, -14 },
  { 706, 10, 14, 11, 1, -14 },
  { 724, 9, 14, 11, 1, -14 },
  { 740, 9, 14, 11, 1, -14 },
  { 756, 3, 18, 11, 4, -15 },
  { 763, 7, 15, 11, 2, -14 },
  { 777, 3, 18, 11, 4, -15 },
  { 784, 7, 8, 11, 2, -14 },
  { 791, 8, 1, 11, 2, 0 },
  { 792, 3, 3, 11, 4, -14 },
  { 794, 8, 10, 11, 2, -10 },
  { 804, 8, 14, 11, 2, -14 },
  { 818, 9, 10, 11, 1, -10 },
  { 830, 9, 14, 11, 1, -14 },
  { 846, 9, 10, 11, 1, -10 },
  { 858, 8, 15, 11, 2, -15 },
  { 873, 9, 14, 11, 1, -10 },
  { 889, 8, 14, 11, 2, -14 },
  { 903, 8, 14, 11, 2, -14 },
  { 917, 6, 18, 11, 2, -14 },
  { 931, 8, 14, 11, 2, -14 },
  { 945, 8, 14, 11, 2, -14 },
  { 959, 10, 10, 11, 1, -10 },
  { 972, 8, 10, 11, 2, -10 },
  { 982, 9, 10, 11, 1, -10 },
  { 994, 8, 14, 11, 2, -10 },
  { 1008, 9, 14, 11, 1, -10 },
  { 1024, 7, 10, 11, 3, -10 },
  { 1033, 8, 10, 11, 2, -10 },
  { 1043, 8, 13, 11, 2, -13 },
  { 1056, 8, 10, 11, 2, -10 },
  { 1066, 9, 10, 11, 1, -10 },
  { 1078, 10, 10, 11, 1, -10 },
  { 1091, 9, 10, 11, 1, -10 },
  { 1103, 10, 14, 11, 1, -10 },
  { 1121, 9, 10, 11, 1, -10 },
  { 1133, 6, 19, 11, 3, -15 },
  { 1148, 1, 17, 11, 5, -14 },
  { 1151, 6, 19, 11, 3, -15 },
  { 1166, 10, 3, 11, 1, -7 },
};

const GFXfont RobotoMono_Light19pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light19pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOMONO_LIGHT19PT7B_H_
