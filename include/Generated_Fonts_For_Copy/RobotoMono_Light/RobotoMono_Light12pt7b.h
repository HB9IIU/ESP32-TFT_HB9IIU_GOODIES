#ifndef _ROBOTOMONO_LIGHT12PT7B_H_
#define _ROBOTOMONO_LIGHT12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0x80, 0xB6, 0x80, 0x14, 0x28, 0x93, 0xF2, 0x85, 0x3F, 0x24,
  0x48, 0x21, 0x93, 0x18, 0x30, 0x61, 0x8B, 0xC8, 0x41, 0x4A, 0xA7, 0x41,
  0x02, 0x8A, 0x95, 0x0E, 0x21, 0x49, 0x18, 0x42, 0x99, 0x62, 0xF4, 0xE0,
  0x25, 0x29, 0x24, 0x91, 0x22, 0x91, 0x22, 0x49, 0x25, 0x28, 0x21, 0x3E,
  0x45, 0x24, 0x20, 0x82, 0x3F, 0x20, 0x80, 0x58, 0xF8, 0x80, 0x11, 0x22,
  0x44, 0x48, 0x88, 0x74, 0x63, 0x3A, 0xE6, 0x31, 0x70, 0x3C, 0x92, 0x49,
  0x20, 0x64, 0xA2, 0x11, 0x11, 0x08, 0xF8, 0x74, 0x62, 0x17, 0x04, 0x31,
  0xF0, 0x08, 0x10, 0x61, 0x42, 0x89, 0x3F, 0x84, 0x08, 0x7A, 0x11, 0x45,
  0x84, 0x31, 0x78, 0x32, 0x21, 0x6C, 0xC6, 0x31, 0x70, 0xF8, 0x42, 0x21,
  0x10, 0x84, 0x40, 0x36, 0x63, 0x17, 0x46, 0x31, 0x78, 0x74, 0x63, 0x18,
  0xBC, 0x21, 0x70, 0xC0, 0x30, 0xC0, 0x2A, 0x1B, 0x30, 0x60, 0x80, 0xF8,
  0x3E, 0xC1, 0x86, 0xC8, 0x00, 0x74, 0x42, 0x11, 0x10, 0x80, 0x20, 0x18,
  0xC9, 0x6D, 0x5A, 0xB5, 0x6F, 0xA0, 0x38, 0x20, 0x83, 0x14, 0x51, 0x2F,
  0xA2, 0x84, 0xF4, 0x63, 0x1F, 0x46, 0x31, 0xF0, 0x74, 0x63, 0x08, 0x42,
  0x31, 0x70, 0xE2, 0x68, 0xA1, 0x86, 0x18, 0x62, 0xF0, 0xFC, 0x21, 0x0F,
  0xC2, 0x10, 0xF8, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0x80, 0x74, 0x63, 0x08,
  0x4E, 0x31, 0x78, 0x8C, 0x63, 0x1F, 0xC6, 0x31, 0x88, 0xF9, 0x08, 0x42,
  0x10, 0x84, 0xF8, 0x08, 0x42, 0x10, 0x84, 0x31, 0x70, 0x86, 0x29, 0x28,
  0xE2, 0x89, 0x22, 0x84, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0x8C, 0x77,
  0xBD, 0xD6, 0x31, 0x88, 0x8C, 0x73, 0x9A, 0xCE, 0x71, 0x88, 0x74, 0x63,
  0x18, 0xC6, 0x31, 0x70, 0xF2, 0x28, 0x61, 0x8B, 0xC8, 0x20, 0x80, 0x72,
  0x28, 0xA1, 0x86, 0x18, 0x62, 0x70, 0x30, 0xF2, 0x28, 0xA2, 0x8B, 0xC9,
  0x22, 0x8C, 0x72, 0x28, 0x60, 0x70, 0x20, 0x61, 0x78, 0xFC, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x70, 0x86, 0x28,
  0xA2, 0x51, 0x45, 0x08, 0x20, 0x93, 0x25, 0x4A, 0xD6, 0xAD, 0x99, 0x32,
  0x24, 0x86, 0x24, 0x94, 0x20, 0xC5, 0x22, 0x84, 0x82, 0x89, 0x11, 0x42,
  0x82, 0x04, 0x08, 0x10, 0xF8, 0x44, 0x22, 0x21, 0x10, 0xF8, 0xEA, 0xAA,
  0xAB, 0x82, 0x10, 0x82, 0x10, 0x42, 0x10, 0x40, 0xD5, 0x55, 0x57, 0x21,
  0x14, 0xAC, 0x80, 0xF8, 0x90, 0xF8, 0x5F, 0x18, 0xFC, 0x84, 0x29, 0xB8,
  0xC6, 0x31, 0xF0, 0x7C, 0x61, 0x08, 0xB8, 0x08, 0x4A, 0xB8, 0xC6, 0x31,
  0x78, 0x7C, 0x7F, 0x08, 0x3C, 0x3C, 0x8F, 0x88, 0x20, 0x82, 0x08, 0x20,
  0x7C, 0x63, 0x18, 0xBC, 0x31, 0x70, 0x84, 0x2D, 0x98, 0xC6, 0x31, 0x88,
  0x20, 0x30, 0x42, 0x10, 0x84, 0xF8, 0x10, 0x61, 0x11, 0x11, 0x11, 0x2C,
  0x82, 0x08, 0xA4, 0xA3, 0x8A, 0x24, 0x8C, 0xE1, 0x08, 0x42, 0x10, 0x84,
  0xF8, 0xFE, 0x9A, 0x69, 0xA6, 0x90, 0xFC, 0x63, 0x18, 0xC4, 0xFC, 0x63,
  0x18, 0xB8, 0xFC, 0x63, 0x18, 0xFA, 0x10, 0x7C, 0x63, 0x18, 0xBC, 0x21,
  0xF8, 0x88, 0x88, 0xFC, 0x1C, 0x18, 0xBC, 0x27, 0xC8, 0x42, 0x10, 0x87,
  0x8C, 0x63, 0x18, 0xBC, 0x8E, 0x25, 0x14, 0x30, 0x80, 0x92, 0xA5, 0xB3,
  0x66, 0x44, 0x80, 0x89, 0x42, 0x0C, 0x52, 0x30, 0xC6, 0x88, 0x91, 0x41,
  0x82, 0x04, 0x10, 0x40, 0xF8, 0x88, 0x84, 0x7C, 0x32, 0x44, 0x48, 0x44,
  0x42, 0x30, 0xFF, 0xE0, 0xC4, 0x44, 0x21, 0x24, 0x44, 0xC0, 0x61, 0x24,
  0x30,
};

const GFXglyph RobotoMono_Light12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 9, 7, 3, -9 },
  { 3, 3, 3, 7, 2, -9 },
  { 5, 7, 9, 7, 0, -9 },
  { 13, 5, 11, 7, 1, -10 },
  { 20, 7, 9, 7, 0, -9 },
  { 28, 6, 9, 7, 1, -9 },
  { 35, 1, 3, 7, 3, -9 },
  { 36, 3, 13, 7, 2, -10 },
  { 41, 3, 13, 7, 2, -10 },
  { 46, 5, 6, 7, 1, -9 },
  { 50, 6, 6, 7, 1, -7 },
  { 55, 2, 3, 7, 2, -1 },
  { 56, 5, 1, 7, 1, -4 },
  { 57, 1, 1, 7, 3, -1 },
  { 58, 4, 10, 7, 2, -9 },
  { 63, 5, 9, 7, 1, -9 },
  { 69, 3, 9, 7, 1, -9 },
  { 73, 5, 9, 7, 1, -9 },
  { 79, 5, 9, 7, 1, -9 },
  { 85, 7, 9, 7, 0, -9 },
  { 93, 5, 9, 7, 1, -9 },
  { 99, 5, 9, 7, 1, -9 },
  { 105, 5, 9, 7, 1, -9 },
  { 111, 5, 9, 7, 1, -9 },
  { 117, 5, 9, 7, 1, -9 },
  { 123, 2, 6, 7, 3, -6 },
  { 125, 2, 8, 7, 3, -6 },
  { 127, 5, 5, 7, 1, -6 },
  { 131, 5, 3, 7, 1, -5 },
  { 133, 5, 5, 7, 1, -6 },
  { 137, 5, 9, 7, 1, -9 },
  { 143, 7, 9, 7, 0, -9 },
  { 151, 6, 9, 7, 1, -9 },
  { 158, 5, 9, 7, 1, -9 },
  { 164, 5, 9, 7, 1, -9 },
  { 170, 6, 9, 7, 1, -9 },
  { 177, 5, 9, 7, 1, -9 },
  { 183, 5, 9, 7, 1, -9 },
  { 189, 5, 9, 7, 1, -9 },
  { 195, 5, 9, 7, 1, -9 },
  { 201, 5, 9, 7, 1, -9 },
  { 207, 5, 9, 7, 1, -9 },
  { 213, 6, 9, 7, 1, -9 },
  { 220, 5, 9, 7, 1, -9 },
  { 226, 5, 9, 7, 1, -9 },
  { 232, 5, 9, 7, 1, -9 },
  { 238, 5, 9, 7, 1, -9 },
  { 244, 6, 9, 7, 1, -9 },
  { 251, 6, 10, 7, 1, -9 },
  { 259, 6, 9, 7, 1, -9 },
  { 266, 6, 9, 7, 1, -9 },
  { 273, 6, 9, 7, 1, -9 },
  { 280, 5, 9, 7, 1, -9 },
  { 286, 6, 9, 7, 1, -9 },
  { 293, 7, 9, 7, 0, -9 },
  { 301, 6, 9, 7, 1, -9 },
  { 308, 7, 9, 7, 0, -9 },
  { 316, 5, 9, 7, 1, -9 },
  { 322, 2, 12, 7, 3, -10 },
  { 325, 5, 10, 7, 1, -9 },
  { 332, 2, 12, 7, 3, -10 },
  { 335, 5, 5, 7, 1, -9 },
  { 339, 5, 1, 7, 1, 0 },
  { 340, 2, 2, 7, 3, -9 },
  { 341, 5, 6, 7, 1, -6 },
  { 345, 5, 9, 7, 1, -9 },
  { 351, 5, 6, 7, 1, -6 },
  { 355, 5, 9, 7, 1, -9 },
  { 361, 5, 6, 7, 1, -6 },
  { 365, 6, 9, 7, 1, -9 },
  { 372, 5, 9, 7, 1, -6 },
  { 378, 5, 9, 7, 1, -9 },
  { 384, 5, 9, 7, 1, -9 },
  { 390, 4, 12, 7, 1, -9 },
  { 396, 6, 9, 7, 1, -9 },
  { 403, 5, 9, 7, 1, -9 },
  { 409, 6, 6, 7, 1, -6 },
  { 414, 5, 6, 7, 1, -6 },
  { 418, 5, 6, 7, 1, -6 },
  { 422, 5, 8, 7, 1, -6 },
  { 427, 5, 8, 7, 1, -6 },
  { 432, 4, 6, 7, 2, -6 },
  { 435, 5, 6, 7, 1, -6 },
  { 439, 5, 8, 7, 1, -8 },
  { 444, 5, 6, 7, 1, -6 },
  { 448, 6, 6, 7, 1, -6 },
  { 453, 7, 6, 7, 0, -6 },
  { 459, 6, 6, 7, 1, -6 },
  { 464, 7, 9, 7, 0, -6 },
  { 472, 5, 6, 7, 1, -6 },
  { 476, 4, 11, 7, 2, -9 },
  { 482, 1, 11, 7, 3, -9 },
  { 484, 4, 11, 7, 2, -9 },
  { 490, 7, 3, 7, 0, -5 },
};

const GFXfont RobotoMono_Light12pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light12pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOMONO_LIGHT12PT7B_H_
