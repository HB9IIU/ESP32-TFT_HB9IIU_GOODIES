#ifndef _ROBOTOMONO_LIGHT18PT7B_H_
#define _ROBOTOMONO_LIGHT18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x88, 0xB6, 0xD0, 0x11, 0x08, 0x84, 0x42, 0x4F, 0xF9, 0x10,
  0x88, 0x44, 0xFB, 0x92, 0x09, 0x08, 0x84, 0x40, 0x10, 0x10, 0x3C, 0x46,
  0x82, 0x82, 0x80, 0x40, 0x38, 0x06, 0x02, 0x83, 0x82, 0x82, 0x7C, 0x10,
  0x10, 0x70, 0x12, 0x08, 0x92, 0x24, 0x4A, 0x0C, 0x80, 0x40, 0x26, 0x0A,
  0x44, 0x91, 0x24, 0xC9, 0x01, 0xC0, 0x3C, 0x12, 0x10, 0x88, 0x82, 0x41,
  0xC0, 0xC0, 0x91, 0xC4, 0xC3, 0x60, 0xC8, 0x63, 0xC8, 0xF0, 0x19, 0x08,
  0x84, 0x21, 0x10, 0x84, 0x20, 0x84, 0x21, 0x04, 0x10, 0x40, 0x84, 0x22,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x22, 0x48, 0x10, 0x10, 0x10, 0xF7, 0x18,
  0x28, 0x64, 0x46, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xFF, 0xFC, 0x20, 0x10,
  0x08, 0x04, 0x00, 0x55, 0xC0, 0xFE, 0xB0, 0x02, 0x08, 0x10, 0x20, 0x81,
  0x04, 0x08, 0x10, 0x40, 0x82, 0x04, 0x18, 0x00, 0x1C, 0x62, 0x41, 0x41,
  0x83, 0x85, 0x89, 0x91, 0xE1, 0x41, 0x41, 0x43, 0x3E, 0x0B, 0xE6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x80, 0x3C, 0x42, 0x82, 0x83, 0x02, 0x02,
  0x04, 0x0C, 0x18, 0x10, 0x20, 0x40, 0xFF, 0x3C, 0x42, 0x83, 0x81, 0x02,
  0x02, 0x1C, 0x02, 0x01, 0x01, 0x81, 0xC2, 0x7C, 0x06, 0x03, 0x02, 0x83,
  0x41, 0x21, 0x11, 0x88, 0x84, 0x82, 0x7F, 0xC0, 0x80, 0x40, 0x20, 0x7E,
  0x40, 0x40, 0x40, 0x80, 0xFC, 0x86, 0x02, 0x03, 0x03, 0x82, 0xC6, 0x7C,
  0x0E, 0x30, 0x20, 0x40, 0x40, 0xBE, 0xC3, 0x81, 0x81, 0x81, 0x41, 0x63,
  0x3E, 0xFF, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x18, 0x08, 0x04,
  0x04, 0x02, 0x02, 0x00, 0x3C, 0xC6, 0x82, 0x82, 0x82, 0x46, 0x3C, 0xC2,
  0x83, 0x81, 0x81, 0x82, 0x7C, 0x3C, 0x62, 0x41, 0xC1, 0x81, 0xC1, 0x41,
  0x63, 0x1D, 0x01, 0x02, 0x06, 0x38, 0x70, 0x00, 0x70, 0x70, 0x00, 0xFA,
  0x80, 0x01, 0x03, 0x1C, 0x60, 0xC0, 0x38, 0x06, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x81, 0x80, 0xC0, 0x70, 0x63, 0x18, 0x40, 0x39, 0x8E, 0x08, 0x10,
  0x20, 0x82, 0x08, 0x10, 0x00, 0x00, 0x01, 0x00, 0x0F, 0x04, 0x22, 0x05,
  0x3D, 0x49, 0x54, 0x59, 0x26, 0x49, 0x92, 0x57, 0x64, 0x00, 0x80, 0x1F,
  0x00, 0x08, 0x04, 0x05, 0x02, 0x81, 0x41, 0x10, 0x88, 0x44, 0x7F, 0x20,
  0x90, 0x50, 0x18, 0x08, 0xF8, 0x86, 0x82, 0x82, 0x82, 0x84, 0xFC, 0x82,
  0x81, 0x81, 0x83, 0x82, 0xFC, 0x1C, 0x31, 0x90, 0x50, 0x38, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x50, 0x4C, 0x23, 0xE0, 0xF0, 0x8C, 0x82, 0x82,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0xF8, 0xFF, 0x02, 0x04,
  0x08, 0x10, 0x3F, 0x40, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0xFF, 0x02, 0x04,
  0x08, 0x10, 0x3F, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x00, 0x1C, 0x31, 0x90,
  0x50, 0x18, 0x04, 0x02, 0x01, 0x0F, 0x80, 0xC0, 0x50, 0x2C, 0x33, 0xE0,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8F,
  0xE0, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x81, 0x81,
  0x42, 0x3C, 0x83, 0x82, 0x84, 0x88, 0x90, 0xA0, 0xF0, 0xD0, 0x88, 0x84,
  0x86, 0x82, 0x81, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0xC1, 0xE0, 0xE8, 0xB4, 0x5A, 0x2C, 0xA6, 0x53,
  0xB3, 0xC9, 0xE0, 0xF0, 0x78, 0x3C, 0x18, 0xC1, 0xC1, 0xA1, 0xA1, 0x91,
  0x91, 0x89, 0x89, 0x85, 0x87, 0x83, 0x81, 0x81, 0x1C, 0x31, 0x10, 0x50,
  0x28, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x90, 0x4C, 0x63, 0xE0, 0xFC,
  0x82, 0x81, 0x81, 0x81, 0x81, 0x86, 0xF8, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x1C, 0x31, 0x90, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x50,
  0x48, 0x63, 0xE0, 0x18, 0x06, 0xF8, 0x86, 0x82, 0x83, 0x82, 0x82, 0x84,
  0xF8, 0x8C, 0x84, 0x86, 0x82, 0x81, 0x3E, 0x31, 0x90, 0x48, 0x14, 0x01,
  0x00, 0x70, 0x06, 0x01, 0xC0, 0x70, 0x28, 0x23, 0xE0, 0xFF, 0x84, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x43,
  0x3E, 0x80, 0xC0, 0xD0, 0x48, 0x24, 0x13, 0x10, 0x88, 0x44, 0x24, 0x0A,
  0x05, 0x03, 0x00, 0x80, 0x88, 0xC4, 0x62, 0x32, 0x99, 0x4C, 0xA5, 0x54,
  0xAA, 0x63, 0x31, 0x98, 0xCC, 0x66, 0x30, 0x80, 0xA0, 0x98, 0xC4, 0x41,
  0x40, 0xA0, 0x20, 0x28, 0x14, 0x11, 0x18, 0xC8, 0x28, 0x08, 0x80, 0xE0,
  0x90, 0x48, 0x42, 0x21, 0x20, 0x50, 0x30, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0xFF, 0x01, 0x02, 0x06, 0x04, 0x08, 0x08, 0x10, 0x30, 0x20, 0x40,
  0x40, 0xFF, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0x9C, 0x80, 0x81, 0x01,
  0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0xC0, 0xE4, 0x92,
  0x49, 0x24, 0x92, 0x49, 0x3C, 0x10, 0x60, 0xA1, 0x44, 0x48, 0xA1, 0x80,
  0xFE, 0xCC, 0x1C, 0x62, 0x41, 0x01, 0x0F, 0x71, 0x41, 0xC1, 0x43, 0x3D,
  0x81, 0x02, 0x04, 0x0B, 0x98, 0xA0, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x77,
  0x80, 0x1C, 0x22, 0x41, 0x41, 0xC0, 0x80, 0x40, 0x41, 0x61, 0x3E, 0x01,
  0x01, 0x01, 0x01, 0x19, 0x27, 0x41, 0x41, 0x81, 0x81, 0xC1, 0x41, 0x43,
  0x3D, 0x1C, 0x22, 0x41, 0x41, 0xFF, 0x80, 0x80, 0x40, 0x61, 0x3E, 0x0F,
  0x10, 0x20, 0x20, 0xFE, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x19, 0x27, 0x41, 0x41, 0x81, 0x81, 0xC1, 0x41, 0x43, 0x3D, 0x01,
  0x01, 0x62, 0x1C, 0x81, 0x02, 0x04, 0x09, 0x9C, 0xE0, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x40, 0x18, 0x10, 0x00, 0xF0, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0xFF, 0x08, 0x40, 0xF0, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x22, 0xE0, 0x80, 0x80, 0x80, 0x80, 0x82, 0x84, 0x88, 0x90,
  0xA0, 0xD0, 0x98, 0x8C, 0x84, 0x83, 0xF0, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0xB3, 0x6E, 0x62, 0x31,
  0x18, 0x8C, 0x46, 0x23, 0x11, 0x88, 0xC4, 0x40, 0x99, 0xCE, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x04, 0x1C, 0x31, 0x10, 0x50, 0x28, 0x0C, 0x06,
  0x06, 0x82, 0x43, 0x1F, 0x00, 0xB9, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x87, 0xFA, 0x04, 0x08, 0x10, 0x00, 0x19, 0x27, 0x41, 0x41, 0x81, 0x81,
  0xC1, 0x41, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01, 0x8E, 0xDC, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x00, 0x38, 0x8E, 0x0C, 0x06, 0x03, 0x80, 0xC1, 0x82,
  0xF8, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x18,
  0x0F, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x86, 0xF4, 0x80, 0xC0,
  0x90, 0x48, 0x62, 0x21, 0x10, 0x90, 0x28, 0x18, 0x04, 0x00, 0x88, 0xC4,
  0x66, 0x32, 0x99, 0x4A, 0xA9, 0x94, 0xC6, 0x63, 0x11, 0x00, 0xC1, 0xA0,
  0x88, 0x82, 0x81, 0xC0, 0x40, 0x50, 0x44, 0x63, 0x60, 0xC0, 0x80, 0xC0,
  0xD0, 0x48, 0x22, 0x21, 0x10, 0xD0, 0x28, 0x1C, 0x04, 0x02, 0x02, 0x03,
  0x07, 0x00, 0xFF, 0x00, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x40,
  0x7F, 0xC0, 0x0C, 0x41, 0x08, 0x20, 0x82, 0x08, 0xC1, 0x82, 0x08, 0x20,
  0x83, 0x04, 0x18, 0x10, 0xFF, 0xFF, 0xC1, 0x82, 0x08, 0x20, 0x82, 0x04,
  0x0C, 0x42, 0x08, 0x20, 0x82, 0x08, 0x42, 0x00, 0x70, 0xCC, 0x61, 0xE0,
};

const GFXglyph RobotoMono_Light18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 1, 13, 11, 5, -13 },
  { 3, 3, 4, 11, 4, -14 },
  { 5, 9, 13, 11, 1, -13 },
  { 20, 8, 17, 11, 2, -15 },
  { 37, 10, 13, 11, 0, -13 },
  { 54, 9, 13, 11, 1, -13 },
  { 69, 1, 4, 11, 5, -14 },
  { 70, 5, 18, 11, 3, -14 },
  { 82, 4, 18, 11, 3, -14 },
  { 91, 8, 8, 11, 2, -13 },
  { 99, 9, 10, 11, 1, -11 },
  { 111, 2, 5, 11, 3, -2 },
  { 113, 7, 1, 11, 2, -6 },
  { 114, 2, 2, 11, 5, -2 },
  { 115, 7, 14, 11, 2, -13 },
  { 128, 8, 13, 11, 1, -13 },
  { 141, 5, 13, 11, 2, -13 },
  { 150, 8, 13, 11, 1, -13 },
  { 163, 8, 13, 11, 1, -13 },
  { 176, 9, 13, 11, 1, -13 },
  { 191, 8, 13, 11, 2, -13 },
  { 204, 8, 13, 11, 1, -13 },
  { 217, 9, 13, 11, 1, -13 },
  { 232, 8, 13, 11, 2, -13 },
  { 245, 8, 13, 11, 1, -13 },
  { 258, 2, 10, 11, 5, -10 },
  { 261, 2, 13, 11, 5, -10 },
  { 265, 8, 8, 11, 1, -10 },
  { 273, 7, 4, 11, 2, -8 },
  { 277, 7, 8, 11, 2, -10 },
  { 284, 7, 13, 11, 2, -13 },
  { 296, 10, 13, 11, 0, -13 },
  { 313, 9, 13, 11, 1, -13 },
  { 328, 8, 13, 11, 2, -13 },
  { 341, 9, 13, 11, 1, -13 },
  { 356, 8, 13, 11, 2, -13 },
  { 369, 7, 13, 11, 2, -13 },
  { 381, 7, 13, 11, 2, -13 },
  { 393, 9, 13, 11, 1, -13 },
  { 408, 8, 13, 11, 1, -13 },
  { 421, 7, 13, 11, 2, -13 },
  { 433, 8, 13, 11, 1, -13 },
  { 446, 8, 13, 11, 2, -13 },
  { 459, 8, 13, 11, 2, -13 },
  { 472, 9, 13, 11, 1, -13 },
  { 487, 8, 13, 11, 1, -13 },
  { 500, 9, 13, 11, 1, -13 },
  { 515, 8, 13, 11, 2, -13 },
  { 528, 9, 15, 11, 1, -13 },
  { 545, 8, 13, 11, 2, -13 },
  { 558, 9, 13, 11, 1, -13 },
  { 573, 9, 13, 11, 1, -13 },
  { 588, 8, 13, 11, 1, -13 },
  { 601, 9, 13, 11, 1, -13 },
  { 616, 9, 13, 11, 1, -13 },
  { 631, 9, 13, 11, 1, -13 },
  { 646, 9, 13, 11, 1, -13 },
  { 661, 8, 13, 11, 1, -13 },
  { 674, 3, 18, 11, 4, -15 },
  { 681, 7, 14, 11, 2, -13 },
  { 694, 3, 18, 11, 4, -15 },
  { 701, 7, 7, 11, 2, -13 },
  { 708, 7, 1, 11, 2, 0 },
  { 709, 3, 2, 11, 4, -13 },
  { 710, 8, 10, 11, 1, -10 },
  { 720, 7, 14, 11, 2, -14 },
  { 733, 8, 10, 11, 1, -10 },
  { 743, 8, 14, 11, 1, -14 },
  { 757, 8, 10, 11, 1, -10 },
  { 767, 8, 14, 11, 2, -14 },
  { 781, 8, 14, 11, 1, -10 },
  { 795, 7, 14, 11, 2, -14 },
  { 808, 8, 13, 11, 2, -13 },
  { 821, 5, 17, 11, 2, -13 },
  { 832, 8, 14, 11, 2, -14 },
  { 846, 8, 14, 11, 2, -14 },
  { 860, 9, 10, 11, 1, -10 },
  { 872, 7, 10, 11, 2, -10 },
  { 881, 9, 10, 11, 1, -10 },
  { 893, 7, 14, 11, 2, -10 },
  { 906, 8, 14, 11, 1, -10 },
  { 920, 6, 10, 11, 3, -10 },
  { 928, 7, 10, 11, 2, -10 },
  { 937, 8, 12, 11, 1, -12 },
  { 949, 7, 10, 11, 2, -10 },
  { 958, 9, 10, 11, 1, -10 },
  { 970, 9, 10, 11, 1, -10 },
  { 982, 9, 10, 11, 1, -10 },
  { 994, 9, 14, 11, 1, -10 },
  { 1010, 9, 10, 11, 1, -10 },
  { 1022, 6, 18, 11, 3, -14 },
  { 1036, 1, 16, 11, 5, -13 },
  { 1038, 6, 18, 11, 3, -14 },
  { 1052, 9, 3, 11, 1, -7 },
};

const GFXfont RobotoMono_Light18pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light18pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _ROBOTOMONO_LIGHT18PT7B_H_
