#ifndef _ROBOTOMONO_LIGHT51PT7B_H_
#define _ROBOTOMONO_LIGHT51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light51pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xE0, 0x00, 0x00, 0x00, 0x6F, 0xFF, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0x00, 0x18, 0x07,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x1C, 0x07, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x70, 0x1C, 0x00, 0x0C, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF0, 0x0E, 0x01, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x30, 0x0E, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x38, 0x06, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0x18, 0x07, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0xE0, 0x18, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xF0, 0x0C, 0x03, 0x80, 0x01, 0x80, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x0E,
  0x03, 0x80, 0x01, 0x80, 0x70, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x01, 0x80,
  0x01, 0xC0, 0x30, 0x00, 0x38, 0x06, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0x81,
  0xF0, 0x3C, 0x00, 0xF0, 0x70, 0x00, 0xE1, 0xC0, 0x01, 0xE3, 0x80, 0x01,
  0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xF7, 0x80, 0x01, 0xC7, 0x80, 0x07,
  0x87, 0x80, 0x1E, 0x07, 0xE1, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0E, 0x03, 0x80, 0xC0,
  0xE0, 0x38, 0x0E, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x18, 0x0E, 0x03,
  0x83, 0x80, 0xE0, 0x38, 0x30, 0x0E, 0x03, 0x07, 0x00, 0x60, 0x30, 0x60,
  0x07, 0x07, 0x0E, 0x00, 0x3F, 0xE1, 0xC0, 0x01, 0xFC, 0x18, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x1C, 0x3F, 0xC0,
  0x01, 0x87, 0x9E, 0x00, 0x38, 0x60, 0x70, 0x07, 0x0E, 0x07, 0x00, 0x60,
  0xC0, 0x30, 0x0E, 0x0C, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x1C, 0x0C, 0x03,
  0x01, 0x80, 0xC0, 0x30, 0x38, 0x0C, 0x03, 0x01, 0x00, 0xE0, 0x30, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00,
  0xE0, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x70,
  0x00, 0xE0, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC3,
  0xC0, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x38, 0x00,
  0x07, 0x07, 0x00, 0x63, 0xC1, 0xE0, 0x39, 0xE0, 0x3C, 0x0E, 0x70, 0x07,
  0x83, 0x9C, 0x00, 0xE0, 0xEF, 0x00, 0x1C, 0x3B, 0x80, 0x07, 0x9C, 0xE0,
  0x00, 0xF7, 0x3C, 0x00, 0x1F, 0x87, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0xF0,
  0x78, 0x00, 0x7E, 0x0F, 0x00, 0x3F, 0xC1, 0xF0, 0x3E, 0x78, 0x3F, 0xFF,
  0x0E, 0x03, 0xFF, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xF6, 0xDB,
  0x00, 0x00, 0x20, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70,
  0x0C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x02, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x08, 0x03, 0x00, 0x7C, 0x0C, 0x0F, 0xFC, 0x30, 0xFD, 0xFE,
  0xDF, 0xE0, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xF0,
  0x00, 0x1C, 0xE0, 0x00, 0xE3, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x0E, 0x00,
  0xE0, 0x1C, 0x07, 0x80, 0x78, 0x1C, 0x00, 0xE0, 0x20, 0x01, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x39, 0xCE, 0x73,
  0x9C, 0xEE, 0x73, 0xB9, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x67, 0xBF, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x78, 0x0F, 0x01, 0xC0, 0x0F, 0x07, 0x00,
  0x0F, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0x77, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1D,
  0xF8, 0x00, 0x73, 0xF0, 0x01, 0xC7, 0xE0, 0x0F, 0x0F, 0xC0, 0x3C, 0x1F,
  0x80, 0xF0, 0x3F, 0x03, 0xC0, 0x7E, 0x0E, 0x00, 0xFC, 0x38, 0x01, 0xF8,
  0xE0, 0x03, 0xF3, 0x80, 0x07, 0xEE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x37, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00,
  0x0E, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0x3C, 0x01, 0xE0, 0x3E, 0x0F,
  0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C,
  0x01, 0xF0, 0x3F, 0xC3, 0xFF, 0x3F, 0x1F, 0xF0, 0x7F, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0x01,
  0xF0, 0x1C, 0x00, 0x78, 0x38, 0x00, 0x38, 0x78, 0x00, 0x3C, 0x70, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x78, 0x0F, 0x81, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x0E, 0x00, 0x07,
  0x3C, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xBC, 0x00, 0x0E,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x3E, 0x07, 0xC0, 0x3F, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0x70, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x38, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0x80,
  0x70, 0x01, 0xC0, 0x1C, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C,
  0x00, 0x70, 0x0F, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE7, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3C,
  0x07, 0xF1, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xC0,
  0x00, 0xE7, 0x80, 0x07, 0x8F, 0x00, 0x3E, 0x3E, 0x01, 0xF0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x81, 0xF0, 0x0E,
  0x1F, 0xF8, 0x39, 0xFF, 0xF0, 0xEF, 0x01, 0xE3, 0xF0, 0x03, 0xCF, 0x80,
  0x07, 0xBC, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x03, 0x8E, 0x00,
  0x0E, 0x3C, 0x00, 0x70, 0x78, 0x03, 0xC0, 0xF8, 0x3E, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x0F, 0x81, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x38,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x0F, 0x81, 0xF0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0x00, 0xF0, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x3E, 0x00, 0x78,
  0x1F, 0x81, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x3C,
  0x00, 0xF0, 0xE0, 0x01, 0xC7, 0x80, 0x07, 0x9C, 0x00, 0x0E, 0xF0, 0x00,
  0x3B, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0x77, 0x00, 0x03, 0xDE, 0x00, 0x1F, 0x3C, 0x00, 0xFC, 0x78, 0x07,
  0x70, 0xFD, 0xF9, 0xC1, 0xFF, 0xC7, 0x01, 0xFC, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x67, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x9F, 0xFF, 0xFC, 0x18,
  0x7C, 0xF9, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xC3,
  0x87, 0x0E, 0x38, 0x71, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00,
  0x3E, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3E, 0x07, 0xC3, 0xC0, 0x1E,
  0x3C, 0x00, 0x79, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x74, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xF0, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x07, 0x80, 0x01, 0x80, 0x70, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0xC1, 0xC0, 0x3C, 0x06, 0x18, 0x0F, 0xF0, 0x63, 0x81, 0xE7, 0x86,
  0x30, 0x38, 0x30, 0x73, 0x03, 0x03, 0x03, 0x70, 0x60, 0x30, 0x36, 0x06,
  0x03, 0x03, 0x60, 0xE0, 0x30, 0x36, 0x0C, 0x03, 0x03, 0x60, 0xC0, 0x30,
  0x36, 0x0C, 0x03, 0x03, 0x60, 0xC0, 0x30, 0x36, 0x0C, 0x03, 0x03, 0x60,
  0xC0, 0x60, 0x36, 0x0C, 0x06, 0x06, 0x60, 0xC0, 0x60, 0x66, 0x0C, 0x0E,
  0x06, 0x60, 0xC1, 0xF0, 0xC6, 0x0E, 0x3B, 0x0C, 0x70, 0x7F, 0x3F, 0x83,
  0x03, 0xE1, 0xF0, 0x30, 0x18, 0x04, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x08, 0x00, 0x7E, 0x03, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x38, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x70, 0x30, 0x00, 0x18, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03,
  0x80, 0x60, 0x00, 0xC0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0x80, 0x7F,
  0x07, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x38, 0x00, 0x0E,
  0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7,
  0x00, 0x01, 0xCE, 0x00, 0x07, 0x9C, 0x00, 0x0E, 0x38, 0x00, 0x78, 0x70,
  0x03, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0x00,
  0x0F, 0x8E, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x07, 0x70, 0x00,
  0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0x70, 0x00, 0x3C,
  0xE0, 0x01, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x07, 0x80, 0xF8,
  0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x1E,
  0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x78, 0x07, 0xC1, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0xE0, 0x1F, 0xC0, 0xE0, 0x03, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x3C, 0x1C,
  0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x38,
  0x00, 0x07, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x0F,
  0x00, 0x1F, 0x07, 0xE0, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xCE, 0x00, 0x07, 0x9C,
  0x00, 0x0E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x3E, 0x07, 0xC0, 0x3F,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0xE0,
  0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0,
  0x01, 0xE0, 0xE0, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0xE0, 0x0F, 0x00, 0xE0,
  0x1E, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x78, 0x00, 0xE0,
  0xF0, 0x00, 0xE1, 0xE0, 0x00, 0xE3, 0xC0, 0x00, 0xE7, 0xC0, 0x00, 0xEF,
  0xE0, 0x00, 0xFE, 0xF0, 0x00, 0xFC, 0x70, 0x00, 0xF8, 0x78, 0x00, 0xF0,
  0x3C, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xE0,
  0x07, 0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0xE0,
  0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFB, 0x00, 0x3B, 0xF7, 0x00, 0x77, 0xEE, 0x00,
  0xEF, 0xCC, 0x03, 0x9F, 0x9C, 0x07, 0x3F, 0x38, 0x0C, 0x7E, 0x38, 0x38,
  0xFC, 0x70, 0x71, 0xF8, 0xE1, 0xC3, 0xF0, 0xE3, 0x87, 0xE1, 0xC7, 0x0F,
  0xC1, 0x9C, 0x1F, 0x83, 0xB8, 0x3F, 0x07, 0x60, 0x7E, 0x07, 0xC0, 0xFC,
  0x0F, 0x81, 0xF8, 0x1E, 0x03, 0xF0, 0x1C, 0x07, 0xE0, 0x30, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFB, 0x80, 0x03, 0xF7, 0x00, 0x07, 0xE7, 0x00, 0x0F, 0xCE, 0x00, 0x1F,
  0x8E, 0x00, 0x3F, 0x1C, 0x00, 0x7E, 0x1C, 0x00, 0xFC, 0x3C, 0x01, 0xF8,
  0x38, 0x03, 0xF0, 0x78, 0x07, 0xE0, 0x70, 0x0F, 0xC0, 0x70, 0x1F, 0x80,
  0xE0, 0x3F, 0x00, 0xE0, 0x7E, 0x01, 0xC0, 0xFC, 0x01, 0xC1, 0xF8, 0x03,
  0x83, 0xF0, 0x03, 0x87, 0xE0, 0x07, 0x8F, 0xC0, 0x07, 0x1F, 0x80, 0x0F,
  0x3F, 0x00, 0x0E, 0x7E, 0x00, 0x0E, 0xFC, 0x00, 0x1D, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0xF0, 0x00,
  0x70, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x07, 0x80,
  0x3C, 0x01, 0xF0, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x40, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0x80, 0x0F, 0xC7, 0x00,
  0x07, 0xCE, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0E,
  0xE0, 0x00, 0x39, 0xC0, 0x01, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xF0, 0x3E, 0x01, 0xE0,
  0x07, 0x80, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x0F, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x78,
  0x00, 0x38, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x7C, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x43, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0x80, 0x3F, 0x07, 0x00, 0x0F,
  0x0E, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1E,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE,
  0x00, 0x01, 0xDC, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x3C, 0xE0,
  0x00, 0xF1, 0xC0, 0x07, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x1C, 0x01, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0xE0, 0x03,
  0x81, 0xC0, 0x07, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0F, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0x70, 0x00, 0x3E, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x03,
  0xC0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x0E, 0x38, 0x00,
  0x07, 0x3C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x1C, 0x70, 0x00,
  0x0E, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x3F, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x07, 0x9E, 0x00, 0x0E, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0xF0, 0x1F, 0x07, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x39, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x01, 0xC0,
  0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00,
  0xE0, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70,
  0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE1,
  0xC0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80, 0x3C, 0x03, 0xB0,
  0x07, 0x80, 0x77, 0x00, 0xF0, 0x0E, 0xE0, 0x3E, 0x01, 0xDC, 0x07, 0xC0,
  0x33, 0x80, 0xDC, 0x0E, 0x70, 0x1B, 0x81, 0xCE, 0x03, 0x70, 0x38, 0xC0,
  0xE6, 0x07, 0x1C, 0x1C, 0xC0, 0xE3, 0x83, 0x98, 0x1C, 0x70, 0x63, 0x83,
  0x0E, 0x0C, 0x70, 0x61, 0xC3, 0x8E, 0x1C, 0x38, 0x70, 0xC3, 0x83, 0x0E,
  0x18, 0x70, 0x61, 0x83, 0x8E, 0x0E, 0x30, 0x71, 0xC1, 0xC6, 0x0E, 0x30,
  0x39, 0xC0, 0xC6, 0x07, 0x38, 0x19, 0xC0, 0xE7, 0x03, 0xB8, 0x0C, 0xC0,
  0x77, 0x01, 0x98, 0x0E, 0xE0, 0x3F, 0x00, 0xDC, 0x07, 0xE0, 0x1B, 0x00,
  0xFC, 0x03, 0x60, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0xF0, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x0F, 0x00, 0xF0,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x07, 0x80, 0x70, 0x00, 0xE0, 0x38, 0x00,
  0x1C, 0x1E, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x3C, 0xE0,
  0x00, 0x07, 0x70, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x87, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0xE0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x38, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x38, 0x38,
  0x00, 0x0F, 0x1E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x78, 0xE0, 0x00,
  0x1C, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x81, 0xE0, 0x01, 0xE0, 0x38,
  0x00, 0x70, 0x0F, 0x00, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x07, 0x80,
  0x0E, 0x01, 0xC0, 0x03, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x1C,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03,
  0x70, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3B, 0x00, 0x07, 0x70, 0x01, 0xCE, 0x00, 0x38,
  0xE0, 0x06, 0x1C, 0x01, 0xC1, 0x80, 0x38, 0x38, 0x0E, 0x07, 0x01, 0xC0,
  0x70, 0x30, 0x0E, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00,
  0x3B, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x7C, 0x0F, 0x81, 0xE0, 0x07, 0x83, 0x80, 0x07, 0x8E, 0x00, 0x07,
  0x1C, 0x00, 0x0E, 0x08, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F,
  0x80, 0x07, 0x1C, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x3B, 0x80,
  0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0x9C, 0x00,
  0x3F, 0x3C, 0x00, 0xEE, 0x3E, 0x0F, 0x9C, 0x3F, 0xFE, 0x38, 0x1F, 0xF0,
  0x78, 0x02, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x7F,
  0x80, 0xE7, 0xFF, 0x83, 0xBC, 0x1F, 0x0F, 0xC0, 0x1E, 0x3E, 0x00, 0x3C,
  0xF0, 0x00, 0x73, 0x80, 0x01, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0,
  0x00, 0x3B, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3B,
  0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x1E, 0xF0, 0x00, 0x73, 0xE0,
  0x03, 0xCF, 0xC0, 0x1E, 0x3B, 0xC1, 0xF0, 0xE7, 0xFF, 0x83, 0x87, 0xF8,
  0x00, 0x01, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xF8, 0x3E,
  0x07, 0x80, 0x3C, 0x3C, 0x00, 0x38, 0xE0, 0x00, 0xF7, 0x00, 0x01, 0xDC,
  0x00, 0x07, 0x70, 0x00, 0x1F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x70,
  0x00, 0x1C, 0xE0, 0x00, 0x73, 0xC0, 0x03, 0x87, 0x80, 0x1C, 0x0F, 0x81,
  0xF0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0xFF, 0x87, 0x07, 0xFF, 0x9C, 0x3E, 0x1F, 0x71,
  0xE0, 0x0F, 0xCF, 0x00, 0x1F, 0x38, 0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00,
  0x0F, 0x38, 0x00, 0x3C, 0xF0, 0x01, 0xF1, 0xE0, 0x0F, 0xC3, 0xE0, 0xF7,
  0x07, 0xFF, 0x9C, 0x0F, 0xF8, 0x70, 0x02, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x3E, 0x0F, 0x80, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x87,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x01,
  0x0F, 0x00, 0x07, 0x0F, 0x00, 0x1E, 0x0F, 0xC0, 0xF8, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xFE, 0x1C, 0x1F, 0xFE, 0x70, 0xF8, 0x7D, 0xC7,
  0x80, 0x3F, 0x3C, 0x00, 0x7C, 0xE0, 0x00, 0xF7, 0x00, 0x03, 0xDC, 0x00,
  0x07, 0x70, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00,
  0x3C, 0xE0, 0x00, 0xF3, 0xC0, 0x07, 0xC7, 0x80, 0x3F, 0x0F, 0x83, 0xDC,
  0x1F, 0xFE, 0x70, 0x3F, 0xE1, 0xC0, 0x08, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x84, 0x00, 0x1E, 0x30, 0x00, 0x71, 0xE0, 0x03,
  0xC1, 0xE0, 0x3E, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC1, 0xFF, 0x0E, 0x3F, 0xFC, 0x73, 0xC1,
  0xF3, 0xB8, 0x03, 0xDF, 0x00, 0x0E, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x04,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x03, 0xCE, 0x00, 0x0F, 0x1C,
  0x00, 0x3C, 0x38, 0x00, 0xF0, 0x70, 0x03, 0xC0, 0xE0, 0x0F, 0x01, 0xC0,
  0x3C, 0x03, 0x81, 0xE0, 0x07, 0x07, 0x80, 0x0E, 0x1E, 0x00, 0x1C, 0x78,
  0x00, 0x39, 0xE0, 0x00, 0x77, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xF9, 0xE0,
  0x03, 0xE1, 0xE0, 0x07, 0x81, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x38, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0xE0, 0x03, 0xC1, 0xC0, 0x03, 0xC3,
  0x80, 0x03, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x9C, 0x00, 0x07, 0xC0,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0xF0, 0x7F,
  0x3B, 0xFE, 0x7F, 0xEF, 0xC3, 0xDC, 0x7F, 0xC0, 0x7C, 0x07, 0xF0, 0x0E,
  0x01, 0xF8, 0x03, 0x80, 0x7E, 0x00, 0xE0, 0x0F, 0x80, 0x38, 0x03, 0xE0,
  0x0E, 0x00, 0xF8, 0x03, 0x80, 0x3E, 0x00, 0xE0, 0x0F, 0x80, 0x38, 0x03,
  0xE0, 0x0E, 0x00, 0xF8, 0x03, 0x80, 0x3E, 0x00, 0xE0, 0x0F, 0x80, 0x38,
  0x03, 0xE0, 0x0E, 0x00, 0xF8, 0x03, 0x80, 0x3E, 0x00, 0xE0, 0x0F, 0x80,
  0x38, 0x03, 0xE0, 0x0E, 0x00, 0xF8, 0x03, 0x80, 0x3E, 0x00, 0xE0, 0x0F,
  0x80, 0x38, 0x03, 0xE0, 0x0E, 0x00, 0xF8, 0x03, 0x80, 0x3E, 0x00, 0xE0,
  0x0C, 0xE0, 0xFF, 0x07, 0x1F, 0xFE, 0x39, 0xE0, 0xF9, 0xDC, 0x01, 0xEF,
  0x80, 0x07, 0x78, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0E,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xC1, 0xF0, 0x0F, 0x00, 0x78,
  0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x78,
  0x0F, 0x81, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00,
  0xE1, 0xFE, 0x03, 0x9F, 0xFE, 0x0E, 0xF0, 0x7C, 0x3F, 0x00, 0x78, 0xF8,
  0x00, 0xF3, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x0E, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3B, 0x80,
  0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x73, 0xC0, 0x01,
  0xCF, 0x00, 0x0E, 0x3F, 0x00, 0x78, 0xEF, 0x07, 0xC3, 0x9F, 0xFE, 0x0E,
  0x3F, 0xF0, 0x38, 0x04, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x1C, 0x1F, 0xFE, 0x71,
  0xF8, 0x3D, 0xC7, 0x80, 0x3F, 0x3C, 0x00, 0x7C, 0xE0, 0x00, 0xF7, 0x00,
  0x03, 0xDC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xDC, 0x00,
  0x07, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0xF3, 0xC0, 0x07, 0xC7, 0x80, 0x3F,
  0x0F, 0x83, 0xDC, 0x1F, 0xFE, 0x70, 0x3F, 0xE1, 0xC0, 0x08, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x7F, 0xFB, 0xBC, 0x00, 0xEC, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xF0, 0x3E, 0x0F, 0x00, 0x3C,
  0x70, 0x00, 0x79, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xE7, 0x00, 0x03, 0x9E, 0x00, 0x1E, 0x3E, 0x03, 0xF0, 0x7F, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x02, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x08, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xB8, 0x00, 0x3D, 0xC0, 0x03, 0xE7, 0x00, 0x37, 0x3E, 0x0F,
  0xB8, 0xFF, 0xF9, 0xC1, 0xFF, 0x0E, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00,
  0x38, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x03, 0x80, 0x01,
  0xC1, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0x7C, 0x01, 0xC0, 0x1F, 0x80, 0x38, 0x03, 0xF0, 0x07, 0x00, 0x76,
  0x01, 0xF0, 0x0C, 0xC0, 0x36, 0x01, 0x9C, 0x06, 0xC0, 0x73, 0x80, 0xD8,
  0x0E, 0x70, 0x3B, 0x81, 0xC6, 0x06, 0x70, 0x30, 0xC0, 0xC6, 0x06, 0x1C,
  0x18, 0xC1, 0xC3, 0x87, 0x1C, 0x38, 0x30, 0xC3, 0x86, 0x06, 0x18, 0x30,
  0xC0, 0xE3, 0x06, 0x38, 0x1C, 0xE0, 0xE7, 0x03, 0x98, 0x0C, 0xE0, 0x33,
  0x01, 0x98, 0x06, 0x60, 0x33, 0x00, 0xDC, 0x07, 0x60, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x00, 0x78, 0x00, 0x07, 0x9C, 0x00, 0x07,
  0x07, 0x00, 0x07, 0x83, 0xC0, 0x07, 0x80, 0xF0, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x0E, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0x71,
  0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x71, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x0F, 0x00,
  0x38, 0x03, 0xC0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x1E,
  0x3C, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78,
  0x78, 0x00, 0x0E, 0x07, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x70, 0x0E, 0x00,
  0x0E, 0x01, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00,
  0x38, 0x03, 0x80, 0x07, 0x00, 0xF0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x40, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0xE0,
  0x0F, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x03, 0x1F, 0xF8, 0x00, 0x33,
  0xC3, 0xE0, 0x07, 0x70, 0x0F, 0x00, 0x77, 0x00, 0x78, 0x0E, 0x60, 0x03,
  0xE3, 0xE6, 0x00, 0x1F, 0xFC, 0xA0, 0x00, 0x7F, 0x80,
};

const GFXglyph RobotoMono_Light51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 4, 36, 31, 13, -36 },
  { 19, 10, 11, 31, 10, -38 },
  { 33, 27, 36, 31, 2, -36 },
  { 155, 23, 47, 31, 4, -42 },
  { 291, 28, 38, 31, 1, -37 },
  { 424, 26, 38, 31, 3, -37 },
  { 548, 3, 11, 31, 13, -38 },
  { 553, 11, 53, 31, 10, -41 },
  { 626, 12, 53, 31, 9, -41 },
  { 706, 22, 22, 31, 5, -36 },
  { 767, 25, 26, 31, 3, -30 },
  { 849, 5, 12, 31, 10, -5 },
  { 857, 18, 3, 31, 6, -18 },
  { 864, 5, 5, 31, 14, -5 },
  { 868, 18, 39, 31, 7, -36 },
  { 956, 23, 38, 31, 4, -37 },
  { 1066, 14, 36, 31, 5, -36 },
  { 1129, 24, 37, 31, 2, -37 },
  { 1240, 23, 38, 31, 2, -37 },
  { 1350, 26, 36, 31, 2, -36 },
  { 1467, 22, 37, 31, 5, -36 },
  { 1569, 22, 38, 31, 4, -37 },
  { 1674, 24, 36, 31, 3, -36 },
  { 1782, 24, 38, 31, 4, -37 },
  { 1896, 22, 37, 31, 4, -37 },
  { 1998, 5, 27, 31, 15, -27 },
  { 2015, 7, 34, 31, 13, -27 },
  { 2045, 21, 21, 31, 4, -27 },
  { 2101, 23, 13, 31, 4, -23 },
  { 2139, 21, 21, 31, 5, -27 },
  { 2195, 21, 37, 31, 5, -37 },
  { 2293, 28, 36, 31, 1, -36 },
  { 2419, 26, 36, 31, 3, -36 },
  { 2536, 23, 36, 31, 5, -36 },
  { 2640, 24, 38, 31, 3, -37 },
  { 2754, 24, 36, 31, 4, -36 },
  { 2862, 21, 36, 31, 5, -36 },
  { 2957, 22, 36, 31, 5, -36 },
  { 3056, 24, 38, 31, 3, -37 },
  { 3170, 23, 36, 31, 4, -36 },
  { 3274, 21, 36, 31, 5, -36 },
  { 3369, 23, 37, 31, 3, -36 },
  { 3476, 24, 36, 31, 5, -36 },
  { 3584, 22, 36, 31, 5, -36 },
  { 3683, 23, 36, 31, 4, -36 },
  { 3787, 23, 36, 31, 4, -36 },
  { 3891, 25, 38, 31, 3, -37 },
  { 4010, 23, 36, 31, 5, -36 },
  { 4114, 25, 43, 31, 3, -37 },
  { 4249, 23, 36, 31, 5, -36 },
  { 4353, 25, 38, 31, 3, -37 },
  { 4472, 26, 36, 31, 2, -36 },
  { 4589, 23, 37, 31, 4, -36 },
  { 4696, 26, 36, 31, 2, -36 },
  { 4813, 27, 36, 31, 2, -36 },
  { 4935, 26, 36, 31, 3, -36 },
  { 5052, 26, 36, 31, 2, -36 },
  { 5169, 23, 36, 31, 3, -36 },
  { 5273, 9, 49, 31, 11, -41 },
  { 5329, 18, 39, 31, 6, -36 },
  { 5417, 8, 49, 31, 11, -41 },
  { 5466, 19, 19, 31, 6, -36 },
  { 5512, 22, 3, 31, 4, 0 },
  { 5521, 8, 6, 31, 11, -37 },
  { 5527, 23, 28, 31, 4, -27 },
  { 5608, 22, 39, 31, 5, -38 },
  { 5716, 22, 28, 31, 4, -27 },
  { 5793, 22, 39, 31, 4, -38 },
  { 5901, 23, 28, 31, 4, -27 },
  { 5982, 24, 39, 31, 4, -39 },
  { 6099, 22, 38, 31, 4, -27 },
  { 6204, 21, 38, 31, 5, -38 },
  { 6304, 22, 37, 31, 5, -37 },
  { 6406, 16, 48, 31, 5, -37 },
  { 6502, 23, 38, 31, 5, -38 },
  { 6612, 22, 38, 31, 5, -38 },
  { 6717, 26, 27, 31, 2, -27 },
  { 6805, 21, 27, 31, 5, -27 },
  { 6876, 24, 28, 31, 3, -27 },
  { 6960, 22, 37, 31, 5, -27 },
  { 7062, 22, 37, 31, 4, -27 },
  { 7164, 18, 27, 31, 9, -27 },
  { 7225, 22, 28, 31, 5, -27 },
  { 7302, 22, 35, 31, 4, -34 },
  { 7399, 21, 28, 31, 5, -27 },
  { 7473, 25, 27, 31, 3, -27 },
  { 7558, 27, 27, 31, 2, -27 },
  { 7650, 25, 27, 31, 3, -27 },
  { 7735, 27, 38, 31, 2, -27 },
  { 7864, 23, 27, 31, 4, -27 },
  { 7942, 17, 50, 31, 8, -40 },
  { 8049, 3, 44, 31, 14, -36 },
  { 8066, 17, 50, 31, 8, -40 },
  { 8173, 28, 9, 31, 1, -20 },
};

const GFXfont RobotoMono_Light51pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light51pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOMONO_LIGHT51PT7B_H_
