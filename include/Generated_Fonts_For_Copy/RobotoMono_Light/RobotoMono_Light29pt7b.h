#ifndef _ROBOTOMONO_LIGHT29PT7B_H_
#define _ROBOTOMONO_LIGHT29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light29pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x90, 0x00, 0x7E, 0x8E, 0x38, 0xA2,
  0x8A, 0x28, 0x80, 0x03, 0x0C, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x06,
  0x18, 0x06, 0x18, 0x7F, 0xFF, 0x7F, 0xFF, 0x04, 0x10, 0x04, 0x30, 0x0C,
  0x30, 0x0C, 0x20, 0x08, 0x20, 0x08, 0x20, 0xFF, 0xFE, 0x18, 0x60, 0x18,
  0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x30, 0xC0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xF8, 0x3F, 0xC6, 0x06, 0x40, 0x3C, 0x03, 0xC0, 0x3C, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x3E, 0x03, 0x70, 0xE1, 0xFC, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x38, 0x00, 0xEC, 0x00, 0x86, 0x00, 0x86, 0x10, 0x86, 0x30,
  0x86, 0x20, 0x86, 0x60, 0xC4, 0x40, 0x7C, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x02, 0x3C, 0x06, 0x66, 0x04, 0x42, 0x0C, 0x43, 0x08, 0x43,
  0x18, 0x43, 0x10, 0x43, 0x00, 0x62, 0x00, 0x3C, 0x0F, 0x00, 0x3F, 0x00,
  0xC3, 0x01, 0x82, 0x02, 0x04, 0x06, 0x18, 0x0C, 0x30, 0x18, 0xC0, 0x1F,
  0x00, 0x18, 0x00, 0x70, 0x01, 0xB0, 0x06, 0x30, 0x58, 0x31, 0xB0, 0x33,
  0x60, 0x64, 0xC0, 0x79, 0x80, 0x61, 0x80, 0xE3, 0x87, 0x61, 0xF8, 0xE0,
  0xFF, 0xFC, 0x02, 0x0C, 0x30, 0xC1, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x02,
  0x0C, 0x18, 0x30, 0x60, 0xC0, 0x81, 0x03, 0x06, 0x0C, 0x08, 0x18, 0x30,
  0x30, 0x20, 0x60, 0x60, 0x40, 0x81, 0x81, 0x81, 0x81, 0x03, 0x02, 0x06,
  0x0C, 0x18, 0x10, 0x20, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x20, 0xC1,
  0x82, 0x0C, 0x18, 0x60, 0x83, 0x0C, 0x10, 0x00, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x08, 0x61, 0x7B, 0x7C, 0xFF, 0x00, 0xC0, 0x0F, 0x00, 0xCC,
  0x04, 0x30, 0xE1, 0xC2, 0x04, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x33, 0x32, 0x66,
  0xC0, 0xFF, 0xFF, 0xFC, 0x5F, 0x00, 0x00, 0x40, 0x30, 0x08, 0x06, 0x01,
  0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x80, 0x40, 0x30, 0x08, 0x02, 0x01,
  0x80, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x00, 0x0F,
  0x80, 0xFF, 0x0C, 0x0C, 0xC0, 0x66, 0x01, 0xA0, 0x0F, 0x00, 0xF8, 0x0F,
  0xC0, 0xDE, 0x0C, 0xF0, 0xC3, 0x8C, 0x1C, 0xC0, 0xEC, 0x07, 0xC0, 0x78,
  0x03, 0x40, 0x1B, 0x00, 0x8C, 0x0C, 0x71, 0xC0, 0xFC, 0x00, 0x01, 0x07,
  0x3F, 0xF3, 0x83, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x0F, 0x80, 0x7F, 0x83, 0x03,
  0x18, 0x0C, 0x40, 0x1B, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x7F, 0xFC, 0x0F, 0x80, 0xFF, 0x0C,
  0x0C, 0xC0, 0x36, 0x01, 0xA0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x07,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x78, 0x01, 0xC0, 0x0B,
  0x00, 0xD8, 0x04, 0x70, 0xE0, 0xFC, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x03,
  0xC0, 0x05, 0x80, 0x1B, 0x00, 0x66, 0x00, 0x8C, 0x03, 0x18, 0x0C, 0x30,
  0x10, 0x60, 0x60, 0xC1, 0x81, 0x82, 0x03, 0x0C, 0x06, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x3F,
  0xF3, 0xFF, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x5F,
  0x87, 0xFE, 0x40, 0xE0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xC0,
  0x3C, 0x03, 0x60, 0x63, 0xFE, 0x1F, 0x80, 0x01, 0xC0, 0x3E, 0x07, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x08, 0x60, 0xDF, 0xC7, 0x83, 0x38,
  0x0D, 0x80, 0x2C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x40, 0x1B, 0x01,
  0x8C, 0x0C, 0x71, 0xC0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x07, 0x80, 0x7F, 0x83, 0x03, 0x18, 0x06,
  0x60, 0x19, 0x80, 0x66, 0x01, 0x98, 0x06, 0x30, 0x30, 0x73, 0x80, 0xFC,
  0x0E, 0x1C, 0x60, 0x19, 0x80, 0x64, 0x00, 0xF0, 0x03, 0x40, 0x0D, 0x80,
  0x66, 0x01, 0x8E, 0x1C, 0x0F, 0xE0, 0x0F, 0x80, 0xFE, 0x0C, 0x18, 0xC0,
  0x64, 0x01, 0x60, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xD8, 0x06,
  0xC0, 0x73, 0x8D, 0x8F, 0xCC, 0x00, 0x40, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x1F, 0x01, 0xE0, 0x00, 0x5D, 0x80, 0x00, 0x00, 0x05, 0xD8, 0x37,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x33, 0x32, 0x66, 0xC0, 0x00, 0x10, 0x0F,
  0x03, 0xC0, 0xF0, 0x78, 0x0E, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0x00, 0xF0, 0x38, 0x1E, 0x07, 0x80, 0xC0, 0x08, 0x00, 0x1F, 0x03, 0xFC,
  0x60, 0x6C, 0x06, 0xC0, 0x20, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xE0, 0x0F, 0xF8, 0x18, 0x0C, 0x30,
  0x04, 0x20, 0x06, 0x63, 0xE2, 0x46, 0x22, 0xC4, 0x22, 0x8C, 0x22, 0x88,
  0x23, 0x88, 0x22, 0x88, 0x22, 0x88, 0x62, 0x88, 0x62, 0x8C, 0xE6, 0xCF,
  0xBC, 0x47, 0x18, 0x60, 0x00, 0x20, 0x00, 0x18, 0x30, 0x0F, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x2C, 0x00, 0xC8, 0x01, 0x98,
  0x02, 0x30, 0x0C, 0x20, 0x18, 0x60, 0x20, 0xC0, 0x40, 0x81, 0x81, 0x83,
  0x03, 0x07, 0xFE, 0x18, 0x06, 0x30, 0x0C, 0x40, 0x19, 0x80, 0x1B, 0x00,
  0x3C, 0x00, 0x60, 0xFC, 0x07, 0xFE, 0x20, 0x39, 0x00, 0xC8, 0x03, 0x40,
  0x1A, 0x00, 0xD0, 0x06, 0x80, 0x64, 0x1E, 0x3F, 0xE1, 0x01, 0xC8, 0x03,
  0x40, 0x0A, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xA0, 0x1D, 0xFF, 0xCF,
  0xF8, 0x00, 0x0F, 0x80, 0x7F, 0x83, 0x03, 0x18, 0x06, 0x40, 0x1B, 0x00,
  0x2C, 0x00, 0xF0, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x02, 0x40, 0x19, 0x80, 0x63, 0x03, 0x0E,
  0x18, 0x0F, 0xC0, 0xF8, 0x07, 0xFC, 0x20, 0x71, 0x00, 0xC8, 0x03, 0x40,
  0x1A, 0x00, 0x50, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x06, 0x80, 0x34, 0x03, 0x20, 0x31, 0x0F, 0x0F,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xEC, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xFF, 0xEC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x7F, 0x83, 0x03, 0x18,
  0x06, 0x40, 0x1B, 0x00, 0x2C, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x7F, 0x81, 0xFE, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x40, 0x0D,
  0x80, 0x33, 0x01, 0xC7, 0x1E, 0x0F, 0xE0, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F,
  0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x70, 0x02, 0xC0, 0x36, 0x01, 0x98, 0x18, 0xE3, 0xC1, 0xF8,
  0x00, 0xC0, 0x1B, 0x00, 0xCC, 0x06, 0x30, 0x38, 0xC1, 0xC3, 0x06, 0x0C,
  0x30, 0x31, 0x80, 0xCC, 0x03, 0x60, 0x0F, 0xC0, 0x3D, 0x80, 0xE7, 0x03,
  0x0C, 0x0C, 0x18, 0x30, 0x30, 0xC0, 0xC3, 0x01, 0x8C, 0x03, 0x30, 0x06,
  0xC0, 0x1C, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xE0, 0x1F,
  0x00, 0xF8, 0x0F, 0xE0, 0x7F, 0x02, 0xE8, 0x37, 0x61, 0x3B, 0x19, 0xC8,
  0xCE, 0x64, 0x71, 0x63, 0x8E, 0x1C, 0x70, 0xE1, 0x87, 0x08, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x80, 0xC0, 0x1F, 0x00,
  0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xEC, 0x0F, 0x20, 0x79, 0x83, 0xC4, 0x1E,
  0x30, 0xF0, 0xC7, 0x86, 0x3C, 0x19, 0xE0, 0xCF, 0x03, 0x78, 0x1B, 0xC0,
  0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0x80, 0x0F, 0x80, 0x7F, 0x83,
  0x07, 0x18, 0x0C, 0x40, 0x1B, 0x00, 0x6C, 0x00, 0xB0, 0x02, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xB0, 0x06,
  0x40, 0x19, 0x80, 0x43, 0x03, 0x0E, 0x38, 0x0F, 0xC0, 0xFE, 0x07, 0xFE,
  0x30, 0x1D, 0x80, 0x6C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x01, 0xB0, 0x1D, 0xFF, 0x8F, 0xE0, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0F, 0x80, 0x7F, 0x83,
  0x03, 0x18, 0x04, 0xC0, 0x1B, 0x00, 0x2C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x02,
  0xC0, 0x19, 0x80, 0x67, 0x03, 0x0E, 0x38, 0x0F, 0xE0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x08, 0xFC, 0x07, 0xFE, 0x30, 0x39, 0x80, 0x6C, 0x03,
  0x60, 0x0B, 0x00, 0x58, 0x06, 0xC0, 0x36, 0x03, 0x30, 0x39, 0xFF, 0x0C,
  0x18, 0x60, 0xC3, 0x03, 0x18, 0x18, 0xC0, 0x66, 0x03, 0x30, 0x0D, 0x80,
  0x6C, 0x01, 0x80, 0x07, 0x80, 0x7F, 0x83, 0x03, 0x18, 0x06, 0x40, 0x09,
  0x00, 0x34, 0x00, 0x18, 0x00, 0x30, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x36, 0x01,
  0x8E, 0x1C, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x40, 0x1B,
  0x00, 0xDC, 0x0C, 0x71, 0xC0, 0xFC, 0x00, 0xC0, 0x06, 0x80, 0x0D, 0x80,
  0x13, 0x00, 0x62, 0x00, 0xC6, 0x01, 0x0C, 0x06, 0x08, 0x0C, 0x18, 0x10,
  0x30, 0x60, 0x60, 0xC0, 0x61, 0x00, 0xC6, 0x01, 0x8C, 0x01, 0x18, 0x03,
  0x20, 0x06, 0xC0, 0x05, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xC1,
  0x83, 0xC1, 0x83, 0xC1, 0x82, 0x41, 0x82, 0x43, 0x82, 0x63, 0xC6, 0x62,
  0xC6, 0x62, 0x46, 0x62, 0x46, 0x66, 0x44, 0x26, 0x64, 0x26, 0x64, 0x24,
  0x2C, 0x34, 0x2C, 0x34, 0x2C, 0x3C, 0x3C, 0x3C, 0x38, 0x18, 0x38, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xC0, 0x0F, 0x00, 0x66, 0x01, 0x8C, 0x0C,
  0x30, 0x30, 0x61, 0x81, 0x8C, 0x03, 0x30, 0x07, 0x80, 0x1E, 0x00, 0x30,
  0x01, 0xE0, 0x07, 0x80, 0x33, 0x00, 0x8C, 0x06, 0x18, 0x30, 0x30, 0xC0,
  0xC6, 0x01, 0xB0, 0x06, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x19, 0x80, 0x31,
  0x80, 0xC3, 0x01, 0x83, 0x06, 0x06, 0x0C, 0x06, 0x30, 0x0C, 0x60, 0x08,
  0x80, 0x1B, 0x00, 0x14, 0x00, 0x38, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x10, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF1, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0xF0, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x02,
  0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x20, 0x0C, 0xFF, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC7, 0xF0, 0x04, 0x00, 0xC0, 0x38, 0x05, 0x81, 0xB0, 0x32, 0x04, 0x61,
  0x84, 0x20, 0xCC, 0x19, 0x81, 0xE0, 0x30, 0xFF, 0xF8, 0xE1, 0x84, 0x30,
  0x07, 0x00, 0xFF, 0x0C, 0x1C, 0xC0, 0x66, 0x01, 0x80, 0x0C, 0x00, 0x61,
  0xFF, 0x3E, 0x1B, 0x00, 0xD0, 0x07, 0x80, 0x3C, 0x03, 0xB0, 0x3D, 0xC3,
  0x67, 0xF3, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC6,
  0x0D, 0xFC, 0xF0, 0xEC, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x2E, 0x06, 0xB1, 0xC9, 0xF8, 0x03,
  0x00, 0xFF, 0x0E, 0x1C, 0xC0, 0x66, 0x01, 0xA0, 0x0F, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x36, 0x01, 0x98, 0x18, 0xE1, 0x81,
  0xF8, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x18,
  0x63, 0xFB, 0x30, 0x7B, 0x01, 0xD8, 0x06, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1A, 0x00, 0xD8, 0x06, 0xE0, 0x73, 0x8F, 0x8F,
  0xCC, 0x03, 0x00, 0xFF, 0x0E, 0x1C, 0xC0, 0x66, 0x01, 0xA0, 0x0F, 0x00,
  0x3F, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x0C,
  0x71, 0xC1, 0xFC, 0x03, 0xF8, 0x38, 0x43, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x1F, 0xFE, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x06, 0x00, 0xFE, 0xCC, 0x1E, 0xC0, 0x76, 0x01, 0xA0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x06, 0x80, 0x36, 0x01,
  0xB8, 0x1C, 0xE3, 0xE3, 0xF3, 0x00, 0x18, 0x00, 0x88, 0x0C, 0xC0, 0xE3,
  0x9E, 0x07, 0xC0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x82, 0x09, 0xFC, 0xB0, 0x6A, 0x02, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x06, 0x00, 0x70, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0x01, 0xC0, 0x40,
  0x00, 0x00, 0x01, 0xFC, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x03,
  0x07, 0x3F, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x58, 0x0C, 0xC0, 0xC6, 0x0C, 0x30, 0xC1, 0x8C, 0x0D, 0xC0,
  0x7C, 0x03, 0xF0, 0x1C, 0xC0, 0xC3, 0x06, 0x0C, 0x30, 0x31, 0x81, 0xCC,
  0x06, 0x60, 0x1C, 0xFE, 0x0F, 0xE0, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0x0C, 0x11, 0xFE, 0xFB, 0x8E, 0x1E, 0x0C, 0x3C, 0x18, 0x38, 0x30, 0x70,
  0x60, 0xE0, 0xC1, 0xC1, 0x83, 0x83, 0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x18,
  0x38, 0x30, 0x70, 0x60, 0xE0, 0xC1, 0x02, 0x09, 0xFC, 0xB0, 0x6E, 0x02,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x03, 0x00, 0x7F, 0x03, 0x07, 0x18,
  0x0C, 0x40, 0x1B, 0x00, 0x6C, 0x00, 0xB0, 0x03, 0xC0, 0x0F, 0x00, 0x2C,
  0x00, 0xB0, 0x06, 0x60, 0x19, 0x80, 0xC3, 0x8E, 0x03, 0xF0, 0x06, 0x09,
  0xF8, 0xA0, 0xCC, 0x06, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0xC0, 0x2C, 0x06, 0xB1, 0xC9, 0xF8, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x07, 0x00, 0xFE, 0xCC, 0x1E,
  0xC0, 0x76, 0x01, 0xA0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x06, 0x80, 0x36, 0x01, 0xB8, 0x1C, 0xE3, 0xE3, 0xF3, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x03, 0xB3, 0xFD, 0x83, 0x80,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x06, 0x03, 0xFC, 0x60, 0x6C, 0x03, 0xC0, 0x3C, 0x00,
  0x60, 0x03, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x30, 0x03, 0xC0, 0x3C, 0x03,
  0x70, 0xE3, 0xFC, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x0F, 0xFF, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x38, 0x40, 0xFE, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x77, 0x1B, 0x3F, 0x30, 0xC0, 0x0F, 0x00,
  0x64, 0x01, 0x98, 0x04, 0x20, 0x30, 0xC0, 0x83, 0x06, 0x06, 0x18, 0x18,
  0xC0, 0x23, 0x00, 0xC8, 0x03, 0x60, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xC1, 0x83, 0xC1, 0x82, 0x43, 0x82, 0x43, 0x86, 0x42, 0xC6, 0x62, 0xC4,
  0x66, 0x44, 0x26, 0x44, 0x24, 0x6C, 0x24, 0x2C, 0x3C, 0x28, 0x3C, 0x28,
  0x18, 0x38, 0x18, 0x18, 0x18, 0x10, 0xE0, 0x1D, 0xC0, 0xC3, 0x06, 0x06,
  0x18, 0x0C, 0xC0, 0x1E, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x80, 0x33, 0x01,
  0x8C, 0x06, 0x18, 0x30, 0x31, 0x80, 0x6C, 0x01, 0xC0, 0xC0, 0x06, 0xC0,
  0x09, 0x80, 0x31, 0x80, 0x63, 0x01, 0x83, 0x03, 0x06, 0x0C, 0x06, 0x18,
  0x0C, 0x20, 0x08, 0xC0, 0x19, 0x00, 0x16, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x81, 0xC1, 0x81, 0x80, 0xC0, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x83, 0x83, 0x00, 0xE0, 0x18, 0x0C,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x06, 0x01, 0x80, 0x70,
  0x08, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x70, 0x0C, 0x02, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x06, 0x0E, 0x0C,
  0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x1C,
  0x08, 0x00, 0x3C, 0x03, 0x67, 0x02, 0xC1, 0x86, 0x80, 0xFE, 0x40, 0x78,
};

const GFXglyph RobotoMono_Light29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 3, 21, 17, 7, -21 },
  { 9, 6, 7, 17, 6, -22 },
  { 15, 16, 21, 17, 1, -21 },
  { 57, 12, 27, 17, 3, -24 },
  { 98, 16, 21, 17, 1, -21 },
  { 140, 15, 21, 17, 2, -21 },
  { 180, 2, 7, 17, 7, -22 },
  { 182, 7, 30, 17, 5, -23 },
  { 209, 7, 30, 17, 5, -23 },
  { 236, 13, 13, 17, 3, -21 },
  { 258, 14, 15, 17, 2, -17 },
  { 285, 4, 7, 17, 5, -3 },
  { 289, 11, 2, 17, 3, -10 },
  { 292, 3, 3, 17, 8, -3 },
  { 294, 10, 23, 17, 4, -21 },
  { 323, 13, 21, 17, 2, -21 },
  { 358, 8, 21, 17, 3, -21 },
  { 379, 14, 21, 17, 1, -21 },
  { 416, 13, 21, 17, 1, -21 },
  { 451, 15, 21, 17, 1, -21 },
  { 491, 12, 21, 17, 3, -21 },
  { 523, 13, 21, 17, 2, -21 },
  { 558, 13, 21, 17, 2, -21 },
  { 593, 14, 21, 17, 2, -21 },
  { 630, 13, 21, 17, 2, -21 },
  { 665, 3, 15, 17, 8, -15 },
  { 671, 4, 19, 17, 7, -15 },
  { 681, 12, 12, 17, 2, -15 },
  { 699, 13, 7, 17, 2, -13 },
  { 711, 12, 12, 17, 3, -15 },
  { 729, 12, 21, 17, 3, -21 },
  { 761, 16, 21, 17, 1, -21 },
  { 803, 15, 21, 17, 1, -21 },
  { 843, 13, 21, 17, 3, -21 },
  { 878, 14, 21, 17, 2, -21 },
  { 915, 13, 21, 17, 3, -21 },
  { 950, 12, 21, 17, 3, -21 },
  { 982, 12, 21, 17, 3, -21 },
  { 1014, 14, 21, 17, 2, -21 },
  { 1051, 13, 21, 17, 2, -21 },
  { 1086, 12, 21, 17, 3, -21 },
  { 1118, 13, 21, 17, 2, -21 },
  { 1153, 14, 21, 17, 3, -21 },
  { 1190, 12, 21, 17, 3, -21 },
  { 1222, 13, 21, 17, 2, -21 },
  { 1257, 13, 21, 17, 2, -21 },
  { 1292, 14, 21, 17, 2, -21 },
  { 1329, 13, 21, 17, 3, -21 },
  { 1364, 14, 25, 17, 2, -21 },
  { 1408, 13, 21, 17, 3, -21 },
  { 1443, 14, 21, 17, 2, -21 },
  { 1480, 15, 21, 17, 1, -21 },
  { 1520, 13, 21, 17, 2, -21 },
  { 1555, 15, 21, 17, 1, -21 },
  { 1595, 16, 21, 17, 1, -21 },
  { 1637, 14, 21, 17, 2, -21 },
  { 1674, 15, 21, 17, 1, -21 },
  { 1714, 13, 21, 17, 2, -21 },
  { 1749, 5, 28, 17, 6, -24 },
  { 1767, 10, 23, 17, 4, -21 },
  { 1796, 5, 28, 17, 6, -24 },
  { 1814, 11, 12, 17, 3, -21 },
  { 1831, 13, 1, 17, 2, 0 },
  { 1833, 5, 4, 17, 6, -21 },
  { 1836, 13, 16, 17, 2, -16 },
  { 1862, 12, 22, 17, 3, -22 },
  { 1895, 13, 16, 17, 2, -16 },
  { 1921, 13, 22, 17, 2, -22 },
  { 1957, 13, 16, 17, 2, -16 },
  { 1983, 13, 22, 17, 3, -22 },
  { 2019, 13, 22, 17, 2, -16 },
  { 2055, 12, 22, 17, 3, -22 },
  { 2088, 12, 21, 17, 3, -21 },
  { 2120, 9, 27, 17, 3, -21 },
  { 2151, 13, 22, 17, 3, -22 },
  { 2187, 12, 22, 17, 3, -22 },
  { 2220, 15, 16, 17, 1, -16 },
  { 2250, 12, 16, 17, 3, -16 },
  { 2274, 14, 16, 17, 2, -16 },
  { 2302, 12, 22, 17, 3, -16 },
  { 2335, 13, 22, 17, 2, -16 },
  { 2371, 10, 16, 17, 5, -16 },
  { 2391, 12, 16, 17, 3, -16 },
  { 2415, 13, 19, 17, 2, -19 },
  { 2446, 12, 15, 17, 3, -15 },
  { 2469, 14, 15, 17, 2, -15 },
  { 2496, 16, 15, 17, 1, -15 },
  { 2526, 14, 15, 17, 2, -15 },
  { 2553, 15, 21, 17, 1, -15 },
  { 2593, 14, 15, 17, 2, -15 },
  { 2620, 9, 29, 17, 5, -23 },
  { 2653, 1, 26, 17, 8, -21 },
  { 2657, 9, 29, 17, 5, -23 },
  { 2690, 16, 5, 17, 1, -11 },
};

const GFXfont RobotoMono_Light29pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light29pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOMONO_LIGHT29PT7B_H_
