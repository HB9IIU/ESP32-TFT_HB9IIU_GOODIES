#ifndef _ROBOTOMONO_LIGHT27PT7B_H_
#define _ROBOTOMONO_LIGHT27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0xCF, 0x3C, 0xF3, 0xCF, 0x30, 0x02,
  0x18, 0x0C, 0x20, 0x18, 0x40, 0x20, 0x80, 0x43, 0x0F, 0xFF, 0xDF, 0xFF,
  0x86, 0x10, 0x08, 0x20, 0x10, 0xC0, 0x21, 0x80, 0x42, 0x0F, 0xFF, 0xDF,
  0xFF, 0x84, 0x30, 0x08, 0x60, 0x10, 0x80, 0x61, 0x00, 0xC2, 0x00, 0x02,
  0x00, 0x20, 0x02, 0x01, 0xFC, 0x30, 0x66, 0x03, 0x60, 0x36, 0x03, 0x60,
  0x06, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x60, 0x03, 0xC0,
  0x1C, 0x01, 0x40, 0x36, 0x03, 0x38, 0xE1, 0xFC, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x78, 0x01, 0x18, 0x02, 0x10, 0xC4, 0x21, 0x08, 0x44, 0x10, 0x88,
  0x33, 0x20, 0x3C, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x33, 0xC0,
  0x4C, 0x41, 0x90, 0x82, 0x21, 0x88, 0x43, 0x10, 0x84, 0x01, 0x88, 0x01,
  0xE0, 0x1F, 0x00, 0xC6, 0x02, 0x08, 0x18, 0x30, 0x20, 0x80, 0x86, 0x03,
  0x30, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x06, 0x60, 0x90, 0xC6, 0xC1, 0x1A,
  0x06, 0x68, 0x0D, 0x30, 0x1C, 0xC0, 0x71, 0x87, 0x43, 0xF1, 0xC0, 0xFC,
  0x04, 0x10, 0x86, 0x30, 0x86, 0x18, 0x41, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x10, 0x41, 0x82, 0x08, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x18,
  0x20, 0xC1, 0x06, 0x08, 0x20, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x82,
  0x18, 0x61, 0x0C, 0x21, 0x8C, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x84,
  0x2F, 0x27, 0x8F, 0xE0, 0x1C, 0x00, 0xA0, 0x08, 0x80, 0xC6, 0x0C, 0x18,
  0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x03,
  0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x6D, 0xB5, 0x00, 0xFF, 0xC0, 0xFC, 0x01, 0x80, 0xC0, 0x40, 0x60,
  0x20, 0x30, 0x18, 0x08, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x01, 0x80, 0xC0,
  0x40, 0x60, 0x20, 0x30, 0x18, 0x08, 0x00, 0x1F, 0x83, 0x0C, 0x60, 0x64,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x19, 0xC3, 0x1C, 0x61, 0xCC, 0x1D,
  0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x34, 0x02, 0x60, 0x63, 0x0C, 0x1F, 0x80,
  0x06, 0x7F, 0xDC, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x1F, 0xC1, 0x87, 0x18, 0x08, 0x80, 0x6C,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x1F, 0xFE,
  0x1F, 0xC3, 0x06, 0x60, 0x34, 0x03, 0x40, 0x30, 0x03, 0x00, 0x30, 0x06,
  0x03, 0xC0, 0xFC, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0xC0, 0x14, 0x03,
  0x60, 0x33, 0x0E, 0x1F, 0xC0, 0x00, 0x60, 0x03, 0x80, 0x1E, 0x00, 0x58,
  0x02, 0x60, 0x19, 0x80, 0x46, 0x03, 0x18, 0x18, 0x60, 0x41, 0x83, 0x06,
  0x18, 0x18, 0x40, 0x63, 0xFF, 0xF0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x7F, 0xEC, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10,
  0x03, 0xFC, 0xF3, 0xC8, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1E,
  0x03, 0x40, 0xEF, 0x78, 0x7E, 0x00, 0x07, 0x81, 0xE0, 0x38, 0x03, 0x00,
  0x60, 0x04, 0x00, 0xC2, 0x0D, 0xFC, 0xF0, 0xEC, 0x06, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x34, 0x02, 0x60, 0x63, 0x0C, 0x1F, 0x80, 0xFF,
  0xF0, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x30, 0x00, 0x1F, 0xC1, 0x83, 0x18, 0x0C, 0xC0, 0x64, 0x03,
  0x30, 0x19, 0x80, 0xC6, 0x0C, 0x1F, 0xC0, 0xFE, 0x0C, 0x18, 0xC0, 0x64,
  0x01, 0x60, 0x0F, 0x00, 0x68, 0x02, 0x60, 0x31, 0x83, 0x07, 0xF0, 0x1F,
  0x83, 0x0C, 0x60, 0x64, 0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x36, 0x07, 0x60, 0xF3, 0xFB, 0x0E, 0x30, 0x02, 0x00, 0x60, 0x04, 0x01,
  0xC0, 0x78, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x76, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x66, 0x64, 0xC8, 0x00, 0x20, 0x3C, 0x1E, 0x0E,
  0x07, 0x01, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1C, 0x00, 0x80, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0x01, 0xE0, 0x70, 0x3C, 0x0F,
  0x00, 0x80, 0x00, 0x3F, 0x8C, 0x3B, 0x03, 0x60, 0x20, 0x06, 0x00, 0x80,
  0x30, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x07, 0xE0, 0x60, 0xC3, 0x00, 0x88,
  0x03, 0x43, 0xC5, 0x11, 0x18, 0xC4, 0x62, 0x11, 0x88, 0x46, 0x21, 0x19,
  0x84, 0x62, 0x11, 0x88, 0xC6, 0x35, 0x2C, 0x67, 0x10, 0x00, 0x60, 0x00,
  0xE1, 0x80, 0xFC, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x01, 0xA0, 0x06,
  0xC0, 0x13, 0x00, 0xC4, 0x03, 0x18, 0x08, 0x60, 0x60, 0x81, 0x82, 0x04,
  0x0C, 0x3F, 0xF0, 0xFF, 0xC2, 0x01, 0x98, 0x06, 0x60, 0x09, 0x00, 0x3C,
  0x00, 0xC0, 0xFF, 0x08, 0x1C, 0x80, 0xC8, 0x06, 0x80, 0x68, 0x06, 0x80,
  0x68, 0x0C, 0xFF, 0x8F, 0xF8, 0x80, 0xC8, 0x06, 0x80, 0x28, 0x03, 0x80,
  0x38, 0x06, 0x80, 0x68, 0x3C, 0xFF, 0x00, 0x1F, 0xC1, 0x87, 0x18, 0x0C,
  0x80, 0x6C, 0x01, 0x60, 0x0E, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x60, 0x0F, 0x00, 0x48, 0x06, 0x60, 0x21, 0x87,
  0x07, 0xE0, 0xFF, 0x06, 0x0E, 0x30, 0x19, 0x80, 0x6C, 0x03, 0x60, 0x0B,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0B, 0x00, 0xD8, 0x04, 0xC0, 0x66, 0x1E, 0x3F, 0xC0, 0xFF, 0xF0, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF, 0xDF, 0xFA, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0xFF, 0x80,
  0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x1F, 0xFA, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x00, 0x1F, 0xC3, 0x0E, 0x60, 0x3C, 0x03, 0xC0, 0x18, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x83, 0xF8, 0x01, 0x80, 0x1C, 0x01,
  0xC0, 0x14, 0x01, 0x60, 0x13, 0x87, 0x1F, 0xC0, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x10, 0xFF, 0xE1, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x83, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0xC0, 0x09, 0x00, 0x4C, 0x06, 0x60, 0x31, 0xC7, 0x07, 0xF0, 0x80,
  0x74, 0x03, 0x20, 0x31, 0x03, 0x08, 0x30, 0x43, 0x02, 0x30, 0x13, 0x00,
  0x98, 0x05, 0xE0, 0x3B, 0x01, 0x8C, 0x08, 0x30, 0x40, 0xC2, 0x06, 0x10,
  0x18, 0x80, 0x64, 0x01, 0xA0, 0x0E, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0xFF, 0x80, 0xC0, 0x3E, 0x03,
  0xE0, 0x7F, 0x05, 0xF0, 0xDD, 0x0D, 0xD8, 0x9C, 0x99, 0xC9, 0x1C, 0xD1,
  0xC7, 0x1C, 0x61, 0xC6, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x10, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xD0, 0x1D, 0x81, 0xC8,
  0x1C, 0xC1, 0xC4, 0x1C, 0x61, 0xC3, 0x1C, 0x31, 0xC1, 0x9C, 0x09, 0xC0,
  0xDC, 0x05, 0xC0, 0x7C, 0x03, 0xC0, 0x30, 0x1F, 0x81, 0x86, 0x18, 0x18,
  0x80, 0x6C, 0x03, 0x60, 0x0A, 0x00, 0x50, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x60, 0x0B, 0x00, 0xC8, 0x06, 0x60, 0x61, 0x86,
  0x07, 0xE0, 0xFF, 0x88, 0x0C, 0x80, 0x68, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x68, 0x1C, 0xFF, 0x88, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0x61, 0xC3, 0x01,
  0x18, 0x06, 0x60, 0x09, 0x00, 0x34, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x40, 0x0D, 0x00, 0x26, 0x00, 0x98, 0x06, 0x30,
  0x30, 0x61, 0x80, 0xFE, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0xFF, 0x08,
  0x1C, 0x80, 0x48, 0x06, 0x80, 0x28, 0x02, 0x80, 0x28, 0x06, 0x80, 0xC8,
  0x38, 0xFF, 0x08, 0x30, 0x81, 0x08, 0x18, 0x80, 0xC8, 0x0C, 0x80, 0x68,
  0x06, 0x80, 0x30, 0x1F, 0xC1, 0x83, 0x18, 0x0D, 0x80, 0x2C, 0x01, 0xE0,
  0x01, 0x80, 0x06, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0x00, 0x0F, 0x00, 0x78, 0x03, 0x60, 0x31, 0x83, 0x07, 0xF0, 0xFF, 0xFC,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x34, 0x03, 0x60, 0x63, 0x8C, 0x1F,
  0x80, 0xC0, 0x0D, 0x00, 0x26, 0x01, 0x98, 0x06, 0x20, 0x10, 0xC0, 0xC3,
  0x03, 0x04, 0x08, 0x18, 0x20, 0x61, 0x80, 0x86, 0x03, 0x10, 0x0C, 0xC0,
  0x13, 0x00, 0x48, 0x01, 0xE0, 0x07, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC1,
  0x07, 0x86, 0x0B, 0x0E, 0x12, 0x1C, 0x24, 0x28, 0xC8, 0x51, 0x99, 0xA3,
  0x33, 0x44, 0x64, 0xC8, 0xC8, 0x90, 0x91, 0x21, 0x62, 0xC2, 0xC5, 0x85,
  0x0F, 0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x60,
  0x0C, 0x80, 0x63, 0x01, 0x06, 0x0C, 0x18, 0x60, 0x31, 0x80, 0x4C, 0x01,
  0xA0, 0x03, 0x80, 0x0C, 0x00, 0x38, 0x01, 0xB0, 0x0C, 0xC0, 0x31, 0x81,
  0x82, 0x04, 0x0C, 0x30, 0x19, 0x80, 0x6E, 0x00, 0xC0, 0xC0, 0x0D, 0x80,
  0x66, 0x01, 0x0C, 0x0C, 0x30, 0x20, 0x61, 0x81, 0x84, 0x03, 0x30, 0x0C,
  0x80, 0x1E, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x60,
  0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xF0,
  0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x87, 0xC0, 0xC0, 0x18, 0x06, 0x00, 0x80, 0x30, 0x04,
  0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30,
  0x0C, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0xC0, 0xF1, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x0C, 0x03, 0x01,
  0xE0, 0x48, 0x13, 0x0C, 0x42, 0x11, 0x86, 0x40, 0xB0, 0x30, 0xFF, 0xF0,
  0xC6, 0x21, 0x06, 0x03, 0xFC, 0x70, 0x64, 0x02, 0x40, 0x30, 0x03, 0x00,
  0x31, 0xFF, 0x70, 0x34, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x76, 0x1F, 0x3F,
  0x30, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x08, 0x2F, 0xE7, 0x0E,
  0xC0, 0xD0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80,
  0x78, 0x1B, 0x86, 0x4F, 0x80, 0x02, 0x01, 0xFC, 0x30, 0x66, 0x02, 0x40,
  0x3C, 0x03, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x03, 0x60,
  0x23, 0x0E, 0x1F, 0x80, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x43, 0x1F, 0xB3, 0x0F, 0x60, 0x74, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x40, 0x36, 0x07, 0x30, 0xF1, 0xFB, 0x02, 0x01,
  0xFC, 0x30, 0x66, 0x02, 0x40, 0x3C, 0x01, 0xC0, 0x1F, 0xFF, 0xC0, 0x0C,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x33, 0x86, 0x0F, 0xC0, 0x00, 0x70, 0x1F,
  0xC1, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x1F, 0xFE, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x04, 0x01, 0xFB, 0x30,
  0xF6, 0x07, 0x40, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x34, 0x03, 0x60, 0x73, 0x8F, 0x1F, 0xB0, 0x03, 0x00, 0x24, 0x06, 0x60,
  0xC3, 0xFC, 0x0E, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x0C,
  0x27, 0xE5, 0x06, 0xC0, 0x50, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC3, 0xFF, 0x80, 0x03,
  0x03, 0x00, 0x00, 0x00, 0x7F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0xFC, 0xF0,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x02, 0x80, 0xC8, 0x18,
  0x83, 0x08, 0x60, 0x8C, 0x09, 0x80, 0xB8, 0x0E, 0xC0, 0xC6, 0x08, 0x30,
  0x81, 0x88, 0x1C, 0x80, 0xC8, 0x07, 0xFE, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x7F, 0xF0, 0x08, 0x23,
  0xFB, 0xEE, 0x38, 0xF0, 0xC3, 0xC3, 0x07, 0x0C, 0x1C, 0x30, 0x70, 0xC1,
  0xC3, 0x07, 0x0C, 0x1C, 0x30, 0x70, 0xC1, 0xC3, 0x07, 0x0C, 0x1C, 0x30,
  0x40, 0x06, 0x13, 0xF2, 0x83, 0x60, 0x28, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x06, 0x01,
  0xFC, 0x30, 0xE6, 0x02, 0xC0, 0x3C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0xC0, 0x3C, 0x03, 0x60, 0x63, 0x0C, 0x1F, 0x80, 0x04, 0x17, 0xF3,
  0x87, 0x60, 0x68, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x2C, 0x0D, 0xC3, 0x27, 0xC4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x00, 0x04, 0x01, 0xFB, 0x30, 0xF6, 0x07, 0x40, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x34, 0x03, 0x60, 0x73, 0x0F, 0x1F, 0xB0,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x01, 0x4F, 0xEC, 0x1C, 0x0C,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00,
  0x02, 0x01, 0xFC, 0x30, 0x66, 0x03, 0x60, 0x36, 0x00, 0x30, 0x01, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x34, 0x03, 0x60, 0x33, 0x06, 0x1F, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xFF, 0xE0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x3F, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x76, 0x1E, 0x7C, 0xC0, 0xC0, 0x0D,
  0x80, 0x62, 0x01, 0x8C, 0x04, 0x30, 0x30, 0x40, 0x81, 0x86, 0x02, 0x10,
  0x0C, 0x40, 0x13, 0x00, 0x48, 0x01, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x83,
  0x07, 0x86, 0x0B, 0x0C, 0x12, 0x1C, 0x64, 0x68, 0xC8, 0x91, 0x19, 0x22,
  0x12, 0x64, 0x2C, 0x58, 0x50, 0xA0, 0xA1, 0x41, 0xC3, 0x81, 0x83, 0x02,
  0x06, 0x00, 0xC0, 0x3B, 0x03, 0x0C, 0x10, 0x31, 0x80, 0x98, 0x07, 0x80,
  0x18, 0x00, 0xE0, 0x0D, 0x80, 0xCC, 0x0C, 0x30, 0x60, 0xC6, 0x03, 0x60,
  0x0C, 0xC0, 0x0D, 0x80, 0x26, 0x01, 0x8C, 0x04, 0x30, 0x30, 0x40, 0xC1,
  0x86, 0x02, 0x18, 0x0C, 0x40, 0x33, 0x00, 0x68, 0x01, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x07, 0x80, 0x1C, 0x00,
  0xFF, 0xF0, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0F, 0xFF, 0x01, 0x81, 0x81,
  0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x0F, 0x07,
  0x00, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C,
  0x06, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x18, 0x06,
  0x03, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0x00, 0x80, 0x38,
  0x1C, 0x18, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30,
  0x30, 0x70, 0x00, 0x7C, 0x07, 0x1C, 0x18, 0x18, 0xE0, 0x3E,
};

const GFXglyph RobotoMono_Light27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 2, 19, 16, 7, -19 },
  { 6, 6, 6, 16, 5, -20 },
  { 11, 15, 19, 16, 1, -19 },
  { 47, 12, 25, 16, 2, -22 },
  { 85, 15, 19, 16, 1, -19 },
  { 121, 14, 19, 16, 2, -19 },
  { 155, 1, 6, 16, 7, -20 },
  { 156, 6, 28, 16, 5, -22 },
  { 177, 6, 28, 16, 5, -22 },
  { 198, 13, 12, 16, 2, -19 },
  { 218, 13, 14, 16, 2, -16 },
  { 241, 3, 6, 16, 5, -2 },
  { 244, 10, 1, 16, 3, -9 },
  { 246, 3, 2, 16, 7, -2 },
  { 247, 9, 21, 16, 4, -19 },
  { 271, 12, 19, 16, 2, -19 },
  { 300, 7, 19, 16, 3, -19 },
  { 317, 13, 19, 16, 1, -19 },
  { 348, 12, 19, 16, 1, -19 },
  { 377, 14, 19, 16, 1, -19 },
  { 411, 11, 19, 16, 3, -19 },
  { 438, 12, 19, 16, 2, -19 },
  { 467, 12, 19, 16, 2, -19 },
  { 496, 13, 19, 16, 2, -19 },
  { 527, 12, 19, 16, 2, -19 },
  { 556, 3, 14, 16, 8, -14 },
  { 562, 4, 18, 16, 7, -14 },
  { 571, 11, 11, 16, 2, -14 },
  { 587, 12, 7, 16, 2, -12 },
  { 598, 12, 11, 16, 2, -14 },
  { 615, 11, 19, 16, 3, -19 },
  { 642, 14, 19, 16, 1, -19 },
  { 676, 14, 19, 16, 1, -19 },
  { 710, 12, 19, 16, 3, -19 },
  { 739, 13, 19, 16, 2, -19 },
  { 770, 13, 19, 16, 2, -19 },
  { 801, 11, 19, 16, 3, -19 },
  { 828, 11, 19, 16, 3, -19 },
  { 855, 12, 19, 16, 2, -19 },
  { 884, 12, 19, 16, 2, -19 },
  { 913, 11, 19, 16, 3, -19 },
  { 940, 13, 19, 16, 1, -19 },
  { 971, 13, 19, 16, 3, -19 },
  { 1002, 11, 19, 16, 3, -19 },
  { 1029, 12, 19, 16, 2, -19 },
  { 1058, 12, 19, 16, 2, -19 },
  { 1087, 13, 19, 16, 2, -19 },
  { 1118, 12, 19, 16, 3, -19 },
  { 1147, 14, 22, 16, 1, -19 },
  { 1186, 12, 19, 16, 3, -19 },
  { 1215, 13, 19, 16, 2, -19 },
  { 1246, 14, 19, 16, 1, -19 },
  { 1280, 12, 19, 16, 2, -19 },
  { 1309, 14, 19, 16, 1, -19 },
  { 1343, 15, 19, 16, 1, -19 },
  { 1379, 14, 19, 16, 1, -19 },
  { 1413, 14, 19, 16, 1, -19 },
  { 1447, 12, 19, 16, 2, -19 },
  { 1476, 5, 26, 16, 6, -22 },
  { 1493, 10, 21, 16, 3, -19 },
  { 1520, 4, 26, 16, 6, -22 },
  { 1533, 10, 10, 16, 3, -19 },
  { 1546, 12, 1, 16, 2, 0 },
  { 1548, 4, 4, 16, 6, -20 },
  { 1550, 12, 15, 16, 2, -15 },
  { 1573, 11, 20, 16, 3, -20 },
  { 1601, 12, 15, 16, 2, -15 },
  { 1624, 12, 20, 16, 2, -20 },
  { 1654, 12, 15, 16, 2, -15 },
  { 1677, 13, 21, 16, 2, -21 },
  { 1712, 12, 21, 16, 2, -15 },
  { 1744, 11, 20, 16, 3, -20 },
  { 1772, 11, 19, 16, 3, -19 },
  { 1799, 8, 25, 16, 3, -19 },
  { 1824, 12, 20, 16, 3, -20 },
  { 1854, 11, 20, 16, 3, -20 },
  { 1882, 14, 15, 16, 1, -15 },
  { 1909, 11, 15, 16, 3, -15 },
  { 1930, 12, 15, 16, 2, -15 },
  { 1953, 11, 20, 16, 3, -15 },
  { 1981, 12, 20, 16, 2, -15 },
  { 2011, 9, 15, 16, 5, -15 },
  { 2028, 12, 15, 16, 2, -15 },
  { 2051, 12, 18, 16, 2, -18 },
  { 2078, 11, 14, 16, 3, -14 },
  { 2098, 14, 14, 16, 1, -14 },
  { 2123, 15, 14, 16, 1, -14 },
  { 2150, 13, 14, 16, 2, -14 },
  { 2173, 14, 20, 16, 1, -14 },
  { 2208, 12, 14, 16, 2, -14 },
  { 2229, 9, 26, 16, 4, -21 },
  { 2259, 2, 23, 16, 7, -19 },
  { 2265, 9, 26, 16, 4, -21 },
  { 2295, 14, 4, 16, 1, -10 },
};

const GFXfont RobotoMono_Light27pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light27pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOMONO_LIGHT27PT7B_H_
