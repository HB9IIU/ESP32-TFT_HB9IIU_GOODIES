#ifndef _ROBOTOMONO_LIGHT25PT7B_H_
#define _ROBOTOMONO_LIGHT25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light25pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x40, 0xF0, 0x8C, 0x63, 0x18, 0xC4, 0x04, 0x30,
  0x21, 0x01, 0x08, 0x08, 0x40, 0xC2, 0x3F, 0xFC, 0x21, 0x01, 0x08, 0x08,
  0x40, 0x42, 0x06, 0x30, 0x21, 0x0F, 0xFF, 0x08, 0x40, 0x42, 0x06, 0x30,
  0x21, 0x01, 0x08, 0x00, 0x06, 0x00, 0xC0, 0x7C, 0x1C, 0xE6, 0x04, 0x80,
  0xD0, 0x0A, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0xC0, 0x1C, 0x00, 0xC0,
  0x0E, 0x01, 0xC0, 0x28, 0x0D, 0xC3, 0x0F, 0xC0, 0x60, 0x0C, 0x01, 0x80,
  0x70, 0x04, 0x40, 0x23, 0x19, 0x08, 0x88, 0x4C, 0x46, 0x43, 0x26, 0x0E,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x1C, 0x09, 0x30, 0x98, 0x8C, 0x84, 0x44,
  0x26, 0x31, 0x00, 0x88, 0x07, 0x80, 0x1E, 0x03, 0x30, 0x61, 0x86, 0x18,
  0x61, 0x06, 0x30, 0x36, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x66, 0x1C, 0x23,
  0x83, 0x38, 0x1A, 0x80, 0xEC, 0x0C, 0x61, 0xA3, 0xF3, 0xFF, 0xE0, 0x08,
  0x71, 0x08, 0x61, 0x04, 0x30, 0xC2, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83,
  0x0C, 0x10, 0x40, 0x82, 0x04, 0x08, 0x10, 0x81, 0x02, 0x0C, 0x10, 0x60,
  0x82, 0x0C, 0x30, 0xC1, 0x04, 0x10, 0x43, 0x0C, 0x30, 0x82, 0x18, 0x43,
  0x08, 0x42, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x42, 0x1E, 0x4E, 0x7F, 0x01,
  0x80, 0x58, 0x19, 0x86, 0x10, 0x83, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x00, 0x57, 0xE0, 0xFF, 0xFF, 0xC0, 0xF0, 0x00,
  0x80, 0xC0, 0x40, 0x20, 0x30, 0x10, 0x18, 0x08, 0x04, 0x06, 0x02, 0x03,
  0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x10, 0x18, 0x00, 0x1F, 0x06,
  0x31, 0x83, 0x20, 0x3C, 0x07, 0x80, 0xE0, 0x2C, 0x09, 0x86, 0x31, 0x86,
  0x60, 0xD8, 0x1E, 0x03, 0x80, 0xF0, 0x1B, 0x02, 0x31, 0x83, 0xE0, 0x04,
  0x7F, 0x61, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x1F, 0x03, 0x1C, 0x60, 0x44, 0x06, 0xC0, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x03,
  0x00, 0x60, 0x07, 0xFF, 0x1F, 0x06, 0x39, 0x81, 0x20, 0x3C, 0x02, 0x00,
  0xC0, 0x18, 0x06, 0x0F, 0x81, 0xF0, 0x01, 0x00, 0x30, 0x03, 0x80, 0x70,
  0x0A, 0x03, 0x70, 0xC3, 0xF0, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x6C, 0x02, 0x60, 0x33, 0x03, 0x18, 0x10, 0xC1, 0x86, 0x18, 0x30, 0x81,
  0x8F, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x7F,
  0xDF, 0xF4, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0xFC, 0xC3, 0x80, 0x30,
  0x0C, 0x03, 0x00, 0x60, 0x38, 0x0F, 0x03, 0x73, 0x8F, 0xC0, 0x07, 0x83,
  0xE0, 0xC0, 0x30, 0x06, 0x00, 0x80, 0x33, 0x85, 0xFC, 0xE0, 0xD8, 0x0A,
  0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x13, 0x06, 0x31, 0x83, 0xE0, 0xFF,
  0xFF, 0xFC, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0x1F, 0x06, 0x39, 0x81, 0x20, 0x34, 0x02, 0x80, 0xD8, 0x19, 0x06, 0x1F,
  0x87, 0xF1, 0x81, 0x20, 0x1C, 0x03, 0x80, 0x70, 0x0A, 0x03, 0x70, 0xC3,
  0xF0, 0x1F, 0x06, 0x31, 0x83, 0x60, 0x2C, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0xC0, 0x68, 0x1D, 0xC7, 0x8F, 0xB0, 0x04, 0x00, 0x80, 0x30, 0x0C, 0x07,
  0x07, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x77, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x26, 0x64, 0xC0, 0x00, 0x40, 0x70, 0xF0, 0xE0, 0xE0, 0x38, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x10, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x01, 0xC1, 0xE0,
  0xE0, 0x70, 0x18, 0x00, 0x3E, 0x18, 0xCC, 0x1A, 0x02, 0x00, 0xC0, 0x20,
  0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x06, 0x00, 0x07, 0x80, 0xE3, 0x0C, 0x0C, 0xC0, 0x24, 0x78, 0xA6,
  0x66, 0x22, 0x31, 0x11, 0x90, 0x8C, 0x84, 0x64, 0x23, 0x21, 0x19, 0x99,
  0x47, 0x7B, 0x00, 0x08, 0x00, 0x30, 0x40, 0xFC, 0x00, 0x02, 0x00, 0x18,
  0x01, 0xC0, 0x0A, 0x00, 0x58, 0x06, 0x40, 0x22, 0x01, 0x18, 0x18, 0x40,
  0x82, 0x04, 0x18, 0x60, 0x43, 0xFE, 0x10, 0x19, 0x80, 0xCC, 0x02, 0x40,
  0x1E, 0x00, 0xC0, 0xFE, 0x0F, 0xF8, 0xC0, 0xCC, 0x06, 0xC0, 0x6C, 0x06,
  0xC0, 0x6C, 0x0C, 0xFF, 0x0C, 0x3C, 0xC0, 0x6C, 0x02, 0xC0, 0x3C, 0x02,
  0xC0, 0x2C, 0x06, 0xC1, 0xCF, 0xF0, 0x1F, 0x06, 0x39, 0x81, 0x60, 0x3C,
  0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x70, 0x1A, 0x02, 0x30, 0xC3, 0xF0, 0xFC, 0x0C, 0x78, 0xC0, 0xCC,
  0x04, 0xC0, 0x6C, 0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x2C, 0x06, 0xC0, 0x6C, 0x0C, 0xC3, 0x8F, 0xE0, 0xFF, 0xFF,
  0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xD8, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFC, 0xFF,
  0xFF, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xBF, 0xE8,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x0F, 0x81,
  0x8E, 0x30, 0x26, 0x03, 0x60, 0x14, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC1, 0xFC, 0x01, 0x40, 0x14, 0x01, 0x60, 0x13, 0x01, 0x18, 0x70,
  0xFC, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0xFF, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0xFF, 0xFF, 0xFC, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x1F, 0xFC, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3C, 0x02,
  0x40, 0x26, 0x06, 0x30, 0xC1, 0xF8, 0xC0, 0x3C, 0x06, 0xC0, 0xCC, 0x18,
  0xC3, 0x0C, 0x20, 0xC6, 0x0C, 0xC0, 0xDC, 0x0F, 0xC0, 0xE6, 0x0C, 0x30,
  0xC1, 0x0C, 0x18, 0xC0, 0xCC, 0x06, 0xC0, 0x2C, 0x03, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0xC0, 0x78, 0x0F, 0x83,
  0xD0, 0x5A, 0x0B, 0x63, 0x64, 0x4C, 0xC9, 0x9B, 0x31, 0x46, 0x38, 0xC2,
  0x18, 0x43, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0xC0, 0x38, 0x07,
  0x80, 0xD0, 0x1B, 0x03, 0x20, 0x66, 0x0C, 0x41, 0x8C, 0x30, 0xC6, 0x18,
  0xC1, 0x98, 0x13, 0x03, 0x60, 0x2C, 0x07, 0x80, 0x70, 0x0C, 0x1F, 0x07,
  0x71, 0x83, 0x60, 0x3C, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x1B, 0x06, 0x31, 0x83, 0xE0, 0xFE,
  0x10, 0xF2, 0x03, 0x40, 0x28, 0x07, 0x00, 0xE0, 0x1C, 0x02, 0x80, 0xDF,
  0xF3, 0xF0, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00,
  0x0F, 0x80, 0xE6, 0x0C, 0x18, 0xC0, 0x64, 0x01, 0x20, 0x0B, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x34, 0x01, 0x20, 0x09, 0x80,
  0xC4, 0x04, 0x38, 0xE0, 0x7E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0xFE,
  0x0C, 0x38, 0xC0, 0xCC, 0x06, 0xC0, 0x2C, 0x02, 0xC0, 0x2C, 0x06, 0xC0,
  0xCF, 0xF8, 0xFF, 0x0C, 0x10, 0xC1, 0x8C, 0x08, 0xC0, 0xCC, 0x06, 0xC0,
  0x6C, 0x03, 0x1F, 0x03, 0x1C, 0x60, 0x6C, 0x02, 0xC0, 0x2C, 0x00, 0x40,
  0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xC0, 0x06, 0x00, 0x28, 0x03, 0xC0,
  0x3C, 0x06, 0x70, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0xF0, 0x1A, 0x02, 0x71, 0xC3, 0xE0,
  0xC0, 0x1E, 0x00, 0x90, 0x04, 0xC0, 0x66, 0x02, 0x10, 0x10, 0xC1, 0x86,
  0x0C, 0x10, 0x40, 0xC6, 0x06, 0x30, 0x11, 0x00, 0x98, 0x06, 0xC0, 0x14,
  0x00, 0xA0, 0x07, 0x00, 0x10, 0x00, 0x82, 0x0E, 0x18, 0x70, 0xC3, 0x8E,
  0x14, 0x71, 0xA2, 0x8D, 0x16, 0x48, 0xB2, 0x64, 0x93, 0x64, 0x9A, 0x24,
  0x51, 0x22, 0x8F, 0x14, 0x30, 0xE1, 0x86, 0x0C, 0x30, 0x61, 0x83, 0x00,
  0xC0, 0x1B, 0x01, 0x8C, 0x0C, 0x60, 0xC1, 0x84, 0x04, 0x60, 0x36, 0x00,
  0xA0, 0x03, 0x00, 0x18, 0x01, 0x40, 0x1B, 0x00, 0x8C, 0x0C, 0x20, 0xC1,
  0x86, 0x06, 0x60, 0x36, 0x00, 0xC0, 0xC0, 0x1A, 0x01, 0x98, 0x0C, 0x40,
  0xC3, 0x06, 0x08, 0x60, 0x63, 0x01, 0x30, 0x0D, 0x00, 0x28, 0x01, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x30, 0x04,
  0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x1F,
  0xFC, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x8F, 0xC0, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x20, 0x18, 0x04,
  0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10,
  0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F,
  0x08, 0x0E, 0x05, 0x02, 0x83, 0x61, 0x11, 0x8C, 0x82, 0x41, 0x60, 0xC0,
  0xFF, 0xE0, 0xCC, 0x80, 0x3F, 0x8C, 0x19, 0x01, 0x40, 0x30, 0x06, 0x1F,
  0xCF, 0x1A, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xB0, 0xF3, 0xE6, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x37, 0xE7, 0x06, 0xC0, 0x58, 0x0F,
  0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x5E, 0x3B, 0x7E,
  0x00, 0x3F, 0x8C, 0x19, 0x01, 0xE0, 0x3C, 0x01, 0x00, 0x20, 0x04, 0x00,
  0xC0, 0x18, 0x0D, 0x81, 0x18, 0x61, 0xF8, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xCF, 0xDB, 0x07, 0x40, 0x78, 0x0F, 0x01, 0xC0, 0x38,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x60, 0x6E, 0x3C, 0x7D, 0x80, 0x1F, 0x84,
  0x19, 0x01, 0x60, 0x38, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x98, 0x61, 0xF8, 0x03, 0xF0, 0x60, 0x0C, 0x00, 0x80, 0x08, 0x00,
  0x80, 0xFF, 0xE0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x3F, 0x6C, 0x1D,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0D, 0x81,
  0xB8, 0xF1, 0xF6, 0x00, 0xC0, 0x12, 0x06, 0x61, 0x87, 0xE0, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x37, 0xE7, 0x86, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0x80, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xF0,
  0x03, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0xFC, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x74, 0x18, 0x86, 0x11,
  0x82, 0x60, 0x58, 0x0F, 0x81, 0x98, 0x21, 0x84, 0x18, 0x81, 0x10, 0x32,
  0x03, 0x80, 0xFC, 0x3F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x0F, 0xFC, 0xBE, 0xF6, 0x38, 0xF0, 0x87, 0x04, 0x18, 0x20, 0xC1, 0x06,
  0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x18, 0x20, 0x80,
  0xDF, 0x9E, 0x1B, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x06, 0x3F, 0x8C, 0x19, 0x01, 0x60, 0x38,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x0D, 0x01, 0x38, 0xE1, 0xF0,
  0xDF, 0x9C, 0x1B, 0x01, 0x60, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x78, 0x0F, 0x03, 0x78, 0xED, 0xF1, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x00, 0x3F, 0x6C, 0x1D, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0xC0, 0x78, 0x0D, 0x81, 0xB8, 0xF1, 0xF6, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0xCF, 0xF8, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x00, 0x3F, 0x8C, 0x19, 0x01, 0xA0, 0x06, 0x00,
  0x70, 0x03, 0xE0, 0x06, 0x00, 0x78, 0x05, 0x01, 0xB0, 0x61, 0xF8, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x0F, 0xFC, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x07, 0xE0, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x68,
  0x0D, 0x03, 0xB0, 0xF3, 0xF6, 0xC0, 0x1B, 0x01, 0x98, 0x08, 0x40, 0x43,
  0x06, 0x08, 0x20, 0x63, 0x01, 0x10, 0x08, 0x80, 0x6C, 0x01, 0x40, 0x0E,
  0x00, 0x20, 0x00, 0x82, 0x0C, 0x18, 0x71, 0x42, 0x8A, 0x34, 0x51, 0x22,
  0xC9, 0xB2, 0x4D, 0x16, 0x28, 0xA1, 0x47, 0x0E, 0x18, 0x60, 0xC1, 0x06,
  0x00, 0xC0, 0x66, 0x0C, 0x30, 0x81, 0x18, 0x1B, 0x00, 0xE0, 0x06, 0x00,
  0xE0, 0x1B, 0x03, 0x18, 0x20, 0xC6, 0x06, 0xC0, 0x30, 0xC0, 0x1A, 0x00,
  0x98, 0x0C, 0x40, 0x43, 0x06, 0x08, 0x20, 0x63, 0x03, 0x18, 0x0C, 0x80,
  0x6C, 0x01, 0x40, 0x0E, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x03, 0x80, 0x00, 0xFF, 0xE0, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x60, 0x0F, 0xFE, 0x01, 0x07, 0x04,
  0x08, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0xE0, 0x60, 0x10,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x08, 0x0C, 0x06, 0x01, 0xFF, 0xFF,
  0xFC, 0x80, 0xE0, 0x30, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08,
  0x0C, 0x03, 0x06, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30,
  0x60, 0xC0, 0x10, 0x03, 0xE0, 0x71, 0x83, 0x03, 0x60, 0x0E, 0x00,
};

const GFXglyph RobotoMono_Light25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 2, 18, 15, 6, -18 },
  { 6, 5, 6, 15, 5, -19 },
  { 10, 13, 18, 15, 1, -18 },
  { 40, 11, 23, 15, 2, -20 },
  { 72, 13, 18, 15, 1, -18 },
  { 102, 12, 18, 15, 2, -18 },
  { 129, 2, 6, 15, 6, -19 },
  { 131, 6, 26, 15, 5, -20 },
  { 151, 6, 26, 15, 4, -20 },
  { 171, 11, 11, 15, 2, -18 },
  { 187, 13, 13, 15, 1, -15 },
  { 209, 2, 6, 15, 5, -2 },
  { 211, 9, 2, 15, 3, -9 },
  { 214, 2, 2, 15, 7, -2 },
  { 215, 9, 20, 15, 3, -18 },
  { 238, 11, 18, 15, 2, -18 },
  { 263, 6, 18, 15, 3, -18 },
  { 277, 12, 18, 15, 1, -18 },
  { 304, 11, 18, 15, 1, -18 },
  { 329, 13, 18, 15, 1, -18 },
  { 359, 10, 18, 15, 3, -18 },
  { 382, 11, 18, 15, 2, -18 },
  { 407, 11, 18, 15, 2, -18 },
  { 432, 11, 18, 15, 2, -18 },
  { 457, 11, 18, 15, 2, -18 },
  { 482, 3, 13, 15, 7, -13 },
  { 487, 4, 17, 15, 6, -13 },
  { 496, 10, 10, 15, 2, -13 },
  { 509, 11, 6, 15, 2, -11 },
  { 518, 11, 10, 15, 2, -13 },
  { 532, 10, 18, 15, 3, -18 },
  { 555, 13, 18, 15, 1, -18 },
  { 585, 13, 18, 15, 1, -18 },
  { 615, 12, 18, 15, 2, -18 },
  { 642, 11, 18, 15, 2, -18 },
  { 667, 12, 18, 15, 2, -18 },
  { 694, 11, 18, 15, 2, -18 },
  { 719, 10, 18, 15, 3, -18 },
  { 742, 12, 18, 15, 1, -18 },
  { 769, 11, 18, 15, 2, -18 },
  { 794, 11, 18, 15, 2, -18 },
  { 819, 12, 18, 15, 1, -18 },
  { 846, 12, 18, 15, 2, -18 },
  { 873, 10, 18, 15, 3, -18 },
  { 896, 11, 18, 15, 2, -18 },
  { 921, 11, 18, 15, 2, -18 },
  { 946, 11, 18, 15, 2, -18 },
  { 971, 11, 18, 15, 3, -18 },
  { 996, 13, 21, 15, 1, -18 },
  { 1031, 12, 18, 15, 2, -18 },
  { 1058, 12, 18, 15, 2, -18 },
  { 1085, 13, 18, 15, 1, -18 },
  { 1115, 11, 18, 15, 2, -18 },
  { 1140, 13, 18, 15, 1, -18 },
  { 1170, 13, 18, 15, 1, -18 },
  { 1200, 13, 18, 15, 1, -18 },
  { 1230, 13, 18, 15, 1, -18 },
  { 1260, 11, 18, 15, 2, -18 },
  { 1285, 4, 24, 15, 6, -20 },
  { 1297, 9, 20, 15, 3, -18 },
  { 1320, 4, 24, 15, 5, -20 },
  { 1332, 9, 10, 15, 3, -18 },
  { 1344, 11, 1, 15, 2, 0 },
  { 1346, 3, 3, 15, 6, -18 },
  { 1348, 11, 13, 15, 2, -13 },
  { 1366, 11, 19, 15, 2, -19 },
  { 1393, 11, 13, 15, 2, -13 },
  { 1411, 11, 19, 15, 2, -19 },
  { 1438, 11, 13, 15, 2, -13 },
  { 1456, 12, 19, 15, 2, -19 },
  { 1485, 11, 18, 15, 2, -13 },
  { 1510, 11, 19, 15, 2, -19 },
  { 1537, 10, 18, 15, 3, -18 },
  { 1560, 8, 23, 15, 2, -18 },
  { 1583, 11, 19, 15, 3, -19 },
  { 1610, 10, 19, 15, 3, -19 },
  { 1634, 13, 13, 15, 1, -13 },
  { 1656, 11, 13, 15, 2, -13 },
  { 1674, 11, 13, 15, 2, -13 },
  { 1692, 11, 18, 15, 2, -13 },
  { 1717, 11, 18, 15, 2, -13 },
  { 1742, 9, 13, 15, 4, -13 },
  { 1757, 11, 13, 15, 2, -13 },
  { 1775, 11, 17, 15, 2, -17 },
  { 1799, 11, 13, 15, 2, -13 },
  { 1817, 13, 13, 15, 1, -13 },
  { 1839, 13, 13, 15, 1, -13 },
  { 1861, 12, 13, 15, 2, -13 },
  { 1881, 13, 18, 15, 1, -13 },
  { 1911, 11, 13, 15, 2, -13 },
  { 1929, 8, 25, 15, 4, -20 },
  { 1954, 1, 22, 15, 7, -18 },
  { 1957, 8, 25, 15, 4, -20 },
  { 1982, 13, 5, 15, 1, -10 },
};

const GFXfont RobotoMono_Light25pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light25pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOMONO_LIGHT25PT7B_H_
