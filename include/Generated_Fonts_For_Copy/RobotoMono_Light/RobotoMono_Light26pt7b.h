#ifndef _ROBOTOMONO_LIGHT26PT7B_H_
#define _ROBOTOMONO_LIGHT26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light26pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0x00, 0xF0, 0x8C, 0x63, 0x18, 0xC4, 0x06, 0x10,
  0x10, 0xC0, 0x42, 0x01, 0x08, 0x04, 0x21, 0xFF, 0xF0, 0x86, 0x02, 0x18,
  0x08, 0x40, 0x21, 0x01, 0x84, 0x06, 0x30, 0xFF, 0xF8, 0x42, 0x01, 0x08,
  0x0C, 0x20, 0x30, 0x80, 0x86, 0x00, 0x02, 0x00, 0x20, 0x0F, 0x03, 0xFC,
  0x30, 0x66, 0x06, 0x40, 0x24, 0x03, 0x60, 0x03, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x20, 0x03, 0xC0, 0x3C, 0x03, 0x60, 0x63, 0x0E,
  0x1F, 0x80, 0x20, 0x02, 0x00, 0x20, 0x30, 0x03, 0x60, 0x08, 0xC0, 0x21,
  0x08, 0x84, 0x42, 0x11, 0x08, 0xC8, 0x3E, 0x60, 0x21, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x9E, 0x04, 0xC8, 0x22, 0x10, 0x88, 0x44, 0x21, 0x10, 0x84,
  0x02, 0x30, 0x07, 0x80, 0x0E, 0x01, 0xF8, 0x0C, 0x60, 0xC1, 0x06, 0x08,
  0x30, 0xC0, 0x8C, 0x06, 0xC0, 0x1C, 0x00, 0xE0, 0x19, 0x00, 0x8C, 0x2C,
  0x31, 0x40, 0xCA, 0x03, 0xD0, 0x1C, 0xC0, 0x63, 0x0D, 0x8F, 0xC6, 0xFC,
  0x04, 0x31, 0x84, 0x21, 0x84, 0x10, 0xC3, 0x0C, 0x20, 0x82, 0x08, 0x20,
  0xC3, 0x0C, 0x10, 0x41, 0x82, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x02, 0x0C,
  0x10, 0x60, 0x83, 0x0C, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0xC3,
  0x08, 0x21, 0x04, 0x21, 0x08, 0x00, 0x06, 0x00, 0x20, 0x02, 0x04, 0x23,
  0xFB, 0xE0, 0xF0, 0x07, 0x00, 0x90, 0x18, 0x83, 0x0C, 0x10, 0x40, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xF0, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x6D, 0xAD, 0x00, 0xFF, 0x80,
  0xF8, 0x01, 0x81, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x10, 0x18, 0x08, 0x0C,
  0x04, 0x02, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x10, 0x00,
  0x0F, 0x03, 0xF8, 0x60, 0xC4, 0x06, 0xC0, 0x2C, 0x02, 0xC0, 0x7C, 0x0B,
  0xC3, 0x3C, 0x63, 0xCC, 0x3D, 0x83, 0xF0, 0x3E, 0x03, 0xC0, 0x24, 0x06,
  0x60, 0x63, 0x0C, 0x1F, 0x80, 0x0D, 0xFC, 0x61, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x06, 0x03, 0xFC, 0x60, 0x64,
  0x06, 0xC0, 0x2C, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0x7F, 0xF0,
  0x07, 0x03, 0xFC, 0x60, 0x66, 0x02, 0x40, 0x20, 0x03, 0x00, 0x20, 0x06,
  0x00, 0xC0, 0xF0, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0xC0, 0x3C, 0x03,
  0x60, 0x23, 0x0E, 0x1F, 0x80, 0x00, 0xC0, 0x0E, 0x00, 0x50, 0x06, 0x80,
  0x64, 0x02, 0x20, 0x31, 0x03, 0x08, 0x10, 0x41, 0x82, 0x18, 0x10, 0x80,
  0x8F, 0xFF, 0x80, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x7F,
  0xC8, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x17, 0x87, 0xFC, 0xC1, 0xC0,
  0x18, 0x01, 0x80, 0x30, 0x07, 0x00, 0xF0, 0x1E, 0x06, 0x73, 0x87, 0xE0,
  0x01, 0x81, 0xF0, 0x60, 0x18, 0x06, 0x00, 0x80, 0x30, 0x06, 0xFC, 0xB1,
  0xDC, 0x0F, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x60, 0x46,
  0x18, 0x7E, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x18, 0x03, 0x00, 0x07, 0x03, 0xFC, 0x60, 0x66, 0x02,
  0x40, 0x24, 0x03, 0x40, 0x26, 0x06, 0x30, 0xC0, 0xF0, 0x30, 0xC6, 0x06,
  0x40, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x60, 0x23, 0x0E, 0x1F, 0x80, 0x0E,
  0x07, 0xF1, 0x83, 0x20, 0x3C, 0x07, 0x80, 0x60, 0x0E, 0x01, 0xC0, 0x38,
  0x0D, 0x83, 0x9D, 0xD1, 0xE2, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x70, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x6C, 0x00, 0x00, 0x00, 0x24, 0x96,
  0x80, 0x00, 0x20, 0x1C, 0x0E, 0x07, 0x07, 0x81, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x38, 0x3C, 0x1C, 0x1E, 0x03, 0x00, 0x00, 0x1C, 0x1F, 0xEC, 0x1B,
  0x03, 0x80, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x00, 0x3F, 0x81,
  0x81, 0x08, 0x06, 0x61, 0x89, 0x1B, 0x2C, 0xC4, 0x62, 0x11, 0x88, 0x46,
  0x61, 0x19, 0x08, 0x64, 0x23, 0x98, 0x8A, 0x27, 0x28, 0xE7, 0x10, 0x00,
  0x60, 0x00, 0xC1, 0x00, 0xFC, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x78, 0x01,
  0x20, 0x04, 0x80, 0x33, 0x00, 0x8C, 0x02, 0x10, 0x18, 0x60, 0x61, 0x81,
  0x02, 0x0F, 0xFC, 0x3F, 0xF0, 0x80, 0x46, 0x01, 0x98, 0x06, 0x40, 0x0B,
  0x00, 0x30, 0xFF, 0x8C, 0x0C, 0xC0, 0x6C, 0x02, 0xC0, 0x2C, 0x02, 0xC0,
  0x6C, 0x1C, 0xFF, 0x8C, 0x0E, 0xC0, 0x2C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x06, 0xC1, 0xCF, 0xF8, 0x07, 0x03, 0xFC, 0x60, 0x64, 0x06, 0xC0,
  0x38, 0x03, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x03, 0xC0, 0x3C, 0x02, 0x60, 0x63, 0x0C, 0x1F, 0x80, 0xFF, 0x0C,
  0x1C, 0xC0, 0x6C, 0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x02, 0xC0, 0x6C, 0x0C, 0xC3, 0x8F,
  0xE0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF,
  0xA0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0,
  0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF,
  0x90, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x00, 0x03, 0x00, 0xFF, 0x0C, 0x0C, 0x40, 0x26, 0x01, 0xA0, 0x0D, 0x00,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x7F, 0x83, 0xF4, 0x01, 0xA0, 0x0D,
  0x80, 0x64, 0x03, 0x30, 0x18, 0xC1, 0x83, 0xF8, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xFF, 0xF8, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xFF,
  0xE0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x1F, 0xFC,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3C, 0x03, 0x40, 0x36, 0x06,
  0x30, 0xC1, 0xF8, 0x80, 0x78, 0x0C, 0x81, 0x88, 0x30, 0x86, 0x08, 0xC0,
  0x8C, 0x09, 0x80, 0xB8, 0x0E, 0xC0, 0xC6, 0x08, 0x60, 0x83, 0x08, 0x18,
  0x80, 0x88, 0x0C, 0x80, 0x68, 0x03, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xFC, 0xC0, 0x7E, 0x07, 0xE0, 0x7F,
  0x0F, 0xF0, 0xBD, 0x1B, 0xD9, 0xBC, 0x93, 0xCB, 0x3C, 0xE3, 0xC6, 0x3C,
  0x63, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E,
  0x03, 0xE0, 0x3F, 0x03, 0xD0, 0x3D, 0x83, 0xC8, 0x3C, 0xC3, 0xC4, 0x3C,
  0x63, 0xC3, 0x3C, 0x33, 0xC1, 0xBC, 0x0B, 0xC0, 0xFC, 0x07, 0xC0, 0x7C,
  0x03, 0x0E, 0x03, 0xF8, 0x60, 0xC4, 0x06, 0xC0, 0x2C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x24,
  0x02, 0x60, 0x63, 0x0C, 0x1F, 0x80, 0xFF, 0x90, 0x1A, 0x01, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0xDF, 0xF2, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x07, 0x80, 0xFE, 0x0C, 0x18,
  0x40, 0x66, 0x01, 0xA0, 0x0D, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xA0, 0x0D, 0x80, 0x6C, 0x02, 0x30, 0x30, 0xC3,
  0x03, 0xF0, 0x00, 0xC0, 0x03, 0x80, 0x0C, 0xFF, 0x10, 0x3A, 0x03, 0x40,
  0x38, 0x07, 0x00, 0xE0, 0x14, 0x06, 0x81, 0x9F, 0xE2, 0x08, 0x41, 0x88,
  0x11, 0x03, 0x20, 0x34, 0x06, 0x80, 0x70, 0x0C, 0x06, 0x03, 0xFC, 0x60,
  0x64, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xF0, 0x03,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x03, 0x40, 0x37, 0x0E, 0x1F,
  0xC0, 0xFF, 0xF8, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x3C, 0x02, 0xC0, 0x26, 0x06, 0x30, 0xC1, 0xF8, 0xC0, 0x1A,
  0x00, 0xD8, 0x04, 0xC0, 0x22, 0x03, 0x18, 0x10, 0xC0, 0x82, 0x0C, 0x18,
  0x60, 0xC2, 0x02, 0x30, 0x11, 0x80, 0xC8, 0x02, 0xC0, 0x16, 0x00, 0xE0,
  0x03, 0x00, 0x18, 0x00, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xD0, 0xC2, 0x47,
  0x89, 0x1A, 0x24, 0x48, 0x99, 0x26, 0x64, 0x99, 0xB3, 0x62, 0xCD, 0x0A,
  0x14, 0x28, 0x50, 0xA1, 0x43, 0x87, 0x0E, 0x1C, 0x30, 0x30, 0x40, 0x80,
  0x60, 0x18, 0xC0, 0xC3, 0x03, 0x06, 0x18, 0x08, 0x40, 0x33, 0x00, 0x48,
  0x01, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x78, 0x03, 0x30, 0x08, 0x40, 0x61,
  0x81, 0x03, 0x0C, 0x0C, 0x60, 0x1B, 0x00, 0x30, 0xC0, 0x1B, 0x00, 0x98,
  0x0C, 0x60, 0x41, 0x06, 0x0C, 0x20, 0x23, 0x01, 0x90, 0x05, 0x80, 0x38,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0xFF, 0xE0, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0,
  0x30, 0x04, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00,
  0xC0, 0x1F, 0xFC, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0xF0, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x40,
  0x30, 0x08, 0x06, 0x03, 0x00, 0x80, 0x60, 0x10, 0x08, 0x06, 0x01, 0x00,
  0xC0, 0x20, 0x10, 0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0xF8, 0x0C, 0x07, 0x01, 0x60, 0x48,
  0x32, 0x08, 0xC6, 0x11, 0x06, 0x40, 0xB0, 0x30, 0xFF, 0xE0, 0xC6, 0x30,
  0x1F, 0x03, 0x1C, 0x60, 0x64, 0x06, 0x80, 0x20, 0x02, 0x1F, 0xE7, 0x02,
  0x40, 0x2C, 0x02, 0xC0, 0x6C, 0x06, 0x61, 0xA3, 0xF3, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x27, 0x85, 0x9C, 0xC0, 0xD0, 0x1A, 0x01,
  0x40, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x02, 0x80, 0xD8, 0x1B, 0x86, 0x5F,
  0x80, 0x0F, 0x07, 0x39, 0x81, 0xA0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x01, 0x00, 0xB0, 0x33, 0x0C, 0x3F, 0x00, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x47, 0xC9, 0xCD, 0x60, 0x68, 0x0F, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x40, 0x2C, 0x0C, 0xC2, 0x8F,
  0x90, 0x0F, 0x03, 0x9C, 0x60, 0x64, 0x02, 0xC0, 0x3C, 0x03, 0xFF, 0xF8,
  0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x02, 0x30, 0x61, 0xFC, 0x01, 0xF0,
  0x79, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xFF, 0xEF, 0xFE, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x1F, 0x27, 0x35, 0x81, 0xA0, 0x3C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x05, 0x00, 0xB0, 0x33, 0x0A, 0x3E, 0x40,
  0x18, 0x03, 0x40, 0x6C, 0x18, 0xFE, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x33, 0xE6, 0xCE, 0xE0, 0x7C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x10, 0x04,
  0x01, 0xC0, 0x10, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x83,
  0xFF, 0x80, 0x01, 0x01, 0xC0, 0x40, 0x00, 0x01, 0xF8, 0xFC, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x18, 0x18, 0xF8, 0xA0, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x34, 0x0C, 0x83, 0x10, 0xC2, 0x30, 0x4C, 0x0B,
  0x81, 0xD8, 0x33, 0x04, 0x30, 0x83, 0x10, 0x32, 0x03, 0x40, 0x30, 0xFC,
  0x1F, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x7F, 0xF0, 0xDC, 0xF3, 0x9E, 0x6C, 0x30, 0xB0, 0xC3, 0xC3, 0x0B,
  0x0C, 0x2C, 0x30, 0xB0, 0xC2, 0xC3, 0x0B, 0x0C, 0x2C, 0x30, 0xB0, 0xC2,
  0xC3, 0x0B, 0x0C, 0x20, 0xCF, 0x9B, 0x3B, 0x81, 0xF0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x40,
  0x1F, 0x03, 0x9C, 0x60, 0x6C, 0x02, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x3C, 0x03, 0xC0, 0x26, 0x06, 0x30, 0xC1, 0xF8, 0xCF, 0x0F, 0xBC,
  0xE0, 0x4C, 0x06, 0xC0, 0x2C, 0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x2C, 0x02,
  0xC0, 0x6E, 0x06, 0xF0, 0xCD, 0xF8, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x00, 0x1F, 0x27, 0x35, 0x81, 0xA0, 0x3C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x05, 0x00, 0xB0, 0x33, 0x0A, 0x3E, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x8F, 0xDF, 0xB8, 0x18, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x1F, 0x83, 0x9C,
  0x60, 0x64, 0x02, 0x60, 0x07, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x60, 0x02,
  0xC0, 0x34, 0x02, 0x70, 0xE1, 0xFC, 0x0C, 0x01, 0x80, 0x30, 0x7F, 0xFF,
  0xFE, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x30, 0x07, 0xE0, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0F, 0x03, 0x63, 0x4F, 0x90,
  0xC0, 0x1A, 0x00, 0xD8, 0x04, 0x40, 0x63, 0x02, 0x08, 0x30, 0x61, 0x83,
  0x08, 0x08, 0xC0, 0x64, 0x01, 0x60, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x83,
  0x06, 0x0C, 0x3C, 0x30, 0xB0, 0xC2, 0x47, 0x89, 0x16, 0x26, 0x49, 0x99,
  0x24, 0x28, 0xD0, 0xA1, 0x42, 0x85, 0x0A, 0x1C, 0x30, 0x60, 0x40, 0x80,
  0xC0, 0x36, 0x06, 0x20, 0x43, 0x0C, 0x19, 0x80, 0xF0, 0x06, 0x00, 0x60,
  0x0F, 0x01, 0x98, 0x30, 0xC2, 0x04, 0x60, 0x6C, 0x03, 0xC0, 0x0D, 0x00,
  0x66, 0x01, 0x98, 0x0C, 0x30, 0x30, 0xC0, 0x81, 0x86, 0x06, 0x10, 0x08,
  0xC0, 0x32, 0x00, 0x58, 0x01, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x07, 0x80, 0x10, 0x00, 0xFF, 0xEF, 0xFE, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x0F, 0xFF, 0x03, 0x83, 0x03, 0x01, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x06, 0x06, 0x0C, 0x01, 0x80, 0x60, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x01, 0x80, 0xFF, 0xFF,
  0xFC, 0xE0, 0x18, 0x04, 0x03, 0x01, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x03, 0x00, 0xC0, 0x38, 0x30, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01,
  0x80, 0xC0, 0x40, 0x60, 0xC0, 0x00, 0x38, 0x07, 0xB8, 0x38, 0x30, 0xA0,
  0x7E, 0x00, 0x60,
};

const GFXglyph RobotoMono_Light26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 2, 18, 16, 7, -18 },
  { 6, 5, 6, 16, 5, -20 },
  { 10, 14, 18, 16, 1, -18 },
  { 42, 12, 24, 16, 2, -21 },
  { 78, 14, 19, 16, 1, -19 },
  { 112, 13, 19, 16, 2, -19 },
  { 143, 1, 6, 16, 7, -20 },
  { 144, 6, 27, 16, 5, -21 },
  { 165, 6, 27, 16, 4, -21 },
  { 186, 12, 11, 16, 2, -18 },
  { 203, 12, 13, 16, 2, -15 },
  { 223, 3, 6, 16, 5, -2 },
  { 226, 9, 1, 16, 3, -9 },
  { 228, 3, 2, 16, 7, -2 },
  { 229, 9, 20, 16, 4, -18 },
  { 252, 12, 19, 16, 2, -19 },
  { 281, 6, 18, 16, 3, -18 },
  { 295, 12, 19, 16, 1, -19 },
  { 324, 12, 19, 16, 1, -19 },
  { 353, 13, 18, 16, 1, -18 },
  { 383, 11, 18, 16, 3, -18 },
  { 408, 11, 19, 16, 2, -19 },
  { 435, 12, 18, 16, 2, -18 },
  { 462, 12, 19, 16, 2, -19 },
  { 491, 11, 19, 16, 2, -19 },
  { 518, 2, 13, 16, 8, -13 },
  { 522, 3, 17, 16, 7, -13 },
  { 529, 11, 11, 16, 2, -14 },
  { 545, 12, 7, 16, 2, -12 },
  { 556, 11, 11, 16, 2, -14 },
  { 572, 10, 19, 16, 3, -19 },
  { 596, 14, 19, 16, 1, -19 },
  { 630, 14, 18, 16, 1, -18 },
  { 662, 12, 18, 16, 2, -18 },
  { 689, 12, 19, 16, 2, -19 },
  { 718, 12, 18, 16, 2, -18 },
  { 745, 10, 18, 16, 3, -18 },
  { 768, 11, 18, 16, 3, -18 },
  { 793, 13, 19, 16, 1, -19 },
  { 824, 12, 18, 16, 2, -18 },
  { 851, 11, 18, 16, 2, -18 },
  { 876, 12, 18, 16, 1, -18 },
  { 903, 12, 18, 16, 3, -18 },
  { 930, 11, 18, 16, 3, -18 },
  { 955, 12, 18, 16, 2, -18 },
  { 982, 12, 18, 16, 2, -18 },
  { 1009, 12, 19, 16, 2, -19 },
  { 1038, 11, 18, 16, 3, -18 },
  { 1063, 13, 22, 16, 1, -19 },
  { 1099, 11, 18, 16, 3, -18 },
  { 1124, 12, 19, 16, 2, -19 },
  { 1153, 13, 18, 16, 1, -18 },
  { 1183, 12, 18, 16, 2, -18 },
  { 1210, 13, 18, 16, 1, -18 },
  { 1240, 14, 18, 16, 1, -18 },
  { 1272, 14, 18, 16, 1, -18 },
  { 1304, 13, 18, 16, 1, -18 },
  { 1334, 11, 18, 16, 2, -18 },
  { 1359, 4, 25, 16, 6, -21 },
  { 1372, 9, 20, 16, 3, -18 },
  { 1395, 5, 25, 16, 5, -21 },
  { 1411, 10, 10, 16, 3, -18 },
  { 1424, 11, 1, 16, 2, 0 },
  { 1426, 4, 3, 16, 6, -19 },
  { 1428, 12, 14, 16, 2, -14 },
  { 1449, 11, 20, 16, 3, -20 },
  { 1477, 11, 14, 16, 2, -14 },
  { 1497, 11, 20, 16, 2, -20 },
  { 1525, 12, 14, 16, 2, -14 },
  { 1546, 12, 20, 16, 2, -20 },
  { 1576, 11, 19, 16, 2, -14 },
  { 1603, 11, 20, 16, 2, -20 },
  { 1631, 11, 19, 16, 3, -19 },
  { 1658, 9, 25, 16, 2, -19 },
  { 1687, 11, 20, 16, 3, -20 },
  { 1715, 11, 20, 16, 3, -20 },
  { 1743, 14, 14, 16, 1, -14 },
  { 1768, 11, 14, 16, 2, -14 },
  { 1788, 12, 14, 16, 2, -14 },
  { 1809, 12, 19, 16, 2, -14 },
  { 1838, 11, 19, 16, 2, -14 },
  { 1865, 9, 14, 16, 5, -14 },
  { 1881, 12, 14, 16, 2, -14 },
  { 1902, 11, 17, 16, 2, -17 },
  { 1926, 10, 14, 16, 3, -14 },
  { 1944, 13, 14, 16, 1, -14 },
  { 1967, 14, 14, 16, 1, -14 },
  { 1992, 12, 14, 16, 2, -14 },
  { 2013, 14, 20, 16, 1, -14 },
  { 2048, 12, 14, 16, 2, -14 },
  { 2069, 9, 25, 16, 4, -20 },
  { 2098, 1, 22, 16, 7, -18 },
  { 2101, 9, 25, 16, 4, -20 },
  { 2130, 14, 5, 16, 1, -10 },
};

const GFXfont RobotoMono_Light26pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light26pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOMONO_LIGHT26PT7B_H_
