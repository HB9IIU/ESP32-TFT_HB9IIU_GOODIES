#ifndef _ROBOTOMONO_LIGHT62PT7B_H_
#define _ROBOTOMONO_LIGHT62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light62pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0xF7, 0xFF, 0xE0, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC0,
  0xEE, 0x07, 0x70, 0x38, 0x00, 0x07, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3C,
  0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x01,
  0xE3, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x18, 0x07, 0x00, 0x38, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x1C, 0x00,
  0xE0, 0x3C, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x70, 0x03, 0x81, 0xE0, 0x0E,
  0x00, 0x70, 0x38, 0x00, 0xE0, 0x0C, 0x0E, 0x00, 0x1C, 0x03, 0x81, 0xC0,
  0x03, 0x80, 0x70, 0x70, 0x00, 0x38, 0x1C, 0x0E, 0x00, 0x07, 0xCF, 0x83,
  0x80, 0x00, 0x7F, 0xE0, 0x70, 0x00, 0x03, 0xF0, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x03, 0xF8, 0x00, 0x01, 0xC1, 0xFF, 0x80, 0x00, 0x70,
  0x7C, 0xF8, 0x00, 0x0E, 0x0E, 0x07, 0x80, 0x03, 0x83, 0x80, 0x70, 0x00,
  0xF0, 0x70, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x70, 0x03, 0x80, 0x38, 0x0E, 0x00, 0x70, 0x07, 0x01, 0xC0,
  0x0E, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x78, 0x03, 0x00, 0x38, 0x02, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x03, 0xC3, 0xE0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x1C, 0x1E, 0x07, 0x80, 0x1C, 0x3C, 0x03, 0xC0, 0x1C, 0x3C, 0x03, 0xE0,
  0x1C, 0x78, 0x01, 0xF0, 0x1C, 0x78, 0x00, 0xF0, 0x3C, 0xF0, 0x00, 0x78,
  0x3C, 0xF0, 0x00, 0x3C, 0x38, 0xF0, 0x00, 0x3E, 0x78, 0xF0, 0x00, 0x1F,
  0x78, 0xF0, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x07, 0xF0, 0x70, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x0F,
  0xF0, 0x1F, 0x00, 0x3E, 0x78, 0x0F, 0xFF, 0xFC, 0x3C, 0x07, 0xFF, 0xF0,
  0x3E, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x70, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x80, 0x60, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0x80,
  0x0E, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x40, 0x0E, 0x00, 0x5F,
  0x01, 0xC0, 0x7F, 0xFC, 0x38, 0x3F, 0xFF, 0xE7, 0x3F, 0xF1, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0x70,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xC0, 0x01, 0xC0, 0x08, 0x00, 0x20,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xE7, 0x9E, 0xF3, 0x84, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x38, 0xF9, 0xFF, 0xF7, 0xCF, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x9F, 0xC0, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78,
  0x38, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x07,
  0xEF, 0x00, 0x00, 0xFE, 0xE0, 0x00, 0x1E, 0xFE, 0x00, 0x03, 0xCF, 0xE0,
  0x00, 0x78, 0xFE, 0x00, 0x0F, 0x0F, 0xE0, 0x01, 0xE0, 0xFE, 0x00, 0x7C,
  0x0F, 0xE0, 0x0F, 0x80, 0xFE, 0x01, 0xE0, 0x0F, 0xE0, 0x3C, 0x00, 0xFE,
  0x07, 0x80, 0x0F, 0xE0, 0xF0, 0x00, 0xFF, 0x1E, 0x00, 0x0F, 0xF3, 0xC0,
  0x00, 0xFF, 0x78, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xEF, 0xE0, 0x00, 0x0E,
  0xF8, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x1C, 0x78, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x7F, 0x03, 0xFF, 0x0F, 0xFF, 0x7F,
  0xCF, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x03,
  0x8F, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0x9F, 0xE0, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x3C, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C,
  0x70, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x1E, 0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x07,
  0x81, 0xF8, 0x01, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x70, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00,
  0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x7F, 0xE0, 0x07, 0xBF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xF3, 0xFF, 0x03, 0xE0, 0x07, 0xF0, 0x78, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7D, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x7C, 0x78, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE0, 0xF8, 0x01, 0xF8,
  0x0F, 0xE0, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0xFE, 0x00, 0xF0,
  0xFF, 0xF0, 0x1E, 0x7F, 0xFF, 0x83, 0x9F, 0x83, 0xF8, 0x77, 0x80, 0x1F,
  0x8F, 0xE0, 0x00, 0xF1, 0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0x78, 0x00,
  0x0F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x0F, 0xC0, 0x1F, 0x81, 0xF0,
  0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x1E, 0x3C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x80,
  0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0xF0, 0x00, 0xF8,
  0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFD, 0xFE, 0x00,
  0xF8, 0x07, 0xE0, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0x3C, 0x00, 0x0F, 0xE3, 0xC0,
  0x03, 0xFC, 0x7E, 0x01, 0xF7, 0x87, 0xFF, 0xFC, 0xF0, 0x3F, 0xFF, 0x1C,
  0x03, 0xFF, 0x83, 0x80, 0x06, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x31, 0xFF, 0xFF, 0xFD, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x7F, 0xFF, 0xFF, 0x78, 0x0C, 0x1F, 0x3F, 0x3F, 0x3F,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0xF0,
  0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x00, 0xFC,
  0x7C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xF7, 0xF8,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0xFE, 0x03, 0x87, 0x00, 0xFF, 0x80, 0xC7, 0x00, 0xFF,
  0xE0, 0x63, 0x80, 0xF0, 0x70, 0x39, 0x80, 0xE0, 0x18, 0x1D, 0xC0, 0x70,
  0x1C, 0x0E, 0xE0, 0x70, 0x0E, 0x03, 0x60, 0x38, 0x07, 0x01, 0xB0, 0x38,
  0x03, 0x80, 0xF8, 0x1C, 0x01, 0xC0, 0x7C, 0x0E, 0x00, 0xC0, 0x3E, 0x07,
  0x00, 0x60, 0x1F, 0x03, 0x00, 0x30, 0x0F, 0x83, 0x80, 0x18, 0x07, 0xC1,
  0xC0, 0x0C, 0x03, 0xE0, 0xE0, 0x0E, 0x03, 0xF0, 0x70, 0x07, 0x01, 0xF8,
  0x38, 0x03, 0x80, 0xFC, 0x1C, 0x01, 0xC0, 0x6E, 0x06, 0x01, 0xE0, 0x37,
  0x03, 0x81, 0xF0, 0x3B, 0x81, 0xC0, 0xF8, 0x18, 0xC0, 0xF1, 0xCE, 0x1C,
  0x70, 0x3F, 0xE7, 0xFC, 0x38, 0x0F, 0xE1, 0xFC, 0x1C, 0x03, 0xC0, 0x78,
  0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0x00, 0x07, 0xE0, 0x03,
  0x80, 0x00, 0xFF, 0x9F, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x01, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0E, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x38, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x1E, 0x70, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x1F, 0xE0,
  0xF0, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x03, 0xF0, 0xF0, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x07, 0x8F, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x7C,
  0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x07,
  0xC0, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xE0, 0x03, 0xF8, 0x0F, 0x00, 0x07,
  0xE0, 0x78, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0xC0, 0xF0, 0x03, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE3, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE3, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x1E, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00,
  0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x3E,
  0x00, 0x0F, 0x01, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3C, 0x7C, 0x00, 0x00,
  0xF3, 0xF8, 0x00, 0x03, 0xDF, 0xE0, 0x00, 0x0F, 0xFB, 0xC0, 0x00, 0x3F,
  0xCF, 0x80, 0x00, 0xFE, 0x1F, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x0F, 0xBC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x77, 0xEE, 0x00, 0x07, 0x7E, 0xE0, 0x00, 0xFF, 0xEF, 0x00, 0x0E,
  0xFE, 0x70, 0x01, 0xEF, 0xE7, 0x80, 0x1C, 0xFE, 0x78, 0x01, 0xCF, 0xE3,
  0x80, 0x3C, 0xFE, 0x3C, 0x03, 0x8F, 0xE1, 0xC0, 0x38, 0xFE, 0x1C, 0x07,
  0x8F, 0xF1, 0xE0, 0x70, 0xFF, 0x0E, 0x0F, 0x0F, 0xF0, 0xE0, 0xE0, 0xFF,
  0x0F, 0x0E, 0x0F, 0xF0, 0x71, 0xE0, 0xFF, 0x07, 0x1C, 0x0F, 0xF0, 0x7B,
  0xC0, 0xFF, 0x03, 0xB8, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0x00, 0xFF, 0x01, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00,
  0xE0, 0x0F, 0xF0, 0x0E, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFE, 0xF0, 0x00,
  0x1F, 0xDE, 0x00, 0x03, 0xF9, 0xE0, 0x00, 0x7F, 0x1C, 0x00, 0x0F, 0xE3,
  0xC0, 0x01, 0xFC, 0x38, 0x00, 0x3F, 0x87, 0x80, 0x07, 0xF0, 0x78, 0x00,
  0xFE, 0x0F, 0x00, 0x1F, 0xC0, 0xF0, 0x03, 0xF8, 0x1E, 0x00, 0x7F, 0x01,
  0xE0, 0x0F, 0xE0, 0x3C, 0x01, 0xFC, 0x03, 0xC0, 0x3F, 0x80, 0x38, 0x07,
  0xF0, 0x07, 0x80, 0xFE, 0x00, 0x70, 0x1F, 0xC0, 0x0F, 0x03, 0xF8, 0x00,
  0xF0, 0x7F, 0x00, 0x1E, 0x0F, 0xE0, 0x01, 0xE1, 0xFC, 0x00, 0x3C, 0x3F,
  0x80, 0x03, 0xC7, 0xF0, 0x00, 0x78, 0xFE, 0x00, 0x07, 0x9F, 0xC0, 0x00,
  0x73, 0xF8, 0x00, 0x0F, 0x7F, 0x00, 0x00, 0xEF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7E,
  0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0x78, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x0F,
  0x80, 0x3F, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x70, 0x00, 0x3F, 0x0E, 0x00, 0x01, 0xF1,
  0xC0, 0x00, 0x1F, 0x38, 0x00, 0x01, 0xF7, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x70,
  0x00, 0x03, 0xEE, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x3E, 0x38, 0x00, 0x3F,
  0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x78, 0x03,
  0xE0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0xF0, 0x07,
  0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x80, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xF0, 0x01, 0xE0,
  0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3C, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x07, 0x8F, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x1F, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xE0, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x03, 0x80, 0x00, 0xE0, 0x07,
  0x80, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0xF0, 0x01, 0xE0, 0x03, 0xB8, 0x00, 0xF0, 0x01,
  0xDC, 0x00, 0x78, 0x00, 0xEF, 0x00, 0x3E, 0x00, 0x77, 0x80, 0x1F, 0x00,
  0x3B, 0xC0, 0x1F, 0x80, 0x3C, 0xE0, 0x0F, 0xC0, 0x1E, 0x70, 0x07, 0xE0,
  0x0E, 0x38, 0x03, 0xB8, 0x07, 0x1C, 0x01, 0xDC, 0x03, 0x8F, 0x01, 0xCE,
  0x01, 0xC7, 0x80, 0xE7, 0x00, 0xE3, 0xC0, 0x73, 0x80, 0xF0, 0xE0, 0x39,
  0xC0, 0x78, 0x70, 0x1C, 0x70, 0x38, 0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x0E,
  0x1C, 0x0E, 0x0F, 0x07, 0x0E, 0x07, 0x07, 0x83, 0x87, 0x03, 0x83, 0xC1,
  0xC1, 0xC3, 0xC0, 0xE1, 0xE0, 0xE1, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x38,
  0x70, 0x38, 0x70, 0x1C, 0x38, 0x1C, 0x38, 0x0E, 0x1C, 0x0F, 0x1C, 0x07,
  0x8E, 0x03, 0x8E, 0x03, 0xCE, 0x01, 0xC7, 0x00, 0xE7, 0x00, 0xE7, 0x80,
  0x73, 0x80, 0x73, 0xC0, 0x39, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0xE0,
  0x0E, 0xF0, 0x07, 0x70, 0x07, 0xF0, 0x03, 0xB8, 0x03, 0xF8, 0x01, 0xDC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80,
  0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0xC0,
  0x00, 0xF3, 0x80, 0x01, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0E, 0x0E, 0x00,
  0x3C, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07,
  0x00, 0x70, 0x1E, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xE1, 0xE0,
  0x01, 0xC3, 0x80, 0x03, 0x8F, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x78, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xE0,
  0x00, 0xF8, 0x78, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xF8, 0x00, 0x38, 0xF8, 0x00,
  0x07, 0x3E, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xE7, 0xC0, 0x03, 0xDC, 0x7C,
  0x01, 0xF3, 0xC7, 0xFF, 0xFC, 0x78, 0x7F, 0xFF, 0x0F, 0x03, 0xFF, 0x81,
  0xE0, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x07, 0xFC, 0x03, 0xC7, 0xFF, 0xC0, 0xF3, 0xFF, 0xF8, 0x3D,
  0xE0, 0x3F, 0x0F, 0xE0, 0x03, 0xE3, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x0F,
  0x3E, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x3F, 0x00, 0x03, 0xCF, 0xE0, 0x01, 0xE3,
  0xFE, 0x01, 0xF8, 0xF7, 0xFF, 0xFC, 0x38, 0xFF, 0xFC, 0x0E, 0x0F, 0xFE,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x78, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x0F, 0xF8, 0x1C,
  0x0F, 0xFF, 0x87, 0x07, 0xFF, 0xF9, 0xC3, 0xF0, 0x1F, 0x71, 0xF0, 0x01,
  0xDC, 0xF8, 0x00, 0x3F, 0x3C, 0x00, 0x07, 0xDE, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x3D, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x07,
  0xCF, 0x80, 0x01, 0xF1, 0xF0, 0x01, 0xFC, 0x3E, 0x00, 0xF7, 0x07, 0xFF,
  0xF9, 0xC0, 0xFF, 0xFC, 0x70, 0x0F, 0xFC, 0x1C, 0x00, 0x30, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7C, 0x03,
  0xF0, 0x0F, 0x80, 0x0F, 0x81, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x81, 0xE0, 0x00,
  0x1E, 0x1F, 0x80, 0x03, 0xC0, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x81, 0xC0, 0xFF, 0xF8, 0x70, 0x7F, 0xFF, 0x9C, 0x3F,
  0x01, 0xF7, 0x1F, 0x00, 0x1D, 0xC7, 0x80, 0x03, 0xF3, 0xC0, 0x00, 0x7D,
  0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0xC3,
  0xE0, 0x0F, 0x70, 0x7F, 0xFF, 0x9C, 0x0F, 0xFF, 0xC7, 0x00, 0xFF, 0xC1,
  0xC0, 0x03, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE1, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x3E, 0x3C,
  0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x81, 0xFC, 0x0F, 0xC0, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xFF, 0x03, 0xC3, 0xFF, 0xE0, 0xF1,
  0xFF, 0xFE, 0x3C, 0xF0, 0x0F, 0x8F, 0x70, 0x01, 0xF3, 0xF8, 0x00, 0x3E,
  0xFC, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3C, 0x00, 0x08, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x1F, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFC,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xE7, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x3E, 0x1C, 0x00,
  0x0F, 0x83, 0x80, 0x03, 0xE0, 0x70, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x07, 0xC0, 0x07, 0x01, 0xF0, 0x00, 0xE0, 0x7C,
  0x00, 0x1C, 0x1F, 0x00, 0x03, 0x87, 0xC0, 0x00, 0x71, 0xF0, 0x00, 0x0E,
  0x7E, 0x00, 0x01, 0xDF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF3, 0xC0,
  0x00, 0xFC, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0x80, 0x7C, 0x00, 0x70,
  0x07, 0xC0, 0x0E, 0x00, 0x7C, 0x01, 0xC0, 0x07, 0x80, 0x38, 0x00, 0x78,
  0x07, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xF8, 0x1C, 0x00, 0x0F, 0x83, 0x80,
  0x00, 0xF8, 0x70, 0x00, 0x0F, 0x8E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F,
  0x38, 0x00, 0x01, 0xF8, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xE3, 0xFC, 0x0F, 0xF0, 0xE7, 0xFE, 0x1F, 0xF8, 0xEF, 0xFF, 0x3F,
  0xFC, 0xFC, 0x0F, 0xF0, 0x3E, 0xF8, 0x07, 0xE0, 0x1E, 0xF0, 0x07, 0xC0,
  0x0E, 0xF0, 0x03, 0xC0, 0x0E, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80,
  0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80,
  0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80,
  0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80,
  0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80,
  0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80,
  0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80,
  0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80,
  0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80,
  0x0F, 0xE0, 0x3F, 0xE0, 0x38, 0x3F, 0xFE, 0x0E, 0x1F, 0xFF, 0xE3, 0x8F,
  0x00, 0xF8, 0xE7, 0x00, 0x1F, 0x3B, 0x80, 0x03, 0xEF, 0xC0, 0x00, 0x7B,
  0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xE0, 0xF8,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x7F, 0xC0, 0x38, 0x7F, 0xFC, 0x0E,
  0x7F, 0xFF, 0x83, 0xBE, 0x03, 0xF0, 0xEE, 0x00, 0x3E, 0x3F, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0E, 0xF0,
  0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x7C,
  0xFC, 0x00, 0x3E, 0x3F, 0xC0, 0x1F, 0x0F, 0x7F, 0xFF, 0xC3, 0xCF, 0xFF,
  0xC0, 0xF0, 0xFF, 0xE0, 0x3C, 0x01, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC1, 0xC0, 0xFF, 0xF8, 0x70, 0x7F, 0xFF, 0x9C, 0x3F, 0x01, 0xF7,
  0x1F, 0x00, 0x1F, 0xCF, 0x80, 0x03, 0xF3, 0xC0, 0x00, 0x7D, 0xF0, 0x00,
  0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x0F,
  0x70, 0x7F, 0xFF, 0x9C, 0x0F, 0xFF, 0xC7, 0x00, 0xFF, 0xC1, 0xC0, 0x03,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xEE, 0x1F,
  0xFF, 0xBC, 0xFE, 0x06, 0xF7, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x7E, 0x00,
  0xFC, 0x3E, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3D, 0xE0,
  0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0x8F, 0xC0,
  0x07, 0xC1, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xB8, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xEF, 0x00, 0x03, 0xF3,
  0xC0, 0x03, 0xB9, 0xF0, 0x07, 0xDC, 0x7F, 0xFF, 0xCE, 0x1F, 0xFF, 0x87,
  0x03, 0xFF, 0x83, 0x80, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x78, 0x0E, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x1C, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xE0, 0x0F,
  0x00, 0x01, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xFC, 0x00, 0x70, 0x00, 0xEF,
  0x00, 0x1E, 0x00, 0x39, 0xC0, 0x07, 0x80, 0x0E, 0x70, 0x03, 0xE0, 0x03,
  0x9C, 0x00, 0xF8, 0x01, 0xE7, 0x80, 0x3F, 0x00, 0x71, 0xE0, 0x0D, 0xC0,
  0x1C, 0x38, 0x07, 0x70, 0x07, 0x0E, 0x01, 0xCC, 0x01, 0xC3, 0x80, 0x73,
  0x80, 0xE0, 0xF0, 0x1C, 0xE0, 0x38, 0x1C, 0x0E, 0x38, 0x0E, 0x07, 0x03,
  0x8E, 0x03, 0x81, 0xC0, 0xE1, 0xC1, 0xE0, 0x70, 0x38, 0x70, 0x70, 0x1E,
  0x1C, 0x1C, 0x1C, 0x03, 0x87, 0x07, 0x07, 0x00, 0xE1, 0xC0, 0xE1, 0xC0,
  0x38, 0x70, 0x38, 0xE0, 0x0E, 0x38, 0x0E, 0x38, 0x01, 0xCE, 0x01, 0x8E,
  0x00, 0x73, 0x80, 0x73, 0x80, 0x1C, 0xE0, 0x1C, 0xE0, 0x07, 0x30, 0x07,
  0x30, 0x01, 0xDC, 0x00, 0xDC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E,
  0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xC7, 0xFF, 0x80, 0x00, 0xE7, 0xEF, 0xF0, 0x00, 0x77,
  0x80, 0xFC, 0x00, 0x3B, 0x80, 0x1F, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x3D,
  0xC0, 0x01, 0xF8, 0x3E, 0xE0, 0x00, 0x7F, 0xFE, 0x70, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00,
};

const GFXglyph RobotoMono_Light62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 5, 44, 37, 16, -44 },
  { 29, 13, 14, 37, 12, -47 },
  { 52, 34, 44, 37, 2, -44 },
  { 239, 28, 57, 37, 5, -51 },
  { 439, 35, 46, 37, 1, -45 },
  { 641, 32, 46, 37, 4, -45 },
  { 825, 3, 14, 37, 16, -47 },
  { 831, 14, 63, 37, 12, -49 },
  { 942, 15, 63, 37, 10, -49 },
  { 1061, 27, 27, 37, 6, -44 },
  { 1153, 30, 33, 37, 4, -37 },
  { 1277, 6, 15, 37, 12, -6 },
  { 1289, 23, 3, 37, 7, -21 },
  { 1298, 7, 6, 37, 16, -6 },
  { 1304, 22, 48, 37, 8, -44 },
  { 1436, 28, 46, 37, 5, -45 },
  { 1597, 16, 44, 37, 7, -44 },
  { 1685, 29, 45, 37, 3, -45 },
  { 1849, 28, 46, 37, 3, -45 },
  { 2010, 31, 44, 37, 3, -44 },
  { 2181, 27, 45, 37, 6, -44 },
  { 2333, 27, 45, 37, 5, -44 },
  { 2485, 29, 44, 37, 4, -44 },
  { 2645, 28, 46, 37, 5, -45 },
  { 2806, 27, 45, 37, 5, -45 },
  { 2958, 6, 33, 37, 18, -33 },
  { 2983, 8, 42, 37, 16, -33 },
  { 3025, 26, 26, 37, 5, -33 },
  { 3110, 27, 16, 37, 5, -28 },
  { 3164, 26, 26, 37, 6, -33 },
  { 3249, 24, 45, 37, 7, -45 },
  { 3384, 33, 44, 37, 2, -44 },
  { 3566, 32, 44, 37, 3, -44 },
  { 3742, 28, 44, 37, 6, -44 },
  { 3896, 29, 46, 37, 4, -45 },
  { 4063, 29, 44, 37, 5, -44 },
  { 4223, 26, 44, 37, 6, -44 },
  { 4366, 26, 44, 37, 6, -44 },
  { 4509, 29, 46, 37, 4, -45 },
  { 4676, 27, 44, 37, 5, -44 },
  { 4825, 25, 44, 37, 6, -44 },
  { 4963, 28, 45, 37, 3, -44 },
  { 5121, 30, 44, 37, 6, -44 },
  { 5286, 26, 44, 37, 7, -44 },
  { 5429, 28, 44, 37, 5, -44 },
  { 5583, 27, 44, 37, 5, -44 },
  { 5732, 29, 46, 37, 4, -45 },
  { 5899, 27, 44, 37, 7, -44 },
  { 6048, 31, 53, 37, 3, -45 },
  { 6254, 28, 44, 37, 6, -44 },
  { 6408, 30, 46, 37, 4, -45 },
  { 6581, 32, 44, 37, 3, -44 },
  { 6757, 27, 45, 37, 5, -44 },
  { 6909, 31, 44, 37, 3, -44 },
  { 7080, 33, 44, 37, 3, -44 },
  { 7262, 32, 44, 37, 3, -44 },
  { 7438, 32, 44, 37, 2, -44 },
  { 7614, 28, 44, 37, 4, -44 },
  { 7768, 10, 59, 37, 14, -50 },
  { 7842, 22, 48, 37, 8, -44 },
  { 7974, 11, 59, 37, 13, -50 },
  { 8056, 23, 24, 37, 7, -44 },
  { 8125, 27, 3, 37, 5, 0 },
  { 8136, 9, 8, 37, 14, -45 },
  { 8145, 27, 34, 37, 5, -33 },
  { 8260, 26, 48, 37, 6, -47 },
  { 8416, 27, 34, 37, 5, -33 },
  { 8531, 26, 48, 37, 5, -47 },
  { 8687, 28, 34, 37, 5, -33 },
  { 8806, 29, 47, 37, 5, -47 },
  { 8977, 26, 46, 37, 5, -33 },
  { 9127, 26, 47, 37, 6, -47 },
  { 9280, 26, 45, 37, 7, -45 },
  { 9427, 19, 58, 37, 6, -45 },
  { 9565, 27, 47, 37, 7, -47 },
  { 9724, 26, 47, 37, 7, -47 },
  { 9877, 32, 33, 37, 3, -33 },
  { 10009, 26, 33, 37, 6, -33 },
  { 10117, 29, 34, 37, 4, -33 },
  { 10241, 26, 46, 37, 6, -33 },
  { 10391, 26, 46, 37, 5, -33 },
  { 10541, 22, 33, 37, 11, -33 },
  { 10632, 26, 34, 37, 6, -33 },
  { 10743, 26, 42, 37, 5, -41 },
  { 10880, 25, 34, 37, 6, -33 },
  { 10987, 31, 33, 37, 3, -33 },
  { 11115, 34, 33, 37, 2, -33 },
  { 11256, 30, 33, 37, 4, -33 },
  { 11380, 33, 46, 37, 2, -33 },
  { 11570, 28, 33, 37, 5, -33 },
  { 11686, 20, 60, 37, 10, -48 },
  { 11836, 3, 54, 37, 17, -44 },
  { 11857, 20, 60, 37, 10, -48 },
  { 12007, 33, 11, 37, 2, -24 },
};

const GFXfont RobotoMono_Light62pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light62pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light62pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _ROBOTOMONO_LIGHT62PT7B_H_
