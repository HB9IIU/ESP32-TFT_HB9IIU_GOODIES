#ifndef _ROBOTOMONO_LIGHT23PT7B_H_
#define _ROBOTOMONO_LIGHT23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light23pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xA8, 0x0B, 0x99, 0x99, 0x90, 0x04, 0x60, 0xC4, 0x08,
  0x40, 0x84, 0x7F, 0xF0, 0x88, 0x18, 0x81, 0x08, 0x10, 0x81, 0x08, 0xFF,
  0xE1, 0x10, 0x21, 0x02, 0x10, 0x21, 0x02, 0x30, 0x04, 0x01, 0x00, 0xC0,
  0xFC, 0x60, 0x90, 0x34, 0x05, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x38, 0x07, 0x01, 0xC0, 0xD8, 0x63, 0xF0, 0x10, 0x04, 0x00, 0x10,
  0x03, 0x60, 0x11, 0x10, 0x88, 0xCC, 0x44, 0x22, 0x41, 0x32, 0x07, 0x20,
  0x01, 0x00, 0x10, 0x01, 0x9C, 0x09, 0x10, 0x88, 0x84, 0x44, 0x42, 0x20,
  0x11, 0x00, 0x70, 0x08, 0x07, 0xC1, 0x8C, 0x20, 0x84, 0x30, 0xC4, 0x09,
  0x01, 0xC0, 0x38, 0x0D, 0x03, 0x11, 0xC3, 0x38, 0x35, 0x03, 0xA0, 0x26,
  0x1E, 0x7E, 0x60, 0xF8, 0x0C, 0x61, 0x08, 0x21, 0x84, 0x10, 0x43, 0x0C,
  0x30, 0xC3, 0x04, 0x10, 0x41, 0x82, 0x08, 0x10, 0x60, 0xC0, 0x82, 0x08,
  0x41, 0x08, 0x61, 0x08, 0x42, 0x10, 0x84, 0x21, 0x18, 0x84, 0x42, 0x22,
  0x00, 0x04, 0x01, 0x00, 0x43, 0x93, 0x3F, 0x03, 0x01, 0xA0, 0x4C, 0x61,
  0x88, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF,
  0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x6D, 0xAC, 0xFF, 0xF0,
  0x01, 0x03, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x10, 0x10, 0x30,
  0x20, 0x20, 0x60, 0x40, 0xC0, 0x0C, 0x0F, 0xC6, 0x1B, 0x02, 0x80, 0xE0,
  0x38, 0x16, 0x09, 0x84, 0x66, 0x1B, 0x07, 0x81, 0xC0, 0x70, 0x34, 0x09,
  0x86, 0x3F, 0x00, 0x0C, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x0C, 0x07, 0xE1, 0x82, 0x60, 0x6C, 0x04, 0x00, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0xFF, 0xE0, 0x0C, 0x0F, 0xE6, 0x09, 0x03, 0xC0, 0x40, 0x10, 0x0C,
  0x06, 0x0F, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x70, 0x14, 0x05, 0x82, 0x3F,
  0x00, 0x01, 0x80, 0x38, 0x02, 0x80, 0x48, 0x0C, 0x80, 0x88, 0x10, 0x83,
  0x08, 0x20, 0x84, 0x08, 0xC0, 0x8F, 0xFF, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x3F, 0xC8, 0x06, 0x01, 0x80, 0x60, 0x10, 0x07, 0xF1, 0x86, 0x00,
  0xC0, 0x30, 0x04, 0x01, 0xC0, 0xD0, 0x37, 0x18, 0x7C, 0x0F, 0x0C, 0x06,
  0x01, 0x00, 0xC0, 0x23, 0x8B, 0x33, 0x06, 0x80, 0xA0, 0x38, 0x0E, 0x03,
  0x80, 0xF0, 0x26, 0x18, 0xF8, 0xFF, 0xE0, 0x0C, 0x01, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0x80, 0x0C, 0x0F, 0xC6, 0x09, 0x03, 0xC0, 0x70, 0x14, 0x0D,
  0x86, 0x1E, 0x1C, 0x64, 0x0F, 0x01, 0x80, 0x60, 0x1C, 0x05, 0x86, 0x3F,
  0x00, 0x0C, 0x0F, 0xC4, 0x1B, 0x02, 0x80, 0xE0, 0x38, 0x06, 0x01, 0xC0,
  0xD0, 0x57, 0xFC, 0x73, 0x00, 0x80, 0x60, 0x10, 0x18, 0x3C, 0x00, 0xF0,
  0x00, 0x0F, 0x6C, 0x00, 0x00, 0x01, 0x24, 0xA0, 0x00, 0x81, 0xC7, 0x0E,
  0x0C, 0x03, 0x00, 0x70, 0x0E, 0x01, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xC0, 0xE0, 0xE1,
  0xC0, 0xC0, 0x00, 0x0C, 0x0F, 0xC6, 0x19, 0x02, 0x80, 0xC0, 0x20, 0x08,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x20, 0x0C,
  0x00, 0x1F, 0xC3, 0x06, 0x60, 0x24, 0x71, 0x88, 0x99, 0x89, 0x90, 0x99,
  0x11, 0x91, 0x19, 0x11, 0x91, 0x19, 0xEA, 0x8C, 0xC4, 0x00, 0x60, 0x81,
  0xF8, 0x06, 0x00, 0x60, 0x07, 0x00, 0x90, 0x09, 0x00, 0x98, 0x18, 0x81,
  0x08, 0x10, 0xC3, 0x04, 0x3F, 0xC2, 0x06, 0x60, 0x64, 0x02, 0x40, 0x2C,
  0x03, 0xFF, 0x30, 0x6C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1B, 0xF8, 0xC1,
  0xB0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x1B, 0xFC, 0x06, 0x03, 0xF0,
  0xC1, 0x30, 0x34, 0x02, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x20, 0x04, 0x02, 0x80, 0x48, 0x19, 0x86, 0x1F, 0x80, 0xFE, 0x10, 0x32,
  0x02, 0x40, 0x68, 0x05, 0x00, 0xA0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0x40, 0x28, 0x0D, 0x03, 0x20, 0xC7, 0xE0, 0xFF, 0xF0, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0xFE, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0xFE, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x06,
  0x03, 0xF0, 0xC1, 0x30, 0x34, 0x02, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x7F, 0x00, 0xE0, 0x14, 0x02, 0x80, 0x48, 0x09, 0x83, 0x0F, 0x80, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0xFF, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xFF, 0xC3, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC3, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xE0, 0x2C, 0x04, 0x81, 0x98, 0x60,
  0xF8, 0xC0, 0xF8, 0x13, 0x04, 0x61, 0x8C, 0x61, 0x98, 0x36, 0x07, 0xC0,
  0xEC, 0x18, 0xC3, 0x08, 0x61, 0x8C, 0x19, 0x81, 0x30, 0x16, 0x03, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xC0, 0xF0, 0x3E, 0x1E, 0x85,
  0xA1, 0x6C, 0x99, 0x26, 0x59, 0x8C, 0x63, 0x18, 0xC6, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0xC0, 0x70, 0x1E, 0x06, 0x81, 0xB0, 0x64, 0x19, 0x86,
  0x21, 0x84, 0x61, 0x98, 0x26, 0x0D, 0x81, 0x60, 0x78, 0x0E, 0x03, 0x06,
  0x03, 0xF0, 0xC3, 0x30, 0x24, 0x02, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xA0, 0x14, 0x02, 0x80, 0xC8, 0x11, 0x86, 0x1F, 0x00, 0xFF,
  0x98, 0x1B, 0x01, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x16, 0x06, 0xFF, 0x98,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x06, 0x01, 0xF8,
  0x30, 0xC6, 0x06, 0x40, 0x2C, 0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0x40, 0x24, 0x02, 0x60, 0x43, 0x0C, 0x1F, 0x80, 0x0C,
  0x00, 0x70, 0x02, 0xFF, 0x18, 0x33, 0x03, 0x60, 0x2C, 0x05, 0x80, 0xB0,
  0x36, 0x0C, 0xFF, 0x18, 0x43, 0x0C, 0x60, 0x8C, 0x19, 0x81, 0x30, 0x36,
  0x03, 0x0C, 0x07, 0xF1, 0x03, 0x60, 0x28, 0x05, 0x80, 0x10, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0x00, 0x28, 0x07, 0x00, 0xB0, 0x13, 0x06, 0x3F,
  0x00, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xF0, 0x26, 0x18, 0xFC, 0xC0, 0x34, 0x02,
  0x40, 0x66, 0x04, 0x20, 0x42, 0x0C, 0x30, 0xC1, 0x08, 0x10, 0x81, 0x18,
  0x19, 0x00, 0x90, 0x0B, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x86, 0x18, 0x61,
  0xC6, 0x1C, 0x63, 0x47, 0x34, 0xD2, 0x49, 0x24, 0x92, 0x49, 0x26, 0x9A,
  0x78, 0xA3, 0x0E, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x04, 0xC0, 0x32, 0x06,
  0x30, 0x41, 0x08, 0x19, 0x80, 0x90, 0x07, 0x00, 0x60, 0x06, 0x00, 0xD0,
  0x09, 0x81, 0x08, 0x30, 0xC2, 0x04, 0x60, 0x6C, 0x03, 0xC0, 0x34, 0x06,
  0x60, 0x42, 0x0C, 0x30, 0x81, 0x18, 0x19, 0x00, 0xB0, 0x0E, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x7F, 0xE0, 0x08,
  0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60,
  0x08, 0x02, 0x00, 0xC0, 0x10, 0x07, 0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0xF0, 0x80, 0x40, 0x40, 0x60, 0x20,
  0x20, 0x10, 0x10, 0x18, 0x08, 0x08, 0x0C, 0x04, 0x04, 0x02, 0x02, 0x03,
  0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xF0,
  0x18, 0x18, 0x2C, 0x24, 0x64, 0x42, 0x42, 0x83, 0x81, 0xFF, 0xC0, 0xC6,
  0x30, 0x3F, 0x10, 0x6C, 0x08, 0x03, 0x00, 0xCF, 0xF6, 0x0F, 0x03, 0x80,
  0xE0, 0x3C, 0x3D, 0xFB, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0xCE,
  0x1B, 0x02, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0B, 0x86,
  0xDF, 0x00, 0x3F, 0x18, 0x6C, 0x0E, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00,
  0xC0, 0x50, 0x36, 0x18, 0xFC, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xCF,
  0xB6, 0x1F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x34, 0x0D,
  0x87, 0x3E, 0xC0, 0x3F, 0x18, 0x6C, 0x0E, 0x01, 0x80, 0x7F, 0xF8, 0x02,
  0x00, 0xC0, 0x10, 0x16, 0x0C, 0x7C, 0x01, 0xC0, 0xFC, 0x20, 0x04, 0x01,
  0x80, 0x30, 0x3F, 0xF0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x3E, 0xD8, 0x7C, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x36, 0x1C, 0xFB, 0x00, 0xC0,
  0x2C, 0x19, 0x8C, 0x1E, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37,
  0xCE, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xC0, 0x04, 0x03, 0x00, 0x40, 0x00, 0x00, 0x3F, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0xFF,
  0xC0, 0x02, 0x0C, 0x08, 0x00, 0x0F, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x30, 0xDF, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x7C, 0x33, 0x18, 0xCC, 0x36, 0x0F, 0x83, 0xB0,
  0xC6, 0x30, 0x8C, 0x13, 0x06, 0xC0, 0xC0, 0xFC, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0xFF, 0xC0, 0xBD, 0xEC, 0x63, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x9F,
  0x28, 0x6C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0x1F, 0x86, 0x19, 0x81, 0xA0, 0x14, 0x03, 0x80, 0x70, 0x0A,
  0x01, 0x40, 0x2C, 0x08, 0xC3, 0x0F, 0xC0, 0xBF, 0x38, 0x6C, 0x0B, 0x03,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x2E, 0x1B, 0x7C, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x00, 0x3E, 0xD8, 0x7C, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x36, 0x1C, 0xFB, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x9F, 0xA0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x3F, 0x18, 0x24, 0x0D, 0x00, 0x60, 0x0F, 0x00, 0x38,
  0x03, 0x00, 0x70, 0x16, 0x08, 0xFC, 0x18, 0x06, 0x01, 0x83, 0xFE, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00,
  0x7C, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xD0, 0x36, 0x1C, 0xFB, 0xC0, 0x34, 0x06, 0x60, 0x42, 0x04, 0x30, 0xC1,
  0x08, 0x11, 0x81, 0x90, 0x09, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x86, 0x18,
  0x61, 0x86, 0x34, 0x62, 0x49, 0x24, 0x92, 0x49, 0x26, 0x96, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x60, 0x63, 0x04, 0x10, 0x81, 0x98, 0x0F, 0x00,
  0x60, 0x06, 0x00, 0xD0, 0x19, 0x83, 0x0C, 0x20, 0x4C, 0x03, 0xC0, 0x34,
  0x02, 0x60, 0x62, 0x04, 0x20, 0xC3, 0x08, 0x10, 0x81, 0x90, 0x09, 0x00,
  0xF0, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x60, 0x00,
  0xFF, 0xC0, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x18,
  0x0C, 0x03, 0xFF, 0x06, 0x18, 0x60, 0x81, 0x02, 0x04, 0x08, 0x10, 0x61,
  0x86, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xC0, 0x80, 0xC0, 0x80,
  0xFF, 0xFF, 0xF0, 0x80, 0xC0, 0x81, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x30, 0x31, 0x82, 0x04, 0x08, 0x10, 0x20, 0x41, 0x82, 0x18, 0x20, 0x00,
  0x70, 0x0C, 0xC1, 0x86, 0x38, 0x1E,
};

const GFXglyph RobotoMono_Light23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 2, 16, 14, 6, -16 },
  { 5, 4, 5, 14, 5, -17 },
  { 8, 12, 16, 14, 1, -16 },
  { 32, 10, 21, 14, 2, -19 },
  { 59, 13, 17, 14, 0, -17 },
  { 87, 11, 17, 14, 2, -17 },
  { 111, 1, 5, 14, 6, -17 },
  { 112, 6, 23, 14, 4, -18 },
  { 130, 5, 23, 14, 4, -18 },
  { 145, 10, 10, 14, 2, -16 },
  { 158, 12, 12, 14, 1, -14 },
  { 176, 3, 5, 14, 4, -2 },
  { 178, 8, 1, 14, 3, -8 },
  { 179, 2, 2, 14, 6, -2 },
  { 180, 8, 17, 14, 3, -16 },
  { 197, 10, 17, 14, 2, -17 },
  { 219, 6, 16, 14, 2, -16 },
  { 231, 11, 17, 14, 1, -17 },
  { 255, 10, 17, 14, 1, -17 },
  { 277, 12, 16, 14, 1, -16 },
  { 301, 10, 16, 14, 2, -16 },
  { 321, 10, 16, 14, 2, -16 },
  { 341, 11, 16, 14, 1, -16 },
  { 363, 10, 17, 14, 2, -17 },
  { 385, 10, 17, 14, 2, -17 },
  { 407, 2, 12, 14, 7, -12 },
  { 410, 3, 15, 14, 6, -12 },
  { 416, 9, 9, 14, 2, -12 },
  { 427, 10, 6, 14, 2, -10 },
  { 435, 10, 9, 14, 2, -12 },
  { 447, 10, 17, 14, 2, -17 },
  { 469, 12, 16, 14, 1, -16 },
  { 493, 12, 16, 14, 1, -16 },
  { 517, 10, 16, 14, 2, -16 },
  { 537, 11, 17, 14, 1, -17 },
  { 561, 11, 16, 14, 2, -16 },
  { 583, 10, 16, 14, 2, -16 },
  { 603, 10, 16, 14, 2, -16 },
  { 623, 11, 17, 14, 1, -17 },
  { 647, 10, 16, 14, 2, -16 },
  { 667, 10, 16, 14, 2, -16 },
  { 687, 11, 16, 14, 1, -16 },
  { 709, 11, 16, 14, 2, -16 },
  { 731, 10, 16, 14, 2, -16 },
  { 751, 10, 16, 14, 2, -16 },
  { 771, 10, 16, 14, 2, -16 },
  { 791, 11, 17, 14, 1, -17 },
  { 815, 11, 16, 14, 2, -16 },
  { 837, 12, 20, 14, 1, -17 },
  { 867, 11, 16, 14, 2, -16 },
  { 889, 11, 17, 14, 2, -17 },
  { 913, 12, 16, 14, 1, -16 },
  { 937, 10, 16, 14, 2, -16 },
  { 957, 12, 16, 14, 1, -16 },
  { 981, 12, 16, 14, 1, -16 },
  { 1005, 12, 16, 14, 1, -16 },
  { 1029, 12, 16, 14, 1, -16 },
  { 1053, 11, 16, 14, 1, -16 },
  { 1075, 4, 23, 14, 5, -19 },
  { 1087, 8, 17, 14, 3, -16 },
  { 1104, 4, 23, 14, 5, -19 },
  { 1116, 8, 9, 14, 3, -16 },
  { 1125, 10, 1, 14, 2, 0 },
  { 1127, 4, 3, 14, 5, -17 },
  { 1129, 10, 12, 14, 2, -12 },
  { 1144, 10, 17, 14, 2, -17 },
  { 1166, 10, 12, 14, 2, -12 },
  { 1181, 10, 17, 14, 2, -17 },
  { 1203, 10, 12, 14, 2, -12 },
  { 1218, 11, 18, 14, 2, -18 },
  { 1243, 10, 17, 14, 2, -12 },
  { 1265, 10, 17, 14, 2, -17 },
  { 1287, 10, 17, 14, 2, -17 },
  { 1309, 7, 22, 14, 2, -17 },
  { 1329, 10, 17, 14, 2, -17 },
  { 1351, 10, 17, 14, 2, -17 },
  { 1373, 12, 12, 14, 1, -12 },
  { 1391, 10, 12, 14, 2, -12 },
  { 1406, 11, 12, 14, 1, -12 },
  { 1423, 10, 17, 14, 2, -12 },
  { 1445, 10, 17, 14, 2, -12 },
  { 1467, 8, 12, 14, 4, -12 },
  { 1479, 10, 12, 14, 2, -12 },
  { 1494, 10, 15, 14, 2, -15 },
  { 1513, 10, 12, 14, 2, -12 },
  { 1528, 12, 12, 14, 1, -12 },
  { 1546, 12, 12, 14, 1, -12 },
  { 1564, 12, 12, 14, 1, -12 },
  { 1582, 12, 17, 14, 1, -12 },
  { 1608, 10, 12, 14, 2, -12 },
  { 1623, 7, 23, 14, 4, -18 },
  { 1644, 1, 20, 14, 6, -16 },
  { 1647, 7, 23, 14, 4, -18 },
  { 1668, 12, 4, 14, 1, -9 },
};

const GFXfont RobotoMono_Light23pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light23pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOMONO_LIGHT23PT7B_H_
