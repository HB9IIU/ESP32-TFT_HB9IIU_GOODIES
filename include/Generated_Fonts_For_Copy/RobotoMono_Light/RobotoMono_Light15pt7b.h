#ifndef _ROBOTOMONO_LIGHT15PT7B_H_
#define _ROBOTOMONO_LIGHT15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0x80, 0x09, 0x09, 0x04, 0x8F, 0xF1, 0x20, 0x90,
  0x91, 0xFE, 0x24, 0x12, 0x09, 0x00, 0x10, 0x71, 0x12, 0x14, 0x08, 0x0E,
  0x02, 0x03, 0x05, 0x0B, 0xE1, 0x02, 0x00, 0x60, 0x48, 0x24, 0x92, 0x86,
  0x40, 0x40, 0x2C, 0x29, 0x24, 0x92, 0x41, 0xC0, 0x30, 0x48, 0x48, 0x48,
  0x30, 0x20, 0x52, 0x8A, 0x86, 0x84, 0x7B, 0xE0, 0x25, 0x49, 0x24, 0x92,
  0x44, 0x88, 0x91, 0x22, 0x49, 0x24, 0x94, 0xA0, 0x10, 0x22, 0x4B, 0xE1,
  0x84, 0x91, 0x00, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08, 0xE0, 0xF8,
  0x80, 0x08, 0x42, 0x21, 0x10, 0x84, 0x42, 0x21, 0x00, 0x38, 0x8A, 0x0C,
  0x38, 0xB2, 0x68, 0xE1, 0x82, 0x88, 0xE0, 0x2E, 0x92, 0x49, 0x24, 0x80,
  0x79, 0x0A, 0x10, 0x20, 0x41, 0x04, 0x10, 0x20, 0x83, 0xF8, 0x3B, 0x18,
  0x41, 0x04, 0xE0, 0x41, 0x86, 0x17, 0x80, 0x0C, 0x18, 0x51, 0x22, 0x48,
  0xA1, 0x7F, 0x04, 0x08, 0x10, 0xFE, 0x08, 0x20, 0xF2, 0x20, 0x41, 0x86,
  0x37, 0x80, 0x18, 0x41, 0x04, 0x0B, 0x98, 0xA0, 0xC1, 0x82, 0x88, 0xE0,
  0xFE, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x10, 0x41, 0x80, 0x38, 0x89,
  0x0A, 0x14, 0x47, 0x11, 0x41, 0x82, 0x85, 0xF0, 0x38, 0x8A, 0x14, 0x18,
  0x30, 0x53, 0x99, 0x04, 0x18, 0xC0, 0xC0, 0x0C, 0xC0, 0x0A, 0x80, 0x06,
  0x31, 0x86, 0x03, 0x01, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0xC0, 0x60, 0x30,
  0x33, 0x98, 0x00, 0x72, 0x28, 0x42, 0x08, 0x42, 0x08, 0x00, 0x02, 0x00,
  0x1E, 0x10, 0x92, 0x4A, 0x99, 0x4D, 0x26, 0x93, 0x4A, 0x5A, 0x20, 0x0F,
  0x80, 0x10, 0x20, 0xA1, 0x42, 0x88, 0x91, 0x3E, 0x83, 0x06, 0x08, 0xF9,
  0x0A, 0x0C, 0x18, 0x5F, 0x21, 0xC1, 0x83, 0x07, 0xF0, 0x38, 0x8A, 0x0C,
  0x18, 0x10, 0x20, 0x40, 0x82, 0x88, 0xF0, 0xF1, 0x1A, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x0B, 0xE0, 0xFF, 0x02, 0x04, 0x08, 0x1F, 0xA0, 0x40,
  0x81, 0x03, 0xF8, 0xFE, 0x08, 0x20, 0x83, 0xE8, 0x20, 0x82, 0x08, 0x00,
  0x38, 0x8A, 0x0C, 0x08, 0x10, 0x23, 0xC1, 0x82, 0x84, 0xF0, 0x83, 0x06,
  0x0C, 0x18, 0x3F, 0xE0, 0xC1, 0x83, 0x06, 0x08, 0xFE, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x23, 0xF8, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x85, 0x09, 0xE0, 0x82, 0x84, 0x8C, 0x88, 0x90, 0xB0, 0xD0, 0x88,
  0x84, 0x86, 0x83, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0,
  0x83, 0x8F, 0x1D, 0x5A, 0xB5, 0x64, 0xC9, 0x83, 0x06, 0x08, 0x83, 0x87,
  0x0D, 0x1A, 0x32, 0x64, 0xC5, 0x87, 0x0E, 0x08, 0x38, 0x8A, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x82, 0x88, 0xE0, 0xF2, 0x38, 0x61, 0x86, 0x3F, 0x20,
  0x82, 0x08, 0x00, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x88,
  0xE0, 0x20, 0x20, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0xBE, 0x44, 0x85, 0x06,
  0x08, 0x38, 0x8A, 0x0C, 0x04, 0x07, 0x01, 0x01, 0x83, 0x85, 0xF0, 0xFE,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x82, 0x88, 0xE0, 0x83, 0x06, 0x0A, 0x24, 0x48,
  0x8A, 0x14, 0x28, 0x60, 0x40, 0x91, 0x91, 0x92, 0x9A, 0xAA, 0xAA, 0xAA,
  0x6A, 0x44, 0x44, 0x44, 0x82, 0x85, 0x11, 0x42, 0x82, 0x06, 0x14, 0x44,
  0x86, 0x08, 0x83, 0x05, 0x12, 0x22, 0x85, 0x04, 0x08, 0x10, 0x20, 0x40,
  0xFE, 0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0x41, 0x03, 0xF8, 0xF2, 0x49,
  0x24, 0x92, 0x49, 0xC0, 0x84, 0x10, 0x84, 0x10, 0x82, 0x10, 0x82, 0x10,
  0xE4, 0x92, 0x49, 0x24, 0x93, 0xC0, 0x21, 0x14, 0xA8, 0xC4, 0xFE, 0xCC,
  0x3C, 0x8A, 0x09, 0xF4, 0x30, 0x61, 0xBD, 0x81, 0x02, 0x05, 0xEC, 0x50,
  0x60, 0xC1, 0x83, 0x8A, 0xF0, 0x3C, 0x8A, 0x0C, 0x08, 0x10, 0x10, 0x9E,
  0x02, 0x04, 0x09, 0xD4, 0x70, 0x60, 0xC1, 0x82, 0x8D, 0xE8, 0x3C, 0x8A,
  0x0F, 0xF8, 0x10, 0x10, 0x9E, 0x1E, 0x20, 0x87, 0xF2, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x80, 0x3A, 0x8E, 0x0C, 0x18, 0x30, 0x51, 0xBD, 0x02, 0x89,
  0xE0, 0x81, 0x02, 0x05, 0xEC, 0x50, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x30,
  0x80, 0x38, 0x20, 0x82, 0x08, 0x20, 0x8F, 0xC0, 0x08, 0x40, 0xF0, 0x84,
  0x21, 0x08, 0x42, 0x10, 0xF8, 0x82, 0x08, 0x23, 0x92, 0x8C, 0x28, 0x92,
  0x28, 0x40, 0xE0, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x8F, 0xC0, 0xFF,
  0x26, 0x4C, 0x99, 0x32, 0x64, 0xC9, 0xBD, 0x8A, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x51, 0x3E, 0xB9, 0x8A, 0x0C, 0x18,
  0x30, 0x71, 0x5E, 0x81, 0x02, 0x00, 0x3A, 0x8E, 0x0C, 0x18, 0x30, 0x51,
  0xBD, 0x02, 0x04, 0x08, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x3C, 0x85, 0x03,
  0x80, 0xC0, 0x70, 0xBE, 0x20, 0x43, 0xF1, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x3C, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x51, 0xBD, 0x83, 0x05, 0x12, 0x22,
  0x85, 0x0A, 0x08, 0x88, 0xA4, 0x95, 0x4A, 0xA5, 0x51, 0xA8, 0x88, 0x44,
  0x82, 0x88, 0xA0, 0x81, 0x05, 0x11, 0x41, 0x83, 0x05, 0x12, 0x22, 0x85,
  0x0A, 0x08, 0x10, 0x43, 0x80, 0xFE, 0x08, 0x20, 0x83, 0x04, 0x10, 0x7F,
  0x08, 0x84, 0x42, 0x10, 0x98, 0x21, 0x08, 0x41, 0x08, 0x20, 0xFF, 0xF8,
  0xC1, 0x08, 0x42, 0x10, 0x41, 0x11, 0x08, 0x42, 0x13, 0x00, 0x30, 0xA4,
  0xA1, 0xC0,
};

const GFXglyph RobotoMono_Light15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 1, 11, 9, 4, -11 },
  { 3, 3, 3, 9, 3, -11 },
  { 5, 9, 11, 9, 0, -11 },
  { 18, 7, 14, 9, 1, -12 },
  { 31, 9, 11, 9, 0, -11 },
  { 44, 8, 11, 9, 1, -11 },
  { 55, 1, 3, 9, 4, -11 },
  { 56, 3, 15, 9, 3, -12 },
  { 62, 3, 15, 9, 3, -12 },
  { 68, 7, 7, 9, 1, -11 },
  { 75, 7, 8, 9, 1, -9 },
  { 82, 1, 3, 9, 3, -1 },
  { 83, 5, 1, 9, 2, -5 },
  { 84, 1, 1, 9, 4, -1 },
  { 85, 5, 12, 9, 2, -11 },
  { 93, 7, 11, 9, 1, -11 },
  { 103, 3, 11, 9, 2, -11 },
  { 108, 7, 11, 9, 1, -11 },
  { 118, 6, 11, 9, 1, -11 },
  { 127, 7, 11, 9, 1, -11 },
  { 137, 6, 11, 9, 2, -11 },
  { 146, 7, 11, 9, 1, -11 },
  { 156, 7, 11, 9, 1, -11 },
  { 166, 7, 11, 9, 1, -11 },
  { 176, 7, 11, 9, 1, -11 },
  { 186, 2, 7, 9, 4, -7 },
  { 188, 2, 9, 9, 4, -7 },
  { 191, 7, 6, 9, 1, -8 },
  { 197, 7, 4, 9, 1, -7 },
  { 201, 7, 6, 9, 1, -8 },
  { 207, 6, 11, 9, 2, -11 },
  { 216, 9, 11, 9, 0, -11 },
  { 229, 7, 11, 9, 1, -11 },
  { 239, 7, 11, 9, 1, -11 },
  { 249, 7, 11, 9, 1, -11 },
  { 259, 7, 11, 9, 1, -11 },
  { 269, 7, 11, 9, 1, -11 },
  { 279, 6, 11, 9, 2, -11 },
  { 288, 7, 11, 9, 1, -11 },
  { 298, 7, 11, 9, 1, -11 },
  { 308, 7, 11, 9, 1, -11 },
  { 318, 7, 11, 9, 1, -11 },
  { 328, 8, 11, 9, 1, -11 },
  { 339, 6, 11, 9, 2, -11 },
  { 348, 7, 11, 9, 1, -11 },
  { 358, 7, 11, 9, 1, -11 },
  { 368, 7, 11, 9, 1, -11 },
  { 378, 6, 11, 9, 2, -11 },
  { 387, 7, 13, 9, 1, -11 },
  { 399, 7, 11, 9, 1, -11 },
  { 409, 7, 11, 9, 1, -11 },
  { 419, 7, 11, 9, 1, -11 },
  { 429, 7, 11, 9, 1, -11 },
  { 439, 7, 11, 9, 1, -11 },
  { 449, 8, 11, 9, 1, -11 },
  { 460, 7, 11, 9, 1, -11 },
  { 470, 7, 11, 9, 1, -11 },
  { 480, 7, 11, 9, 1, -11 },
  { 490, 3, 14, 9, 3, -12 },
  { 496, 5, 12, 9, 2, -11 },
  { 504, 3, 14, 9, 3, -12 },
  { 510, 5, 6, 9, 2, -11 },
  { 514, 7, 1, 9, 1, 0 },
  { 515, 3, 2, 9, 3, -11 },
  { 516, 7, 8, 9, 1, -8 },
  { 523, 7, 11, 9, 1, -11 },
  { 533, 7, 8, 9, 1, -8 },
  { 540, 7, 11, 9, 1, -11 },
  { 550, 7, 8, 9, 1, -8 },
  { 557, 7, 11, 9, 1, -11 },
  { 567, 7, 11, 9, 1, -8 },
  { 577, 7, 11, 9, 1, -11 },
  { 587, 6, 11, 9, 2, -11 },
  { 596, 5, 14, 9, 1, -11 },
  { 605, 6, 11, 9, 2, -11 },
  { 614, 6, 11, 9, 2, -11 },
  { 623, 7, 8, 9, 1, -8 },
  { 630, 7, 8, 9, 1, -8 },
  { 637, 7, 8, 9, 1, -8 },
  { 644, 7, 11, 9, 1, -8 },
  { 654, 7, 11, 9, 1, -8 },
  { 664, 5, 8, 9, 3, -8 },
  { 669, 7, 8, 9, 1, -8 },
  { 676, 7, 10, 9, 1, -10 },
  { 685, 7, 8, 9, 1, -8 },
  { 692, 7, 8, 9, 1, -8 },
  { 699, 9, 8, 9, 0, -8 },
  { 708, 7, 8, 9, 1, -8 },
  { 715, 7, 11, 9, 1, -8 },
  { 725, 7, 8, 9, 1, -8 },
  { 732, 5, 15, 9, 2, -12 },
  { 742, 1, 13, 9, 4, -11 },
  { 744, 5, 15, 9, 2, -12 },
  { 754, 9, 3, 9, 0, -6 },
};

const GFXfont RobotoMono_Light15pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light15pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOMONO_LIGHT15PT7B_H_
