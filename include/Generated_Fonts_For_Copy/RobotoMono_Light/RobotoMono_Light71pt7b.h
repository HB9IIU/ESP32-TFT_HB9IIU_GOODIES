#ifndef _ROBOTOMONO_LIGHT71PT7B_H_
#define _ROBOTOMONO_LIGHT71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light71pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF,
  0xFF, 0xFD, 0xE0, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x07, 0x00, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x07, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0xFC, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF9,
  0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x3F, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x02, 0x00, 0x70, 0x03, 0xC0, 0x07,
  0x00, 0xE0, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x70,
  0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x1E, 0x07,
  0x80, 0x01, 0xE0, 0x7C, 0x0E, 0x00, 0x01, 0xFB, 0xF0, 0x3C, 0x00, 0x01,
  0xFF, 0xC0, 0xF0, 0x00, 0x01, 0xFF, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x03, 0xF8,
  0x00, 0x00, 0x78, 0x1F, 0xF8, 0x00, 0x01, 0xE0, 0x7F, 0xF8, 0x00, 0x03,
  0x81, 0xF0, 0x78, 0x00, 0x0F, 0x03, 0x80, 0x78, 0x00, 0x1C, 0x0F, 0x00,
  0x70, 0x00, 0x78, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x03,
  0xC0, 0xF0, 0x03, 0xC0, 0x07, 0x01, 0xE0, 0x03, 0x80, 0x1E, 0x03, 0xC0,
  0x07, 0x00, 0x38, 0x07, 0x80, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x1C, 0x03,
  0xC0, 0x1E, 0x00, 0x38, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x06, 0x00, 0x38,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x00, 0x1E, 0x3F, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xC1, 0xF0,
  0x3E, 0x00, 0x1C, 0x3E, 0x01, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x80, 0x3C,
  0x7C, 0x00, 0xF8, 0x03, 0xC7, 0x80, 0x07, 0xC0, 0x3C, 0xF8, 0x00, 0x3E,
  0x03, 0xCF, 0x00, 0x01, 0xF0, 0x7C, 0xF0, 0x00, 0x0F, 0x87, 0x8F, 0x00,
  0x00, 0xF8, 0x78, 0xF0, 0x00, 0x07, 0xCF, 0x8F, 0x00, 0x00, 0x3E, 0xF0,
  0xF0, 0x00, 0x01, 0xFF, 0x0F, 0x00, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x00,
  0xFC, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xFE, 0x03, 0xE0,
  0x00, 0x3F, 0xF0, 0x3F, 0x00, 0x07, 0xFF, 0x81, 0xFC, 0x03, 0xFC, 0xF8,
  0x0F, 0xFF, 0xFF, 0x07, 0xC0, 0x3F, 0xFF, 0xE0, 0x3E, 0x00, 0xFF, 0xF8,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE,
  0xEE, 0xE0, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x7C, 0x01, 0xC0, 0x3E, 0x7F, 0x81,
  0xC0, 0xFF, 0xFF, 0xF1, 0xC7, 0xFF, 0x1F, 0xFD, 0xDF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF8,
  0x0F, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0x80, 0x01, 0xE0, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0xF8,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x10,
  0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0x7F, 0x80, 0x00, 0x7C,
  0xFF, 0x00, 0x01, 0xF1, 0xFE, 0x00, 0x07, 0xC3, 0xFC, 0x00, 0x1F, 0x07,
  0xF8, 0x00, 0x7C, 0x0F, 0xF0, 0x01, 0xE0, 0x1F, 0xE0, 0x07, 0x80, 0x3F,
  0xC0, 0x3E, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0xFF, 0x03, 0xE0, 0x01, 0xFE,
  0x0F, 0x80, 0x03, 0xFC, 0x3E, 0x00, 0x07, 0xF8, 0xF8, 0x00, 0x0F, 0xF3,
  0xE0, 0x00, 0x1F, 0xEF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xF8, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07, 0xC1, 0xE0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xF0, 0x03, 0xFC,
  0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xFC, 0xFF, 0xFC, 0x3F, 0xF8, 0x0F, 0xF8,
  0x03, 0xF8, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x01,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x1F, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0xFF, 0xE0, 0x00, 0xE7, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F,
  0x00, 0x07, 0xF8, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x1F, 0x3C, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7F,
  0x01, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x1F,
  0xE0, 0x03, 0xC1, 0xFF, 0xF8, 0x07, 0x8F, 0xFF, 0xF8, 0x0F, 0x3F, 0xEF,
  0xFC, 0x1E, 0xF8, 0x01, 0xF8, 0x7B, 0xC0, 0x00, 0xF8, 0xFF, 0x00, 0x00,
  0xF9, 0xFC, 0x00, 0x00, 0xF3, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x7C,
  0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1E,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x7C,
  0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1E, 0x7C,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x01, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFE, 0x7F, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0xF8,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x3C,
  0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7F, 0x1F,
  0x00, 0x00, 0xEF, 0x0F, 0x80, 0x01, 0xFE, 0x0F, 0xC0, 0x07, 0xDE, 0x07,
  0xF8, 0x3F, 0x9E, 0x03, 0xFF, 0xFF, 0x1E, 0x00, 0xFF, 0xFC, 0x1E, 0x00,
  0x3F, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x10,
  0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x3E, 0xFF, 0xFF, 0xFF, 0xE7, 0xC0, 0x02, 0x03, 0xE1, 0xF8,
  0x7F, 0x1F, 0xC7, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x0F,
  0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x00, 0xFC,
  0x7C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x78, 0x01, 0xFC, 0x01,
  0xC0, 0xE0, 0x0F, 0xFE, 0x03, 0x83, 0x80, 0x3F, 0xFE, 0x07, 0x07, 0x00,
  0xF8, 0x3C, 0x07, 0x1C, 0x03, 0xC0, 0x38, 0x0E, 0x38, 0x07, 0x00, 0x70,
  0x1C, 0x70, 0x1E, 0x00, 0xE0, 0x39, 0xC0, 0x38, 0x01, 0xC0, 0x73, 0x80,
  0xF0, 0x03, 0x00, 0xE7, 0x01, 0xC0, 0x06, 0x00, 0xCE, 0x03, 0x80, 0x1C,
  0x01, 0x9C, 0x07, 0x00, 0x38, 0x03, 0x70, 0x1E, 0x00, 0x70, 0x06, 0xE0,
  0x38, 0x00, 0xE0, 0x0D, 0xC0, 0x70, 0x01, 0xC0, 0x3B, 0x80, 0xE0, 0x03,
  0x80, 0x77, 0x01, 0xC0, 0x07, 0x00, 0xEE, 0x03, 0x80, 0x0E, 0x01, 0xDC,
  0x07, 0x00, 0x18, 0x03, 0xB8, 0x0E, 0x00, 0x70, 0x07, 0x70, 0x1C, 0x00,
  0xE0, 0x0C, 0xE0, 0x38, 0x03, 0xC0, 0x39, 0xC0, 0x70, 0x07, 0x80, 0x73,
  0xC0, 0xF0, 0x1F, 0x00, 0xC3, 0x80, 0xE0, 0x37, 0x03, 0x87, 0x01, 0xE1,
  0xEE, 0x0E, 0x0E, 0x03, 0xFF, 0x9E, 0x3C, 0x1E, 0x03, 0xFE, 0x1F, 0xF0,
  0x1C, 0x03, 0xF8, 0x1F, 0xC0, 0x3C, 0x00, 0x80, 0x0C, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x06, 0x00, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x1E,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x00, 0x3E, 0x78, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x03, 0xFE, 0x0F,
  0x00, 0x00, 0xFE, 0x1E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x7C, 0x78,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x0F, 0xBC, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0xC7, 0x80, 0x00,
  0x1F, 0x0F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x83, 0xC0, 0x00, 0x3F, 0x87, 0x80, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0x0F,
  0x9E, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFB, 0xC0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07, 0xCF, 0x00,
  0x00, 0x3F, 0x1E, 0x00, 0x01, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x1E,
  0x3E, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x1F, 0xE0, 0x0F, 0x00, 0x01, 0xFC, 0x07,
  0x80, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x7C,
  0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xFC, 0x07, 0x80, 0x01, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x8F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F,
  0x3E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xF0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xBC,
  0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x7E,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x07,
  0xC0, 0x0F, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x03, 0xC0,
  0x0F, 0x80, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x7E, 0x00, 0x00,
  0x3C, 0x3F, 0x00, 0x00, 0x0F, 0x0F, 0xC0, 0x00, 0x03, 0xC7, 0xF8, 0x00,
  0x00, 0xF3, 0xFE, 0x00, 0x00, 0x3D, 0xF7, 0xC0, 0x00, 0x0F, 0xF8, 0xF8,
  0x00, 0x03, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x0F, 0x00, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x3C, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1F, 0x83, 0xC0, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x0F, 0x8F, 0x00,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x0F, 0xBC,
  0x00, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xEF, 0xFF, 0x00,
  0x01, 0xEF, 0xFF, 0x00, 0x01, 0xEF, 0xF7, 0x80, 0x03, 0xCF, 0xF7, 0x80,
  0x03, 0xCF, 0xF3, 0x80, 0x03, 0x8F, 0xF3, 0xC0, 0x07, 0x8F, 0xF3, 0xC0,
  0x07, 0x8F, 0xF1, 0xC0, 0x0F, 0x0F, 0xF1, 0xE0, 0x0F, 0x0F, 0xF1, 0xE0,
  0x0F, 0x0F, 0xF0, 0xF0, 0x1E, 0x0F, 0xF0, 0xF0, 0x1E, 0x0F, 0xF0, 0xF0,
  0x1C, 0x0F, 0xF0, 0x78, 0x3C, 0x0F, 0xF0, 0x78, 0x3C, 0x0F, 0xF0, 0x78,
  0x78, 0x0F, 0xF0, 0x3C, 0x78, 0x0F, 0xF0, 0x3C, 0x78, 0x0F, 0xF0, 0x1C,
  0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xC0, 0x0F, 0xF0, 0x07,
  0xC0, 0x0F, 0xF0, 0x07, 0x80, 0x0F, 0xF0, 0x07, 0x80, 0x0F, 0xF0, 0x03,
  0x80, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xEF, 0x00, 0x00, 0x3F, 0xDF, 0x00, 0x00, 0x7F, 0x9E, 0x00, 0x00,
  0xFF, 0x3E, 0x00, 0x01, 0xFE, 0x3C, 0x00, 0x03, 0xFC, 0x3C, 0x00, 0x07,
  0xF8, 0x78, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x1F, 0xE0, 0xF8, 0x00, 0x3F,
  0xC0, 0xF0, 0x00, 0x7F, 0x81, 0xF0, 0x00, 0xFF, 0x01, 0xE0, 0x01, 0xFE,
  0x03, 0xE0, 0x03, 0xFC, 0x03, 0xC0, 0x07, 0xF8, 0x07, 0xC0, 0x0F, 0xF0,
  0x07, 0x80, 0x1F, 0xE0, 0x07, 0x80, 0x3F, 0xC0, 0x0F, 0x00, 0x7F, 0x80,
  0x0F, 0x00, 0xFF, 0x00, 0x1F, 0x01, 0xFE, 0x00, 0x1E, 0x03, 0xFC, 0x00,
  0x3E, 0x07, 0xF8, 0x00, 0x3C, 0x0F, 0xF0, 0x00, 0x7C, 0x1F, 0xE0, 0x00,
  0x78, 0x3F, 0xC0, 0x00, 0xF8, 0x7F, 0x80, 0x00, 0xF0, 0xFF, 0x00, 0x00,
  0xF1, 0xFE, 0x00, 0x01, 0xF3, 0xFC, 0x00, 0x01, 0xE7, 0xF8, 0x00, 0x03,
  0xEF, 0xF0, 0x00, 0x03, 0xDF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0x80, 0x00, 0xFF,
  0x0F, 0x00, 0x00, 0x7F, 0x1E, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3E,
  0x78, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0xBC, 0x00,
  0x00, 0x3E, 0x78, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0xE1, 0xE0, 0x00,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x3E, 0x1E,
  0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00,
  0x01, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00,
  0x3F, 0xC0, 0xF0, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x03, 0xF0, 0xF0, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0xE0, 0xF0, 0x00,
  0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xF0, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x03,
  0xC7, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x07, 0x9F, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x79, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x00,
  0x00, 0x78, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x7C, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0x80, 0x03, 0xBC, 0x00, 0x3F, 0x00, 0x1E, 0x78, 0x00, 0xFC, 0x00, 0x79,
  0xE0, 0x03, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0xC0, 0x07, 0x9E, 0x00, 0x3F,
  0x00, 0x1E, 0x78, 0x01, 0xFC, 0x00, 0x79, 0xE0, 0x07, 0xF8, 0x01, 0xC7,
  0x80, 0x1F, 0xE0, 0x0F, 0x0E, 0x00, 0x73, 0x80, 0x3C, 0x3C, 0x01, 0xCE,
  0x00, 0xF0, 0xF0, 0x0F, 0x38, 0x03, 0xC3, 0xC0, 0x3C, 0xF0, 0x0F, 0x0F,
  0x00, 0xF3, 0xC0, 0x3C, 0x3C, 0x03, 0x8F, 0x00, 0xE0, 0xF0, 0x0E, 0x1C,
  0x03, 0x81, 0xC0, 0x38, 0x70, 0x1E, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0x1E,
  0x07, 0x87, 0x81, 0xE0, 0x78, 0x1C, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x38,
  0x1E, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0x38,
  0x3C, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x3C, 0x3C, 0x03, 0xC3, 0x80, 0xF0,
  0xF0, 0x0F, 0x0E, 0x01, 0xC3, 0xC0, 0x3C, 0x78, 0x07, 0x0F, 0x00, 0xF1,
  0xE0, 0x1E, 0x38, 0x03, 0xC7, 0x80, 0x78, 0xE0, 0x07, 0x1C, 0x01, 0xE3,
  0x80, 0x1C, 0x70, 0x03, 0x9E, 0x00, 0x7B, 0xC0, 0x0E, 0x78, 0x01, 0xEF,
  0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE,
  0x00, 0x7B, 0x80, 0x0F, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x3E,
  0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00,
  0x00, 0xF9, 0xE0, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x00, 0xF9, 0xE0,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xCF,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x03,
  0x80, 0x07, 0x83, 0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x78,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xC1, 0xFE, 0x01, 0xFC, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00,
  0x7C, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xE1,
  0xFC, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFE, 0x7C, 0x00,
  0x07, 0xFC, 0xFC, 0x00, 0x1F, 0x78, 0xFF, 0x01, 0xFC, 0xF0, 0xFF, 0xFF,
  0xF1, 0xE0, 0x7F, 0xFF, 0x83, 0xE0, 0x7F, 0xFC, 0x07, 0xC0, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x07,
  0xFC, 0x00, 0xF0, 0x7F, 0xFC, 0x03, 0xC7, 0xFF, 0xFC, 0x0F, 0x3F, 0xDF,
  0xF8, 0x3D, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3E, 0x3F, 0x80,
  0x01, 0xF8, 0xFF, 0x80, 0x0F, 0xC3, 0xDF, 0x80, 0xFE, 0x0F, 0x3F, 0xFF,
  0xF0, 0x3C, 0x3F, 0xFF, 0x80, 0xF0, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xF1, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x80, 0x00,
  0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xF8, 0x0F, 0x00,
  0x7F, 0xFC, 0x1E, 0x03, 0xFF, 0xFE, 0x3C, 0x0F, 0xFD, 0xFE, 0x78, 0x3F,
  0x00, 0x3E, 0xF0, 0xFC, 0x00, 0x1D, 0xE1, 0xF0, 0x00, 0x1F, 0xC7, 0xC0,
  0x00, 0x1F, 0x8F, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x3E, 0x78, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E,
  0xF8, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3,
  0xE0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3F, 0x87,
  0xC0, 0x00, 0xFF, 0x07, 0xC0, 0x03, 0xDE, 0x07, 0xF0, 0x1F, 0xBC, 0x07,
  0xFF, 0xFE, 0x78, 0x07, 0xFF, 0xF0, 0xF0, 0x03, 0xFF, 0x81, 0xE0, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x7C,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x04, 0x0F, 0x80, 0x00, 0x0E, 0x0F,
  0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7C, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0xE0, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x3C, 0x03, 0xFF, 0xE0, 0xF0, 0x3F, 0xFF, 0xE3, 0xC1, 0xFF, 0xBF,
  0xCF, 0x0F, 0xC0, 0x0F, 0xBC, 0x7E, 0x00, 0x0F, 0xF1, 0xF0, 0x00, 0x1F,
  0xCF, 0x80, 0x00, 0x3F, 0x3C, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3F, 0x1F, 0x00,
  0x03, 0xFC, 0x3F, 0x00, 0x1E, 0xF0, 0x7F, 0x01, 0xFB, 0xC0, 0xFF, 0xFF,
  0xCF, 0x01, 0xFF, 0xFC, 0x3C, 0x01, 0xFF, 0xC0, 0xF0, 0x00, 0x70, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x10, 0x00, 0x00, 0xF0, 0x60,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x01, 0xFF, 0x00, 0xF0, 0x3F, 0xFF, 0x07, 0x87, 0xFF, 0xFC, 0x3C, 0x7F,
  0x9F, 0xF1, 0xE7, 0xC0, 0x0F, 0xCF, 0x78, 0x00, 0x3F, 0x7B, 0x80, 0x00,
  0xFB, 0xF8, 0x00, 0x03, 0xDF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0x9F, 0xF8, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0xF0, 0x00, 0x03, 0xF3,
  0xC0, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x3E, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0x01, 0xF8,
  0x00, 0x3C, 0x0F, 0xC0, 0x00, 0xF0, 0x7E, 0x00, 0x03, 0xC3, 0xF0, 0x00,
  0x0F, 0x1F, 0x80, 0x00, 0x3C, 0xFC, 0x00, 0x00, 0xF7, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFC,
  0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0xF8, 0x00, 0xF0, 0x03, 0xF0, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0x00, 0x0F,
  0xC0, 0x3C, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x07, 0xE3,
  0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0x7C, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xFF,
  0x00, 0xFF, 0x07, 0x8F, 0xFE, 0x1F, 0xFC, 0x3D, 0xFF, 0xF1, 0xFF, 0xF1,
  0xEF, 0x9F, 0xDF, 0x9F, 0xCF, 0xE0, 0x3F, 0xE0, 0x1F, 0x7E, 0x00, 0xFE,
  0x00, 0x7B, 0xE0, 0x03, 0xE0, 0x03, 0xDF, 0x00, 0x1F, 0x00, 0x1E, 0xF0,
  0x00, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0x80, 0x03, 0xFC, 0x00, 0x3C, 0x00,
  0x1F, 0xE0, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x07, 0xF8, 0x00,
  0x78, 0x00, 0x3F, 0xC0, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x0F,
  0xF0, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0x80, 0x03, 0xFC, 0x00, 0x3C,
  0x00, 0x1F, 0xE0, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x07, 0xF8,
  0x00, 0x78, 0x00, 0x3F, 0xC0, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0x1E, 0x00,
  0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0x80, 0x03, 0xFC, 0x00,
  0x3C, 0x00, 0x1F, 0xE0, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x07,
  0xF8, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0x1E,
  0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0x80, 0x03, 0xFC,
  0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0x00,
  0x07, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0xF0, 0x0F, 0xF8, 0x07, 0x81, 0xFF,
  0xF8, 0x3C, 0x3F, 0xFF, 0xE1, 0xE3, 0xFC, 0xFF, 0x8F, 0x3E, 0x00, 0x7E,
  0x7B, 0xC0, 0x01, 0xF3, 0xFC, 0x00, 0x07, 0xDF, 0xC0, 0x00, 0x1E, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x1F, 0xF0, 0x03, 0xC3, 0xFF, 0xF0,
  0x0F, 0x1F, 0xFF, 0xF0, 0x3C, 0xFE, 0x7F, 0xE0, 0xF7, 0xC0, 0x1F, 0xC3,
  0xFC, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0xBC, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0xF8, 0xFE, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x3F,
  0x0F, 0x7C, 0x03, 0xF8, 0x3C, 0xFF, 0xFF, 0xC0, 0xF1, 0xFF, 0xFE, 0x03,
  0xC1, 0xFF, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x3C,
  0x03, 0xFF, 0xE0, 0xF0, 0x3F, 0xFF, 0xE3, 0xC1, 0xFF, 0x1F, 0xCF, 0x0F,
  0xC0, 0x0F, 0xBC, 0x7E, 0x00, 0x0F, 0xF1, 0xF0, 0x00, 0x1F, 0xCF, 0x80,
  0x00, 0x3F, 0x3C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xFC,
  0x3E, 0x00, 0x1F, 0xF0, 0x7E, 0x01, 0xFB, 0xC0, 0xFF, 0xFF, 0xCF, 0x01,
  0xFF, 0xFC, 0x3C, 0x01, 0xFF, 0xC0, 0xF0, 0x00, 0x70, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x9F, 0xC0, 0x0F, 0xDF, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0x1F,
  0xF0, 0x1F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x1E, 0x7C, 0x00,
  0x00, 0xF8, 0xFC, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x02, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xE0, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xBC, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7F, 0x3E, 0x00, 0x07,
  0xF9, 0xF8, 0x00, 0x7B, 0xC7, 0xF0, 0x1F, 0x9E, 0x1F, 0xFF, 0xF8, 0xF0,
  0x7F, 0xFF, 0x87, 0x80, 0xFF, 0xF0, 0x3C, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1F, 0xE0, 0x00, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0xF0, 0x00,
  0x73, 0xC0, 0x03, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0xC0, 0x03, 0xCF, 0x00,
  0x0F, 0x80, 0x07, 0x9E, 0x00, 0x1F, 0x80, 0x0F, 0x1C, 0x00, 0x77, 0x00,
  0x1C, 0x3C, 0x00, 0xEE, 0x00, 0x78, 0x78, 0x01, 0xDC, 0x00, 0xF0, 0xF0,
  0x03, 0xBC, 0x01, 0xE0, 0xE0, 0x0F, 0x78, 0x03, 0x81, 0xC0, 0x1C, 0x70,
  0x07, 0x03, 0xC0, 0x38, 0xE0, 0x1E, 0x07, 0x80, 0x71, 0xE0, 0x3C, 0x0F,
  0x01, 0xE3, 0xC0, 0x78, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0x1E, 0x07, 0x07,
  0x01, 0xC0, 0x3C, 0x0E, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x1E, 0x0F, 0x00,
  0x70, 0x70, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x38, 0x38, 0x01, 0xE1, 0xC0,
  0x78, 0x70, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x07, 0x8E, 0x00, 0xE3, 0xC0,
  0x07, 0x1C, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0x1E, 0xF0,
  0x07, 0x9C, 0x00, 0x3D, 0xC0, 0x07, 0x78, 0x00, 0x3B, 0x80, 0x0E, 0xF0,
  0x00, 0x77, 0x00, 0x1D, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x7D, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3C, 0x7F, 0xFF, 0x00, 0x00, 0x71, 0xFC,
  0xFF, 0x00, 0x00, 0xE3, 0xC0, 0x3F, 0x00, 0x03, 0xCF, 0x00, 0x1F, 0x80,
  0x07, 0x9E, 0x00, 0x1F, 0x80, 0x1E, 0x78, 0x00, 0x1F, 0xC0, 0x7C, 0xF0,
  0x00, 0x1F, 0xE7, 0xF1, 0xC0, 0x00, 0x0F, 0xFF, 0xC3, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
};

const GFXglyph RobotoMono_Light71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 6, 50, 43, 18, -50 },
  { 39, 14, 15, 43, 14, -53 },
  { 66, 39, 50, 43, 2, -50 },
  { 310, 31, 65, 43, 6, -58 },
  { 562, 39, 52, 43, 2, -51 },
  { 816, 36, 52, 43, 5, -51 },
  { 1050, 4, 15, 43, 18, -53 },
  { 1058, 17, 73, 43, 13, -57 },
  { 1214, 17, 73, 43, 12, -57 },
  { 1370, 32, 30, 43, 6, -50 },
  { 1490, 35, 37, 43, 4, -42 },
  { 1652, 8, 17, 43, 13, -7 },
  { 1669, 26, 3, 43, 8, -24 },
  { 1679, 7, 7, 43, 19, -7 },
  { 1686, 25, 54, 43, 10, -50 },
  { 1855, 31, 52, 43, 6, -51 },
  { 2057, 18, 50, 43, 8, -50 },
  { 2170, 33, 51, 43, 3, -51 },
  { 2381, 32, 52, 43, 3, -51 },
  { 2589, 36, 50, 43, 3, -50 },
  { 2814, 31, 51, 43, 7, -50 },
  { 3012, 31, 52, 43, 5, -51 },
  { 3214, 34, 50, 43, 4, -50 },
  { 3427, 32, 52, 43, 6, -51 },
  { 3635, 32, 51, 43, 5, -51 },
  { 3839, 7, 37, 43, 21, -37 },
  { 3872, 10, 47, 43, 18, -37 },
  { 3931, 29, 30, 43, 6, -38 },
  { 4040, 31, 18, 43, 6, -32 },
  { 4110, 31, 30, 43, 6, -38 },
  { 4227, 28, 51, 43, 8, -51 },
  { 4406, 39, 51, 43, 2, -51 },
  { 4655, 36, 50, 43, 4, -50 },
  { 4880, 31, 50, 43, 7, -50 },
  { 5074, 34, 52, 43, 4, -51 },
  { 5295, 33, 50, 43, 6, -50 },
  { 5502, 30, 50, 43, 7, -50 },
  { 5690, 30, 50, 43, 7, -50 },
  { 5878, 34, 52, 43, 4, -51 },
  { 6099, 31, 50, 43, 6, -50 },
  { 6293, 29, 50, 43, 7, -50 },
  { 6475, 32, 51, 43, 4, -50 },
  { 6679, 34, 50, 43, 7, -50 },
  { 6892, 29, 50, 43, 8, -50 },
  { 7074, 32, 50, 43, 6, -50 },
  { 7274, 31, 50, 43, 6, -50 },
  { 7468, 34, 52, 43, 4, -51 },
  { 7689, 31, 50, 43, 8, -50 },
  { 7883, 35, 60, 43, 4, -51 },
  { 8146, 32, 50, 43, 7, -50 },
  { 8346, 34, 52, 43, 5, -51 },
  { 8567, 37, 50, 43, 3, -50 },
  { 8799, 32, 51, 43, 5, -50 },
  { 9003, 36, 50, 43, 3, -50 },
  { 9228, 38, 50, 43, 3, -50 },
  { 9466, 36, 50, 43, 4, -50 },
  { 9691, 36, 50, 43, 3, -50 },
  { 9916, 33, 50, 43, 4, -50 },
  { 10123, 12, 69, 43, 16, -58 },
  { 10227, 25, 54, 43, 9, -50 },
  { 10396, 12, 69, 43, 15, -58 },
  { 10500, 25, 27, 43, 9, -50 },
  { 10585, 31, 4, 43, 6, 0 },
  { 10601, 11, 9, 43, 16, -52 },
  { 10614, 31, 39, 43, 6, -38 },
  { 10766, 30, 54, 43, 7, -53 },
  { 10969, 31, 39, 43, 6, -38 },
  { 11121, 31, 54, 43, 5, -53 },
  { 11331, 32, 39, 43, 5, -38 },
  { 11487, 33, 54, 43, 6, -54 },
  { 11710, 30, 53, 43, 6, -38 },
  { 11909, 29, 53, 43, 7, -53 },
  { 12102, 30, 51, 43, 8, -51 },
  { 12294, 22, 66, 43, 7, -51 },
  { 12476, 30, 53, 43, 8, -53 },
  { 12675, 30, 53, 43, 8, -53 },
  { 12874, 37, 38, 43, 3, -38 },
  { 13050, 29, 38, 43, 7, -38 },
  { 13188, 33, 39, 43, 5, -38 },
  { 13349, 30, 52, 43, 7, -38 },
  { 13544, 30, 52, 43, 6, -38 },
  { 13739, 25, 38, 43, 12, -38 },
  { 13858, 30, 39, 43, 7, -38 },
  { 14005, 30, 48, 43, 6, -47 },
  { 14185, 29, 39, 43, 7, -38 },
  { 14327, 35, 38, 43, 4, -38 },
  { 14494, 39, 38, 43, 2, -38 },
  { 14680, 35, 38, 43, 4, -38 },
  { 14847, 37, 53, 43, 3, -38 },
  { 15093, 33, 38, 43, 5, -38 },
  { 15250, 24, 69, 43, 11, -55 },
  { 15457, 3, 62, 43, 20, -50 },
  { 15481, 23, 69, 43, 11, -55 },
  { 15680, 39, 12, 43, 2, -27 },
};

const GFXfont RobotoMono_Light71pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light71pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light71pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _ROBOTOMONO_LIGHT71PT7B_H_
