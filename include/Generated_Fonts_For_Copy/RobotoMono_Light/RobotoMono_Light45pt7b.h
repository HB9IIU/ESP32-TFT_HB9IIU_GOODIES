#ifndef _ROBOTOMONO_LIGHT45PT7B_H_
#define _ROBOTOMONO_LIGHT45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light45pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x00, 0x00, 0x00, 0x07, 0xF7, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x0C, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x07, 0x01, 0x80, 0x03, 0x01, 0xC0,
  0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x1F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE0, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03,
  0x00, 0x03, 0x01, 0x80, 0x03, 0x81, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0,
  0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x38, 0x1C, 0x07, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x03,
  0x80, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xE0,
  0x0F, 0xFF, 0x01, 0xE0, 0x78, 0x3C, 0x01, 0xC3, 0x80, 0x1E, 0x70, 0x00,
  0xE7, 0x00, 0x0E, 0x70, 0x00, 0x67, 0x00, 0x06, 0x70, 0x00, 0x17, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x76, 0x00, 0x06, 0x70, 0x00, 0xE3, 0x80, 0x1E, 0x3E, 0x07,
  0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x18, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x06, 0x03, 0x06, 0x03, 0x03,
  0x03, 0x01, 0x81, 0x81, 0x80, 0xC1, 0x80, 0xC0, 0x60, 0xC0, 0x60, 0x30,
  0xC0, 0x18, 0x38, 0xE0, 0x0E, 0x38, 0x60, 0x03, 0xF8, 0x70, 0x00, 0xF8,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x1F, 0x00, 0x06, 0x1F, 0xC0, 0x06, 0x1C, 0x70,
  0x07, 0x1C, 0x18, 0x03, 0x0C, 0x06, 0x03, 0x86, 0x03, 0x01, 0x83, 0x01,
  0x81, 0x81, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x60, 0x30, 0x00, 0x30,
  0x38, 0x00, 0x0C, 0x18, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xF8, 0x03, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x3C, 0x38, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70,
  0x03, 0x80, 0x60, 0x06, 0x00, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00,
  0x38, 0x1C, 0x00, 0x30, 0x70, 0x00, 0x71, 0xC0, 0x00, 0x77, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x39,
  0xE0, 0x00, 0xE1, 0xC0, 0x33, 0x81, 0xC0, 0xE7, 0x01, 0xC1, 0xDC, 0x01,
  0xC3, 0xB8, 0x03, 0xC6, 0x70, 0x03, 0x9C, 0xE0, 0x03, 0xB9, 0xC0, 0x03,
  0xE3, 0x80, 0x03, 0x83, 0x80, 0x07, 0x07, 0x80, 0x3F, 0x07, 0x80, 0xF7,
  0x07, 0xFF, 0x87, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xD8, 0x00, 0x20,
  0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30,
  0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07,
  0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x60, 0x60, 0x3F, 0x86, 0x1F, 0x7F, 0x6F, 0xF0, 0xFF,
  0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x39, 0xC0, 0x03,
  0x0E, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x01, 0xC0, 0x3C, 0x0C, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x39, 0xCE, 0x73, 0x9C,
  0xE6, 0x77, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xF8, 0x03, 0x80, 0xE0, 0x38, 0x03, 0x83, 0x80, 0x0E, 0x18, 0x00, 0x31,
  0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x60, 0x00, 0x33, 0x00, 0x07, 0x98, 0x00,
  0x7E, 0xC0, 0x07, 0x7E, 0x00, 0x73, 0xF0, 0x07, 0x1F, 0x80, 0x70, 0xFC,
  0x07, 0x07, 0xE0, 0x70, 0x3F, 0x07, 0x01, 0xF8, 0xE0, 0x0F, 0xCE, 0x00,
  0x76, 0xE0, 0x03, 0xBE, 0x00, 0x1D, 0xE0, 0x00, 0xCE, 0x00, 0x06, 0x70,
  0x00, 0x73, 0x80, 0x03, 0x8E, 0x00, 0x18, 0x70, 0x01, 0xC1, 0xC0, 0x1C,
  0x07, 0x01, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x20, 0x3C, 0x1F,
  0x9F, 0xBF, 0xC7, 0xE0, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0x81, 0xE0,
  0x70, 0x03, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x71, 0x80, 0x03, 0x9C, 0x00,
  0x0C, 0xE0, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1E, 0x03, 0xC3,
  0x80, 0x1C, 0x38, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0x66, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x70, 0x00, 0x77,
  0x00, 0x0E, 0x38, 0x01, 0xE1, 0xE0, 0x3C, 0x0F, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0x70, 0x00, 0x18, 0xE0, 0x00,
  0x71, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x38,
  0x1C, 0x00, 0x60, 0x38, 0x01, 0xC0, 0x70, 0x07, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0xE0, 0x07, 0x01, 0x80, 0x0E, 0x07, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x20,
  0x07, 0x7F, 0xC0, 0xFF, 0xFC, 0x1F, 0x0F, 0xC3, 0x80, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3B, 0x80, 0x07,
  0x38, 0x01, 0xE7, 0x80, 0x78, 0x7E, 0x7E, 0x07, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x0F, 0xC0, 0x63, 0xFF, 0x06, 0xF8, 0xF8, 0xFC,
  0x03, 0xCF, 0x80, 0x1E, 0xF0, 0x00, 0xEE, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07,
  0x70, 0x00, 0x77, 0x00, 0x07, 0x30, 0x00, 0xE3, 0x80, 0x0E, 0x1C, 0x01,
  0xC0, 0xF0, 0x78, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xF0, 0x1E, 0x07, 0x83, 0x80, 0x1C, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70,
  0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x70, 0x00, 0xE7,
  0x00, 0x0E, 0x38, 0x01, 0xC1, 0xC0, 0x38, 0x0F, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xFF, 0x01, 0xC0, 0x38, 0x38, 0x01, 0xC7, 0x00, 0x0E, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x77, 0x00, 0x0E, 0x78, 0x01, 0xE3, 0xC0, 0x3C, 0x1F,
  0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1E, 0x07, 0x81,
  0xC0, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0x66, 0x00, 0x07,
  0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00,
  0x36, 0x00, 0x03, 0x70, 0x00, 0x77, 0x00, 0x07, 0x38, 0x00, 0xF3, 0xC0,
  0x1B, 0x1E, 0x07, 0xB0, 0xFF, 0xF7, 0x07, 0xFC, 0x70, 0x04, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00,
  0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xEF, 0xFD, 0xC0, 0x39, 0xE7, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x30, 0xC3, 0x1C, 0x71, 0xC6, 0x38,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80,
  0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x07,
  0xFF, 0x83, 0xC0, 0xF1, 0xC0, 0x1C, 0xE0, 0x03, 0xB8, 0x00, 0x6E, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x00,
  0xE0, 0x60, 0x00, 0x30, 0x60, 0x18, 0x18, 0x30, 0x3F, 0x06, 0x30, 0x3D,
  0xC3, 0x18, 0x30, 0x61, 0x98, 0x30, 0x30, 0x4C, 0x18, 0x18, 0x26, 0x18,
  0x0C, 0x1B, 0x0C, 0x06, 0x0D, 0x06, 0x02, 0x07, 0x83, 0x01, 0x03, 0xC1,
  0x81, 0x81, 0x60, 0x80, 0xC0, 0xB0, 0x40, 0x60, 0xD8, 0x30, 0x30, 0x6C,
  0x18, 0x38, 0x33, 0x0C, 0x1C, 0x11, 0x86, 0x1E, 0x18, 0xC1, 0xF9, 0xF8,
  0x60, 0xF8, 0xF8, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x06, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x73, 0x00,
  0x00, 0xC7, 0x00, 0x01, 0x86, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x1C, 0x00,
  0x18, 0x18, 0x00, 0x70, 0x30, 0x00, 0xC0, 0x70, 0x01, 0x80, 0xE0, 0x07,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x03, 0x00, 0xE0,
  0x07, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x18, 0x00,
  0x38, 0x70, 0x00, 0x30, 0xE0, 0x00, 0x71, 0x80, 0x00, 0xE7, 0x00, 0x00,
  0xCE, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xE0, 0x3F, 0x8E, 0x00, 0x3C, 0xE0, 0x01, 0xCE, 0x00, 0x0E,
  0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x0C, 0xE0, 0x01, 0xCE, 0x00, 0x78, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x8E, 0x00, 0x3C, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0E, 0xE0, 0x01, 0xCE, 0x01, 0xF8,
  0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xC0,
  0xF0, 0x38, 0x03, 0xC3, 0x80, 0x0E, 0x18, 0x00, 0x39, 0xC0, 0x00, 0xCC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x07, 0x60, 0x00, 0x3B, 0x80,
  0x01, 0x8C, 0x00, 0x1C, 0x70, 0x00, 0xC1, 0xC0, 0x0E, 0x07, 0x01, 0xE0,
  0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x38, 0x1F,
  0x81, 0xC0, 0x1E, 0x0E, 0x00, 0x38, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x9C,
  0x00, 0x1C, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x0D, 0xC0, 0x00,
  0x6E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0x70, 0x00, 0x1B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0xE7, 0x00,
  0x07, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x0E, 0x00, 0xF0, 0x70, 0x3F, 0x03,
  0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xF8, 0xFF,
  0xFF, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xC0, 0xF0, 0x38, 0x01, 0xC3,
  0x80, 0x0F, 0x38, 0x00, 0x39, 0xC0, 0x00, 0xEC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x80, 0x00, 0xCE, 0x00, 0x06,
  0x70, 0x00, 0x71, 0xC0, 0x07, 0x87, 0x80, 0xF8, 0x1F, 0xFF, 0x00, 0x3F,
  0xE0, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xDC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x80, 0x03, 0x9C, 0x00, 0x1C,
  0x70, 0x01, 0xC3, 0xC0, 0x1C, 0x0F, 0x03, 0xE0, 0x3F, 0xFE, 0x00, 0x7F,
  0xC0, 0xE0, 0x00, 0x7B, 0x80, 0x03, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0x70,
  0xE0, 0x03, 0x83, 0x80, 0x1C, 0x0E, 0x00, 0xF0, 0x38, 0x07, 0x80, 0xE0,
  0x3C, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x00, 0x38, 0x38, 0x00, 0xE1, 0xC0,
  0x03, 0x8F, 0x00, 0x0E, 0x78, 0x00, 0x3B, 0xF0, 0x00, 0xEF, 0xE0, 0x03,
  0xF3, 0x80, 0x0F, 0x87, 0x00, 0x3C, 0x0E, 0x00, 0xE0, 0x3C, 0x03, 0x80,
  0x70, 0x0E, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x83, 0x80, 0x0E,
  0x0E, 0x00, 0x1C, 0x38, 0x00, 0x78, 0xE0, 0x00, 0xE3, 0x80, 0x01, 0xCE,
  0x00, 0x03, 0xB8, 0x00, 0x0F, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFD, 0x80, 0x3F,
  0xD8, 0x03, 0x7D, 0xC0, 0x37, 0xCC, 0x07, 0x7C, 0xC0, 0x67, 0xCE, 0x0E,
  0x7C, 0x60, 0xC7, 0xC7, 0x0C, 0x7C, 0x71, 0xC7, 0xC3, 0x18, 0x7C, 0x3B,
  0x87, 0xC3, 0xB8, 0x7C, 0x1B, 0x07, 0xC1, 0xF0, 0x7C, 0x0E, 0x07, 0xC0,
  0xE0, 0x7C, 0x0E, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xF7, 0x00, 0x1E, 0xE0, 0x03,
  0xCE, 0x00, 0x78, 0xC0, 0x0F, 0x1C, 0x01, 0xE1, 0x80, 0x3C, 0x38, 0x07,
  0x83, 0x80, 0xF0, 0x70, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x0E, 0x0F,
  0x01, 0xC1, 0xE0, 0x1C, 0x3C, 0x01, 0x87, 0x80, 0x38, 0xF0, 0x03, 0x1E,
  0x00, 0x73, 0xC0, 0x07, 0x78, 0x00, 0xEF, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0x03, 0xFE, 0x00,
  0x3F, 0xF8, 0x03, 0xC1, 0xE0, 0x38, 0x03, 0x83, 0x80, 0x0E, 0x18, 0x00,
  0x31, 0xC0, 0x01, 0xCC, 0x00, 0x06, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0x60, 0x00, 0x33, 0x80, 0x03, 0x8C, 0x00, 0x18, 0x70, 0x01, 0xC1, 0xC0,
  0x1C, 0x07, 0x83, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0xC0, 0x0F, 0x8C, 0x00, 0x3C, 0xC0, 0x01, 0xEC, 0x00, 0x0E,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x01, 0xEC, 0x00,
  0x3C, 0xC0, 0x3F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3E,
  0x0F, 0x80, 0x70, 0x07, 0x81, 0xC0, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00,
  0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x19, 0x80, 0x00,
  0x33, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x76, 0x00, 0x00, 0xEC, 0x00, 0x01, 0x9C, 0x00, 0x03, 0x38,
  0x00, 0x0E, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x30, 0xE0, 0x00, 0xE0, 0xE0,
  0x03, 0x80, 0xE0, 0x0F, 0x00, 0xF0, 0x7C, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x38, 0x07, 0xE1, 0xC0, 0x07, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0x73, 0x80,
  0x01, 0x9C, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D,
  0xC0, 0x00, 0xEE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x07, 0x1C, 0x00,
  0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xC0, 0x38, 0x0E,
  0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x60, 0xE0, 0x03,
  0x87, 0x00, 0x0C, 0x38, 0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70,
  0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x07, 0x03, 0xFF, 0x00, 0x7F, 0xFC,
  0x07, 0xC0, 0xF8, 0x78, 0x01, 0xC3, 0x80, 0x07, 0x38, 0x00, 0x1D, 0xC0,
  0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x1B, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xDC, 0x00, 0x0E, 0xF0, 0x00, 0x73, 0xC0, 0x07, 0x0F,
  0x80, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xEC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x80, 0x03, 0x9C,
  0x00, 0x1C, 0x70, 0x01, 0xC1, 0xC0, 0x1C, 0x0F, 0x83, 0xE0, 0x1F, 0xFC,
  0x00, 0x7F, 0xC0, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x19, 0xC0, 0x00, 0x73,
  0x80, 0x00, 0xE7, 0x00, 0x01, 0x86, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C,
  0x00, 0x18, 0x18, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x60,
  0x03, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x03, 0x80,
  0xE0, 0x07, 0x01, 0xC0, 0x06, 0x03, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x30, 0x00, 0x30, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x00,
  0x00, 0xCE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x60, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xC0,
  0x18, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x06, 0x60,
  0x3C, 0x06, 0x60, 0x3C, 0x06, 0x60, 0x3C, 0x06, 0x60, 0x7C, 0x0E, 0x70,
  0x6E, 0x0E, 0x70, 0x66, 0x0E, 0x70, 0x66, 0x0C, 0x70, 0x66, 0x0C, 0x30,
  0xE6, 0x0C, 0x30, 0xC7, 0x0C, 0x30, 0xC3, 0x1C, 0x30, 0xC3, 0x1C, 0x38,
  0xC3, 0x1C, 0x39, 0xC3, 0x18, 0x39, 0xC3, 0x98, 0x19, 0x83, 0x98, 0x19,
  0x81, 0x98, 0x19, 0x81, 0x98, 0x1B, 0x81, 0xB8, 0x1F, 0x81, 0xB8, 0x1F,
  0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0x60, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xF0, 0xE0, 0x01, 0xC1, 0xC0,
  0x07, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0xE0, 0x03, 0x81,
  0xC0, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x60,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x38, 0x00, 0x1C, 0x70, 0x00,
  0x38, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x01, 0xC0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00,
  0x03, 0x9C, 0x00, 0x07, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x39, 0xC0, 0x00, 0x63, 0x80, 0x01, 0xC3, 0x80, 0x03, 0x07, 0x00, 0x0E,
  0x07, 0x00, 0x18, 0x06, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x0C, 0x03, 0x80,
  0x1C, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x30, 0xE0, 0x00,
  0x71, 0x80, 0x00, 0x67, 0x00, 0x00, 0xEC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x18, 0xFF, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x3B, 0x80, 0x18, 0xC0,
  0x1C, 0x70, 0x0C, 0x38, 0x06, 0x0C, 0x07, 0x07, 0x03, 0x01, 0x83, 0x80,
  0xE1, 0x80, 0x70, 0xC0, 0x18, 0xE0, 0x0E, 0xE0, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE0, 0xE0, 0xE0, 0xC0, 0xC1, 0xC0, 0x07, 0xFC, 0x01,
  0xFF, 0xE0, 0xF8, 0x3E, 0x3C, 0x01, 0xE7, 0x00, 0x1D, 0xC0, 0x01, 0xB8,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x07, 0xFF, 0x87,
  0xFF, 0xF3, 0xF0, 0x0E, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7E, 0xF0,
  0x3D, 0xCF, 0xFF, 0x38, 0xFF, 0x87, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE1, 0xFC, 0x0E, 0x7F, 0xF0,
  0xEE, 0x0F, 0x8F, 0x80, 0x38, 0xF0, 0x01, 0xCF, 0x00, 0x1C, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0,
  0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xCF, 0x00, 0x1C, 0xF8, 0x03, 0x8F,
  0xE0, 0x78, 0xEF, 0xFF, 0x0E, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0xE0,
  0x78, 0x3E, 0x1C, 0x01, 0xE7, 0x00, 0x1C, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x0D, 0xC0, 0x03, 0xB8, 0x00, 0x63, 0x80, 0x1C, 0x3C, 0x0F, 0x03,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x03, 0xF8, 0x70, 0x7F, 0xE7, 0x0F, 0x07,
  0x71, 0xC0, 0x1F, 0x38, 0x00, 0xF3, 0x80, 0x0F, 0x70, 0x00, 0x77, 0x00,
  0x07, 0x60, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0x77,
  0x00, 0x07, 0x30, 0x00, 0x73, 0x80, 0x0F, 0x1C, 0x01, 0xF1, 0xE0, 0x7F,
  0x0F, 0xFF, 0x70, 0x3F, 0xC7, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xC1,
  0xF0, 0x3C, 0x03, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x39, 0xC0, 0x01, 0xCE,
  0x00, 0x06, 0x60, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x41, 0xE0, 0x07,
  0x07, 0x80, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xFC, 0x70, 0x7F, 0xE7, 0x0F, 0x07, 0x71, 0xC0, 0x1F,
  0x38, 0x00, 0xF3, 0x80, 0x0F, 0x70, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00,
  0x76, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00,
  0x07, 0x60, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x30,
  0x00, 0x73, 0x80, 0x0F, 0x1C, 0x01, 0xF1, 0xE0, 0x7F, 0x0F, 0xFF, 0x70,
  0x3F, 0xC7, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x10, 0x00, 0xE3, 0x80, 0x1C, 0x1E, 0x07, 0x80, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x87, 0xF8, 0x71, 0xFF, 0x8E, 0x70, 0x79, 0xD8, 0x03, 0xBE, 0x00,
  0x77, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x3F, 0xF8,
  0xFF, 0xC0, 0xF0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x07, 0x60, 0x03, 0xCC, 0x00, 0xF1, 0x80,
  0x3C, 0x30, 0x0F, 0x06, 0x03, 0xC0, 0xC0, 0xF0, 0x18, 0x3C, 0x03, 0x0E,
  0x00, 0x63, 0x80, 0x0C, 0xF0, 0x01, 0xBF, 0x00, 0x3E, 0xF0, 0x07, 0x8E,
  0x00, 0xE0, 0xE0, 0x18, 0x0E, 0x03, 0x00, 0xE0, 0x60, 0x1E, 0x0C, 0x01,
  0xE1, 0x80, 0x1E, 0x30, 0x01, 0xC6, 0x00, 0x1C, 0xC0, 0x01, 0xD8, 0x00,
  0x1C, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC7, 0xE1,
  0xF9, 0xBF, 0xEF, 0xFB, 0x61, 0xD8, 0x77, 0x81, 0xE0, 0x7E, 0x03, 0x80,
  0xFC, 0x07, 0x01, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xE1, 0xFE, 0x1C, 0x7F, 0xE3,
  0xBC, 0x1E, 0x76, 0x00, 0xEF, 0x80, 0x1D, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xC1, 0xE0,
  0x38, 0x03, 0x83, 0x80, 0x0E, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xCC, 0x00,
  0x06, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3B, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0x70, 0x01, 0xC3, 0xC0, 0x1E, 0x0F,
  0x01, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0xE3, 0xFC, 0x1C, 0xFF, 0xC3,
  0xB8, 0x3C, 0x7C, 0x01, 0xCF, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0x78, 0x00, 0xEF, 0x80, 0x39, 0xF8, 0x0F, 0x3B,
  0xFF, 0xC7, 0x1F, 0xE0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x70, 0x7F, 0xE7, 0x0F, 0x07, 0x71, 0xC0, 0x1F,
  0x38, 0x00, 0xF3, 0x80, 0x0F, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00,
  0x76, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00,
  0x07, 0x60, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x30,
  0x00, 0x73, 0x80, 0x0F, 0x1C, 0x01, 0xF1, 0xE0, 0x3F, 0x0F, 0xFF, 0x70,
  0x3F, 0xC7, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0xC0, 0xFF, 0xC3, 0xFE, 0xEF, 0xE2, 0xEE, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x78, 0x1E, 0x1C, 0x00, 0xE7, 0x00,
  0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x1B, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xB8, 0x00,
  0x77, 0x00, 0x0E, 0x78, 0x07, 0x87, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xEC, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0xF3, 0x80, 0x3E,
  0x78, 0x1D, 0xC7, 0xFF, 0x38, 0x7F, 0xC7, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x39, 0xC0, 0x00, 0x71, 0x80, 0x01, 0xC3, 0x80, 0x03, 0x83, 0x00, 0x06,
  0x07, 0x00, 0x1C, 0x0E, 0x00, 0x30, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x18, 0x03, 0x00, 0x38, 0x0E, 0x00, 0x30, 0x18, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0xE0, 0x00, 0xC1, 0x80, 0x01, 0xC7, 0x00, 0x01, 0x8C, 0x00, 0x03,
  0xB8, 0x00, 0x07, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x0C, 0x03, 0xB0, 0x0E, 0x01, 0xD8, 0x07,
  0x00, 0xCC, 0x03, 0x80, 0x67, 0x01, 0xE0, 0x31, 0x81, 0xB0, 0x38, 0xC0,
  0xD8, 0x1C, 0x60, 0x6C, 0x0C, 0x38, 0x33, 0x06, 0x1C, 0x31, 0x83, 0x06,
  0x18, 0xC3, 0x83, 0x0C, 0x61, 0x81, 0x86, 0x18, 0xC0, 0xE6, 0x0C, 0x60,
  0x33, 0x06, 0x30, 0x19, 0x83, 0x38, 0x0C, 0xC0, 0xD8, 0x06, 0xC0, 0x6C,
  0x03, 0xE0, 0x36, 0x00, 0xF0, 0x1B, 0x00, 0x78, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x06, 0x00, 0xE0, 0xF0, 0x00, 0x39, 0xC0, 0x01,
  0xC3, 0x80, 0x0F, 0x07, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x00,
  0x70, 0x70, 0x00, 0xE1, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1D, 0xC0,
  0x00, 0xF3, 0x80, 0x03, 0x87, 0x00, 0x1C, 0x0E, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0x70, 0x1C, 0x00, 0xE0, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0xB8, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x73, 0x80, 0x00,
  0xE3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x38,
  0x1C, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x0E, 0x00,
  0x70, 0x1C, 0x00, 0x70, 0x30, 0x00, 0xE0, 0xE0, 0x00, 0xE1, 0x80, 0x01,
  0xC7, 0x00, 0x01, 0x8E, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x60, 0x01, 0xF0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x0F, 0x80, 0x78, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x02, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x1F, 0xF8,
  0x01, 0xDE, 0x1E, 0x00, 0xCE, 0x07, 0x80, 0x66, 0x00, 0xF0, 0x77, 0x00,
  0x3F, 0xF3, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xE0,
};

const GFXglyph RobotoMono_Light45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 4, 32, 27, 11, -32 },
  { 17, 9, 10, 27, 9, -34 },
  { 29, 25, 32, 27, 1, -32 },
  { 129, 20, 42, 27, 4, -37 },
  { 234, 25, 32, 27, 1, -32 },
  { 334, 23, 32, 27, 3, -32 },
  { 426, 3, 10, 27, 11, -34 },
  { 430, 11, 46, 27, 8, -36 },
  { 494, 10, 46, 27, 8, -36 },
  { 552, 20, 20, 27, 4, -32 },
  { 602, 22, 24, 27, 3, -27 },
  { 668, 5, 10, 27, 8, -4 },
  { 675, 17, 2, 27, 5, -15 },
  { 680, 4, 4, 27, 12, -4 },
  { 682, 16, 35, 27, 6, -32 },
  { 752, 21, 32, 27, 3, -32 },
  { 836, 11, 32, 27, 5, -32 },
  { 880, 21, 32, 27, 2, -32 },
  { 964, 20, 32, 27, 2, -32 },
  { 1044, 23, 32, 27, 2, -32 },
  { 1136, 19, 32, 27, 5, -32 },
  { 1212, 20, 32, 27, 3, -32 },
  { 1292, 21, 32, 27, 3, -32 },
  { 1376, 20, 32, 27, 4, -32 },
  { 1456, 20, 32, 27, 3, -32 },
  { 1536, 5, 23, 27, 13, -23 },
  { 1551, 6, 29, 27, 12, -23 },
  { 1573, 18, 19, 27, 4, -24 },
  { 1616, 19, 11, 27, 4, -20 },
  { 1643, 19, 19, 27, 4, -24 },
  { 1689, 18, 32, 27, 5, -32 },
  { 1761, 25, 32, 27, 1, -32 },
  { 1861, 23, 32, 27, 2, -32 },
  { 1953, 20, 32, 27, 4, -32 },
  { 2033, 21, 32, 27, 3, -32 },
  { 2117, 21, 32, 27, 4, -32 },
  { 2201, 19, 32, 27, 4, -32 },
  { 2277, 19, 32, 27, 5, -32 },
  { 2353, 21, 32, 27, 3, -32 },
  { 2437, 20, 32, 27, 4, -32 },
  { 2517, 19, 32, 27, 4, -32 },
  { 2593, 21, 32, 27, 2, -32 },
  { 2677, 22, 32, 27, 4, -32 },
  { 2765, 19, 32, 27, 5, -32 },
  { 2841, 20, 32, 27, 4, -32 },
  { 2921, 19, 32, 27, 4, -32 },
  { 2997, 21, 32, 27, 3, -32 },
  { 3081, 20, 32, 27, 5, -32 },
  { 3161, 23, 38, 27, 2, -32 },
  { 3271, 21, 32, 27, 4, -32 },
  { 3355, 21, 32, 27, 3, -32 },
  { 3439, 23, 32, 27, 2, -32 },
  { 3531, 21, 32, 27, 3, -32 },
  { 3615, 23, 32, 27, 2, -32 },
  { 3707, 24, 32, 27, 2, -32 },
  { 3803, 23, 32, 27, 2, -32 },
  { 3895, 23, 32, 27, 2, -32 },
  { 3987, 20, 32, 27, 3, -32 },
  { 4067, 8, 44, 27, 10, -37 },
  { 4111, 15, 35, 27, 6, -32 },
  { 4177, 8, 44, 27, 9, -37 },
  { 4221, 17, 17, 27, 5, -32 },
  { 4258, 19, 2, 27, 4, 0 },
  { 4263, 7, 6, 27, 10, -33 },
  { 4269, 19, 24, 27, 4, -24 },
  { 4326, 20, 34, 27, 4, -34 },
  { 4411, 19, 24, 27, 4, -24 },
  { 4468, 20, 34, 27, 3, -34 },
  { 4553, 21, 24, 27, 3, -24 },
  { 4616, 21, 34, 27, 4, -34 },
  { 4706, 20, 33, 27, 3, -24 },
  { 4789, 19, 34, 27, 4, -34 },
  { 4870, 19, 32, 27, 5, -32 },
  { 4946, 14, 42, 27, 4, -32 },
  { 5020, 19, 34, 27, 5, -34 },
  { 5101, 19, 34, 27, 5, -34 },
  { 5182, 23, 24, 27, 2, -24 },
  { 5251, 19, 24, 27, 4, -24 },
  { 5308, 21, 24, 27, 3, -24 },
  { 5371, 19, 33, 27, 4, -24 },
  { 5450, 20, 33, 27, 3, -24 },
  { 5533, 16, 24, 27, 8, -24 },
  { 5581, 19, 24, 27, 4, -24 },
  { 5638, 19, 30, 27, 4, -30 },
  { 5710, 19, 24, 27, 4, -24 },
  { 5767, 23, 24, 27, 2, -24 },
  { 5836, 25, 24, 27, 1, -24 },
  { 5911, 22, 24, 27, 3, -24 },
  { 5977, 23, 34, 27, 2, -24 },
  { 6075, 21, 24, 27, 3, -24 },
  { 6138, 15, 44, 27, 7, -35 },
  { 6221, 3, 39, 27, 12, -32 },
  { 6236, 15, 44, 27, 7, -35 },
  { 6319, 25, 8, 27, 1, -17 },
};

const GFXfont RobotoMono_Light45pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light45pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOMONO_LIGHT45PT7B_H_
