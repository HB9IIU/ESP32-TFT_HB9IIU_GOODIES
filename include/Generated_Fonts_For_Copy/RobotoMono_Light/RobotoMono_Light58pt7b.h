#ifndef _ROBOTOMONO_LIGHT58PT7B_H_
#define _ROBOTOMONO_LIGHT58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light58pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0xE0, 0x7E,
  0x07, 0x60, 0x76, 0x07, 0x60, 0x76, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x06, 0x00, 0x00, 0xC0,
  0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x60, 0x0E,
  0x00, 0x01, 0xC0, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0E, 0x01, 0xC0, 0x00, 0x18, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x70, 0x07, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07,
  0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0x38,
  0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x30, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0x7C,
  0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0xE0, 0x00,
  0x1E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9E, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x3E, 0x03,
  0xFC, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x70, 0x1C, 0x01, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0xE0, 0x0E, 0x01,
  0xC0, 0xE0, 0x0E, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x00, 0xE0, 0x0E, 0x07,
  0x00, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0x0C, 0x0E, 0x00, 0x70, 0x1C, 0x1C,
  0x00, 0x70, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x38, 0x00, 0x3F, 0xF8, 0x38,
  0x00, 0x1F, 0xF0, 0x70, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x03, 0xF0, 0x00, 0x07, 0x07,
  0xFC, 0x00, 0x0E, 0x0F, 0x3E, 0x00, 0x0E, 0x1C, 0x0E, 0x00, 0x1C, 0x1C,
  0x07, 0x00, 0x18, 0x38, 0x07, 0x00, 0x38, 0x38, 0x03, 0x00, 0x70, 0x38,
  0x03, 0x00, 0x70, 0x38, 0x03, 0x00, 0xE0, 0x38, 0x03, 0x00, 0xE0, 0x38,
  0x03, 0x01, 0xC0, 0x38, 0x03, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x00, 0x18,
  0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xF8, 0x78, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x03,
  0x80, 0x1E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x01, 0xE0, 0x00, 0xE0,
  0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x70, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07,
  0xC7, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x70, 0xF0, 0x3E, 0x01, 0xC7, 0x80,
  0x78, 0x07, 0x1C, 0x00, 0xF0, 0x1C, 0xF0, 0x01, 0xE0, 0xF3, 0xC0, 0x03,
  0xC3, 0x8E, 0x00, 0x0F, 0x0E, 0x38, 0x00, 0x1E, 0x78, 0xE0, 0x00, 0x3D,
  0xC3, 0x80, 0x00, 0x7F, 0x0F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xFF, 0x03, 0xE0, 0x07, 0xDE, 0x07,
  0xF1, 0xFE, 0x7C, 0x0F, 0xFF, 0xE0, 0xF0, 0x0F, 0xFE, 0x01, 0xF0, 0x01,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0x6C, 0x00, 0x18, 0x01, 0xC0,
  0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x06, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0xF0, 0x07, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x01, 0x00, 0x38, 0x02, 0x78, 0x0E,
  0x03, 0xDF, 0x83, 0x87, 0xFF, 0xFC, 0xE7, 0xFC, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x03,
  0xC0, 0x03, 0x80, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xE0, 0x18,
  0x00, 0x70, 0x02, 0x00, 0x08, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCE, 0x39, 0xE7, 0x3C, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x79, 0xFF, 0xDF, 0x78, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x83, 0xF0, 0x0F,
  0x80, 0x3E, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E,
  0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x3D, 0xC0, 0x00,
  0x0F, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xF7, 0x00, 0x01, 0xFD, 0xC0,
  0x00, 0xF7, 0xF0, 0x00, 0x79, 0xFC, 0x00, 0x3C, 0x7F, 0x00, 0x1E, 0x1F,
  0xC0, 0x0F, 0x07, 0xF0, 0x07, 0x81, 0xFC, 0x03, 0xC0, 0x7F, 0x03, 0xC0,
  0x1F, 0xC1, 0xE0, 0x07, 0xF0, 0xF0, 0x01, 0xFC, 0x78, 0x00, 0x7F, 0x3C,
  0x00, 0x1D, 0xDE, 0x00, 0x07, 0x7F, 0x00, 0x01, 0xDF, 0x80, 0x00, 0x77,
  0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x07, 0x80, 0xF8, 0x03, 0xE0, 0x1F, 0xC7, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x7C, 0x03, 0xF8,
  0x1F, 0xF1, 0xFE, 0xEF, 0xE1, 0xFF, 0x03, 0xF8, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xE0, 0xFC,
  0x01, 0xE0, 0x07, 0xC0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x78, 0xF0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C,
  0x70, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x03, 0xF0, 0x1F, 0x00,
  0x3E, 0x0F, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x70,
  0x00, 0x07, 0x9C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x39, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x03,
  0xC1, 0xF0, 0x03, 0xE0, 0x3F, 0x87, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x1E,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x1E, 0x00,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xC3, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x73, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xC0, 0xFF, 0x0F, 0x80, 0x1F, 0x81, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x38, 0x00,
  0x07, 0x9E, 0x00, 0x07, 0xC7, 0x80, 0x07, 0xC3, 0xE0, 0x07, 0xE0, 0xFC,
  0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0xFF, 0x00, 0x70, 0xFF, 0xF0, 0x1C, 0xFF,
  0xFE, 0x07, 0x7C, 0x07, 0xC3, 0xFC, 0x00, 0x78, 0xFC, 0x00, 0x0F, 0x3E,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x1C,
  0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0x80, 0xF8, 0x03, 0xC0, 0x1F, 0xC7,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0x80,
  0x07, 0xC3, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x1C, 0x1C, 0x00,
  0x0F, 0x07, 0x80, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x7C, 0x00, 0xF8,
  0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x39, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC1, 0xF0, 0x03,
  0xF0, 0x3F, 0x87, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0x87, 0xE0, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xCF, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0xFC, 0x78, 0x00, 0x77, 0x0F, 0x80, 0x79, 0xC1,
  0xFD, 0xFC, 0xF0, 0x3F, 0xFE, 0x38, 0x03, 0xFE, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xEF, 0xFF, 0xFD, 0xE0, 0x1E, 0x3E, 0x3F, 0x3E, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0x60, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFE, 0x1F,
  0x83, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x9E, 0x00, 0x07, 0x38, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0C, 0x1C, 0x01, 0xF0,
  0x1C, 0x30, 0x0F, 0xF0, 0x38, 0xE0, 0x3F, 0xF0, 0x31, 0x80, 0xE0, 0x60,
  0x67, 0x03, 0x80, 0xC0, 0xEE, 0x07, 0x01, 0x81, 0xD8, 0x1C, 0x03, 0x01,
  0xB0, 0x38, 0x06, 0x03, 0xE0, 0x60, 0x0C, 0x07, 0xC1, 0xC0, 0x18, 0x0F,
  0x03, 0x80, 0x70, 0x1E, 0x07, 0x00, 0xE0, 0x3C, 0x0C, 0x01, 0xC0, 0x78,
  0x18, 0x03, 0x00, 0xF0, 0x30, 0x06, 0x03, 0xE0, 0x60, 0x0C, 0x07, 0xC0,
  0xC0, 0x18, 0x0D, 0x81, 0x80, 0x70, 0x1B, 0x83, 0x00, 0xE0, 0x77, 0x07,
  0x03, 0xC0, 0xCE, 0x0E, 0x0F, 0xC3, 0x9C, 0x0E, 0x3B, 0x86, 0x18, 0x1F,
  0xE3, 0xFC, 0x38, 0x1F, 0x83, 0xF0, 0x70, 0x08, 0x01, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x80, 0x01, 0xC0, 0x0E, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xE0, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x3C, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x1C, 0x00, 0x3F, 0x0E, 0x00, 0x07, 0xC7, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x79, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xB8, 0x00,
  0x03, 0xDC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x79, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x7C, 0x70, 0x00, 0xFC, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x07, 0x00, 0x0F, 0xC3,
  0x80, 0x00, 0xF9, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xEE, 0x00, 0x03, 0xE7, 0x00,
  0x07, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xF0,
  0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F,
  0x70, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0F, 0x1E, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x03, 0xE0, 0x0F, 0x80,
  0x3F, 0x8F, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x70, 0x00, 0xF8, 0x0E, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x78, 0x38, 0x00,
  0x07, 0x87, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x78,
  0x70, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x81, 0xC0, 0x07, 0xE0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x00, 0x7C,
  0x0E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x07, 0x1E, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xC7, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0x9E, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x07, 0xC0,
  0x1F, 0x80, 0xFF, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x07, 0xDC, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x3C, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x38,
  0x00, 0x3E, 0x07, 0x00, 0x0F, 0x80, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x78,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x07, 0x80, 0x0E, 0x01, 0xE0, 0x01, 0xC0,
  0x7C, 0x00, 0x38, 0x1F, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xE0, 0xF0, 0x00,
  0x1C, 0x3C, 0x00, 0x03, 0x8F, 0x80, 0x00, 0x73, 0xF8, 0x00, 0x0E, 0xFF,
  0x80, 0x01, 0xFE, 0xF0, 0x00, 0x3F, 0x8F, 0x00, 0x07, 0xE0, 0xF0, 0x00,
  0xF8, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0xE0, 0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x3C, 0x07,
  0x00, 0x07, 0xC0, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x78, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0x7F, 0xE0, 0x01, 0xDF, 0xB8, 0x00, 0xF7, 0xEE, 0x00, 0x39,
  0xFB, 0xC0, 0x0E, 0x7E, 0x70, 0x07, 0x1F, 0x9C, 0x01, 0xC7, 0xE7, 0x80,
  0xF1, 0xF8, 0xE0, 0x38, 0xFE, 0x38, 0x0E, 0x3F, 0x87, 0x07, 0x0F, 0xE1,
  0xC1, 0xC3, 0xF8, 0x70, 0xF0, 0xFE, 0x0E, 0x38, 0x3F, 0x83, 0x8E, 0x0F,
  0xE0, 0xF7, 0x83, 0xF8, 0x1D, 0xC0, 0xFE, 0x07, 0x70, 0x3F, 0x81, 0xF8,
  0x0F, 0xE0, 0x3E, 0x03, 0xF8, 0x0F, 0x80, 0xFE, 0x03, 0xC0, 0x3F, 0x80,
  0x70, 0x0F, 0xE0, 0x1C, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xDC, 0x00, 0x07, 0xEF, 0x00,
  0x03, 0xF3, 0x80, 0x01, 0xF9, 0xE0, 0x00, 0xFC, 0x70, 0x00, 0x7E, 0x3C,
  0x00, 0x3F, 0x0E, 0x00, 0x1F, 0x87, 0x80, 0x0F, 0xC1, 0xE0, 0x07, 0xE0,
  0x70, 0x03, 0xF0, 0x3C, 0x01, 0xF8, 0x0E, 0x00, 0xFC, 0x07, 0x80, 0x7E,
  0x01, 0xC0, 0x3F, 0x00, 0xF0, 0x1F, 0x80, 0x38, 0x0F, 0xC0, 0x1E, 0x07,
  0xE0, 0x07, 0x03, 0xF0, 0x03, 0xC1, 0xF8, 0x00, 0xF0, 0xFC, 0x00, 0x38,
  0x7E, 0x00, 0x1E, 0x3F, 0x00, 0x07, 0x1F, 0x80, 0x03, 0xCF, 0xC0, 0x00,
  0xE7, 0xE0, 0x00, 0x7B, 0xF0, 0x00, 0x1D, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x3E,
  0x00, 0x3C, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x03,
  0x8F, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x3E,
  0x00, 0x3C, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xC0, 0x01, 0xF8, 0xF0, 0x00, 0x1F,
  0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0E, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x7C, 0xF0, 0x00, 0x7E, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x1E, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78,
  0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x87, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0xE0, 0xE0, 0x00, 0x3C,
  0x38, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x3C, 0xE0, 0x00,
  0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E, 0xE0,
  0x00, 0x07, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x3C,
  0xE0, 0x00, 0x0F, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x03, 0xE3, 0x80, 0x01,
  0xF0, 0xE0, 0x01, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x03,
  0x80, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x07,
  0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x0E, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x3C, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x1F,
  0x80, 0x0F, 0x80, 0x7F, 0x9F, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x03, 0xE0,
  0x0F, 0x80, 0x7F, 0xBF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x38, 0x07, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0xE0, 0x07, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x3C, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xE0, 0x0E, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x39, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0xE0, 0x07, 0x80, 0x1D, 0xC0, 0x0F, 0x00, 0x3B, 0x80, 0x1E, 0x00, 0x77,
  0x00, 0x3C, 0x00, 0xEE, 0x00, 0xF8, 0x03, 0xDE, 0x01, 0xF8, 0x07, 0x3C,
  0x03, 0xF0, 0x0E, 0x38, 0x07, 0xE0, 0x1C, 0x70, 0x0D, 0xC0, 0x38, 0xE0,
  0x39, 0x80, 0x71, 0xC0, 0x73, 0x80, 0xE3, 0x80, 0xE7, 0x03, 0xC7, 0x01,
  0xCE, 0x07, 0x0F, 0x03, 0x9C, 0x0E, 0x0E, 0x0E, 0x18, 0x1C, 0x1C, 0x1C,
  0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE1,
  0xC1, 0xC1, 0xC1, 0x83, 0x87, 0x03, 0xC7, 0x03, 0x0E, 0x03, 0x8E, 0x07,
  0x1C, 0x07, 0x1C, 0x0E, 0x38, 0x0E, 0x38, 0x1C, 0x70, 0x1C, 0x60, 0x38,
  0xE0, 0x39, 0xC0, 0x31, 0xC0, 0x73, 0x80, 0x77, 0x00, 0xF7, 0x00, 0xEE,
  0x00, 0xEE, 0x01, 0xDC, 0x01, 0xDC, 0x03, 0xB8, 0x03, 0xF0, 0x07, 0x70,
  0x07, 0xE0, 0x06, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0xF8,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x78, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x1D, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0xF0, 0x07, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x71,
  0xC0, 0x03, 0x8E, 0x00, 0x38, 0x78, 0x01, 0xC1, 0xC0, 0x1E, 0x0F, 0x00,
  0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x0F, 0x03, 0x80, 0x38, 0x38, 0x01,
  0xE1, 0xC0, 0x07, 0x1E, 0x00, 0x38, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x70,
  0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x0F, 0x83, 0xC0, 0x03, 0xE3,
  0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0x80,
  0x07, 0x1E, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x1E, 0xF0,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x9E, 0x00, 0x1F, 0xCF, 0x80, 0x3E, 0xE3,
  0xFD, 0xFE, 0x78, 0xFF, 0xFE, 0x3C, 0x1F, 0xFC, 0x1E, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0xFF, 0x00, 0xE3, 0xFF, 0xC0, 0xE7, 0xFF, 0xF0,
  0xEF, 0x01, 0xF8, 0xFC, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x3C, 0xFC, 0x00, 0x7C,
  0xFE, 0x00, 0xF8, 0xEF, 0xEF, 0xF0, 0xE3, 0xFF, 0xE0, 0xE1, 0xFF, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x01, 0xF0, 0x0F, 0x81, 0xE0, 0x03, 0xE1, 0xE0, 0x00, 0x78, 0xE0, 0x00,
  0x3C, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0x1E, 0x00, 0x07,
  0x87, 0x80, 0x07, 0x83, 0xE0, 0x07, 0x80, 0xFE, 0x3F, 0x80, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x03, 0xFC, 0x1C, 0x07, 0xFF, 0x8E, 0x0F, 0xFF, 0xE7, 0x0F, 0xC0, 0x7B,
  0x87, 0x80, 0x0F, 0xC7, 0x80, 0x03, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00,
  0x79, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00,
  0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70,
  0x00, 0x03, 0xB8, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x39, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0x3E, 0x00, 0x3F,
  0x0F, 0x80, 0x3F, 0x83, 0xFD, 0xFD, 0xC0, 0xFF, 0xF8, 0xE0, 0x1F, 0xF8,
  0x70, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x1E,
  0x07, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0x03, 0xC0, 0x00, 0x30, 0x3C, 0x00, 0x0F, 0x03,
  0xE0, 0x07, 0xC0, 0x3F, 0x8F, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0x83,
  0x80, 0xFF, 0xF1, 0xC1, 0xFF, 0xFC, 0xE1, 0xF8, 0x0F, 0x70, 0xF0, 0x01,
  0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x38, 0x00,
  0x03, 0xBC, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07,
  0x3C, 0x00, 0x07, 0x8F, 0x00, 0x07, 0xC7, 0xC0, 0x07, 0xE1, 0xF0, 0x07,
  0xF0, 0x7F, 0xBF, 0xB8, 0x1F, 0xFF, 0x1C, 0x03, 0xFF, 0x0E, 0x00, 0x10,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0xF8, 0x1F,
  0x00, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xFF, 0x03, 0xC3, 0xFF, 0xE1, 0xE3,
  0xFF, 0xF8, 0xF3, 0xC0, 0x7E, 0x7B, 0x80, 0x0F, 0x3F, 0x80, 0x03, 0xDF,
  0x80, 0x01, 0xEF, 0x80, 0x00, 0x77, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC3, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0xF8, 0xF0, 0x00,
  0xF8, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3D, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xF3, 0xC0, 0x03, 0xF0, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0xF0, 0x1F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x78,
  0x0F, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xE1, 0xE0, 0x00,
  0xF8, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0xF0, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0xF8, 0x1F, 0xC7,
  0x7F, 0xE3, 0xFF, 0x3F, 0xFF, 0xBF, 0xFD, 0xF0, 0x3D, 0xC1, 0xFF, 0x00,
  0xF8, 0x07, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x1C, 0x00, 0xFC, 0x00, 0xE0,
  0x07, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F,
  0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x70, 0x03, 0xF0, 0x03, 0x80, 0x1F, 0x80,
  0x1C, 0x00, 0xFC, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38,
  0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x70, 0x03,
  0xF0, 0x03, 0x80, 0x1F, 0x80, 0x1C, 0x00, 0xFC, 0x00, 0xE0, 0x07, 0xE0,
  0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x0E,
  0x00, 0x7E, 0x00, 0x70, 0x03, 0xF0, 0x03, 0x80, 0x1F, 0x80, 0x1C, 0x00,
  0xE0, 0xF0, 0x3F, 0xE0, 0x78, 0x7F, 0xFC, 0x3C, 0x7F, 0xFF, 0x1E, 0x78,
  0x0F, 0xCF, 0x70, 0x01, 0xE7, 0xF0, 0x00, 0x7B, 0xF0, 0x00, 0x3D, 0xF0,
  0x00, 0x0E, 0xF8, 0x00, 0x07, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1E, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x3C,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x07, 0xC0, 0x1F,
  0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x20, 0x00, 0xE0, 0xFF, 0x00, 0xE3, 0xFF, 0xC0, 0xE7, 0xFF, 0xF0, 0xEF,
  0x01, 0xF8, 0xFC, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x1C, 0xE0,
  0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0xFE,
  0x00, 0xF8, 0xEF, 0xC7, 0xF0, 0xE7, 0xFF, 0xE0, 0xE1, 0xFF, 0x80, 0xE0,
  0x08, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x83, 0x80, 0xFF, 0xF1, 0xC1, 0xFF, 0xFC, 0xE1, 0xF8, 0x0F, 0x71,
  0xF0, 0x01, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0E, 0x70,
  0x00, 0x07, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x07, 0xC7, 0xC0, 0x07, 0xE1,
  0xF0, 0x07, 0xF0, 0x7F, 0x3F, 0xB8, 0x1F, 0xFF, 0x9C, 0x03, 0xFF, 0x0E,
  0x00, 0x10, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0x01,
  0xF7, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xF0, 0x0F, 0xC3, 0xE0, 0x01, 0xF1,
  0xE0, 0x00, 0x78, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x70,
  0x00, 0x03, 0xBC, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xC7, 0xC0, 0x03, 0xE1,
  0xFE, 0x1F, 0xE0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xCF,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x7D,
  0xE0, 0x01, 0xF9, 0xE0, 0x07, 0x73, 0xF8, 0xFC, 0xE1, 0xFF, 0xF1, 0xC1,
  0xFF, 0x83, 0x80, 0x30, 0x00, 0xF0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x78, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x38,
  0x0E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x3F, 0x80, 0x1E,
  0x00, 0x77, 0x00, 0x7C, 0x01, 0xEE, 0x00, 0xF8, 0x03, 0x9C, 0x01, 0xB0,
  0x07, 0x38, 0x03, 0x70, 0x0E, 0x38, 0x0E, 0xE0, 0x1C, 0x70, 0x1D, 0xC0,
  0x70, 0xE0, 0x39, 0x80, 0xE1, 0xC0, 0x63, 0x81, 0xC3, 0x81, 0xC7, 0x03,
  0x83, 0x83, 0x8E, 0x07, 0x07, 0x07, 0x0C, 0x1C, 0x0E, 0x0C, 0x1C, 0x38,
  0x1C, 0x38, 0x38, 0x70, 0x18, 0x70, 0x70, 0xE0, 0x38, 0xE0, 0x61, 0x80,
  0x71, 0x80, 0xE7, 0x00, 0xE7, 0x01, 0xCE, 0x01, 0xCE, 0x03, 0x9C, 0x01,
  0x98, 0x03, 0x38, 0x03, 0xB0, 0x07, 0x60, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x38, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x03, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x1C, 0xFF, 0xF8, 0x00, 0x3B, 0xC0, 0xF8, 0x00, 0x77, 0x00, 0xF8, 0x01,
  0xDC, 0x00, 0x7C, 0x03, 0xB8, 0x00, 0x7E, 0x1E, 0x70, 0x00, 0x7F, 0xFC,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0x80,
};

const GFXglyph RobotoMono_Light58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 4, 41, 35, 15, -41 },
  { 22, 12, 13, 35, 11, -44 },
  { 42, 31, 41, 35, 2, -41 },
  { 201, 26, 54, 35, 5, -48 },
  { 377, 32, 43, 35, 1, -42 },
  { 549, 30, 43, 35, 4, -42 },
  { 711, 3, 13, 35, 15, -44 },
  { 716, 13, 59, 35, 11, -46 },
  { 812, 13, 59, 35, 10, -46 },
  { 908, 26, 25, 35, 5, -41 },
  { 990, 29, 30, 35, 3, -34 },
  { 1099, 6, 13, 35, 11, -5 },
  { 1109, 21, 3, 35, 7, -20 },
  { 1117, 6, 5, 35, 15, -5 },
  { 1121, 20, 45, 35, 8, -41 },
  { 1234, 26, 43, 35, 4, -42 },
  { 1374, 15, 41, 35, 6, -41 },
  { 1451, 27, 42, 35, 3, -42 },
  { 1593, 26, 43, 35, 3, -42 },
  { 1733, 30, 41, 35, 2, -41 },
  { 1887, 25, 42, 35, 6, -41 },
  { 2019, 26, 43, 35, 4, -42 },
  { 2159, 27, 41, 35, 4, -41 },
  { 2298, 26, 43, 35, 5, -42 },
  { 2438, 26, 42, 35, 4, -42 },
  { 2575, 6, 30, 35, 17, -30 },
  { 2598, 8, 38, 35, 15, -30 },
  { 2636, 24, 25, 35, 5, -31 },
  { 2711, 25, 15, 35, 5, -26 },
  { 2758, 25, 24, 35, 5, -31 },
  { 2833, 23, 42, 35, 6, -42 },
  { 2954, 31, 41, 35, 2, -41 },
  { 3113, 30, 41, 35, 3, -41 },
  { 3267, 25, 41, 35, 6, -41 },
  { 3396, 27, 43, 35, 4, -42 },
  { 3542, 27, 41, 35, 5, -41 },
  { 3681, 24, 41, 35, 6, -41 },
  { 3804, 24, 41, 35, 6, -41 },
  { 3927, 28, 43, 35, 3, -42 },
  { 4078, 25, 41, 35, 5, -41 },
  { 4207, 24, 41, 35, 5, -41 },
  { 4330, 26, 42, 35, 3, -41 },
  { 4467, 27, 41, 35, 6, -41 },
  { 4606, 25, 41, 35, 6, -41 },
  { 4735, 26, 41, 35, 5, -41 },
  { 4869, 25, 41, 35, 5, -41 },
  { 4998, 27, 43, 35, 4, -42 },
  { 5144, 26, 41, 35, 6, -41 },
  { 5278, 29, 49, 35, 3, -42 },
  { 5456, 26, 41, 35, 6, -41 },
  { 5590, 28, 43, 35, 4, -42 },
  { 5741, 29, 41, 35, 3, -41 },
  { 5890, 26, 42, 35, 4, -41 },
  { 6027, 29, 41, 35, 3, -41 },
  { 6176, 31, 41, 35, 2, -41 },
  { 6335, 30, 41, 35, 3, -41 },
  { 6489, 30, 41, 35, 2, -41 },
  { 6643, 26, 41, 35, 4, -41 },
  { 6777, 10, 56, 35, 13, -47 },
  { 6847, 21, 45, 35, 7, -41 },
  { 6966, 10, 56, 35, 12, -47 },
  { 7036, 21, 22, 35, 7, -41 },
  { 7094, 25, 3, 35, 5, 0 },
  { 7104, 9, 7, 35, 13, -42 },
  { 7112, 25, 32, 35, 5, -31 },
  { 7212, 24, 45, 35, 6, -44 },
  { 7347, 25, 32, 35, 5, -31 },
  { 7447, 25, 45, 35, 4, -44 },
  { 7588, 27, 32, 35, 4, -31 },
  { 7696, 27, 44, 35, 5, -44 },
  { 7845, 25, 43, 35, 4, -31 },
  { 7980, 25, 44, 35, 5, -44 },
  { 8118, 25, 42, 35, 6, -42 },
  { 8250, 18, 54, 35, 6, -42 },
  { 8372, 25, 44, 35, 6, -44 },
  { 8510, 25, 44, 35, 6, -44 },
  { 8648, 29, 31, 35, 3, -31 },
  { 8761, 25, 31, 35, 5, -31 },
  { 8858, 27, 32, 35, 4, -31 },
  { 8966, 24, 43, 35, 6, -31 },
  { 9095, 25, 43, 35, 4, -31 },
  { 9230, 20, 31, 35, 10, -31 },
  { 9308, 25, 32, 35, 5, -31 },
  { 9408, 24, 39, 35, 5, -38 },
  { 9525, 23, 32, 35, 6, -31 },
  { 9617, 29, 31, 35, 3, -31 },
  { 9730, 31, 31, 35, 2, -31 },
  { 9851, 28, 31, 35, 4, -31 },
  { 9960, 31, 43, 35, 2, -31 },
  { 10127, 27, 31, 35, 4, -31 },
  { 10232, 19, 56, 35, 9, -45 },
  { 10365, 3, 50, 35, 16, -41 },
  { 10384, 19, 56, 35, 9, -45 },
  { 10517, 31, 10, 35, 2, -22 },
};

const GFXfont RobotoMono_Light58pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light58pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light58pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _ROBOTOMONO_LIGHT58PT7B_H_
