#ifndef _ROBOTOMONO_LIGHT49PT7B_H_
#define _ROBOTOMONO_LIGHT49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light49pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x70, 0x00, 0x00, 0x06, 0xFF, 0x70, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x60, 0x00, 0x1C, 0x07, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x06, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xF0, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x0E, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x60, 0x18, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x60,
  0x18, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x1C, 0x00,
  0x0E, 0x03, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01,
  0x80, 0x00, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x00,
  0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xFC, 0x03, 0xF0, 0xF8, 0x1E, 0x00, 0xF0, 0xF0, 0x01, 0xC3, 0x80,
  0x07, 0x8E, 0x00, 0x0E, 0x30, 0x00, 0x39, 0xC0, 0x00, 0x67, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x60,
  0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x03, 0x8E, 0x00, 0x1E, 0x3C, 0x00,
  0xF0, 0x7C, 0x0F, 0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30, 0x38, 0x00,
  0x0E, 0x03, 0x00, 0x81, 0x80, 0x60, 0x38, 0x30, 0x0C, 0x06, 0x06, 0x01,
  0x81, 0xC0, 0xC0, 0x30, 0x70, 0x18, 0x06, 0x0C, 0x03, 0x80, 0xC3, 0x80,
  0x30, 0x38, 0x60, 0x07, 0x0E, 0x1C, 0x00, 0x7F, 0x83, 0x00, 0x07, 0xE0,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x83, 0xF0, 0x00, 0x70,
  0xFF, 0x00, 0x0C, 0x38, 0x70, 0x03, 0x86, 0x07, 0x00, 0x61, 0xC0, 0x60,
  0x1C, 0x38, 0x0C, 0x03, 0x06, 0x01, 0x80, 0xE0, 0xC0, 0x30, 0x18, 0x18,
  0x06, 0x06, 0x03, 0x80, 0xC0, 0xC0, 0x70, 0x18, 0x00, 0x06, 0x07, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x02,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xE1, 0xE0, 0x01, 0xE0,
  0x70, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01,
  0xC1, 0xE0, 0x00, 0x71, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xDC, 0x00,
  0x03, 0xC7, 0x00, 0x63, 0xC3, 0xC0, 0x31, 0xC0, 0xF0, 0x39, 0xC0, 0x38,
  0x1C, 0xE0, 0x0E, 0x0E, 0xE0, 0x03, 0x87, 0x70, 0x01, 0xE7, 0x38, 0x00,
  0x7B, 0x9C, 0x00, 0x1F, 0x8E, 0x00, 0x07, 0xC3, 0x80, 0x01, 0xC1, 0xE0,
  0x01, 0xF0, 0x78, 0x01, 0xFC, 0x1E, 0x07, 0xCE, 0x07, 0xFF, 0xC3, 0x81,
  0xFF, 0x81, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x20, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x02, 0x40,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x30, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x04, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x04, 0x03, 0x80, 0x5C, 0x0E, 0x07,
  0x7E, 0x38, 0xFF, 0xFE, 0xEF, 0xF0, 0x7F, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xB0, 0x00, 0x0C, 0xE0, 0x00, 0x71, 0xC0, 0x03, 0x83,
  0x80, 0x1C, 0x0F, 0x00, 0xF0, 0x1E, 0x07, 0x80, 0x3C, 0x04, 0x00, 0x40,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x33,
  0xB8, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x27, 0xBF, 0xF7,
  0x00, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xF0, 0x7C, 0x07, 0x00, 0x78, 0x38, 0x00, 0xF1,
  0xC0, 0x01, 0xC7, 0x00, 0x03, 0x1C, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80,
  0x00, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x3F, 0xE0, 0x01, 0xDF, 0x80, 0x0E,
  0x7E, 0x00, 0x71, 0xF8, 0x03, 0x87, 0xE0, 0x3C, 0x1F, 0x81, 0xE0, 0x7E,
  0x0F, 0x01, 0xF8, 0x70, 0x07, 0xE3, 0x80, 0x1F, 0x9C, 0x00, 0x7E, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xEE, 0x00, 0x03,
  0x9C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x01, 0xC3, 0x80, 0x0F, 0x07,
  0x00, 0x78, 0x1F, 0x03, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x08, 0x03, 0xC0, 0x7E, 0x1F, 0xF3, 0xF3, 0xFE, 0x1F, 0xC0, 0xF0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x3E, 0x1F, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x07, 0x0F, 0x00,
  0x0F, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xF8, 0x3E, 0x07, 0x80, 0x3C,
  0x3C, 0x00, 0x70, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0xE3,
  0x80, 0x03, 0x8F, 0x00, 0x1C, 0x1F, 0x01, 0xE0, 0x1F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x37, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03,
  0x80, 0x07, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x07, 0x01, 0xC0,
  0x03, 0x80, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x19, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x78, 0x07,
  0xE1, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xF7, 0x00, 0x07, 0x38, 0x00, 0x79, 0xE0,
  0x07, 0xC7, 0xC0, 0x7C, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x0F, 0xC0, 0x71, 0xFF,
  0x83, 0xBF, 0xFF, 0x1F, 0xC0, 0x7C, 0xF8, 0x00, 0xE7, 0x80, 0x03, 0xB8,
  0x00, 0x1D, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x77, 0x00, 0x07, 0x38, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x80, 0x3C,
  0x1F, 0x07, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xF8, 0x7E, 0x07, 0x80, 0x3C,
  0x3C, 0x00, 0x70, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70,
  0x00, 0x19, 0xC0, 0x00, 0x77, 0x00, 0x01, 0x9C, 0x00, 0x0E, 0x38, 0x00,
  0x38, 0xF0, 0x01, 0xC1, 0xE0, 0x0E, 0x03, 0xE0, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0xFC, 0x7C, 0x07, 0x80, 0x3C, 0x38, 0x00, 0x79, 0xC0,
  0x00, 0xE7, 0x00, 0x01, 0xD8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77,
  0x80, 0x03, 0x8F, 0x00, 0x1E, 0x1F, 0x01, 0xF0, 0x3F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xC1, 0xF0, 0x78, 0x03,
  0x83, 0x80, 0x0E, 0x38, 0x00, 0x79, 0xC0, 0x01, 0xDC, 0x00, 0x0E, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3B, 0x80,
  0x03, 0xDE, 0x00, 0x3E, 0x78, 0x03, 0xF1, 0xE0, 0x7B, 0x87, 0xFF, 0x9C,
  0x1F, 0xF0, 0xE0, 0x18, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x23, 0xFF,
  0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x11,
  0xFF, 0xFB, 0xC0, 0x10, 0xF7, 0xDF, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x71, 0xCE, 0x38, 0x40, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0x0F, 0x83, 0xC0, 0x3C, 0x78, 0x01, 0xE7,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xE0,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x60, 0xE0, 0x3C, 0x0E, 0x18, 0x0F, 0xE0, 0xC7, 0x07, 0x9E,
  0x18, 0xC0, 0xC0, 0xC3, 0x18, 0x30, 0x10, 0x36, 0x06, 0x06, 0x06, 0xC1,
  0x80, 0xC0, 0xD8, 0x30, 0x18, 0x1B, 0x06, 0x03, 0x03, 0x61, 0xC0, 0x60,
  0x6C, 0x30, 0x0C, 0x0F, 0x86, 0x01, 0x81, 0xF0, 0xC0, 0x30, 0x3E, 0x18,
  0x06, 0x05, 0xC3, 0x01, 0xC1, 0x98, 0x70, 0x38, 0x33, 0x06, 0x0F, 0x06,
  0x60, 0xC3, 0x61, 0x8C, 0x1F, 0xEE, 0x71, 0xC1, 0xF8, 0xFC, 0x18, 0x1C,
  0x0E, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x80, 0x07, 0xC0, 0x70, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x18, 0x60, 0x00, 0x0E,
  0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x38, 0x00,
  0x1C, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C,
  0x00, 0x38, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x18, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x70, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1C, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE1, 0xC0, 0x0F, 0x8E, 0x00, 0x1E, 0x70, 0x00, 0x73,
  0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00,
  0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x73, 0x80, 0x0F, 0x1C,
  0x03, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x38, 0x01, 0xF1, 0xC0, 0x03,
  0xCE, 0x00, 0x07, 0x70, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xDC, 0x00, 0x3C, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFC, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0x0F,
  0xC0, 0x70, 0x03, 0x81, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x8E, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x73, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x87, 0x00, 0x0E, 0x07, 0x00, 0x3C,
  0x0F, 0x81, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0x00, 0x3E, 0x0E, 0x00, 0x1E, 0x1C,
  0x00, 0x1E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0x38,
  0x00, 0x78, 0x70, 0x03, 0xE0, 0xE0, 0x7F, 0x81, 0xFF, 0xFC, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0x0F, 0xC0, 0x78,
  0x07, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x38, 0x00,
  0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x73, 0x80,
  0x00, 0xE7, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x87, 0x80, 0x0F, 0x07, 0xC0,
  0xFC, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x6E,
  0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x39, 0xC0, 0x01, 0xC7, 0x80,
  0x0F, 0x0F, 0x00, 0x78, 0x1F, 0x07, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xC7, 0x00, 0x07,
  0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x38, 0x01, 0xE0, 0x70, 0x07, 0x80,
  0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0xE0, 0x07, 0x03, 0xC0, 0x0E,
  0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0xF0, 0x00, 0x73, 0xC0, 0x00, 0xE7,
  0xC0, 0x01, 0xDF, 0xC0, 0x03, 0xF3, 0x80, 0x07, 0xE7, 0x80, 0x0F, 0x87,
  0x80, 0x1E, 0x07, 0x00, 0x38, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0F,
  0x01, 0xC0, 0x0E, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x1E,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0x3B, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0D, 0xFB, 0x00, 0x77,
  0xEE, 0x01, 0xDF, 0xB8, 0x06, 0x7E, 0x60, 0x39, 0xF9, 0xC0, 0xE7, 0xE7,
  0x07, 0x1F, 0x8C, 0x1C, 0x7E, 0x38, 0x61, 0xF8, 0xE3, 0x87, 0xE1, 0xCE,
  0x1F, 0x87, 0x30, 0x7E, 0x0D, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F,
  0x81, 0xE0, 0x7E, 0x07, 0x01, 0xF8, 0x1C, 0x07, 0xE0, 0x30, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFB, 0x80,
  0x07, 0xEE, 0x00, 0x1F, 0x9C, 0x00, 0x7E, 0x70, 0x01, 0xF8, 0xE0, 0x07,
  0xE3, 0x80, 0x1F, 0x87, 0x00, 0x7E, 0x0E, 0x01, 0xF8, 0x38, 0x07, 0xE0,
  0x70, 0x1F, 0x81, 0xC0, 0x7E, 0x03, 0x81, 0xF8, 0x0E, 0x07, 0xE0, 0x1C,
  0x1F, 0x80, 0x70, 0x7E, 0x00, 0xE1, 0xF8, 0x03, 0x87, 0xE0, 0x07, 0x1F,
  0x80, 0x0E, 0x7E, 0x00, 0x39, 0xF8, 0x00, 0x77, 0xE0, 0x01, 0xDF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0x1F,
  0x80, 0x78, 0x07, 0x81, 0xC0, 0x07, 0x07, 0x80, 0x07, 0x0E, 0x00, 0x07,
  0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x33, 0x80, 0x00,
  0xE3, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x78,
  0x0F, 0x83, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x38, 0x00, 0x7C, 0xE0, 0x00, 0x73, 0x80,
  0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xB8, 0x00, 0x1E, 0xE0, 0x00, 0xF3, 0x80, 0x07, 0x8F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xF8, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xC3, 0xE0, 0x1E, 0x00, 0xF0, 0x1C, 0x00,
  0x78, 0x38, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x06, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x78, 0x00,
  0x1C, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0xF0, 0x0F, 0x83,
  0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x06, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x38, 0x00, 0xF0,
  0xE0, 0x01, 0xE3, 0x80, 0x03, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1E, 0xE0,
  0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x3B, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xE3,
  0x80, 0x1F, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x38, 0x0E, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x83, 0x80, 0x0E,
  0x0E, 0x00, 0x3C, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E,
  0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00,
  0x01, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xC3, 0xF0, 0x1E,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x1E,
  0x00, 0x3C, 0x0F, 0x80, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x01, 0xC3,
  0x80, 0x0F, 0x0F, 0x00, 0x78, 0x1F, 0x07, 0xC0, 0x3F, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07,
  0x01, 0xC0, 0x03, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0,
  0x38, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x07,
  0x07, 0x00, 0x01, 0x83, 0x80, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00,
  0x18, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x07, 0x70, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x0C, 0x01, 0xF8, 0x03, 0x80, 0x7E, 0x01,
  0xE0, 0x1F, 0x80, 0x78, 0x07, 0x60, 0x1E, 0x01, 0xD8, 0x07, 0x80, 0x67,
  0x01, 0xF0, 0x19, 0xC0, 0xFC, 0x06, 0x70, 0x3B, 0x03, 0x9C, 0x0E, 0xC0,
  0xE7, 0x03, 0x30, 0x38, 0xC0, 0xCE, 0x0E, 0x30, 0x33, 0x83, 0x0E, 0x1C,
  0xE0, 0xC3, 0x87, 0x18, 0x30, 0xE1, 0x86, 0x1C, 0x38, 0x61, 0x87, 0x0E,
  0x18, 0x71, 0xC1, 0x8E, 0x1C, 0x70, 0x63, 0x83, 0x18, 0x1C, 0xC0, 0xC6,
  0x07, 0x30, 0x31, 0x81, 0xCC, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC0,
  0xEE, 0x03, 0x70, 0x1B, 0x80, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x3C, 0x00, 0xF0,
  0x07, 0x00, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0xF0, 0x00,
  0x07, 0x38, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x87, 0x00, 0x03, 0x81, 0xC0,
  0x03, 0xC0, 0xE0, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x07,
  0x00, 0xE0, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x1E, 0x38, 0x00, 0x07, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x70, 0x00, 0x07, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87,
  0x80, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0x70, 0x01, 0xC0, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x01, 0xC0, 0xF0, 0x00, 0x70, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0x9C, 0x00, 0x03, 0xC7, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x1C, 0x00,
  0x70, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x70,
  0x1C, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0xFF,
  0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x3F, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0x70, 0x01, 0xDC, 0x00, 0x73, 0x00, 0x18, 0xE0, 0x0E, 0x38,
  0x03, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x30, 0x18, 0x0E, 0x0E, 0x03, 0x83,
  0x00, 0x71, 0xC0, 0x1C, 0x70, 0x03, 0x98, 0x00, 0xEE, 0x00, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07,
  0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xC0, 0xF8, 0x78, 0x01, 0xC7, 0x80,
  0x07, 0x38, 0x00, 0x39, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xC0,
  0x1C, 0xF0, 0x00, 0xEE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7D, 0xE0, 0x0F,
  0xE7, 0x81, 0xF7, 0x1F, 0xFE, 0x38, 0x7F, 0xE1, 0xC0, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC7, 0xFC, 0x0E, 0x7F, 0xF0, 0x77, 0x87, 0xC3, 0xF0, 0x0F,
  0x1E, 0x00, 0x3C, 0xF0, 0x00, 0xE7, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0,
  0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xEE, 0x00,
  0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x1C, 0xF0, 0x01, 0xE7,
  0xC0, 0x1E, 0x3F, 0x81, 0xE1, 0xDF, 0xFE, 0x0C, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xC0, 0xF8, 0x3C, 0x01, 0xC3, 0x80, 0x07,
  0x3C, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x0E, 0xE0, 0x00, 0x77, 0x80, 0x03, 0x9C, 0x00, 0x38, 0x70, 0x03, 0xC1,
  0xE0, 0x7C, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x07, 0xF8, 0x70, 0xFF, 0xF3, 0x8F, 0x83, 0xDC, 0xF0, 0x07, 0xE7,
  0x00, 0x1F, 0x70, 0x00, 0x7B, 0x80, 0x03, 0xDC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xB0, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x38, 0x00, 0xF9, 0xE0,
  0x0F, 0xC7, 0xC1, 0xEE, 0x1F, 0xFE, 0x70, 0x3F, 0xE3, 0x80, 0x01, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0xF8, 0x3E, 0x07, 0x80, 0x38, 0x38, 0x00, 0x71,
  0xE0, 0x01, 0xE7, 0x00, 0x03, 0x98, 0x00, 0x0E, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x10, 0xF0, 0x00, 0xE1, 0xE0,
  0x07, 0x83, 0xE0, 0x7C, 0x07, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xE0, 0x10, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xFC, 0x38, 0x7F, 0xF9, 0xC7, 0xC1, 0xEE, 0x78, 0x03, 0xF3, 0x80,
  0x0F, 0xBC, 0x00, 0x3D, 0xC0, 0x01, 0xEE, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x07, 0x9C, 0x00, 0x7C, 0xF0, 0x07,
  0xE3, 0xE0, 0xF7, 0x0F, 0xFF, 0x38, 0x1F, 0xE1, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x80, 0x01, 0xCE, 0x00, 0x1C,
  0x3C, 0x01, 0xE0, 0xF8, 0x3E, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x1F, 0xF0, 0xE3, 0xFF, 0x8E, 0xF0, 0x7C, 0xEC, 0x01,
  0xEF, 0x80, 0x0E, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0xFF,
  0xF1, 0xFF, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x07,
  0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x3C, 0xE0, 0x01, 0xE3, 0x80, 0x0F, 0x0E, 0x00, 0x78, 0x38, 0x03,
  0xC0, 0xE0, 0x1E, 0x03, 0x80, 0xF0, 0x0E, 0x07, 0x00, 0x38, 0x38, 0x00,
  0xE3, 0xC0, 0x03, 0x9E, 0x00, 0x0E, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFD,
  0xE0, 0x03, 0xE3, 0xC0, 0x0F, 0x07, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x78, 0x0E, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0xE0, 0x03, 0xC3,
  0x80, 0x07, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x7C, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xE7, 0xF0, 0xFE, 0x77, 0xFC, 0xFF, 0xBF, 0x1E, 0xE1, 0xDE, 0x03,
  0xC0, 0x7F, 0x01, 0xE0, 0x3F, 0x00, 0xE0, 0x1F, 0x80, 0x70, 0x07, 0xC0,
  0x38, 0x03, 0xE0, 0x1C, 0x01, 0xF0, 0x0E, 0x00, 0xF8, 0x07, 0x00, 0x7C,
  0x03, 0x80, 0x3E, 0x01, 0xC0, 0x1F, 0x00, 0xE0, 0x0F, 0x80, 0x70, 0x07,
  0xC0, 0x38, 0x03, 0xE0, 0x1C, 0x01, 0xF0, 0x0E, 0x00, 0xF8, 0x07, 0x00,
  0x7C, 0x03, 0x80, 0x3E, 0x01, 0xC0, 0x1F, 0x00, 0xE0, 0x0F, 0x80, 0x70,
  0x07, 0xC0, 0x38, 0x03, 0xE0, 0x1C, 0x01, 0xF0, 0x0E, 0x00, 0xC0, 0xC1,
  0xFF, 0x0C, 0x7F, 0xF8, 0xCF, 0x07, 0xCD, 0xC0, 0x1E, 0xD8, 0x00, 0xEF,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3E, 0x0F,
  0x80, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x87, 0x00, 0x07, 0x9E, 0x00, 0x07,
  0x38, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x73, 0x80,
  0x00, 0xE3, 0x80, 0x03, 0xC7, 0x80, 0x07, 0x07, 0x80, 0x3C, 0x07, 0xC0,
  0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xC3, 0xFC, 0x06, 0x3F, 0xF8,
  0x37, 0x83, 0xE1, 0xB0, 0x07, 0x8F, 0x00, 0x1E, 0x70, 0x00, 0x73, 0x80,
  0x03, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x0D,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x06, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x01, 0xEE,
  0x00, 0x0E, 0x78, 0x00, 0xF3, 0xE0, 0x0F, 0x1F, 0xC0, 0xF0, 0xEF, 0xFF,
  0x07, 0x1F, 0xF0, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x38, 0x7F, 0xF9, 0xC7,
  0xC1, 0xEE, 0x78, 0x03, 0xF3, 0x80, 0x0F, 0xBC, 0x00, 0x3D, 0xC0, 0x00,
  0xEE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00,
  0x07, 0x9C, 0x00, 0x3C, 0xF0, 0x07, 0xE3, 0xE0, 0x77, 0x0F, 0xFF, 0x38,
  0x1F, 0xF1, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0xC0, 0xFF, 0xE1, 0xFF, 0xF1, 0xFD, 0xD9,
  0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0x81, 0xF0, 0xF0, 0x03, 0xC7,
  0x00, 0x0F, 0x30, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0x78, 0x00, 0x39, 0xE0,
  0x03, 0xC7, 0xC0, 0x7C, 0x1F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x20, 0x0F, 0xFF, 0x00, 0x1F,
  0xF8, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xF7, 0x00, 0x1F, 0x78, 0x03, 0xF3, 0xC0,
  0xF7, 0x1F, 0xFE, 0x70, 0xFF, 0x87, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x18,
  0x38, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x0C, 0x00, 0x70,
  0x0E, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x01, 0xC0,
  0x03, 0x01, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC3, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x06, 0x00, 0x6C, 0x00, 0xC0, 0x1D, 0xC0, 0x38, 0x03, 0xB8, 0x07,
  0x80, 0x67, 0x00, 0xF0, 0x0C, 0x60, 0x3E, 0x01, 0x8C, 0x06, 0xC0, 0x71,
  0xC0, 0xDC, 0x0E, 0x38, 0x19, 0x81, 0x83, 0x07, 0x30, 0x30, 0x60, 0xE6,
  0x0E, 0x0E, 0x18, 0xE1, 0xC1, 0xC3, 0x0C, 0x38, 0x38, 0xE1, 0x86, 0x03,
  0x18, 0x30, 0xC0, 0x63, 0x07, 0x38, 0x0E, 0x60, 0x67, 0x01, 0xDC, 0x0C,
  0xC0, 0x1B, 0x01, 0x98, 0x03, 0x60, 0x3B, 0x00, 0x6C, 0x03, 0x60, 0x0D,
  0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0x78, 0x0E, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x07, 0x81,
  0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xC3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xE7, 0x00, 0x01, 0xC3, 0x80, 0x03, 0x81,
  0xC0, 0x07, 0x81, 0xE0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0xF1, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x38, 0x00, 0x38, 0x0E,
  0x00, 0x1C, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x38, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0F, 0x03, 0x80, 0x03, 0x81, 0xC0,
  0x01, 0xC1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x70,
  0x00, 0x07, 0x30, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0xFC,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x0C, 0xFF, 0xE0, 0x03, 0x9C, 0x1F, 0x00, 0x77, 0x00, 0xF0,
  0x0C, 0xC0, 0x0F, 0x03, 0x98, 0x00, 0xFF, 0xE7, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3C, 0x00,
};

const GFXglyph RobotoMono_Light49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 4, 35, 29, 12, -35 },
  { 19, 9, 11, 29, 10, -37 },
  { 32, 27, 35, 29, 1, -35 },
  { 151, 22, 45, 29, 4, -40 },
  { 275, 27, 36, 29, 1, -35 },
  { 397, 25, 35, 29, 3, -35 },
  { 507, 3, 11, 29, 12, -37 },
  { 512, 12, 50, 29, 9, -39 },
  { 587, 12, 50, 29, 8, -39 },
  { 662, 22, 21, 29, 4, -35 },
  { 720, 24, 26, 29, 3, -29 },
  { 798, 5, 12, 29, 9, -5 },
  { 806, 17, 3, 29, 6, -17 },
  { 813, 5, 5, 29, 13, -5 },
  { 817, 17, 38, 29, 7, -35 },
  { 898, 22, 35, 29, 4, -35 },
  { 995, 13, 35, 29, 5, -35 },
  { 1052, 23, 35, 29, 2, -35 },
  { 1153, 22, 35, 29, 2, -35 },
  { 1250, 25, 35, 29, 2, -35 },
  { 1360, 21, 35, 29, 5, -35 },
  { 1452, 21, 35, 29, 4, -35 },
  { 1544, 23, 35, 29, 3, -35 },
  { 1645, 22, 35, 29, 4, -35 },
  { 1742, 21, 35, 29, 4, -35 },
  { 1834, 5, 26, 29, 14, -26 },
  { 1851, 6, 33, 29, 13, -26 },
  { 1876, 20, 21, 29, 4, -26 },
  { 1929, 22, 12, 29, 4, -22 },
  { 1962, 21, 20, 29, 4, -26 },
  { 2015, 20, 35, 29, 5, -35 },
  { 2103, 27, 35, 29, 1, -35 },
  { 2222, 26, 35, 29, 2, -35 },
  { 2336, 21, 35, 29, 5, -35 },
  { 2428, 23, 35, 29, 3, -35 },
  { 2529, 23, 35, 29, 4, -35 },
  { 2630, 20, 35, 29, 5, -35 },
  { 2718, 21, 35, 29, 5, -35 },
  { 2810, 23, 35, 29, 3, -35 },
  { 2911, 22, 35, 29, 4, -35 },
  { 3008, 20, 35, 29, 5, -35 },
  { 3096, 22, 35, 29, 3, -35 },
  { 3193, 23, 35, 29, 5, -35 },
  { 3294, 21, 35, 29, 5, -35 },
  { 3386, 22, 35, 29, 4, -35 },
  { 3483, 22, 35, 29, 4, -35 },
  { 3580, 23, 35, 29, 3, -35 },
  { 3681, 22, 35, 29, 5, -35 },
  { 3778, 24, 41, 29, 3, -35 },
  { 3901, 22, 35, 29, 5, -35 },
  { 3998, 24, 35, 29, 3, -35 },
  { 4103, 25, 35, 29, 2, -35 },
  { 4213, 22, 35, 29, 4, -35 },
  { 4310, 25, 35, 29, 2, -35 },
  { 4420, 26, 35, 29, 2, -35 },
  { 4534, 25, 35, 29, 3, -35 },
  { 4644, 25, 35, 29, 2, -35 },
  { 4754, 22, 35, 29, 3, -35 },
  { 4851, 8, 47, 29, 11, -40 },
  { 4898, 17, 38, 29, 6, -35 },
  { 4979, 9, 47, 29, 10, -40 },
  { 5032, 18, 19, 29, 6, -35 },
  { 5075, 21, 2, 29, 4, 0 },
  { 5081, 8, 7, 29, 11, -36 },
  { 5088, 21, 26, 29, 4, -26 },
  { 5157, 21, 37, 29, 5, -37 },
  { 5255, 21, 26, 29, 4, -26 },
  { 5324, 21, 37, 29, 4, -37 },
  { 5422, 22, 26, 29, 4, -26 },
  { 5494, 23, 38, 29, 4, -38 },
  { 5604, 21, 36, 29, 4, -26 },
  { 5699, 20, 37, 29, 5, -37 },
  { 5792, 21, 35, 29, 5, -35 },
  { 5884, 15, 45, 29, 5, -35 },
  { 5969, 22, 37, 29, 5, -37 },
  { 6071, 21, 37, 29, 5, -37 },
  { 6169, 25, 26, 29, 2, -26 },
  { 6251, 20, 26, 29, 5, -26 },
  { 6316, 23, 26, 29, 3, -26 },
  { 6391, 21, 36, 29, 5, -26 },
  { 6486, 21, 36, 29, 4, -26 },
  { 6581, 17, 26, 29, 9, -26 },
  { 6637, 21, 26, 29, 5, -26 },
  { 6706, 21, 33, 29, 4, -33 },
  { 6793, 20, 26, 29, 5, -26 },
  { 6858, 24, 26, 29, 3, -26 },
  { 6936, 27, 26, 29, 1, -26 },
  { 7024, 24, 26, 29, 3, -26 },
  { 7102, 25, 36, 29, 2, -26 },
  { 7215, 22, 26, 29, 4, -26 },
  { 7287, 16, 48, 29, 8, -38 },
  { 7383, 3, 43, 29, 13, -35 },
  { 7400, 16, 48, 29, 8, -38 },
  { 7496, 27, 9, 29, 1, -19 },
};

const GFXfont RobotoMono_Light49pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light49pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _ROBOTOMONO_LIGHT49PT7B_H_
